# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cool_asserts"
PV = "2.0.3"
PR = "2.el10_1"
PACKAGES = " \
 rust-cool_asserts+default-devel \
 rust-cool_asserts-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cool_asserts-2.0.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b1197bbdf2162fc3e9cd608e20b3a988ab6a323f1359a8657f8ba5caf3df70c"

URI_x86_64_v2_rust-cool_asserts+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cool_asserts+default-devel-2.0.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cool_asserts+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cool_asserts+default-devel}"
SRC_URI[x86_64_v2_rust-cool_asserts+default-devel.sha256sum] = "962ee6fabef1923f5f880b4f89d61f55aa5055fc9761848e00229837714e41c9"

URI_x86_64_v2_rust-cool_asserts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cool_asserts-devel-2.0.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cool_asserts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cool_asserts-devel}"
SRC_URI[x86_64_v2_rust-cool_asserts-devel.sha256sum] = "b3f791aac8a3b5ca7020df9abaaa6932c1760dec207209f1421b8197e54f2b14"

URI_aarch64_rust-cool_asserts+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cool_asserts+default-devel-2.0.3-2.el10_1.noarch.rpm;name=aarch64_rust-cool_asserts+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cool_asserts+default-devel}"
SRC_URI[aarch64_rust-cool_asserts+default-devel.sha256sum] = "d64a6b5dbb5cb9625321d38259cc5290d2d4238d6701183fe098f32bd65681a8"

URI_aarch64_rust-cool_asserts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cool_asserts-devel-2.0.3-2.el10_1.noarch.rpm;name=aarch64_rust-cool_asserts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cool_asserts-devel}"
SRC_URI[aarch64_rust-cool_asserts-devel.sha256sum] = "53ca2a36dd5f50db4641683ee258dbff79644b66c98399a42cb3f61d845b0299"

RDEPENDS:rust-cool_asserts+default-devel = " \
 cargo \
 rust-cool_asserts-devel \
 "
RDEPENDS:rust-cool_asserts-devel = " \
 cargo \
 rust-indent_write-devel \
 "
