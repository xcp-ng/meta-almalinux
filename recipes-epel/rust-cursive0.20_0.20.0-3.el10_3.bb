# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive0.20"
PV = "0.20.0"
PR = "3.el10_3"
PACKAGES = " \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20+crossterm-devel \
 rust-cursive0.20+default-devel \
 rust-cursive0.20+doc-cfg-devel \
 rust-cursive0.20+maplit-devel \
 rust-cursive0.20+term_size-devel \
 rust-cursive0.20+termion-backend-devel \
 rust-cursive0.20+termion-devel \
 rust-cursive0.20+toml-devel \
 rust-cursive0.20+unstable_scroll-devel \
 rust-cursive0.20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive0.20-0.20.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d943f61a4cf8238522304f0f0ee6247a43466e4ed7f42f184c06d59b38902e19"

URI_x86_64_v2_rust-cursive0.20+crossterm-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+crossterm-backend-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+crossterm-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+crossterm-backend-devel.sha256sum] = "2035b96c4f19f283e3fb734cb43f5dbaa1871cd10e13397355f52581975bcdeb"

URI_x86_64_v2_rust-cursive0.20+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+crossterm-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+crossterm-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+crossterm-devel.sha256sum] = "75fc208bbc2bba7acae5e3f650329cbfac5fea4a4573d6cfe10c1ea74c6f1de9"

URI_x86_64_v2_rust-cursive0.20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+default-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+default-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+default-devel.sha256sum] = "c8e6fa2cb749123ddbdb919ad9f5475f53fdf612b89be045f33f65c74e9ffbc2"

URI_x86_64_v2_rust-cursive0.20+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+doc-cfg-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+doc-cfg-devel.sha256sum] = "ade0369dd6821798d00f50d813891b3c2f1f43b6cbc77bcb497c63c7d70f825e"

URI_x86_64_v2_rust-cursive0.20+maplit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+maplit-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+maplit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+maplit-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+maplit-devel.sha256sum] = "aaf11b4b5b5a2647b51af81e619e1bd44b3b0f747efc3b482bf48a7ab22d36a6"

URI_x86_64_v2_rust-cursive0.20+term_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+term_size-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+term_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+term_size-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+term_size-devel.sha256sum] = "e98cfc7bdf7b9cb9e86a43b6770e8cfaca34f8a9335e47eec896a4bb7ac45aeb"

URI_x86_64_v2_rust-cursive0.20+termion-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+termion-backend-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+termion-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+termion-backend-devel.sha256sum] = "5c0fe5e6197dc0a04297c7478b53e2e1ebb39e0485c97a2caae08116f5a37c19"

URI_x86_64_v2_rust-cursive0.20+termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+termion-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+termion-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+termion-devel.sha256sum] = "4f75ecbecb4c79398082428a9ec05bcbd002b8e989fe86686b7ca33607a0f0b6"

URI_x86_64_v2_rust-cursive0.20+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+toml-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+toml-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+toml-devel.sha256sum] = "cbfa6b331e3012767e242e835481226451b14808ce9d716460e8046e15e6ddc9"

URI_x86_64_v2_rust-cursive0.20+unstable_scroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+unstable_scroll-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+unstable_scroll-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+unstable_scroll-devel.sha256sum] = "fe74421193c27c30bfb363048710bdc0a11ab2d757bd835f760363bac675c692"

URI_x86_64_v2_rust-cursive0.20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20-devel-0.20.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20-devel.sha256sum] = "eea52d8458ac060ce56771af562f1dafd155c2f3b7b3f61e4f40a63697284692"

URI_aarch64_rust-cursive0.20+crossterm-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+crossterm-backend-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+crossterm-backend-devel}"
SRC_URI[aarch64_rust-cursive0.20+crossterm-backend-devel.sha256sum] = "dc4e9f49de68bfd35d3eaa0d6dd464bbc1ad1cb99ef227d16fdc3cf3ec342b10"

URI_aarch64_rust-cursive0.20+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+crossterm-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+crossterm-devel}"
SRC_URI[aarch64_rust-cursive0.20+crossterm-devel.sha256sum] = "612d089c1a359b31968c076d5c4bdf4e51f76a1ff20fdd2d2a20f84dc0287c36"

URI_aarch64_rust-cursive0.20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+default-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+default-devel}"
SRC_URI[aarch64_rust-cursive0.20+default-devel.sha256sum] = "b1badbf038f40d5d576c694269f6cb5965553a9632888b1d314bd8269213fe14"

URI_aarch64_rust-cursive0.20+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+doc-cfg-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+doc-cfg-devel}"
SRC_URI[aarch64_rust-cursive0.20+doc-cfg-devel.sha256sum] = "11294b69ccd92ef67ec41e0575b1636e234b8f830ae65bb4de9ccac4a983b25a"

URI_aarch64_rust-cursive0.20+maplit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+maplit-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20+maplit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+maplit-devel}"
SRC_URI[aarch64_rust-cursive0.20+maplit-devel.sha256sum] = "ac86419feae1e6d4d71e7e744de4dfa7b9887840deec834204e3354e460f0627"

URI_aarch64_rust-cursive0.20+term_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+term_size-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20+term_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+term_size-devel}"
SRC_URI[aarch64_rust-cursive0.20+term_size-devel.sha256sum] = "c07cf6399b7cc5feca8d30650745bac9a6527753e7724e7b726758d6398c3825"

URI_aarch64_rust-cursive0.20+termion-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+termion-backend-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+termion-backend-devel}"
SRC_URI[aarch64_rust-cursive0.20+termion-backend-devel.sha256sum] = "ca9ded3226b4160628ad8508a165e88104890f67743a1d442acd9395f1da4409"

URI_aarch64_rust-cursive0.20+termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+termion-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20+termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+termion-devel}"
SRC_URI[aarch64_rust-cursive0.20+termion-devel.sha256sum] = "804050fdd5e54fe8975707ac3cadf6448b2cbfa865e059d6dc2a2bb76d1ec1ac"

URI_aarch64_rust-cursive0.20+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+toml-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+toml-devel}"
SRC_URI[aarch64_rust-cursive0.20+toml-devel.sha256sum] = "cd145b0e173e92ce1c94e387c0dedcc272214cdb53bf4c7758314865f836019c"

URI_aarch64_rust-cursive0.20+unstable_scroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+unstable_scroll-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+unstable_scroll-devel}"
SRC_URI[aarch64_rust-cursive0.20+unstable_scroll-devel.sha256sum] = "80272cba00e701b9ea11b91a88bb2bc83f732ce91ee96f75eec88316417da4c0"

URI_aarch64_rust-cursive0.20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20-devel-0.20.0-3.el10_3.noarch.rpm;name=aarch64_rust-cursive0.20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20-devel}"
SRC_URI[aarch64_rust-cursive0.20-devel.sha256sum] = "12ac455c6ec7c7ea21c3de9ba417ed47578f43aa329174564b11e48fcf65dbec"

RDEPENDS:rust-cursive0.20+crossterm-backend-devel = " \
 cargo \
 rust-cursive0.20+crossterm-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+crossterm-devel = " \
 cargo \
 rust-crossterm0.25+default-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+default-devel = " \
 cargo \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+doc-cfg-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-cursive_core0.3+doc-cfg-devel \
 "
RDEPENDS:rust-cursive0.20+maplit-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-maplit+default-devel \
 "
RDEPENDS:rust-cursive0.20+term_size-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-term_size+default-devel \
 "
RDEPENDS:rust-cursive0.20+termion-backend-devel = " \
 cargo \
 rust-cursive0.20+termion-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+termion-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-termion+default-devel \
 "
RDEPENDS:rust-cursive0.20+toml-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-cursive_core0.3+toml-devel \
 "
RDEPENDS:rust-cursive0.20+unstable_scroll-devel = " \
 cargo \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20-devel = " \
 cargo \
 rust-ahash+default-devel \
 rust-cfg-if+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-cursive_core0.3+default-devel \
 rust-lazy_static+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-signal-hook0.3+default-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 "
