# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-amqp"
PV = "2.1.2"
PR = "6.el10_0"
PACKAGES = " \
 php-pecl-amqp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-amqp-2.1.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b9bf409cd5813a2272e99b3fabb0a3dda9b1e5f39191f300a378360ad5da705"

URI_x86_64_v2_php-pecl-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-amqp-2.1.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-amqp}"
SRC_URI[x86_64_v2_php-pecl-amqp.sha256sum] = "726c32039c8f08a611f301a90b5f4f959fa890a9d0bc440621cc636765d89bc9"

URI_aarch64_php-pecl-amqp = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-amqp-2.1.2-6.el10_0.aarch64.rpm;name=aarch64_php-pecl-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-amqp}"
SRC_URI[aarch64_php-pecl-amqp.sha256sum] = "568883d27f5c0536c6fd5b29e6909c5ae3ba1508a9f286033742dbb9dddd85d4"

RDEPENDS:php-pecl-amqp = " \
 glibc \
 librabbitmq \
 php-common \
 "
