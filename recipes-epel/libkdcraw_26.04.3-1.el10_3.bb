# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdcraw"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libkdcraw \
 libkdcraw-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdcraw-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4add56440ddf8c32428e7c6c68801e034b762b5e957df9f3f71a9af31e36b85"

URI_x86_64_v2_libkdcraw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdcraw-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdcraw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdcraw}"
SRC_URI[x86_64_v2_libkdcraw.sha256sum] = "06e0671d037c682d5a4ac3b8d689d3b52a238343577b097c6de174383cfed174"

URI_x86_64_v2_libkdcraw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdcraw-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdcraw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdcraw-devel}"
SRC_URI[x86_64_v2_libkdcraw-devel.sha256sum] = "bff54866c6155264dd713d5adf9a7ac5e3f1c6b4a57e66b95696a8503a44955c"

URI_aarch64_libkdcraw = "${EPEL_MIRROR}/aarch64/Packages/l/libkdcraw-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkdcraw;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdcraw}"
SRC_URI[aarch64_libkdcraw.sha256sum] = "b9a82e5e6433b7c8a3ff5d634c4ff303648ad5654e530acf45dfe26f960c9671"

URI_aarch64_libkdcraw-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdcraw-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkdcraw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdcraw-devel}"
SRC_URI[aarch64_libkdcraw-devel.sha256sum] = "7394b3b0f6a29f2f0e8f9a62840d58ef863279bea3f4f9a7baa12c48fa9214f3"

RDEPENDS:libkdcraw = " \
 LibRaw \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdcraw-devel = " \
 cmake-filesystem \
 libkdcraw \
 qt6-qtbase-devel \
 "
