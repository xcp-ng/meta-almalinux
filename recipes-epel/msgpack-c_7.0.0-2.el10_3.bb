# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "msgpack-c"
PV = "7.0.0"
PR = "2.el10_3"
PACKAGES = " \
 msgpack-c \
 msgpack-c-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/msgpack-c-7.0.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43cc80d0d0de3f544ea63b4575cc5b4b053556db95fcaaeef1efeb23ca4cfabd"

URI_x86_64_v2_msgpack-c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/msgpack-c-7.0.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_msgpack-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msgpack-c}"
SRC_URI[x86_64_v2_msgpack-c.sha256sum] = "8bc2cfb4224a289f3baf40308b619d24917b3a827f7e748fb4e67c4f855a7708"

URI_x86_64_v2_msgpack-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/msgpack-c-devel-7.0.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_msgpack-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msgpack-c-devel}"
SRC_URI[x86_64_v2_msgpack-c-devel.sha256sum] = "e0ece69e66009f287e3b8ba4992ca82b97fa20411b848ef1aab9c9ef40fe363b"

URI_aarch64_msgpack-c = "${EPEL_MIRROR}/aarch64/Packages/m/msgpack-c-7.0.0-2.el10_3.aarch64.rpm;name=aarch64_msgpack-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_msgpack-c}"
SRC_URI[aarch64_msgpack-c.sha256sum] = "c7555988b5c85ec967738108bfbb84c11713bac2da60e1c8ec0ffdc4f7b984de"

URI_aarch64_msgpack-c-devel = "${EPEL_MIRROR}/aarch64/Packages/m/msgpack-c-devel-7.0.0-2.el10_3.aarch64.rpm;name=aarch64_msgpack-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_msgpack-c-devel}"
SRC_URI[aarch64_msgpack-c-devel.sha256sum] = "1e60a1f6394eab7bd4d582b819225e81e37edc4ac0f294b84a27be91fa44e6a5"

RDEPENDS:msgpack-c = " \
 glibc \
 "
RDEPENDS:msgpack-c-devel = " \
 cmake-filesystem \
 msgpack-c \
 pkgconf-pkg-config \
 "
