# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-fork"
PV = "3.3"
PR = "9.el10_0"
PACKAGES = " \
 globus-gram-job-manager-fork \
 globus-gram-job-manager-fork-setup-poll \
 globus-gram-job-manager-fork-setup-seg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-fork-3.3-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac0739226a86c65ec874d9b90a2fc407935796570508742d63d78cb5f1294177"

URI_x86_64_v2_globus-gram-job-manager-fork = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-fork-3.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-fork;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-fork}"
SRC_URI[x86_64_v2_globus-gram-job-manager-fork.sha256sum] = "e3ec1be114f7bf71ac843e532a63e30b410d116c28c25d88f2d8167cc329405c"

URI_x86_64_v2_globus-gram-job-manager-fork-setup-poll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-fork-setup-poll-3.3-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-fork-setup-poll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-fork-setup-poll}"
SRC_URI[x86_64_v2_globus-gram-job-manager-fork-setup-poll.sha256sum] = "f4808aea9eaf5430090ba34a6ee03f4c183c315da266ef10bb7c457a789b26c7"
RPROVIDES:globus-gram-job-manager-fork-setup-poll:x86_64_v2 = "virtual/globus-gram-job-manager-fork-setup_eq_3.3-9.el10_0.alma_altarch"

URI_x86_64_v2_globus-gram-job-manager-fork-setup-seg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-fork-setup-seg-3.3-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-fork-setup-seg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-fork-setup-seg}"
SRC_URI[x86_64_v2_globus-gram-job-manager-fork-setup-seg.sha256sum] = "84f3e218ad6c00af3858ca044154596ba93cc334805f30eb9b16c1959ca57135"
RPROVIDES:globus-gram-job-manager-fork-setup-seg:x86_64_v2 = "virtual/globus-gram-job-manager-fork-setup_eq_3.3-9.el10_0.alma_altarch"

URI_aarch64_globus-gram-job-manager-fork = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-fork-3.3-9.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager-fork;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-fork}"
SRC_URI[aarch64_globus-gram-job-manager-fork.sha256sum] = "f9a9562f3430351681f1e14083e5490d973b99f0204141b37949c338a2b6758e"

URI_aarch64_globus-gram-job-manager-fork-setup-poll = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-fork-setup-poll-3.3-9.el10_0.noarch.rpm;name=aarch64_globus-gram-job-manager-fork-setup-poll;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-fork-setup-poll}"
SRC_URI[aarch64_globus-gram-job-manager-fork-setup-poll.sha256sum] = "f1f8a37209f601dff99b56e6669821dfcf4b42a6f0d5fdc284e52aa50175e8f2"
RPROVIDES:globus-gram-job-manager-fork-setup-poll:aarch64 = "virtual/globus-gram-job-manager-fork-setup_eq_3.3-9.el10_0"

URI_aarch64_globus-gram-job-manager-fork-setup-seg = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-fork-setup-seg-3.3-9.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager-fork-setup-seg;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-fork-setup-seg}"
SRC_URI[aarch64_globus-gram-job-manager-fork-setup-seg.sha256sum] = "9425f74409e99a320e4a34652ceced8cef6f045089a8a3189af0af28ebb7100e"
RPROVIDES:globus-gram-job-manager-fork-setup-seg:aarch64 = "virtual/globus-gram-job-manager-fork-setup_eq_3.3-9.el10_0"

RDEPENDS:globus-gram-job-manager-fork:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-fork-setup_eq_3.3-9.el10_0.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-fork:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-fork-setup_eq_3.3-9.el10_0 \
"
RDEPENDS:globus-gram-job-manager-fork-setup-poll = " \
 bash \
 globus-gram-job-manager-fork \
 globus-gram-job-manager-scripts \
 "
RDEPENDS:globus-gram-job-manager-fork-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-fork \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 globus-xio \
 systemd \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/globus-gram-job-manager-fork-setup_eq_3.3-9.el10_0.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/globus-gram-job-manager-fork-setup_eq_3.3-9.el10_0"
