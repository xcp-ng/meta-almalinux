# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-translationstring"
PV = "1.4"
PR = "9.el10_3"
PACKAGES = " \
 python3-translationstring \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-translationstring-1.4-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29dd420e763b5ca1a43a33222d36d6ade57d40f4dea55a15e1daef557a8d7b9c"

URI_x86_64_v2_python3-translationstring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-translationstring-1.4-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-translationstring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-translationstring}"
SRC_URI[x86_64_v2_python3-translationstring.sha256sum] = "e3a16d72fe47fbb58810ea9b8478502922b69880cddfcb9adf07964be4445def"

URI_aarch64_python3-translationstring = "${EPEL_MIRROR}/aarch64/Packages/p/python3-translationstring-1.4-9.el10_3.noarch.rpm;name=aarch64_python3-translationstring;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-translationstring}"
SRC_URI[aarch64_python3-translationstring.sha256sum] = "57f5973470a45128573ff434c842e1777d7ed4079e5968203ecaf3f15e76e552"

RDEPENDS:python3-translationstring = " \
 python3 \
 "
