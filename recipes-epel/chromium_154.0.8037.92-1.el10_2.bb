# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chromium"
PV = "154.0.8037.92"
PR = "1.el10_2"
PACKAGES = " \
 chromedriver \
 chromium \
 chromium-common \
 chromium-headless \
 chromium-qt5-ui \
 chromium-qt6-ui \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/chromium-154.0.8037.92-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "64a96fb4c486642306b87cd67146e952cadc9995f8bcb5d1e6d75c9811d3fee4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromedriver-154.0.8037.92-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromedriver;unpack=0"
SRC_URI[x86_64_v2_chromedriver.sha256sum] = "e7eaceb6e86a7997775d762a6f2ef4b29b4789690a1e97340099c601d5ea7f5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-154.0.8037.92-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium;unpack=0"
SRC_URI[x86_64_v2_chromium.sha256sum] = "8d227f71a4c97e63134d54b61b091fdbb64efe1d68057b28a1c85f6740c21eff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-common-154.0.8037.92-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-common;unpack=0"
SRC_URI[x86_64_v2_chromium-common.sha256sum] = "906d702f0a379c59cb09041e4a2a5ff26ec8c4ad1c21a593ea25194ac6474b19"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-headless-154.0.8037.92-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-headless;unpack=0"
SRC_URI[x86_64_v2_chromium-headless.sha256sum] = "ca24afde012f9b7e29d9978533f9072ebee187d308a7b0cce428f1309c2b7af4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-qt5-ui-154.0.8037.92-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-qt5-ui;unpack=0"
SRC_URI[x86_64_v2_chromium-qt5-ui.sha256sum] = "d390ac91e09bfa06db1474762ff94330acce6fdce307f1861f8a5b89f17da1d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-qt6-ui-154.0.8037.92-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-qt6-ui;unpack=0"
SRC_URI[x86_64_v2_chromium-qt6-ui.sha256sum] = "fd0589e08751c34f4c1b4edac0119e5da8424e4c602785ab074e51bea8d86ed2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromedriver-154.0.8037.92-1.el10_2.aarch64.rpm;name=aarch64_chromedriver;unpack=0"
SRC_URI[aarch64_chromedriver.sha256sum] = "a08c5f0cba9e2f71ac8c4fe2082e8851f1a95546dd14f5008ce99c099aabef15"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-154.0.8037.92-1.el10_2.aarch64.rpm;name=aarch64_chromium;unpack=0"
SRC_URI[aarch64_chromium.sha256sum] = "7bc81e144a57cc229eea4028603b58d8047d7d7e445f2fbe85daecc651a10ddc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-common-154.0.8037.92-1.el10_2.aarch64.rpm;name=aarch64_chromium-common;unpack=0"
SRC_URI[aarch64_chromium-common.sha256sum] = "823999caed2a6e0770132b1e1ca33098c354599e2caebf4fe8411b7a7d285b8e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-headless-154.0.8037.92-1.el10_2.aarch64.rpm;name=aarch64_chromium-headless;unpack=0"
SRC_URI[aarch64_chromium-headless.sha256sum] = "76153e822d011a97685f32b4bc0bdca249f0a32a4cfb20c6d06f2fcbad0087df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt5-ui-154.0.8037.92-1.el10_2.aarch64.rpm;name=aarch64_chromium-qt5-ui;unpack=0"
SRC_URI[aarch64_chromium-qt5-ui.sha256sum] = "0928bfbe1843d13d6f5880e32a5ed1ec0f98c949efb0268287247c1b409f27ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt6-ui-154.0.8037.92-1.el10_2.aarch64.rpm;name=aarch64_chromium-qt6-ui;unpack=0"
SRC_URI[aarch64_chromium-qt6-ui.sha256sum] = "5b34e70612a2b7479c8a5119eb2c06c7b5b764e85fd108dab319f2f8007f51f0"

RDEPENDS:chromedriver = " \
 chromium-common \
 double-conversion \
 glib2 \
 glibc \
 libbrotli \
 libgcc \
 libxcb \
 libzstd \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:chromium = " \
 alsa-lib \
 at-spi2-atk \
 at-spi2-core \
 atk \
 bash \
 cairo \
 chromium-common \
 cups-libs \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gtk4 \
 harfbuzz \
 lcms2 \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libusb1 \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-mdns \
 nss-util \
 openjpeg2 \
 opus \
 pango \
 pipewire-libs \
 policycoreutils \
 policycoreutils-python-utils \
 systemd-libs \
 "
RDEPENDS:chromium-common = " \
 glibc \
 libgcc \
 "
RDEPENDS:chromium-headless = " \
 alsa-lib \
 at-spi2-core \
 atk \
 chromium-common \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libwebp \
 libxcb \
 libxkbcommon \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 opus \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:chromium-qt5-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:chromium-qt6-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
