# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jsch"
PV = "0.1.55"
PR = "16.el10"
PACKAGES = " \
 jsch \
 jsch-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jsch-0.1.55-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebc02bd70dfba1cc4faf9e66ce9294402d79735935bee768076efb6e3b7c6b3f"

URI_x86_64_v2_jsch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jsch-0.1.55-16.el10.noarch.rpm;name=x86_64_v2_jsch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsch}"
SRC_URI[x86_64_v2_jsch.sha256sum] = "3f588112f1e875f1564764869647a4e0901b4ce36dc5737e4ab6711c613b5963"

URI_x86_64_v2_jsch-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jsch-javadoc-0.1.55-16.el10.noarch.rpm;name=x86_64_v2_jsch-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsch-javadoc}"
SRC_URI[x86_64_v2_jsch-javadoc.sha256sum] = "4a347bd10e3b1e2a0cf7c46872c81a4ac706bfadab2fc12fcf19d68a3ba93ec8"

URI_aarch64_jsch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jsch-0.1.55-16.el10.noarch.rpm;name=aarch64_jsch;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsch}"
SRC_URI[aarch64_jsch.sha256sum] = "3f588112f1e875f1564764869647a4e0901b4ce36dc5737e4ab6711c613b5963"

URI_aarch64_jsch-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jsch-javadoc-0.1.55-16.el10.noarch.rpm;name=aarch64_jsch-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsch-javadoc}"
SRC_URI[aarch64_jsch-javadoc.sha256sum] = "4a347bd10e3b1e2a0cf7c46872c81a4ac706bfadab2fc12fcf19d68a3ba93ec8"

RDEPENDS:jsch = " \
 javapackages-filesystem \
 jzlib \
 "
RDEPENDS:jsch-javadoc = " \
 javapackages-filesystem \
 "
