# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnutls"
PV = "3.8.10"
PR = "3.el10_1"
PACKAGES = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 gnutls-fips \
 gnutls-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gnutls-3.8.10-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e21986004c37e2269e73f965b80405f9375adbcf80b9fe8667a8905ba1096feb"

URI_x86_64_v2_gnutls = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gnutls-3.8.10-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls}"
SRC_URI[x86_64_v2_gnutls.sha256sum] = "238c71eb5e915f3d8d20fde8c63bcc196e4c239eed16740da0b7428ce7ea0a8a"

URI_x86_64_v2_gnutls-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-c++-3.8.10-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_gnutls-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-c++}"
SRC_URI[x86_64_v2_gnutls-c++.sha256sum] = "ab9db075faaeae526aaa884a4e12df5272640dc48b65a12f4a4c86431cd85ed3"

URI_x86_64_v2_gnutls-dane = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-dane-3.8.10-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_gnutls-dane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-dane}"
SRC_URI[x86_64_v2_gnutls-dane.sha256sum] = "5c8c9238472eb751fbed5415a1168dc76da68fb14223378ef23e5d391bdcc806"

URI_x86_64_v2_gnutls-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-devel-3.8.10-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-devel}"
SRC_URI[x86_64_v2_gnutls-devel.sha256sum] = "f5b6b7bb801c863fd6de80aaac0600639f6fd99a663edfeb839ece6d85296261"

URI_x86_64_v2_gnutls-fips = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-fips-3.8.10-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_gnutls-fips;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-fips}"
SRC_URI[x86_64_v2_gnutls-fips.sha256sum] = "8da465e15163f1e278d5c21d20866dd212ee860e7d7d5fe8eddd96e57298471c"

URI_x86_64_v2_gnutls-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-utils-3.8.10-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_gnutls-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnutls-utils}"
SRC_URI[x86_64_v2_gnutls-utils.sha256sum] = "45c517ef6ff7377c07bf1c15d75457dc4129af3f8a6bbdf56628d19fb4febf9c"

URI_aarch64_gnutls = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gnutls-3.8.10-3.el10_1.aarch64.rpm;name=aarch64_gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls}"
SRC_URI[aarch64_gnutls.sha256sum] = "06aeb11f78145263383d88d7a55ddd0babf25b86c3e0ac9c0db275935464d880"

URI_aarch64_gnutls-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-c++-3.8.10-3.el10_1.aarch64.rpm;name=aarch64_gnutls-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-c++}"
SRC_URI[aarch64_gnutls-c++.sha256sum] = "61a69d116a9bf98fa6b7fe46114c8cdf500a5a2524f6e484a7ed8b505e2df27e"

URI_aarch64_gnutls-dane = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-dane-3.8.10-3.el10_1.aarch64.rpm;name=aarch64_gnutls-dane;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-dane}"
SRC_URI[aarch64_gnutls-dane.sha256sum] = "b44ba6c4278123b1766b95c2ac983d975f016a74df0a395400cd3adfb00b64c5"

URI_aarch64_gnutls-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-devel-3.8.10-3.el10_1.aarch64.rpm;name=aarch64_gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-devel}"
SRC_URI[aarch64_gnutls-devel.sha256sum] = "d47f4912d5e2aad4dd58258cd54310e4f6b46f24afa514620a2b89476b6a15d9"

URI_aarch64_gnutls-fips = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-fips-3.8.10-3.el10_1.aarch64.rpm;name=aarch64_gnutls-fips;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-fips}"
SRC_URI[aarch64_gnutls-fips.sha256sum] = "224777f3d14f945f70660cd52364dc95752af07bb7159fb6cbc5fa5f3378f45d"

URI_aarch64_gnutls-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-utils-3.8.10-3.el10_1.aarch64.rpm;name=aarch64_gnutls-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnutls-utils}"
SRC_URI[aarch64_gnutls-utils.sha256sum] = "a5ac088681debae2f5c600408a2bf5b3945cc958f8f30785ffa6cbc842abd8a6"

RDEPENDS:gnutls = " \
 crypto-policies \
 glibc \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 p11-kit-trust \
 "
RDEPENDS:gnutls-c++ = " \
 glibc \
 gnutls \
 libgcc \
 libidn2 \
 libstdc++ \
 libtasn1 \
 libunistring \
 p11-kit \
 "
RDEPENDS:gnutls-dane = " \
 glibc \
 gnutls \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 unbound-libs \
 "
RDEPENDS:gnutls-devel = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 libidn2-devel \
 libtasn1-devel \
 p11-kit-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gnutls-fips = " \
 gnutls \
 "
RDEPENDS:gnutls-utils = " \
 glibc \
 gnutls \
 gnutls-dane \
 libtasn1 \
 "
