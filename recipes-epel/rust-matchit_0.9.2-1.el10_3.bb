# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matchit"
PV = "0.9.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-matchit+default-devel \
 rust-matchit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matchit-0.9.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a8bd4ea01141eb5d65128644d8277cf5d286b6c43e8d39818ef06ebd846e9d5"

URI_x86_64_v2_rust-matchit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit+default-devel-0.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit+default-devel}"
SRC_URI[x86_64_v2_rust-matchit+default-devel.sha256sum] = "d930b3bf7bf590253245add9513ef8a595db310a3c078086f7b67aafd416e29f"

URI_x86_64_v2_rust-matchit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit-devel-0.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit-devel}"
SRC_URI[x86_64_v2_rust-matchit-devel.sha256sum] = "94a31521c68ee6fa74c082a5cef94858f0c1e71f3d3b0cd6775aece55c5305d9"

URI_aarch64_rust-matchit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit+default-devel-0.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-matchit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit+default-devel}"
SRC_URI[aarch64_rust-matchit+default-devel.sha256sum] = "5b6005e3c79296a2d7cbe10d8f9b6f99daf863e5cb5ea68cf5024b9eb86adfc8"

URI_aarch64_rust-matchit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit-devel-0.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-matchit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit-devel}"
SRC_URI[aarch64_rust-matchit-devel.sha256sum] = "f109461b12305b81ddb4cd415213e47d07c827051038384e565325cc529befb5"

RDEPENDS:rust-matchit+default-devel = " \
 cargo \
 rust-matchit-devel \
 "
RDEPENDS:rust-matchit-devel = " \
 cargo \
 rust \
 "
