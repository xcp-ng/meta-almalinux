# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "trafficserver"
PV = "10.2.0"
PR = "1.el10_3"
PACKAGES = " \
 trafficserver \
 trafficserver-devel \
 trafficserver-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/trafficserver-10.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b220161ba2227544ca08c61eab28d2029b4a8116107238b3eb6511a198ddd43"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - trafficserver: libcap.so.2()(64bit)

URI_x86_64_v2_trafficserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trafficserver-10.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trafficserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trafficserver}"
SRC_URI[x86_64_v2_trafficserver.sha256sum] = "8832a57081522631e4c41077d6cec1af48cc2fd905a538e7ac2a29f4bb0c908f"

URI_x86_64_v2_trafficserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trafficserver-devel-10.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trafficserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trafficserver-devel}"
SRC_URI[x86_64_v2_trafficserver-devel.sha256sum] = "ae538f521e9d2f7810e476b762b4dbe3b5adeade5ceaf55c455b497717abea04"

URI_x86_64_v2_trafficserver-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trafficserver-selinux-10.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_trafficserver-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trafficserver-selinux}"
SRC_URI[x86_64_v2_trafficserver-selinux.sha256sum] = "2e804426317d9e3993425e2d0dec89bc05bbc8b0e3b4cc9c74fdeb9732d4d07a"

URI_aarch64_trafficserver = "${EPEL_MIRROR}/aarch64/Packages/t/trafficserver-10.2.0-1.el10_3.aarch64.rpm;name=aarch64_trafficserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_trafficserver}"
SRC_URI[aarch64_trafficserver.sha256sum] = "a764424bc2ac9143455ad0fba1ed4074f58684af2ef2b89e9253688b87fe6a0f"

URI_aarch64_trafficserver-devel = "${EPEL_MIRROR}/aarch64/Packages/t/trafficserver-devel-10.2.0-1.el10_3.aarch64.rpm;name=aarch64_trafficserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_trafficserver-devel}"
SRC_URI[aarch64_trafficserver-devel.sha256sum] = "81f845f11ca3f1107990750eff609e05693a9e2c2cb6b9480fa61974bf0dbf42"

URI_aarch64_trafficserver-selinux = "${EPEL_MIRROR}/aarch64/Packages/t/trafficserver-selinux-10.2.0-1.el10_3.noarch.rpm;name=aarch64_trafficserver-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_trafficserver-selinux}"
SRC_URI[aarch64_trafficserver-selinux.sha256sum] = "dbd8a9e53474c5b2336f912aeccf6babcbe9c7d7cc88865a456188711947cb89"

RDEPENDS:trafficserver:x86_64_v2 = " \
 bash \
 expat \
 glibc \
 hwloc \
 hwloc-libs \
 libbrotli \
 libcap \
 libgcc \
 libstdc++ \
 ncurses \
 ncurses-libs \
 openssl \
 openssl-libs \
 pcre2 \
 pkgconf-pkg-config \
 python3 \
 python3-colorama \
 python3-jsonschema \
 python3-pyyaml \
 systemd \
 trafficserver-selinux \
 virtual//usr/bin/env \
 xz \
 xz-libs \
 yaml-cpp \
 zlib-ng-compat \
"
RDEPENDS:trafficserver:aarch64 = " \
 bash \
 expat \
 glibc \
 hwloc \
 hwloc-libs \
 libbrotli \
 libgcc \
 libstdc++ \
 ncurses \
 ncurses-libs \
 openssl \
 openssl-libs \
 pcre2 \
 pkgconf-pkg-config \
 python3 \
 python3-colorama \
 python3-jsonschema \
 python3-pyyaml \
 systemd \
 trafficserver-selinux \
 virtual//usr/bin/env \
 xz \
 xz-libs \
 yaml-cpp \
 zlib-ng-compat \
"
RDEPENDS:trafficserver-devel = " \
 pkgconf-pkg-config \
 trafficserver \
 yaml-cpp-devel \
 "
RDEPENDS:trafficserver-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
