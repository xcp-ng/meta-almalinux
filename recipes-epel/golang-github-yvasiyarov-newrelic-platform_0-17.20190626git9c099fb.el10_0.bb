# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-yvasiyarov-newrelic-platform"
PV = "0"
PR = "17.20190626git9c099fb.el10_0"
PACKAGES = " \
 golang-github-yvasiyarov-newrelic-platform-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-yvasiyarov-newrelic-platform-0-17.20190626git9c099fb.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a91bd6a854723d392eed9028df15228fbf06c80e8af641facaf72658996d6c01"

URI_aarch64_golang-github-yvasiyarov-newrelic-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-yvasiyarov-newrelic-platform-devel-0-17.20190626git9c099fb.el10_0.noarch.rpm;name=aarch64_golang-github-yvasiyarov-newrelic-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-yvasiyarov-newrelic-platform-devel}"
SRC_URI[aarch64_golang-github-yvasiyarov-newrelic-platform-devel.sha256sum] = "044eec33b08086f58f0b05402f7095db3e0df5e7df4b15d21df53c0b8cddfabf"

RDEPENDS:golang-github-yvasiyarov-newrelic-platform-devel = " \
 go-filesystem \
 "
