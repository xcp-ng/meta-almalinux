# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-callout-error"
PV = "4.2"
PR = "7.el10_0"
PACKAGES = " \
 globus-gram-job-manager-callout-error \
 globus-gram-job-manager-callout-error-devel \
 globus-gram-job-manager-callout-error-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-callout-error-4.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "30b5d41f454bc8f28a35433bbf23a0b3888fcf9f21f711e540b45381419fbf1a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-callout-error-4.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-callout-error;unpack=0"
SRC_URI[x86_64_v2_globus-gram-job-manager-callout-error.sha256sum] = "5c2fcf0ce354fa9194916842d3a3f4d615eb5e5a6032d97a7800ce6591d64a37"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-callout-error-devel-4.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-callout-error-devel;unpack=0"
SRC_URI[x86_64_v2_globus-gram-job-manager-callout-error-devel.sha256sum] = "052ce7b660c332218a6f665550937b21504f12a0ce27bb907328252db193a097"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-callout-error-doc-4.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-callout-error-doc;unpack=0"
SRC_URI[x86_64_v2_globus-gram-job-manager-callout-error-doc.sha256sum] = "63a70f81b7f6c2b92a22e5e6dc645f1ee8f4df7fd2f3e3c3366fd2e8d8b6efca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-callout-error-4.2-7.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager-callout-error;unpack=0"
SRC_URI[aarch64_globus-gram-job-manager-callout-error.sha256sum] = "e71ad999790cb3c58656f80e9b0548178f92d4436672cf5758da07a82f9c1f46"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-callout-error-devel-4.2-7.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager-callout-error-devel;unpack=0"
SRC_URI[aarch64_globus-gram-job-manager-callout-error-devel.sha256sum] = "f8604e52ae3380adc247d018bf5303b2c59d37cec4a058008079b103f7a723f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-callout-error-doc-4.2-7.el10_0.noarch.rpm;name=aarch64_globus-gram-job-manager-callout-error-doc;unpack=0"
SRC_URI[aarch64_globus-gram-job-manager-callout-error-doc.sha256sum] = "837f7d9a6c45d4b4f02d841b4e589afc3eb3aa7a577003fd43fce3070ff82557"

RDEPENDS:globus-gram-job-manager-callout-error = " \
 glibc \
 globus-common \
 "
RDEPENDS:globus-gram-job-manager-callout-error-devel = " \
 globus-common-devel \
 globus-gram-job-manager-callout-error \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gram-job-manager-callout-error-doc = " \
 "
