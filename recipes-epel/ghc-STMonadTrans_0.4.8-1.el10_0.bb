# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-STMonadTrans"
PV = "0.4.8"
PR = "1.el10_0"
PACKAGES = " \
 ghc-STMonadTrans \
 ghc-STMonadTrans-devel \
 ghc-STMonadTrans-doc \
 ghc-STMonadTrans-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-STMonadTrans-0.4.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "624d906bb72717a388f3d6ab09ac66011e724aa67c14aa6cd6f9e33d9a978d27"

URI_x86_64_v2_ghc-STMonadTrans = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-STMonadTrans-0.4.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-STMonadTrans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-STMonadTrans}"
SRC_URI[x86_64_v2_ghc-STMonadTrans.sha256sum] = "5464a8a1baa030b887a6ed1bd4f8647d7077560a7118f07e534057df38694b31"

URI_x86_64_v2_ghc-STMonadTrans-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-STMonadTrans-devel-0.4.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-STMonadTrans-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-STMonadTrans-devel}"
SRC_URI[x86_64_v2_ghc-STMonadTrans-devel.sha256sum] = "553bcf1d31910a2b6a7e8a3c79f05275c58d785c1f0f8ebcaef97d9ab8c5131a"

URI_x86_64_v2_ghc-STMonadTrans-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-STMonadTrans-doc-0.4.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-STMonadTrans-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-STMonadTrans-doc}"
SRC_URI[x86_64_v2_ghc-STMonadTrans-doc.sha256sum] = "21819e416c057e0b7e331513cab867869b106a242e739491fbcc786c629f657e"

URI_x86_64_v2_ghc-STMonadTrans-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-STMonadTrans-prof-0.4.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-STMonadTrans-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-STMonadTrans-prof}"
SRC_URI[x86_64_v2_ghc-STMonadTrans-prof.sha256sum] = "e349f096868670b2087844de71692add9aec97b1817001e4544f4aef0c27d263"

URI_aarch64_ghc-STMonadTrans = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-STMonadTrans-0.4.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-STMonadTrans;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-STMonadTrans}"
SRC_URI[aarch64_ghc-STMonadTrans.sha256sum] = "9de859fe8547b2b78c5c7c5558c28d2a9300ea19b9fb412ff779928819b32def"

URI_aarch64_ghc-STMonadTrans-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-STMonadTrans-devel-0.4.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-STMonadTrans-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-STMonadTrans-devel}"
SRC_URI[aarch64_ghc-STMonadTrans-devel.sha256sum] = "853d74b17b7a4b16162e4b01062ab28a1da91ca006c1562a4e7b925efc8a797b"

URI_aarch64_ghc-STMonadTrans-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-STMonadTrans-doc-0.4.8-1.el10_0.noarch.rpm;name=aarch64_ghc-STMonadTrans-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-STMonadTrans-doc}"
SRC_URI[aarch64_ghc-STMonadTrans-doc.sha256sum] = "1054a4dc588219aa1b8d7a4e013a74fa1b2aef9d0a27e004334f8cc6c174525f"

URI_aarch64_ghc-STMonadTrans-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-STMonadTrans-prof-0.4.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-STMonadTrans-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-STMonadTrans-prof}"
SRC_URI[aarch64_ghc-STMonadTrans-prof.sha256sum] = "17dd3519e321bbfe2691c02217b8a54febf45bc9222a56c2c28091201aa82dd8"

RDEPENDS:ghc-STMonadTrans = " \
 ghc-array \
 ghc-base \
 ghc-ghc-bignum \
 ghc-mtl \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-STMonadTrans-devel = " \
 ghc-STMonadTrans \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-mtl-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-STMonadTrans-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-STMonadTrans-prof = " \
 ghc-STMonadTrans-devel \
 ghc-array-prof \
 ghc-base-prof \
 ghc-mtl-prof \
 ghc-transformers-prof \
 "
