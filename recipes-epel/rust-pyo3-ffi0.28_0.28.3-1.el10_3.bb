# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi0.28"
PV = "0.28.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-pyo3-ffi0.28+abi3-devel \
 rust-pyo3-ffi0.28+abi3-py310-devel \
 rust-pyo3-ffi0.28+abi3-py311-devel \
 rust-pyo3-ffi0.28+abi3-py312-devel \
 rust-pyo3-ffi0.28+abi3-py313-devel \
 rust-pyo3-ffi0.28+abi3-py314-devel \
 rust-pyo3-ffi0.28+abi3-py37-devel \
 rust-pyo3-ffi0.28+abi3-py38-devel \
 rust-pyo3-ffi0.28+abi3-py39-devel \
 rust-pyo3-ffi0.28+default-devel \
 rust-pyo3-ffi0.28+extension-module-devel \
 rust-pyo3-ffi0.28-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi0.28-0.28.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd1e6503d4610b6d81b617e4ee6aa1b54f7d98728d337aafb64269b2e278026a"

URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+abi3-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+abi3-devel.sha256sum] = "b22a2744604c87ccfc3723022e6793146dfec48c4e807bd0db6891b963c1e40d"

URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+abi3-py310-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+abi3-py310-devel.sha256sum] = "942bfe753523857065e9116a0c9dd479d2ed4295f4721fe698e4ce59795199e9"

URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+abi3-py311-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+abi3-py311-devel.sha256sum] = "0c7522aaf4509d801814cc8e1719e391f392b31ef38f4d8f56a83e9680e19c20"

URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+abi3-py312-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+abi3-py312-devel.sha256sum] = "7900daccf8b4323e946c363980a0a460ca6dbdda96a8d161a56da3aaf40215eb"

URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+abi3-py313-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+abi3-py313-devel.sha256sum] = "d7c164d7d72f0dc06ec70c5a734520c1a4cba941ea4efac2040a5c275294b926"

URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+abi3-py314-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+abi3-py314-devel.sha256sum] = "45dc10366e347914985b4d7c8f3472274fd0766bcf86bec2989086c0ea674c7f"

URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+abi3-py37-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+abi3-py37-devel.sha256sum] = "9fce6abc2fe16f1a0f27cf7f6b3474a569d4e669b7adac5b6361470cd6fc6d54"

URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+abi3-py38-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+abi3-py38-devel.sha256sum] = "d6233f200e98dc96c1170a963b736fbb7fe866bb801268d830821ea5b91da547"

URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+abi3-py39-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+abi3-py39-devel.sha256sum] = "8212b15e5d9b0847a23b0c3457fc1d4bc3453c46b74185057d6f712a526ac699"

URI_x86_64_v2_rust-pyo3-ffi0.28+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+default-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+default-devel.sha256sum] = "5d4b9c508420d84a6598f150929d9406636c6039a99364a401bf8fca77aaa2fc"

URI_x86_64_v2_rust-pyo3-ffi0.28+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28+extension-module-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28+extension-module-devel.sha256sum] = "4b93f5513773e15b28301cd7b146bdc7c42ed6106000d6fe7adb2e8242ce71e7"

URI_x86_64_v2_rust-pyo3-ffi0.28-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.28-devel-0.28.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.28-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.28-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.28-devel.sha256sum] = "4da5fff364392d8d0f14e2f54bef6a5e1fe9c4c3e9164baae1c6b4aea685a9ff"

URI_aarch64_rust-pyo3-ffi0.28+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+abi3-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+abi3-devel.sha256sum] = "178ec74568c182937134679aa52769ea1d40c2101194de772f3a34de191102cd"

URI_aarch64_rust-pyo3-ffi0.28+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+abi3-py310-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+abi3-py310-devel.sha256sum] = "ce87b475460c9a783fd5eafc62c35cfc09be258af6d0594adcb3c905d031fb00"

URI_aarch64_rust-pyo3-ffi0.28+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+abi3-py311-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+abi3-py311-devel.sha256sum] = "97f343a133fbc3c00510b1664c43cc42c2f8aca2b5a406c7e31e0912422cbe6e"

URI_aarch64_rust-pyo3-ffi0.28+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+abi3-py312-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+abi3-py312-devel.sha256sum] = "9e47be274163734e033d8f3607bc8b1dbb03d05e17e2959d5ce6a9dbc5dfc6d7"

URI_aarch64_rust-pyo3-ffi0.28+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+abi3-py313-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+abi3-py313-devel.sha256sum] = "12a4e8817203848f38882378cbfee831d9eee3f0e792ddb12557816d5e715458"

URI_aarch64_rust-pyo3-ffi0.28+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+abi3-py314-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+abi3-py314-devel.sha256sum] = "92c598e42ec6b8dcab16d896cb00253e441e0b3d8d9aa3135492c6b1352513df"

URI_aarch64_rust-pyo3-ffi0.28+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+abi3-py37-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+abi3-py37-devel.sha256sum] = "930f2a059e2881c7f66990755895b16cffab081e3afb7c82cf996457ae48a2fb"

URI_aarch64_rust-pyo3-ffi0.28+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+abi3-py38-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+abi3-py38-devel.sha256sum] = "cf53f384c7013e3b0aee04f9a0bb5884fd1deafdc000e832c36939475e19f257"

URI_aarch64_rust-pyo3-ffi0.28+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+abi3-py39-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+abi3-py39-devel.sha256sum] = "e1af65db5df9035f8abb282c7b8533fab770239b9bdb2a57eeb4bc9dce2c604e"

URI_aarch64_rust-pyo3-ffi0.28+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+default-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+default-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+default-devel.sha256sum] = "07e6896a4e0b5a92669e2371830c757fdfd2013a6d95b1a26da75b74141dfc77"

URI_aarch64_rust-pyo3-ffi0.28+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28+extension-module-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28+extension-module-devel.sha256sum] = "374873d74f2ca4a31d42f090bdf5bfa52f28968a6b73161508ad35281e4c0d22"

URI_aarch64_rust-pyo3-ffi0.28-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.28-devel-0.28.3-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-ffi0.28-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.28-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.28-devel.sha256sum] = "c0a61e2fdf471fba4c91b89cbf2ce1880c9a1721eb749d48b4e3b27dd3fb1f0c"

RDEPENDS:rust-pyo3-ffi0.28+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py311-devel \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py312-devel \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py313-devel \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py314-devel \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28+abi3-py314-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-devel \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py38-devel \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py39-devel \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.28+abi3-py310-devel \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28+default-devel = " \
 cargo \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.28-devel \
 "
RDEPENDS:rust-pyo3-ffi0.28-devel = " \
 cargo \
 python3-devel \
 rust \
 rust-libc+default-devel \
 rust-pyo3-build-config0.28+default-devel \
 rust-pyo3-build-config0.28+resolve-config-devel \
 "
