# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16-pgvector"
PV = "0.6.2"
PR = "6.el10_0"
PACKAGES = " \
 pgvector \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-pgvector-0.6.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40e03e5dfce9b1f163062df460f7ec4bbfea0482351bcf6cdb718fb35e8a2d0d"

URI_x86_64_v2_pgvector = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pgvector-0.6.2-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_pgvector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pgvector}"
SRC_URI[x86_64_v2_pgvector.sha256sum] = "1f40663114519b789aa34c29133c2752482d127966ff5b56d50cd9adf4be52a6"

URI_aarch64_pgvector = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pgvector-0.6.2-6.el10_0.aarch64.rpm;name=aarch64_pgvector;unpack=0"
SRC_URI:append = " ${URI_aarch64_pgvector}"
SRC_URI[aarch64_pgvector.sha256sum] = "c625005dee385a413c4c1d01be9ca4ccf9932d68d005b51616aaf45a44203d27"

RDEPENDS:pgvector = " \
 glibc \
 postgresql-server \
 "
