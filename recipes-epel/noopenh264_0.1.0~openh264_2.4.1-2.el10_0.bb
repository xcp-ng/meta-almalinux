# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "noopenh264"
PV = "0.1.0~openh264_2.4.1"
PR = "2.el10_0"
PACKAGES = " \
 noopenh264 \
 noopenh264-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/noopenh264-0.1.0~openh264_2.4.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b8f8d2776bfc80aafca9e2fd709a060de7bd3f2c309a080a55d73a970dbe303"

URI_x86_64_v2_noopenh264 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/noopenh264-0.1.0~openh264_2.4.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_noopenh264;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_noopenh264}"
SRC_URI[x86_64_v2_noopenh264.sha256sum] = "d80c5db19cf96140f8cc5b72a8efc25734ffc4f9ff50766448ce349c0624d4cd"

URI_x86_64_v2_noopenh264-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/noopenh264-devel-0.1.0~openh264_2.4.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_noopenh264-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_noopenh264-devel}"
SRC_URI[x86_64_v2_noopenh264-devel.sha256sum] = "9a693fe61138404cd66bfb2d156e0ddadd33239d360457a2a64aa3fca15e49bc"

URI_aarch64_noopenh264 = "${EPEL_MIRROR}/aarch64/Packages/n/noopenh264-0.1.0~openh264_2.4.1-2.el10_0.aarch64.rpm;name=aarch64_noopenh264;unpack=0"
SRC_URI:append = " ${URI_aarch64_noopenh264}"
SRC_URI[aarch64_noopenh264.sha256sum] = "c093a28364f140cc51e9de757c2497a01036ce744e08c0beb24f0387cd280c9c"

URI_aarch64_noopenh264-devel = "${EPEL_MIRROR}/aarch64/Packages/n/noopenh264-devel-0.1.0~openh264_2.4.1-2.el10_0.aarch64.rpm;name=aarch64_noopenh264-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_noopenh264-devel}"
SRC_URI[aarch64_noopenh264-devel.sha256sum] = "ad974d54287bf7eb4ae7a4ea9d191517560b01acd0cda0920d611bda6bfe8187"

RDEPENDS:noopenh264 = " \
 glibc \
 "
RDEPENDS:noopenh264-devel = " \
 noopenh264 \
 pkgconf-pkg-config \
 "
