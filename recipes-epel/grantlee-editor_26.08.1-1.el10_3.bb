# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grantlee-editor"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 grantlee-editor \
 grantlee-editor-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/grantlee-editor-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fc80734449aa5b9ac7ed9749dbc0bd2c4219a9d95685cdd65a1638d0c252e123"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantlee-editor-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantlee-editor;unpack=0"
SRC_URI[x86_64_v2_grantlee-editor.sha256sum] = "17ee9208f34cc4f677a6f73729d1d1f6a05c0921e413a28cf892d759a67ab085"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantlee-editor-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantlee-editor-libs;unpack=0"
SRC_URI[x86_64_v2_grantlee-editor-libs.sha256sum] = "50a2c0f5feeefa9a2aa101a2c3be34b4d19086bfa2da7c7c2481c2d3421affee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/grantlee-editor-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_grantlee-editor;unpack=0"
SRC_URI[aarch64_grantlee-editor.sha256sum] = "6a2987f15f34194e2e6f098da25d2a53e065e31a19fd49bb4d7a462a538b6161"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/grantlee-editor-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_grantlee-editor-libs;unpack=0"
SRC_URI[aarch64_grantlee-editor-libs.sha256sum] = "e61046faaac3b102de90cdce73e8e387830864ef85bbb08da4bc9a3c08d6d8b9"

RDEPENDS:grantlee-editor = " \
 akonadi-contacts \
 glibc \
 grantlee-editor-libs \
 grantleetheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kmime \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:grantlee-editor-libs = " \
 glibc \
 grantlee-editor \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-syntax-highlighting \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
