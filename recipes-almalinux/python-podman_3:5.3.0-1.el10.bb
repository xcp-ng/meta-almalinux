# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-podman"
PE = "3"
PV = "5.3.0"
PR = "1.el10"
PACKAGES = " \
 python3-podman \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-podman-5.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12d14d6e849485d3ccdc34d6389cc3d48ee2a40b5ab506c4ca084d77e6f52cd4"

URI_x86_64_v2_python3-podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-podman-5.3.0-1.el10.noarch.rpm;name=x86_64_v2_python3-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-podman}"
SRC_URI[x86_64_v2_python3-podman.sha256sum] = "1ba9b4e63218ded6ac5a3c93f73281abba643e993533afab37bf7957de28a0fc"

URI_aarch64_python3-podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-podman-5.3.0-1.el10.noarch.rpm;name=aarch64_python3-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-podman}"
SRC_URI[aarch64_python3-podman.sha256sum] = "1ba9b4e63218ded6ac5a3c93f73281abba643e993533afab37bf7957de28a0fc"

RDEPENDS:python3-podman = " \
 python3 \
 python3-requests \
 python3-urllib3 \
 "
