# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-path-io"
PV = "1.8.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-path-io \
 ghc-path-io-devel \
 ghc-path-io-doc \
 ghc-path-io-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-path-io-1.8.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3bf548c0875dcaef1788b8c9a37bd827a7fe657885ca31e01cc741c8505809c"

URI_x86_64_v2_ghc-path-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-path-io-1.8.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-path-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-path-io}"
SRC_URI[x86_64_v2_ghc-path-io.sha256sum] = "77f90d3d5e605be6f303539e161c177d978951ee882a05ebdbe8ade00a9bd368"

URI_x86_64_v2_ghc-path-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-path-io-devel-1.8.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-path-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-path-io-devel}"
SRC_URI[x86_64_v2_ghc-path-io-devel.sha256sum] = "a45c3c2b3bf338f41825bbb4c14bb94a76caf60c90ddef5217b219603814b961"

URI_x86_64_v2_ghc-path-io-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-path-io-doc-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-path-io-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-path-io-doc}"
SRC_URI[x86_64_v2_ghc-path-io-doc.sha256sum] = "b8b69a38c8f1410ba1180ba718a1a87d3826e29ac207ffbd0b6874143d270a47"

URI_x86_64_v2_ghc-path-io-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-path-io-prof-1.8.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-path-io-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-path-io-prof}"
SRC_URI[x86_64_v2_ghc-path-io-prof.sha256sum] = "f782c9149140c81c7e5d42aade0855e3c549761935ec6b62d9dbf71f1773b252"

URI_aarch64_ghc-path-io = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-path-io-1.8.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-path-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-path-io}"
SRC_URI[aarch64_ghc-path-io.sha256sum] = "ff95f1c2d8d8960455a8f250e6e1e178e0a53cda915cac4dd47d62bb1f53f953"

URI_aarch64_ghc-path-io-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-path-io-devel-1.8.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-path-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-path-io-devel}"
SRC_URI[aarch64_ghc-path-io-devel.sha256sum] = "733afe8e0a89facd4fa93ee49bd8a4ba924f5ee551f7f29eff8b074184e46abc"

URI_aarch64_ghc-path-io-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-path-io-doc-1.8.2-1.el10_0.noarch.rpm;name=aarch64_ghc-path-io-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-path-io-doc}"
SRC_URI[aarch64_ghc-path-io-doc.sha256sum] = "c5f7c81ff5028b9bde3124b0a569fb476b95bba2b93b1b585676be781fa9e8b1"

URI_aarch64_ghc-path-io-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-path-io-prof-1.8.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-path-io-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-path-io-prof}"
SRC_URI[aarch64_ghc-path-io-prof.sha256sum] = "854347a18d00ffd7bd336263744c185f4ecc04b2298ca71e2d18a5c190dd9002"

RDEPENDS:ghc-path-io = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-path \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-temporary \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unix-compat \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-path-io-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-dlist-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-path-devel \
 ghc-path-io \
 ghc-temporary-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-compat-devel \
 "
RDEPENDS:ghc-path-io-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-path-io-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-dlist-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-path-io-devel \
 ghc-path-prof \
 ghc-temporary-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-compat-prof \
 "
