# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "udev-hid-bpf"
PV = "2.1.0.20240704"
PR = "5.el10"
PACKAGES = " \
 udev-hid-bpf \
 udev-hid-bpf-stable \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/udev-hid-bpf-2.1.0.20240704-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65b31cbeecac15e8c3852039f3125042654c51a8b2f89d27da7180a7ac887468"

URI_x86_64_v2_udev-hid-bpf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udev-hid-bpf-2.1.0.20240704-5.el10.x86_64_v2.rpm;name=x86_64_v2_udev-hid-bpf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udev-hid-bpf}"
SRC_URI[x86_64_v2_udev-hid-bpf.sha256sum] = "fccec0b11bfdfcaa59c55819798d37edd83de9efc97c12e72ee90b868ef7e371"

URI_x86_64_v2_udev-hid-bpf-stable = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udev-hid-bpf-stable-2.1.0.20240704-5.el10.x86_64_v2.rpm;name=x86_64_v2_udev-hid-bpf-stable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udev-hid-bpf-stable}"
SRC_URI[x86_64_v2_udev-hid-bpf-stable.sha256sum] = "2ca64248c137170b4282c331218632b57f8b6aef5f6970ae737b6304d73f10ac"

URI_aarch64_udev-hid-bpf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udev-hid-bpf-2.1.0.20240704-5.el10.aarch64.rpm;name=aarch64_udev-hid-bpf;unpack=0"
SRC_URI:append = " ${URI_aarch64_udev-hid-bpf}"
SRC_URI[aarch64_udev-hid-bpf.sha256sum] = "12be7718dc42852132e286557eb3ead9dad8343686478100662f633fe3dae3e7"

URI_aarch64_udev-hid-bpf-stable = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udev-hid-bpf-stable-2.1.0.20240704-5.el10.aarch64.rpm;name=aarch64_udev-hid-bpf-stable;unpack=0"
SRC_URI:append = " ${URI_aarch64_udev-hid-bpf-stable}"
SRC_URI[aarch64_udev-hid-bpf-stable.sha256sum] = "36dee0388fbdca5948457dea5b8c837f568f1243ab63110cb93fd4b484228d14"

RDEPENDS:udev-hid-bpf = " \
 elfutils-libelf \
 glibc \
 libgcc \
 systemd-libs \
 systemd-udev \
 udev-hid-bpf-stable \
 zlib-ng-compat \
 "
RDEPENDS:udev-hid-bpf-stable = " \
 udev-hid-bpf \
 "
