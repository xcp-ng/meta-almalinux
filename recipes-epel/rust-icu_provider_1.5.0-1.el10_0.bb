# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_provider"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-icu_provider+datagen-devel \
 rust-icu_provider+default-devel \
 rust-icu_provider+deserialize_bincode_1-devel \
 rust-icu_provider+deserialize_json-devel \
 rust-icu_provider+experimental-devel \
 rust-icu_provider+log_error_context-devel \
 rust-icu_provider+logging-devel \
 rust-icu_provider+macros-devel \
 rust-icu_provider+serde-devel \
 rust-icu_provider+std-devel \
 rust-icu_provider+sync-devel \
 rust-icu_provider-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_provider-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c2729a893c6b0950d23e511501fadd1e8f7fb8836b9266eaba690ca1310235a"

URI_x86_64_v2_rust-icu_provider+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+datagen-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+datagen-devel.sha256sum] = "b9e4cd3d9c45ed7a8a722f7072bd76f3344f9dbcbf7117fc1b03ff94057050e7"

URI_x86_64_v2_rust-icu_provider+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+default-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+default-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+default-devel.sha256sum] = "bf06c696ed3c2a3cd37ca234b08ffc0187465be258d09a38bb704970cb6dd001"

URI_x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+deserialize_bincode_1-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel.sha256sum] = "eee335f302466b27ecde23d7285a3d6e40aeb6884b3eccf886e20a2b19d23aa9"

URI_x86_64_v2_rust-icu_provider+deserialize_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+deserialize_json-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+deserialize_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+deserialize_json-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+deserialize_json-devel.sha256sum] = "ecc75181cf64bcb49a24a657a983a205ae38e4fea5b88cbd482069b73889b541"

URI_x86_64_v2_rust-icu_provider+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+experimental-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+experimental-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+experimental-devel.sha256sum] = "8bca9aa903c88846fc9aa73c3526b7bbead83bd0d30bb6153ef528d75ae582ce"

URI_x86_64_v2_rust-icu_provider+log_error_context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+log_error_context-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+log_error_context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+log_error_context-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+log_error_context-devel.sha256sum] = "63a47e3b6cce32c317126fc108f18cd8d82287f69238db6dbff3907a0f3422d7"

URI_x86_64_v2_rust-icu_provider+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+logging-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+logging-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+logging-devel.sha256sum] = "2c3699e29e28df047348450862f5441bca3e4ced326c258548417615da317ab7"

URI_x86_64_v2_rust-icu_provider+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+macros-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+macros-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+macros-devel.sha256sum] = "c623c6ecadb22468e3d6a3354ee179ba47264bfa757128abacf2f2782ab23b72"

URI_x86_64_v2_rust-icu_provider+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+serde-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+serde-devel.sha256sum] = "2154d069598f7aa5f617724f0c49d8074f9b5265177650aedb70b6049f8d50e3"

URI_x86_64_v2_rust-icu_provider+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+std-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+std-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+std-devel.sha256sum] = "3d4b039a993891bb27d2507bbe07b45e26251b1ee3f93acfaedf3a7095c4feff"

URI_x86_64_v2_rust-icu_provider+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+sync-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+sync-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+sync-devel.sha256sum] = "742d76b221e15aa3a876be56d7eaa106d3aef4ad39d390309e76f39729f43498"

URI_x86_64_v2_rust-icu_provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider-devel}"
SRC_URI[x86_64_v2_rust-icu_provider-devel.sha256sum] = "be88bd18407d8356d1b374c45cdadd5dd6895c414e6ac433351f6563b1aecabd"

URI_aarch64_rust-icu_provider+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+datagen-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+datagen-devel}"
SRC_URI[aarch64_rust-icu_provider+datagen-devel.sha256sum] = "bd06afb77566e4874000a5d05abf616cf47c76534cef51a0190c69d9c27087ec"

URI_aarch64_rust-icu_provider+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+default-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+default-devel}"
SRC_URI[aarch64_rust-icu_provider+default-devel.sha256sum] = "98c3588545a8255e351f2db14c2700a2e4a77e1c71bac48998ad2af65fb40ed9"

URI_aarch64_rust-icu_provider+deserialize_bincode_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+deserialize_bincode_1-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+deserialize_bincode_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+deserialize_bincode_1-devel}"
SRC_URI[aarch64_rust-icu_provider+deserialize_bincode_1-devel.sha256sum] = "69453356a0337ddc90db621824e1776692f7f914de94e5fe142731469fdf32ab"

URI_aarch64_rust-icu_provider+deserialize_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+deserialize_json-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+deserialize_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+deserialize_json-devel}"
SRC_URI[aarch64_rust-icu_provider+deserialize_json-devel.sha256sum] = "7356bfb2175ecb8412c1de7a1884e0807c0d46602e23508b212c619539c363b7"

URI_aarch64_rust-icu_provider+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+experimental-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+experimental-devel}"
SRC_URI[aarch64_rust-icu_provider+experimental-devel.sha256sum] = "699c19160cd90bd84e22b01598525344acad148d3ecd448b944e83f09d03bcd8"

URI_aarch64_rust-icu_provider+log_error_context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+log_error_context-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+log_error_context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+log_error_context-devel}"
SRC_URI[aarch64_rust-icu_provider+log_error_context-devel.sha256sum] = "1d38e41d41327ad01e87961e0d073e0b4b23b06120c3977f92f74c0cd7c31611"

URI_aarch64_rust-icu_provider+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+logging-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+logging-devel}"
SRC_URI[aarch64_rust-icu_provider+logging-devel.sha256sum] = "3e7a0c4ce0abdd3035ded8360863d10396dde6f94ac08be3e639623324c7943b"

URI_aarch64_rust-icu_provider+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+macros-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+macros-devel}"
SRC_URI[aarch64_rust-icu_provider+macros-devel.sha256sum] = "417c66e0eb0d56caac583450a1d415650a039b32ac0479641b6edac2a8290215"

URI_aarch64_rust-icu_provider+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+serde-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+serde-devel}"
SRC_URI[aarch64_rust-icu_provider+serde-devel.sha256sum] = "1c3eb6917208b04d322da6ec07b875c10e3e21f5251479e5d6e542b49220e5da"

URI_aarch64_rust-icu_provider+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+std-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+std-devel}"
SRC_URI[aarch64_rust-icu_provider+std-devel.sha256sum] = "5e51b18e73a0123fbb670b845c8d132c96e79406c604be47437fb3dc0bb531b2"

URI_aarch64_rust-icu_provider+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+sync-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+sync-devel}"
SRC_URI[aarch64_rust-icu_provider+sync-devel.sha256sum] = "4e69a5b3283bc91dfc7bad28e100691b66988b0edde96a1f54924e3e00478a82"

URI_aarch64_rust-icu_provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider-devel}"
SRC_URI[aarch64_rust-icu_provider-devel.sha256sum] = "8cc8fa872b11b29b3aa157231512963ebb19b3fbf118566f88e66e682c301a03"

RDEPENDS:rust-icu_provider+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-erased-serde0.3+alloc-devel \
 rust-erased-serde0.3+default-devel \
 rust-icu_provider+serde-devel \
 rust-icu_provider+std-devel \
 rust-icu_provider+sync-devel \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+default-devel = " \
 cargo \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+deserialize_bincode_1-devel = " \
 cargo \
 rust-bincode+default-devel \
 rust-icu_provider+serde-devel \
 rust-icu_provider+std-devel \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+deserialize_json-devel = " \
 cargo \
 rust-icu_provider+serde-devel \
 rust-icu_provider-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-icu_provider+experimental-devel = " \
 cargo \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+log_error_context-devel = " \
 cargo \
 rust-icu_provider+logging-devel \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+logging-devel = " \
 cargo \
 rust-icu_provider-devel \
 rust-log-devel \
 "
RDEPENDS:rust-icu_provider+macros-devel = " \
 cargo \
 rust-icu_provider-devel \
 rust-icu_provider_macros-devel \
 "
RDEPENDS:rust-icu_provider+serde-devel = " \
 cargo \
 rust-icu_provider-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-yoke+serde-devel \
 "
RDEPENDS:rust-icu_provider+std-devel = " \
 cargo \
 rust-icu_locid+std-devel \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+sync-devel = " \
 cargo \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-icu_locid-devel \
 rust-stable_deref_trait-devel \
 rust-tinystr-devel \
 rust-writeable-devel \
 rust-yoke+alloc-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerofrom+alloc-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 rust-zerovec+derive-devel \
 rust-zerovec-devel \
 "
