# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-syndication"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-syndication \
 kf6-syndication-devel \
 kf6-syndication-doc \
 kf6-syndication-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-syndication-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e1131af9b832ad0bb5e518633c335eba7d7e8b625583834215a984fcb6c2da3"

URI_x86_64_v2_kf6-syndication = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syndication;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication}"
SRC_URI[x86_64_v2_kf6-syndication.sha256sum] = "a22285acd5392e8e6e911dde33f9f82700d14b10a1ec6a8b01ea7d13ea27710c"

URI_x86_64_v2_kf6-syndication-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syndication-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication-devel}"
SRC_URI[x86_64_v2_kf6-syndication-devel.sha256sum] = "396e34d539630bd1e6df2453eb3abcb501129d85a365ba2818275e03c1463761"

URI_x86_64_v2_kf6-syndication-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syndication-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication-doc}"
SRC_URI[x86_64_v2_kf6-syndication-doc.sha256sum] = "26fd3d885d90ec05f2a4ee26ef3b271dadf70fd95d7c54684f5213d58ebc648e"

URI_x86_64_v2_kf6-syndication-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syndication-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication-html}"
SRC_URI[x86_64_v2_kf6-syndication-html.sha256sum] = "d88778ed25ada347174749718960678f088b87df9fa13fb2488bedc288484a12"

URI_aarch64_kf6-syndication = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-syndication;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication}"
SRC_URI[aarch64_kf6-syndication.sha256sum] = "7a26f147ee209c5694538b22df2fd709bc554b7dc08758946de38fbbdf1d052f"

URI_aarch64_kf6-syndication-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-syndication-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication-devel}"
SRC_URI[aarch64_kf6-syndication-devel.sha256sum] = "c1c1607cb2aa45664792a783cdc25717d490ed408722c5b5a2f450d1582e5fa8"

URI_aarch64_kf6-syndication-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-syndication-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication-doc}"
SRC_URI[aarch64_kf6-syndication-doc.sha256sum] = "9d5b948e1cd950858d0df1aea1e4e7e176331b93f0380e0e86244c0dc17328d9"

URI_aarch64_kf6-syndication-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-syndication-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication-html}"
SRC_URI[aarch64_kf6-syndication-html.sha256sum] = "2dc60a02358fb08a0ea135405683bd3a3c7636186f6bfaa29ab32f50ca65a729"

RDEPENDS:kf6-syndication = " \
 glibc \
 kf6-filesystem \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-syndication-devel = " \
 cmake-filesystem \
 kf6-syndication \
 "
RDEPENDS:kf6-syndication-doc = " \
 "
RDEPENDS:kf6-syndication-html = " \
 "
