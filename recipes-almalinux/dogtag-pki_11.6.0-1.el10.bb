# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dogtag-pki"
PV = "11.6.0"
PR = "1.el10"
PACKAGES = " \
 idm-pki-acme \
 idm-pki-base \
 idm-pki-ca \
 idm-pki-java \
 idm-pki-kra \
 idm-pki-server \
 idm-pki-tools \
 python3-idm-pki \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dogtag-pki-11.6.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4278d102eedc519aa1be41fc64f014924e32abeeb49b5090eaea5ab59ce29975"

URI_x86_64_v2_idm-pki-acme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-acme-11.6.0-1.el10.noarch.rpm;name=x86_64_v2_idm-pki-acme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-acme}"
SRC_URI[x86_64_v2_idm-pki-acme.sha256sum] = "0859d7e497939f50c123813aba5ab4ac23fc302bd6c25b2ad4162a588b05bf3c"

URI_x86_64_v2_idm-pki-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-base-11.6.0-1.el10.noarch.rpm;name=x86_64_v2_idm-pki-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-base}"
SRC_URI[x86_64_v2_idm-pki-base.sha256sum] = "dfd92c0e03a82be669d4a815d58a2e48e4c0ef6d52e0a1ce25f459fffaa7bf22"

URI_x86_64_v2_idm-pki-ca = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-ca-11.6.0-1.el10.noarch.rpm;name=x86_64_v2_idm-pki-ca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-ca}"
SRC_URI[x86_64_v2_idm-pki-ca.sha256sum] = "e67767a5e6195a08eb5f4613a1f92d5006855983eb3390b35cb16c8f2a23c145"

URI_x86_64_v2_idm-pki-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-java-11.6.0-1.el10.noarch.rpm;name=x86_64_v2_idm-pki-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-java}"
SRC_URI[x86_64_v2_idm-pki-java.sha256sum] = "a4676580e22e44de5b5a93a1f74352a1855bc5d7d30d8eb8a31c2d74e51c7041"

URI_x86_64_v2_idm-pki-kra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-kra-11.6.0-1.el10.noarch.rpm;name=x86_64_v2_idm-pki-kra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-kra}"
SRC_URI[x86_64_v2_idm-pki-kra.sha256sum] = "c976fd99119bbef7ed6ce46102699486847b114a43141b678c1ee1e639dde694"

URI_x86_64_v2_idm-pki-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-server-11.6.0-1.el10.noarch.rpm;name=x86_64_v2_idm-pki-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-server}"
SRC_URI[x86_64_v2_idm-pki-server.sha256sum] = "2311f08e8b5e6e1c48b27f89553363a280cf826ad0aa99f73b0ef5411f8c9014"

URI_x86_64_v2_idm-pki-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-tools-11.6.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_idm-pki-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-tools}"
SRC_URI[x86_64_v2_idm-pki-tools.sha256sum] = "30d9eeeb409543fd8de26bdd7ad61f50d16f3c488108ef8b1c0239aea210ad29"

URI_x86_64_v2_python3-idm-pki = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-idm-pki-11.6.0-1.el10.noarch.rpm;name=x86_64_v2_python3-idm-pki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-idm-pki}"
SRC_URI[x86_64_v2_python3-idm-pki.sha256sum] = "b587a2f30e0bc7ee501dad7aea575d54c7eba7277cb3428a99b58dab986616f5"

URI_aarch64_idm-pki-acme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-acme-11.6.0-1.el10.noarch.rpm;name=aarch64_idm-pki-acme;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-acme}"
SRC_URI[aarch64_idm-pki-acme.sha256sum] = "0859d7e497939f50c123813aba5ab4ac23fc302bd6c25b2ad4162a588b05bf3c"

URI_aarch64_idm-pki-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-base-11.6.0-1.el10.noarch.rpm;name=aarch64_idm-pki-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-base}"
SRC_URI[aarch64_idm-pki-base.sha256sum] = "dfd92c0e03a82be669d4a815d58a2e48e4c0ef6d52e0a1ce25f459fffaa7bf22"

URI_aarch64_idm-pki-ca = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-ca-11.6.0-1.el10.noarch.rpm;name=aarch64_idm-pki-ca;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-ca}"
SRC_URI[aarch64_idm-pki-ca.sha256sum] = "e67767a5e6195a08eb5f4613a1f92d5006855983eb3390b35cb16c8f2a23c145"

URI_aarch64_idm-pki-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-java-11.6.0-1.el10.noarch.rpm;name=aarch64_idm-pki-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-java}"
SRC_URI[aarch64_idm-pki-java.sha256sum] = "a4676580e22e44de5b5a93a1f74352a1855bc5d7d30d8eb8a31c2d74e51c7041"

URI_aarch64_idm-pki-kra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-kra-11.6.0-1.el10.noarch.rpm;name=aarch64_idm-pki-kra;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-kra}"
SRC_URI[aarch64_idm-pki-kra.sha256sum] = "c976fd99119bbef7ed6ce46102699486847b114a43141b678c1ee1e639dde694"

URI_aarch64_idm-pki-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-server-11.6.0-1.el10.noarch.rpm;name=aarch64_idm-pki-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-server}"
SRC_URI[aarch64_idm-pki-server.sha256sum] = "2311f08e8b5e6e1c48b27f89553363a280cf826ad0aa99f73b0ef5411f8c9014"

URI_aarch64_idm-pki-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-tools-11.6.0-1.el10.aarch64.rpm;name=aarch64_idm-pki-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-tools}"
SRC_URI[aarch64_idm-pki-tools.sha256sum] = "8221530989848dee9d5901b6a32cb0251ef5db230e10918f716d346618e9096a"

URI_aarch64_python3-idm-pki = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-idm-pki-11.6.0-1.el10.noarch.rpm;name=aarch64_python3-idm-pki;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-idm-pki}"
SRC_URI[aarch64_python3-idm-pki.sha256sum] = "b587a2f30e0bc7ee501dad7aea575d54c7eba7277cb3428a99b58dab986616f5"

RDEPENDS:idm-pki-acme = " \
 bash \
 idm-pki-server \
 "
RDEPENDS:idm-pki-base = " \
 bash \
 nss \
 python3-idm-pki \
 "
RDEPENDS:idm-pki-ca = " \
 bash \
 idm-pki-server \
 systemd \
 "
RDEPENDS:idm-pki-java = " \
 apache-commons-cli \
 apache-commons-codec \
 apache-commons-io \
 apache-commons-lang3 \
 apache-commons-logging \
 apache-commons-net \
 httpcomponents-client \
 idm-jss \
 idm-ldapjdk \
 idm-pki-base \
 java-21-openjdk-headless \
 slf4j \
 slf4j-jdk14 \
 "
RDEPENDS:idm-pki-kra = " \
 bash \
 idm-pki-server \
 systemd \
 "
RDEPENDS:idm-pki-server = " \
 bash \
 hostname \
 idm-jss-tomcat \
 idm-pki-tools \
 ipa-healthcheck-core \
 java-21-openjdk-devel \
 keyutils \
 openldap-clients \
 openssl \
 policycoreutils \
 policycoreutils-python-utils \
 procps-ng \
 python3 \
 python3-libselinux \
 python3-lxml \
 python3-policycoreutils \
 selinux-policy-targeted \
 shadow-utils \
 systemd \
 tomcat9 \
 "
RDEPENDS:idm-pki-tools = " \
 bash \
 file \
 glibc \
 idm-pki-java \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-tools \
 openldap \
 openldap-clients \
 openssl \
 p11-kit-trust \
 "
RDEPENDS:python3-idm-pki = " \
 idm-pki-base \
 python3 \
 python3-cryptography \
 python3-ldap \
 python3-lxml \
 python3-requests \
 python3-six \
 "
