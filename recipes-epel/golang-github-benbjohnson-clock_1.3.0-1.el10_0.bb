# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-benbjohnson-clock"
PV = "1.3.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-benbjohnson-clock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-benbjohnson-clock-1.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c492bf9db20a645ff4957b8a48e225a3dbed772a2dad98b90884fe508c44af08"

URI_x86_64_v2_golang-github-benbjohnson-clock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-benbjohnson-clock-devel-1.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-benbjohnson-clock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-benbjohnson-clock-devel}"
SRC_URI[x86_64_v2_golang-github-benbjohnson-clock-devel.sha256sum] = "3de2403b6876ab983c4f77895086d03c0947278bfe5cf7f9a01dbf361b7f5488"

URI_aarch64_golang-github-benbjohnson-clock-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-benbjohnson-clock-devel-1.3.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-benbjohnson-clock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-benbjohnson-clock-devel}"
SRC_URI[aarch64_golang-github-benbjohnson-clock-devel.sha256sum] = "365198a033af25d05efb62008a8371436264313d771fc13c5537f64a6c4afbfd"

RDEPENDS:golang-github-benbjohnson-clock-devel = " \
 go-filesystem \
 "
