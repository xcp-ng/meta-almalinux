# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-ostree"
PE = "1"
PV = "225"
PR = "1.el10"
PACKAGES = " \
 cockpit-ostree \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-ostree-225-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4693b1776c45057e0a633c82d32d94370018edb4ec00fd782b421de3938f9523"

URI_x86_64_v2_cockpit-ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-ostree-225-1.el10.noarch.rpm;name=x86_64_v2_cockpit-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-ostree}"
SRC_URI[x86_64_v2_cockpit-ostree.sha256sum] = "7e3f8d713a60399d0de5989605efc8a283d433f90436d9a32fc47022a5e0a385"

URI_aarch64_cockpit-ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-ostree-225-1.el10.noarch.rpm;name=aarch64_cockpit-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-ostree}"
SRC_URI[aarch64_cockpit-ostree.sha256sum] = "7e3f8d713a60399d0de5989605efc8a283d433f90436d9a32fc47022a5e0a385"

RDEPENDS:cockpit-ostree = " \
 cockpit-bridge \
 cockpit-system \
 rpm-ostree \
 "
