# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-beautifulsoup4"
PV = "4.14.3"
PR = "1.el10_1"
PACKAGES = " \
 python3-beautifulsoup4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-beautifulsoup4-4.14.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f5bc5270f8b9087d6c57f1fd1d1460f447dad421f32002e74bc871a8e317ab9"

URI_x86_64_v2_python3-beautifulsoup4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-beautifulsoup4-4.14.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-beautifulsoup4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-beautifulsoup4}"
SRC_URI[x86_64_v2_python3-beautifulsoup4.sha256sum] = "111dc96e768ed8ce2eb8d3df821a12c4390eb39aa8367fa64fc563917fb055b5"

URI_aarch64_python3-beautifulsoup4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-beautifulsoup4-4.14.3-1.el10_1.noarch.rpm;name=aarch64_python3-beautifulsoup4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-beautifulsoup4}"
SRC_URI[aarch64_python3-beautifulsoup4.sha256sum] = "4cabd39a8169a56f977c625bd7635473cacbbbe8a15fb37d5c34672777a04629"

RDEPENDS:python3-beautifulsoup4 = " \
 python3 \
 python3-lxml \
 python3-soupsieve \
 python3-typing-extensions \
 "
