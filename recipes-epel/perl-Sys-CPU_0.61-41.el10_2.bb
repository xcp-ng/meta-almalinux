# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-CPU"
PV = "0.61"
PR = "41.el10_2"
PACKAGES = " \
 perl-Sys-CPU \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-CPU-0.61-41.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c1bbada76419b3fbf58796ca626589f73c75b85cc4c1bdc369e70848a0e04b8"

URI_x86_64_v2_perl-Sys-CPU = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-CPU-0.61-41.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-CPU;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-CPU}"
SRC_URI[x86_64_v2_perl-Sys-CPU.sha256sum] = "625aa62f8f46548b2a2b84db75fc0cf9f55150d666ce19c28030d372ce259cde"

URI_aarch64_perl-Sys-CPU = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-CPU-0.61-41.el10_2.aarch64.rpm;name=aarch64_perl-Sys-CPU;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-CPU}"
SRC_URI[aarch64_perl-Sys-CPU.sha256sum] = "589863c7241b5a79902559bbfeef67d1fde7c3b7fc272a46e8ca3cd1aca8cf1f"

RDEPENDS:perl-Sys-CPU = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
