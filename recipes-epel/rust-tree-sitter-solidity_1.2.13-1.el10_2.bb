# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-solidity"
PV = "1.2.13"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-solidity+default-devel \
 rust-tree-sitter-solidity-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-solidity-1.2.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c5f1f8f93778f2747c54fd7dd8b5430b6272a4e071e9ae95eed87f0e1b8e2a3"

URI_x86_64_v2_rust-tree-sitter-solidity+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-solidity+default-devel-1.2.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-solidity+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-solidity+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-solidity+default-devel.sha256sum] = "081d8de2f755113ea1b626fecb20b20fd6a82ee24ea82fd40924c30be3bd93e8"

URI_x86_64_v2_rust-tree-sitter-solidity-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-solidity-devel-1.2.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-solidity-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-solidity-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-solidity-devel.sha256sum] = "0f26638366b6aa57eec1e6767fcd4224b889d95aa94eff3da3d042ce8d8f32dc"

URI_aarch64_rust-tree-sitter-solidity+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-solidity+default-devel-1.2.13-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-solidity+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-solidity+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-solidity+default-devel.sha256sum] = "5e407bd271830f2d8c1c8d979784830aef7210c120fc1e0e1f419a09ca66f9f9"

URI_aarch64_rust-tree-sitter-solidity-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-solidity-devel-1.2.13-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-solidity-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-solidity-devel}"
SRC_URI[aarch64_rust-tree-sitter-solidity-devel.sha256sum] = "da608250cabc13f8ae10229b0c9554a9813baa26397d6dfebea11441b50a72de"

RDEPENDS:rust-tree-sitter-solidity+default-devel = " \
 cargo \
 rust-tree-sitter-solidity-devel \
 "
RDEPENDS:rust-tree-sitter-solidity-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
