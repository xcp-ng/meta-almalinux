# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sympa"
PV = "6.2.80"
PR = "1.el10_2"
PACKAGES = " \
 sympa \
 sympa-devel-doc \
 sympa-httpd \
 sympa-lighttpd \
 sympa-nginx \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sympa-6.2.80-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "046bf29e043eb84b6c070c6e176bd4dbb3b094ddbbd0d4d187605109acb04d52"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-6.2.80-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sympa;unpack=0"
SRC_URI[x86_64_v2_sympa.sha256sum] = "793eead9810956d543988e05e6f08091b6caf9e0408dee5e52a23b37074c4ed0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-devel-doc-6.2.80-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-devel-doc;unpack=0"
SRC_URI[x86_64_v2_sympa-devel-doc.sha256sum] = "741c71d267196f0d0450e7a4b67771f1a6350dc6acd7d09fcb0da0a7eb72d518"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-httpd-6.2.80-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-httpd;unpack=0"
SRC_URI[x86_64_v2_sympa-httpd.sha256sum] = "7869ef84878881d506a66cf16de988b03b9686cc322bfecb5b5ef007834ab672"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-lighttpd-6.2.80-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-lighttpd;unpack=0"
SRC_URI[x86_64_v2_sympa-lighttpd.sha256sum] = "ce75e8ae0e4b75732f5eb9999a15b52b572dbb3e157d16cd1dd7ce1679864f89"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-nginx-6.2.80-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-nginx;unpack=0"
SRC_URI[x86_64_v2_sympa-nginx.sha256sum] = "05be015229b9647ceebb4b8d9d513e929fe78aaebcc9625675ebedec8d2c2fdc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sympa-6.2.80-1.el10_2.aarch64.rpm;name=aarch64_sympa;unpack=0"
SRC_URI[aarch64_sympa.sha256sum] = "ca5d805b0092132a2ecf405b568cdb47586c95af649c06d634da2af37621798f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sympa-devel-doc-6.2.80-1.el10_2.noarch.rpm;name=aarch64_sympa-devel-doc;unpack=0"
SRC_URI[aarch64_sympa-devel-doc.sha256sum] = "85d1807505f1b675ff3e1264ded8ead4eb215fb24c8944b3a4dea0cf6acec4c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sympa-httpd-6.2.80-1.el10_2.noarch.rpm;name=aarch64_sympa-httpd;unpack=0"
SRC_URI[aarch64_sympa-httpd.sha256sum] = "25fb0da866c256e911bb38bf7b7e49e29c4aa2bd42f0c4f8ddfdfd422ea93661"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sympa-lighttpd-6.2.80-1.el10_2.noarch.rpm;name=aarch64_sympa-lighttpd;unpack=0"
SRC_URI[aarch64_sympa-lighttpd.sha256sum] = "5be773a89117d68424dc7c40dd9bbef675968cb17041a4a1abe66ce78b6b17e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sympa-nginx-6.2.80-1.el10_2.noarch.rpm;name=aarch64_sympa-nginx;unpack=0"
SRC_URI[aarch64_sympa-nginx.sha256sum] = "38f358a194a206876f363aa05ebb400756dc28bf060ec91f6c5572f75353bfba"

RDEPENDS:sympa = " \
 bash \
 glibc \
 js-jquery \
 js-jquery-ui \
 logrotate \
 mhonarc \
 perl-Archive-Zip-SimpleZip \
 perl-AuthCAS \
 perl-CGI \
 perl-CGI-Fast \
 perl-Carp \
 perl-Class-Singleton \
 perl-Clone \
 perl-Crypt-CipherSaber \
 perl-Crypt-Eksblowfish \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-SMIME \
 perl-DBD-CSV \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Data-Dumper \
 perl-Data-Password \
 perl-DateTime \
 perl-DateTime-Format-Mail \
 perl-DateTime-TimeZone \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Encode-EUCJPASCII \
 perl-Encode-HanExtra \
 perl-Encode-Locale \
 perl-English \
 perl-FCGI \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Copy-Recursive \
 perl-File-Find \
 perl-File-NFSLock \
 perl-File-Path \
 perl-Getopt-Long \
 perl-HTML-Formatter \
 perl-HTML-Parser \
 perl-HTML-StripScripts-Parser \
 perl-HTML-Tree \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-IO-stringy \
 perl-LDAP \
 perl-LWP-Protocol-https \
 perl-MIME-Base64 \
 perl-MIME-Charset \
 perl-MIME-EncWords \
 perl-MIME-Lite-HTML \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-MailTools \
 perl-Net-CIDR \
 perl-Net-DNS \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-SOAP-Lite \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Template-Toolkit \
 perl-Term-ProgressBar \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-URI \
 perl-URI-Find \
 perl-Unicode-LineBreak \
 perl-Unicode-Normalize \
 perl-Unicode-UTF8 \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libintl-perl \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 perl-parent \
 shadow-utils \
 sympa \
 systemd \
 virtual/smtpdaemon \
 "
RDEPENDS:sympa-devel-doc = " \
 sympa \
 "
RDEPENDS:sympa-httpd = " \
 bash \
 httpd \
 multiwatch \
 sympa \
 "
RDEPENDS:sympa-lighttpd = " \
 lighttpd \
 lighttpd-fastcgi \
 sympa \
 "
RDEPENDS:sympa-nginx = " \
 bash \
 multiwatch \
 nginx \
 sympa \
 "
