# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-pass"
PV = "1.2.2"
PR = "1.el10_0"
PACKAGES = " \
 plasma-pass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-pass-1.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2a9e4a6094e4e18a57984856a49fbc340eb03c63467fbcb7aa4f98d43b839bb"

URI_x86_64_v2_plasma-pass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-pass-1.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-pass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-pass}"
SRC_URI[x86_64_v2_plasma-pass.sha256sum] = "0e3bc171a6cfa28d2bc0e7ca1d4a38a57fc9e328997d93d408cc42de95c45c70"

URI_aarch64_plasma-pass = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-pass-1.2.2-1.el10_0.aarch64.rpm;name=aarch64_plasma-pass;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-pass}"
SRC_URI[aarch64_plasma-pass.sha256sum] = "92a16dacc63ad13f8ea5457e82d5f33807626f3a3afd80cc7eb80a1188b4fdf6"

RDEPENDS:plasma-pass = " \
 glibc \
 gnupg2 \
 gpgmepp \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 liboath \
 libstdc++ \
 plasma-desktop \
 plasma5support \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
