# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jmhodges-clock"
PV = "1.2.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-jmhodges-clock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jmhodges-clock-1.2.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "250277160644032089851ec80e76fcbc379faa4e8e14973034ec5f1e205dec2c"

URI_x86_64_v2_golang-github-jmhodges-clock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jmhodges-clock-devel-1.2.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jmhodges-clock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jmhodges-clock-devel}"
SRC_URI[x86_64_v2_golang-github-jmhodges-clock-devel.sha256sum] = "30234d6c84f47371fcfc4e487073164bd7cae23c66c45b98b8825c72d4d80698"

URI_aarch64_golang-github-jmhodges-clock-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jmhodges-clock-devel-1.2.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-jmhodges-clock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jmhodges-clock-devel}"
SRC_URI[aarch64_golang-github-jmhodges-clock-devel.sha256sum] = "4540520c16a4f297dd5ae6af6adbdca12a068b2f3b42d029da17643ddf46ac2a"

RDEPENDS:golang-github-jmhodges-clock-devel = " \
 go-filesystem \
 "
