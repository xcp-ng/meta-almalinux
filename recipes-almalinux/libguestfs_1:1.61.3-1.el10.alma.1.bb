# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libguestfs"
PE = "1"
PV = "1.61.3"
PR = "1.el10.alma.1"
PACKAGES = " \
 libguestfs \
 libguestfs-appliance \
 libguestfs-bash-completion \
 libguestfs-devel \
 libguestfs-inspect-icons \
 libguestfs-man-pages-ja \
 libguestfs-man-pages-uk \
 libguestfs-rescue \
 libguestfs-rsync \
 libguestfs-xfs \
 ocaml-libguestfs \
 ocaml-libguestfs-devel \
 perl-Sys-Guestfs \
 python3-libguestfs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libguestfs-1.61.3-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "596953bc4f7fe629f9559528330594cc7d8406a6bcb985a4e28202cd18440e38"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - libguestfs-appliance: augeas-libs
# - libguestfs: augeas-libs(x86-64) >= 1.7.0
# - ocaml-libguestfs-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs-devel: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libguestfs-devel: ocamlx(CamlinternalOO) = 3bb5173e1a86ae74d96d5b3bc80f14a3
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Array) = b3215f99afe054938b4b66df456093cb
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libguestfs: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - libguestfs-appliance: augeas-libs
# - libguestfs-appliance: libcap
# - libguestfs: augeas-libs(aarch-64) >= 1.7.0
# - libguestfs: libcap(aarch-64)
# - ocaml-libguestfs-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs-devel: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libguestfs-devel: ocamlx(CamlinternalOO) = 3bb5173e1a86ae74d96d5b3bc80f14a3
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Array) = b3215f99afe054938b4b66df456093cb
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libguestfs: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-1.61.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs;unpack=0"
SRC_URI[x86_64_v2_libguestfs.sha256sum] = "8fbce09e3e302591f5d87e858f50946aae3364ef8034be7d3277991115215e47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-appliance-1.61.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-appliance;unpack=0"
SRC_URI[x86_64_v2_libguestfs-appliance.sha256sum] = "d9358952979ef5351b22d34ab9a9690d88e1d6a4723781423774ac09ba5f6647"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-bash-completion-1.61.3-1.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-bash-completion;unpack=0"
SRC_URI[x86_64_v2_libguestfs-bash-completion.sha256sum] = "245ee2440f06e7b3a08f24eb635392892e8666bddc2acf20e40c91c265f620ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-devel-1.61.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-devel;unpack=0"
SRC_URI[x86_64_v2_libguestfs-devel.sha256sum] = "727f5478eedf2aad106a53af39ce6321c08afa0fc2e0031dec2b5954f2b45917"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-inspect-icons-1.61.3-1.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-inspect-icons;unpack=0"
SRC_URI[x86_64_v2_libguestfs-inspect-icons.sha256sum] = "a91a30dfad0110a27302493b9ab8c7895cbec4f22c2b6b39c049f74c3c5cbd64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-man-pages-ja-1.61.3-1.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-man-pages-ja;unpack=0"
SRC_URI[x86_64_v2_libguestfs-man-pages-ja.sha256sum] = "e353b23077be9d06370a4a16e8ec721944237c64e242039a77e0a01c833f8895"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-man-pages-uk-1.61.3-1.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-man-pages-uk;unpack=0"
SRC_URI[x86_64_v2_libguestfs-man-pages-uk.sha256sum] = "0f558022401342eabd4ea4cda95337695f685232b93fa45f7f89562595123aa1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-rescue-1.61.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-rescue;unpack=0"
SRC_URI[x86_64_v2_libguestfs-rescue.sha256sum] = "a05c81b6eb63548b5a9955cecad1a198ba833bc3893f9931f1e1cb9ac5456b45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-rsync-1.61.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-rsync;unpack=0"
SRC_URI[x86_64_v2_libguestfs-rsync.sha256sum] = "1fd5d4d2ba36a51f5c6e55f0482a8809a972e23bfb94687620dedb9a1bd34436"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-xfs-1.61.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-xfs;unpack=0"
SRC_URI[x86_64_v2_libguestfs-xfs.sha256sum] = "fdee19cd9b38f44a97ce17d9fd2ad3040ee47d22ad7e963f9f65919108ca8430"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libguestfs-1.61.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_ocaml-libguestfs;unpack=0"
SRC_URI[x86_64_v2_ocaml-libguestfs.sha256sum] = "6a3bb4fb01c9cba364e9e8a3501f45053ff3eb932a59cb72ca95a719a6ef3236"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libguestfs-devel-1.61.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_ocaml-libguestfs-devel;unpack=0"
SRC_URI[x86_64_v2_ocaml-libguestfs-devel.sha256sum] = "a7c4c3da1ab67bfc922833648dafe84514ae163ff8eb39f2c91b0ea3911d6003"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sys-Guestfs-1.61.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Guestfs;unpack=0"
SRC_URI[x86_64_v2_perl-Sys-Guestfs.sha256sum] = "992a41c5bfeeb69c9c883ccd69b72d1a7efb269c3eab5198ef4bd7c6f98634c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libguestfs-1.61.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-libguestfs;unpack=0"
SRC_URI[x86_64_v2_python3-libguestfs.sha256sum] = "442f6ba990f540dc932d17858aa78b81a2aa4f1dc7f454375fd45a638bdc9696"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-1.61.3-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs;unpack=0"
SRC_URI[aarch64_libguestfs.sha256sum] = "46b012a2f42508934e6f1a0f5aee710596a2b716174eefa77ae481e258f01b5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-appliance-1.61.3-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-appliance;unpack=0"
SRC_URI[aarch64_libguestfs-appliance.sha256sum] = "606b56e4719d1818be2ee94c2e0d389e5696d3aef32b7f0dac86e4444f2a2612"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-bash-completion-1.61.3-1.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-bash-completion;unpack=0"
SRC_URI[aarch64_libguestfs-bash-completion.sha256sum] = "245ee2440f06e7b3a08f24eb635392892e8666bddc2acf20e40c91c265f620ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-devel-1.61.3-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-devel;unpack=0"
SRC_URI[aarch64_libguestfs-devel.sha256sum] = "9e07c92ddad2d0ee18f9fea3cfc11501a3fcf59461e46fab0e121b6aac59d8aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-inspect-icons-1.61.3-1.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-inspect-icons;unpack=0"
SRC_URI[aarch64_libguestfs-inspect-icons.sha256sum] = "a91a30dfad0110a27302493b9ab8c7895cbec4f22c2b6b39c049f74c3c5cbd64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-man-pages-ja-1.61.3-1.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-man-pages-ja;unpack=0"
SRC_URI[aarch64_libguestfs-man-pages-ja.sha256sum] = "e353b23077be9d06370a4a16e8ec721944237c64e242039a77e0a01c833f8895"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-man-pages-uk-1.61.3-1.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-man-pages-uk;unpack=0"
SRC_URI[aarch64_libguestfs-man-pages-uk.sha256sum] = "0f558022401342eabd4ea4cda95337695f685232b93fa45f7f89562595123aa1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-rescue-1.61.3-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-rescue;unpack=0"
SRC_URI[aarch64_libguestfs-rescue.sha256sum] = "43a6173420022f1fa3594e08054ce404b82b37d5df960db5f10132fe30abd58e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-rsync-1.61.3-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-rsync;unpack=0"
SRC_URI[aarch64_libguestfs-rsync.sha256sum] = "e32eb7f55d1f473c4afc783e5bbfa893742b43ace13a96dd685f0d619f2385d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-xfs-1.61.3-1.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-xfs;unpack=0"
SRC_URI[aarch64_libguestfs-xfs.sha256sum] = "f91ca8c2d6ca45c05efa57ad4b34716bdebb3938faef18a823e31ca634d2b18f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libguestfs-1.61.3-1.el10.alma.1.aarch64.rpm;name=aarch64_ocaml-libguestfs;unpack=0"
SRC_URI[aarch64_ocaml-libguestfs.sha256sum] = "49578584d03a86f6a5f7d65ff92fdb9307ed8d372cd0aebf0edf60b57fad0e63"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libguestfs-devel-1.61.3-1.el10.alma.1.aarch64.rpm;name=aarch64_ocaml-libguestfs-devel;unpack=0"
SRC_URI[aarch64_ocaml-libguestfs-devel.sha256sum] = "f28fa0e7828d96e4a0c252b2995c9ec0857ed9dee05bb8ae6770793eab503706"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sys-Guestfs-1.61.3-1.el10.alma.1.aarch64.rpm;name=aarch64_perl-Sys-Guestfs;unpack=0"
SRC_URI[aarch64_perl-Sys-Guestfs.sha256sum] = "2a6628f3bc9e39595ab71310310c30ae3cf7ed955f1e9482c73358a9b454fb41"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libguestfs-1.61.3-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-libguestfs;unpack=0"
SRC_URI[aarch64_python3-libguestfs.sha256sum] = "f7909076a549931371a921af2781ae8042c4b0dea569fc618341e2af32ad577f"

RDEPENDS:libguestfs:x86_64_v2 = " \
 bash \
 fuse \
 fuse-libs \
 glibc \
 grep \
 hexedit \
 hivex-libs \
 json-c \
 less \
 libacl \
 libcap \
 libconfig \
 libgcc \
 libguestfs-appliance \
 libselinux \
 libtirpc \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 libxml2 \
 ncurses-libs \
 passt \
 pcre2 \
 qemu-img \
 qemu-kvm-core \
 readline \
 rpm-libs \
 selinux-policy \
 systemd-libs \
 tar \
 vim-minimal \
 virtual//usr/bin/man \
 virtual/coreutils \
 xz \
"
RDEPENDS:libguestfs:aarch64 = " \
 bash \
 edk2-aarch64 \
 fuse \
 fuse-libs \
 glibc \
 grep \
 hexedit \
 hivex-libs \
 json-c \
 less \
 libacl \
 libconfig \
 libgcc \
 libguestfs-appliance \
 libselinux \
 libtirpc \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 libxml2 \
 ncurses-libs \
 passt \
 pcre2 \
 qemu-img \
 qemu-kvm-core \
 readline \
 rpm-libs \
 selinux-policy \
 systemd-libs \
 tar \
 vim-minimal \
 virtual//usr/bin/man \
 virtual/coreutils \
 xz \
"
RDEPENDS:libguestfs-appliance:x86_64_v2 = " \
 acl \
 attr \
 bash \
 binutils \
 bzip2 \
 clevis-luks \
 cpio \
 cryptsetup \
 dhcpcd \
 diffutils \
 dosfstools \
 e2fsprogs \
 file \
 findutils \
 gawk \
 glibc \
 glibc-gconv-extra \
 grep \
 gzip \
 hivex-libs \
 iproute \
 json-c \
 kmod \
 less \
 libacl \
 libcap \
 libgcc \
 libselinux \
 libtirpc \
 libxml2 \
 lsscsi \
 lvm2 \
 lzop \
 mdadm \
 parted \
 pcre2 \
 policycoreutils \
 procps-ng \
 psmisc \
 rpm-libs \
 scrub \
 sed \
 supermin \
 systemd \
 systemd-libs \
 systemd-udev \
 tar \
 util-linux \
 virtual/coreutils \
 virtual/kernel \
 xz \
 zstd \
"
RDEPENDS:libguestfs-appliance:aarch64 = " \
 acl \
 attr \
 bash \
 binutils \
 bzip2 \
 clevis-luks \
 cpio \
 cryptsetup \
 dhcpcd \
 diffutils \
 dosfstools \
 e2fsprogs \
 file \
 findutils \
 gawk \
 glibc \
 glibc-gconv-extra \
 grep \
 gzip \
 hivex-libs \
 iproute \
 json-c \
 kmod \
 less \
 libacl \
 libgcc \
 libselinux \
 libtirpc \
 libxml2 \
 lsscsi \
 lvm2 \
 lzop \
 mdadm \
 parted \
 pcre2 \
 policycoreutils \
 procps-ng \
 psmisc \
 rpm-libs \
 scrub \
 sed \
 supermin \
 systemd \
 systemd-libs \
 systemd-udev \
 tar \
 util-linux \
 virtual/coreutils \
 virtual/kernel \
 xz \
 zstd \
"
RDEPENDS:libguestfs-bash-completion = " \
 bash-completion \
 "
RDEPENDS:libguestfs-devel = " \
 libguestfs \
 pkgconf-pkg-config \
 "
RDEPENDS:libguestfs-inspect-icons = " \
 icoutils \
 libguestfs \
 netpbm-progs \
 "
RDEPENDS:libguestfs-man-pages-ja = " \
 libguestfs \
 "
RDEPENDS:libguestfs-man-pages-uk = " \
 libguestfs \
 "
RDEPENDS:libguestfs-rescue = " \
 glibc \
 iputils \
 libconfig \
 libgcc \
 libguestfs \
 libxml2 \
 lsof \
 openssh-clients \
 pciutils \
 strace \
 vim-minimal \
 "
RDEPENDS:libguestfs-rsync = " \
 libguestfs \
 rsync \
 "
RDEPENDS:libguestfs-xfs = " \
 libguestfs \
 xfsprogs \
 "
RDEPENDS:ocaml-libguestfs = " \
 glibc \
 libguestfs \
 "
RDEPENDS:ocaml-libguestfs-devel = " \
 ocaml-libguestfs \
 "
RDEPENDS:perl-Sys-Guestfs = " \
 glibc \
 libguestfs \
 perl-libs \
 perl-vars \
 "
RDEPENDS:python3-libguestfs = " \
 glibc \
 libguestfs \
 python3 \
 "
