# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-kylelemons-godebug"
PV = "1.1.0"
PR = "17.el10_0"
PACKAGES = " \
 golang-github-kylelemons-godebug-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-kylelemons-godebug-1.1.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f722692ff347777b0def45d32cd1b5db5553d7dfeaaa8176eef79c51f604295"

URI_x86_64_v2_golang-github-kylelemons-godebug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-kylelemons-godebug-devel-1.1.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-kylelemons-godebug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-kylelemons-godebug-devel}"
SRC_URI[x86_64_v2_golang-github-kylelemons-godebug-devel.sha256sum] = "a84d795dca533c49e02807122ae03db5ab6ae7270d040437f38f31ee9c0172c9"

URI_aarch64_golang-github-kylelemons-godebug-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kylelemons-godebug-devel-1.1.0-17.el10_0.noarch.rpm;name=aarch64_golang-github-kylelemons-godebug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kylelemons-godebug-devel}"
SRC_URI[aarch64_golang-github-kylelemons-godebug-devel.sha256sum] = "53fb60bdc833060b006b54763bc2e7471b32bd607ddcec4aa2ad5be801767910"

RDEPENDS:golang-github-kylelemons-godebug-devel = " \
 go-filesystem \
 "
