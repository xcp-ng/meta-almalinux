# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-cli"
PV = "0.25.10"
PR = "2.el10_2"
PACKAGES = " \
 rust-tree-sitter-cli+default-devel \
 rust-tree-sitter-cli-devel \
 tree-sitter-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-cli-0.25.10-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2c19f82a40977b2a221255975de440fb4a7147eb96bcaed36558a3f969171e1"

URI_x86_64_v2_rust-tree-sitter-cli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cli+default-devel-0.25.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-cli+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-cli+default-devel.sha256sum] = "4f9a0c4f7630a7a1d31b22db42f1b1bcf0b3d6429803a6e29b62ad2a57b4b33a"

URI_x86_64_v2_rust-tree-sitter-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cli-devel-0.25.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-cli-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-cli-devel.sha256sum] = "9af7a6aa2109b953f7b61d6a98c7abd317e18d9a16f005230df8f93e79e6b8d6"

URI_x86_64_v2_tree-sitter-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tree-sitter-cli-0.25.10-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tree-sitter-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tree-sitter-cli}"
SRC_URI[x86_64_v2_tree-sitter-cli.sha256sum] = "1f8518caf3cd0a310788eead064ebed6c72f3e2b827cc82af3bd154eb6f87e90"

URI_aarch64_rust-tree-sitter-cli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cli+default-devel-0.25.10-2.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-cli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-cli+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-cli+default-devel.sha256sum] = "668622ebbe151a79adea3f15105865cdbda0797905b2c426cb27fa6170f254fe"

URI_aarch64_rust-tree-sitter-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cli-devel-0.25.10-2.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-cli-devel}"
SRC_URI[aarch64_rust-tree-sitter-cli-devel.sha256sum] = "c1fc8e78f471698f62c91bcb4b01d6a217b424ba24b0d3add83b95cb4f0c95ee"

URI_aarch64_tree-sitter-cli = "${EPEL_MIRROR}/aarch64/Packages/t/tree-sitter-cli-0.25.10-2.el10_2.aarch64.rpm;name=aarch64_tree-sitter-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_tree-sitter-cli}"
SRC_URI[aarch64_tree-sitter-cli.sha256sum] = "4a7c1a5ff0f6c2470b5271a379cd200862a12eadce053c4e189b5c72bfae9f92"

RDEPENDS:rust-tree-sitter-cli+default-devel = " \
 cargo \
 rust-tree-sitter-cli-devel \
 "
RDEPENDS:rust-tree-sitter-cli-devel = " \
 cargo \
 rust \
 rust-ansi_colours+default-devel \
 rust-anstyle+default-devel \
 rust-anyhow+default-devel \
 rust-bstr+default-devel \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+help-devel \
 rust-clap+unstable-styles-devel \
 rust-clap_complete+default-devel \
 rust-clap_complete_nushell+default-devel \
 rust-ctor+default-devel \
 rust-ctrlc+default-devel \
 rust-ctrlc+termination-devel \
 rust-dialoguer+default-devel \
 rust-dialoguer+fuzzy-select-devel \
 rust-filetime+default-devel \
 rust-glob+default-devel \
 rust-heck+default-devel \
 rust-html-escape+default-devel \
 rust-indexmap+default-devel \
 rust-indoc+default-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 rust-memchr+default-devel \
 rust-rand0.8+default-devel \
 rust-regex+default-devel \
 rust-regex-syntax+default-devel \
 rust-rustc-hash+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 rust-similar+default-devel \
 rust-smallbitvec+default-devel \
 rust-streaming-iterator+default-devel \
 rust-tiny_http+default-devel \
 rust-topological-sort+default-devel \
 rust-tree-sitter+default-devel \
 rust-tree-sitter-config+default-devel \
 rust-tree-sitter-generate+default-devel \
 rust-tree-sitter-highlight+default-devel \
 rust-tree-sitter-loader+default-devel \
 rust-tree-sitter-tags+default-devel \
 rust-url+default-devel \
 rust-url+serde-devel \
 rust-walkdir+default-devel \
 rust-wasmparser+default-devel \
 rust-webbrowser+default-devel \
 "
RDEPENDS:tree-sitter-cli = " \
 glibc \
 libgcc \
 "
