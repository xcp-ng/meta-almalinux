# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-form_urlencoded"
PV = "1.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-form_urlencoded+alloc-devel \
 rust-form_urlencoded+default-devel \
 rust-form_urlencoded+std-devel \
 rust-form_urlencoded-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-form_urlencoded-1.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92d40b3ceccb7e1913b111bea8f2d6c0c2586d4d06c532483ced1ef22dfa01b2"

URI_x86_64_v2_rust-form_urlencoded+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-form_urlencoded+alloc-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-form_urlencoded+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-form_urlencoded+alloc-devel}"
SRC_URI[x86_64_v2_rust-form_urlencoded+alloc-devel.sha256sum] = "d69b751a3ec163d8c41436826cc8b0bad2a31efdb5f89fd833d5feeb65030f7b"

URI_x86_64_v2_rust-form_urlencoded+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-form_urlencoded+default-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-form_urlencoded+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-form_urlencoded+default-devel}"
SRC_URI[x86_64_v2_rust-form_urlencoded+default-devel.sha256sum] = "aee78cc1267999933efd69acd04a8ce38d2c3cd7489f08ee1b0a3c4e61c4cfe5"

URI_x86_64_v2_rust-form_urlencoded+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-form_urlencoded+std-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-form_urlencoded+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-form_urlencoded+std-devel}"
SRC_URI[x86_64_v2_rust-form_urlencoded+std-devel.sha256sum] = "a007f142eef65e6c476fcdbf998c7153352158ed18eafd22c66090908b683c3e"

URI_x86_64_v2_rust-form_urlencoded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-form_urlencoded-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-form_urlencoded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-form_urlencoded-devel}"
SRC_URI[x86_64_v2_rust-form_urlencoded-devel.sha256sum] = "517f2837a51fa2eaee05e675effadaf137c1e2dc53acc6f7e0836e6608b6e756"

URI_aarch64_rust-form_urlencoded+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-form_urlencoded+alloc-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-form_urlencoded+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-form_urlencoded+alloc-devel}"
SRC_URI[aarch64_rust-form_urlencoded+alloc-devel.sha256sum] = "9245ed1379477f0c01389cfc37a98a41328f9daf6db30c30f27d82399d33510a"

URI_aarch64_rust-form_urlencoded+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-form_urlencoded+default-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-form_urlencoded+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-form_urlencoded+default-devel}"
SRC_URI[aarch64_rust-form_urlencoded+default-devel.sha256sum] = "4cbbdf76dffda9afc537f0e02a3a9db2343cd00096e6cbac457187858f300d0d"

URI_aarch64_rust-form_urlencoded+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-form_urlencoded+std-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-form_urlencoded+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-form_urlencoded+std-devel}"
SRC_URI[aarch64_rust-form_urlencoded+std-devel.sha256sum] = "db9e79c96afd22ba1986ebd45a6a1da931fd1b3241889fc5e303157540b07bf1"

URI_aarch64_rust-form_urlencoded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-form_urlencoded-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-form_urlencoded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-form_urlencoded-devel}"
SRC_URI[aarch64_rust-form_urlencoded-devel.sha256sum] = "3496a047847794ccddf7446c4c52080199701e0fa2cf6f571e36c67016f0f0a8"

RDEPENDS:rust-form_urlencoded+alloc-devel = " \
 cargo \
 rust-form_urlencoded-devel \
 rust-percent-encoding+alloc-devel \
 "
RDEPENDS:rust-form_urlencoded+default-devel = " \
 cargo \
 rust-form_urlencoded+std-devel \
 rust-form_urlencoded-devel \
 "
RDEPENDS:rust-form_urlencoded+std-devel = " \
 cargo \
 rust-form_urlencoded+alloc-devel \
 rust-form_urlencoded-devel \
 rust-percent-encoding+std-devel \
 "
RDEPENDS:rust-form_urlencoded-devel = " \
 cargo \
 rust \
 rust-percent-encoding-devel \
 "
