# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-fancyindex"
PV = "0.6.0"
PR = "1.el10_1"
PACKAGES = " \
 nginx-mod-fancyindex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-fancyindex-0.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9eb0af6baef255bbcad29f02824f16f13d9f2e994e32d6cac480eab68333e4db"

URI_x86_64_v2_nginx-mod-fancyindex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-fancyindex-0.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-fancyindex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-fancyindex}"
SRC_URI[x86_64_v2_nginx-mod-fancyindex.sha256sum] = "40e6fbb533c30da16d1a2634ccdb665c0679411dcf02b7a3026b90d211b2bb02"

URI_aarch64_nginx-mod-fancyindex = "${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-fancyindex-0.6.0-1.el10_1.aarch64.rpm;name=aarch64_nginx-mod-fancyindex;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-fancyindex}"
SRC_URI[aarch64_nginx-mod-fancyindex.sha256sum] = "f0e4993bf92e1a5af0027b7b29a1ed2621fc966dbcf4ddac649e7a6b97654502"

RDEPENDS:nginx-mod-fancyindex = " \
 glibc \
 nginx \
 "
