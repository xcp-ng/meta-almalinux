# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdbi"
PV = "0.9.0"
PR = "28.el10_1"
PACKAGES = " \
 libdbi \
 libdbi-devel \
 libdbi-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdbi-0.9.0-28.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c24b989af565642e78c4fcfda8b006bbe3f758c036aff424b45bbdbeb34749f9"

URI_x86_64_v2_libdbi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdbi-0.9.0-28.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdbi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdbi}"
SRC_URI[x86_64_v2_libdbi.sha256sum] = "d997cd2b189b1a1c6604455e0d29520f9c0fa6d8496c8e43ad81f3f272a1b926"

URI_x86_64_v2_libdbi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdbi-devel-0.9.0-28.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdbi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdbi-devel}"
SRC_URI[x86_64_v2_libdbi-devel.sha256sum] = "b91a1e273f9595cca2e028ff58ac44fed84d8a3412119891c1cfa689da75998d"

URI_x86_64_v2_libdbi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdbi-doc-0.9.0-28.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libdbi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdbi-doc}"
SRC_URI[x86_64_v2_libdbi-doc.sha256sum] = "c14bf6f51ec3b4bdc9a6f80b3b0693516b4fec3164861f462da338953af89193"

URI_aarch64_libdbi = "${EPEL_MIRROR}/aarch64/Packages/l/libdbi-0.9.0-28.el10_1.aarch64.rpm;name=aarch64_libdbi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdbi}"
SRC_URI[aarch64_libdbi.sha256sum] = "d6dca9561a8073ce4de9dfe8f82948e787a315280a7a35a69d5be9e2d571c738"

URI_aarch64_libdbi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdbi-devel-0.9.0-28.el10_1.aarch64.rpm;name=aarch64_libdbi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdbi-devel}"
SRC_URI[aarch64_libdbi-devel.sha256sum] = "8382a5f1ddbc11233461337e2b40ba490c457752e016157698dc647b03af7633"

URI_aarch64_libdbi-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libdbi-doc-0.9.0-28.el10_1.noarch.rpm;name=aarch64_libdbi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdbi-doc}"
SRC_URI[aarch64_libdbi-doc.sha256sum] = "eedf0c9400781540f79fb6c1c893547f7b3b1fd58f6a6753a6ce5c5589dd279f"

RDEPENDS:libdbi = " \
 glibc \
 "
RDEPENDS:libdbi-devel = " \
 libdbi \
 pkgconf-pkg-config \
 "
RDEPENDS:libdbi-doc = " \
 "
