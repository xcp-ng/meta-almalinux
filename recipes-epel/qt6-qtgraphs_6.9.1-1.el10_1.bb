# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtgraphs"
PV = "6.9.1"
PR = "1.el10_1"
PACKAGES = " \
 qt6-qtgraphs \
 qt6-qtgraphs-devel \
 qt6-qtgraphs-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtgraphs-6.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fd6cf78ab08c4f79aaac45ecefd58ea77bcf73b8fcce049ee3929685949ad58"

URI_x86_64_v2_qt6-qtgraphs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgraphs-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgraphs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgraphs}"
SRC_URI[x86_64_v2_qt6-qtgraphs.sha256sum] = "ab6ff93d9e9133f683ba7b7e369a0c50314825f8803ec8d5a549690880208387"

URI_x86_64_v2_qt6-qtgraphs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgraphs-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgraphs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgraphs-devel}"
SRC_URI[x86_64_v2_qt6-qtgraphs-devel.sha256sum] = "595a7ce5fa38f0fe4c15514aa91b414c2277ddfedf187b635beb83fd5220dc4c"

URI_x86_64_v2_qt6-qtgraphs-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgraphs-examples-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgraphs-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgraphs-examples}"
SRC_URI[x86_64_v2_qt6-qtgraphs-examples.sha256sum] = "4731bb4a0d74fce89318c95dc2b1704df45a56375a4108750eeff0d6a6b1d454"

URI_aarch64_qt6-qtgraphs = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgraphs-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtgraphs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgraphs}"
SRC_URI[aarch64_qt6-qtgraphs.sha256sum] = "63e4ee731f6acc3f427bb7a59227cc73572e284c7f9de5566a5a01ca19f7d80f"

URI_aarch64_qt6-qtgraphs-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgraphs-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtgraphs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgraphs-devel}"
SRC_URI[aarch64_qt6-qtgraphs-devel.sha256sum] = "db92c292bfbc8c5733f3a207bd3e4ec5eedd9c876c057a189c74488cbb5e67b6"

URI_aarch64_qt6-qtgraphs-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgraphs-examples-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtgraphs-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgraphs-examples}"
SRC_URI[aarch64_qt6-qtgraphs-examples.sha256sum] = "802677976c73e81bcb6e6040385f1b890fb9c4e9030cc2ebc0b9f2eabbb5d906"

RDEPENDS:qt6-qtgraphs = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 "
RDEPENDS:qt6-qtgraphs-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtgraphs \
 qt6-qtgraphs-devel \
 qt6-qtquick3d-devel \
 "
RDEPENDS:qt6-qtgraphs-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtgraphs \
 qt6-qtquick3d \
 "
