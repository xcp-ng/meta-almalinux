# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Encode-JIS2K"
PV = "0.05"
PR = "9.el10_3"
PACKAGES = " \
 perl-Encode-JIS2K \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Encode-JIS2K-0.05-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fdf1afc6a479f913eaf81a2deb1f6fd37cb1b5dc9a32fc6558a927884a85f46"

URI_x86_64_v2_perl-Encode-JIS2K = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Encode-JIS2K-0.05-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Encode-JIS2K;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Encode-JIS2K}"
SRC_URI[x86_64_v2_perl-Encode-JIS2K.sha256sum] = "7777e8012c0d79557f1580d7eadafeced548845b5ee63b9b3244a714c09bd3e5"

URI_aarch64_perl-Encode-JIS2K = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Encode-JIS2K-0.05-9.el10_3.aarch64.rpm;name=aarch64_perl-Encode-JIS2K;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Encode-JIS2K}"
SRC_URI[aarch64_perl-Encode-JIS2K.sha256sum] = "62023ca16cd4a2ac47a8a6e46cadbfe3bb2281d6f7d30f11c514158a258fcc1f"

RDEPENDS:perl-Encode-JIS2K = " \
 glibc \
 perl-Encode \
 perl-Encode-JIS2K \
 perl-base \
 perl-libs \
 "
