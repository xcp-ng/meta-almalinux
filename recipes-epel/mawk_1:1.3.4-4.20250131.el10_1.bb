# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mawk"
PE = "1"
PV = "1.3.4"
PR = "4.20250131.el10_1"
PACKAGES = " \
 mawk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mawk-1.3.4-4.20250131.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da1dedb9d3dc0591bf428d9e82fd8d50c0218a2247b1da9fabca8b3b91dba7e9"

URI_x86_64_v2_mawk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mawk-1.3.4-4.20250131.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mawk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mawk}"
SRC_URI[x86_64_v2_mawk.sha256sum] = "5b80e49e9f7c3d95525d8a100ca6ff265f82d72dce0f6f426836449609d1b7e2"

URI_aarch64_mawk = "${EPEL_MIRROR}/aarch64/Packages/m/mawk-1.3.4-4.20250131.el10_1.aarch64.rpm;name=aarch64_mawk;unpack=0"
SRC_URI:append = " ${URI_aarch64_mawk}"
SRC_URI[aarch64_mawk.sha256sum] = "d0880a2329a14b3a5883cdc8134ecdcf51c8a41fde39bdc3721562767fdb4ee5"

RDEPENDS:mawk = " \
 glibc \
 "
