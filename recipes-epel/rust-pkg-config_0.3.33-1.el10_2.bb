# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pkg-config"
PV = "0.3.33"
PR = "1.el10_2"
PACKAGES = " \
 rust-pkg-config+default-devel \
 rust-pkg-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pkg-config-0.3.33-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45038ac91c466dea5842e5806d8fd457b7378c35720e167e8705ec907ec9ca45"

URI_x86_64_v2_rust-pkg-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config+default-devel-0.3.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkg-config+default-devel}"
SRC_URI[x86_64_v2_rust-pkg-config+default-devel.sha256sum] = "9872d8023b6a8c097556b264139f5d0dc5636a578e5b51988d0a8cfb30d0118b"

URI_x86_64_v2_rust-pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config-devel-0.3.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkg-config-devel}"
SRC_URI[x86_64_v2_rust-pkg-config-devel.sha256sum] = "1c8a7a776392cb4eee1adadb362b7bd73b97896f3c303b2d12647290a3643e0c"

URI_aarch64_rust-pkg-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config+default-devel-0.3.33-1.el10_2.noarch.rpm;name=aarch64_rust-pkg-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkg-config+default-devel}"
SRC_URI[aarch64_rust-pkg-config+default-devel.sha256sum] = "4f59f2685c708c9b29df10584723bb251bf4790be2fa23b154db3480a7b2c96e"

URI_aarch64_rust-pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config-devel-0.3.33-1.el10_2.noarch.rpm;name=aarch64_rust-pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkg-config-devel}"
SRC_URI[aarch64_rust-pkg-config-devel.sha256sum] = "2173d2c43c3a45a8dcf8743722b6960c089d38dfc643781f587bd71be1b14a16"

RDEPENDS:rust-pkg-config+default-devel = " \
 cargo \
 rust-pkg-config-devel \
 "
RDEPENDS:rust-pkg-config-devel = " \
 cargo \
 pkgconf-pkg-config \
 rust \
 "
