# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-idna_adapter"
PV = "1.2.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-idna_adapter+compiled_data-devel \
 rust-idna_adapter+default-devel \
 rust-idna_adapter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-idna_adapter-1.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b85baea35633206190eea8c9384e6baff54566d1e368b4e400c09c20adb99932"

URI_x86_64_v2_rust-idna_adapter+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter+compiled_data-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter+compiled_data-devel.sha256sum] = "d73511b8c92bd2c6647ccd589f92551ee6fa3bf49a34081f3d8d929c39d48360"

URI_x86_64_v2_rust-idna_adapter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter+default-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter+default-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter+default-devel.sha256sum] = "46b6feb52574bd0e86f514aa3d127ce456a9ac2f141f6931ba7d31b6f31a75cb"

URI_x86_64_v2_rust-idna_adapter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter-devel-1.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter-devel.sha256sum] = "faeb69c21ef537b21f4fa35dc924cacf2f3fa1737224ad4110dc513514f826fb"

URI_aarch64_rust-idna_adapter+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter+compiled_data-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-idna_adapter+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter+compiled_data-devel}"
SRC_URI[aarch64_rust-idna_adapter+compiled_data-devel.sha256sum] = "8935e5974a8542bdcb1bef84bf2650cf71c0c63f37dbe225739a74233ced2c32"

URI_aarch64_rust-idna_adapter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter+default-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-idna_adapter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter+default-devel}"
SRC_URI[aarch64_rust-idna_adapter+default-devel.sha256sum] = "913ab9eb221cbbbf923f1e30d1217ac733901d0f2c7f4c3c6d3c9707c54c8c89"

URI_aarch64_rust-idna_adapter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter-devel-1.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-idna_adapter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter-devel}"
SRC_URI[aarch64_rust-idna_adapter-devel.sha256sum] = "107d5b5c435850a95d766ef32f02aab674e9c9717841b5641b1747e8ac303c2d"

RDEPENDS:rust-idna_adapter+compiled_data-devel = " \
 cargo \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_properties+compiled_data-devel \
 rust-idna_adapter-devel \
 "
RDEPENDS:rust-idna_adapter+default-devel = " \
 cargo \
 rust-idna_adapter-devel \
 "
RDEPENDS:rust-idna_adapter-devel = " \
 cargo \
 rust \
 rust-icu_normalizer-devel \
 rust-icu_properties-devel \
 "
