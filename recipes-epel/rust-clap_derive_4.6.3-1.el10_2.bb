# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_derive"
PV = "4.6.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-clap_derive+debug-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive+raw-deprecated-devel \
 rust-clap_derive+unstable-markdown-devel \
 rust-clap_derive+unstable-v5-devel \
 rust-clap_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_derive-4.6.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "decb308105ace71ea003942bb8d1664d3b9e690447d80f4c0736de71717350e4"

URI_x86_64_v2_rust-clap_derive+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+debug-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+debug-devel.sha256sum] = "cf3d689fcabe61fc6f9a3dbb15038ef35acec6c7ce1dcd666713588dbb0ef52e"

URI_x86_64_v2_rust-clap_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+default-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+default-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+default-devel.sha256sum] = "cd68d7c49d446fa191a5057969e1a240df442b161a6eb996ed065cdf5891dec4"

URI_x86_64_v2_rust-clap_derive+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+deprecated-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+deprecated-devel.sha256sum] = "6615c104bc0bfbab8a572932dfa46de87f5c17bd68701aae342ee1aee6e7c5c4"

URI_x86_64_v2_rust-clap_derive+raw-deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+raw-deprecated-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+raw-deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+raw-deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+raw-deprecated-devel.sha256sum] = "d076fe422b38dfeca33a2478bfdaa9836ad804a733daed5ee1fa4dcdcb8998ec"

URI_x86_64_v2_rust-clap_derive+unstable-markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+unstable-markdown-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+unstable-markdown-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+unstable-markdown-devel.sha256sum] = "565057ee102dc726d820e590214959d683a02f5fcd9f19b12b743b9d08bd9736"

URI_x86_64_v2_rust-clap_derive+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+unstable-v5-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+unstable-v5-devel.sha256sum] = "3e2e85bbffa2917b7a5b8ce4e9ea87fef40d0b768dca92b89c63d471b7a6c257"

URI_x86_64_v2_rust-clap_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive-devel-4.6.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive-devel}"
SRC_URI[x86_64_v2_rust-clap_derive-devel.sha256sum] = "e00019e58eb115b916f54a8c8207b3b70df6def67ac545ccbbf15f4ce9a293e7"

URI_aarch64_rust-clap_derive+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+debug-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap_derive+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+debug-devel}"
SRC_URI[aarch64_rust-clap_derive+debug-devel.sha256sum] = "4b848a497be18db470012e4bd3a0dfc5580680506ba9e2e9f779c0932a89511d"

URI_aarch64_rust-clap_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+default-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+default-devel}"
SRC_URI[aarch64_rust-clap_derive+default-devel.sha256sum] = "cfc01a77eedd507a9767baa39f7e631759f4826bd8bca2171310ad71e482963c"

URI_aarch64_rust-clap_derive+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+deprecated-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap_derive+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+deprecated-devel}"
SRC_URI[aarch64_rust-clap_derive+deprecated-devel.sha256sum] = "c05e42b6d84070c747d1e8a4044930775ef4ee328449d39fd83f9e682c50abe2"

URI_aarch64_rust-clap_derive+raw-deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+raw-deprecated-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap_derive+raw-deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+raw-deprecated-devel}"
SRC_URI[aarch64_rust-clap_derive+raw-deprecated-devel.sha256sum] = "3b6b25c58404e8dfd6dd3fc0fb8796385b397e702498d8f6113e80a9629161a4"

URI_aarch64_rust-clap_derive+unstable-markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+unstable-markdown-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap_derive+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+unstable-markdown-devel}"
SRC_URI[aarch64_rust-clap_derive+unstable-markdown-devel.sha256sum] = "a4d29c33c4b7de9219fca58d5364cf27210b6df3296f67e4657ab932bddb48da"

URI_aarch64_rust-clap_derive+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+unstable-v5-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap_derive+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap_derive+unstable-v5-devel.sha256sum] = "0e75181e12abc42759b3c789cf483d5aa9e0250d8448d47b2391d5eb84e753bd"

URI_aarch64_rust-clap_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive-devel-4.6.3-1.el10_2.noarch.rpm;name=aarch64_rust-clap_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive-devel}"
SRC_URI[aarch64_rust-clap_derive-devel.sha256sum] = "04bb71ab30eaa052e2fefa4d5ba8125e698dfeaf3f5ed2ba4b9485da7c0e3277"

RDEPENDS:rust-clap_derive+debug-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+default-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+deprecated-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+raw-deprecated-devel = " \
 cargo \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+unstable-markdown-devel = " \
 cargo \
 rust-anstyle+default-devel \
 rust-clap_derive-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-clap_derive+unstable-v5-devel = " \
 cargo \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
