# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-keystoneclient"
PE = "1"
PV = "5.8.0"
PR = "2.el10_3"
PACKAGES = " \
 python-keystoneclient-doc \
 python3-keystoneclient \
 python3-keystoneclient-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-keystoneclient-5.8.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8084352dd06491cc8953ab683151b9aa1d657f0a7a5daccd3d10269fe234e13"

URI_x86_64_v2_python-keystoneclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-keystoneclient-doc-5.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-keystoneclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-keystoneclient-doc}"
SRC_URI[x86_64_v2_python-keystoneclient-doc.sha256sum] = "64b39828ec5f8799ed775fe03818cddd79a3bab55cc3e6a94f282f0a1b6845ba"

URI_x86_64_v2_python3-keystoneclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneclient-5.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneclient}"
SRC_URI[x86_64_v2_python3-keystoneclient.sha256sum] = "5d53829a8efb79049f1ac6ca411316de200a063c68310dfc96e4e99ad09a235e"

URI_x86_64_v2_python3-keystoneclient-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneclient-tests-5.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneclient-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneclient-tests}"
SRC_URI[x86_64_v2_python3-keystoneclient-tests.sha256sum] = "5c4b898b7d259c94b4560041cbed7f4f11339334080c8acd13b4562c529f1e4c"

URI_aarch64_python-keystoneclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-keystoneclient-doc-5.8.0-2.el10_3.noarch.rpm;name=aarch64_python-keystoneclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-keystoneclient-doc}"
SRC_URI[aarch64_python-keystoneclient-doc.sha256sum] = "af025a396b7dd7a31b08a71a809fb810d7cb41804ff340e4ecc0231f36afc033"

URI_aarch64_python3-keystoneclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneclient-5.8.0-2.el10_3.noarch.rpm;name=aarch64_python3-keystoneclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneclient}"
SRC_URI[aarch64_python3-keystoneclient.sha256sum] = "f5d0cc9759663797c3b526a4874fa806d9e746bf2b94d364a1cd954eb7eb9a58"

URI_aarch64_python3-keystoneclient-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneclient-tests-5.8.0-2.el10_3.noarch.rpm;name=aarch64_python3-keystoneclient-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneclient-tests}"
SRC_URI[aarch64_python3-keystoneclient-tests.sha256sum] = "20f06b2cb3f3dc05b36f22c1b3a4a8426cdddc60bdc7a838c42fda5e505b5a95"

RDEPENDS:python-keystoneclient-doc = " \
 "
RDEPENDS:python3-keystoneclient = " \
 python3 \
 python3-debtcollector \
 python3-keyring \
 python3-keystoneauth1 \
 python3-oslo-config \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-packaging \
 python3-pbr \
 python3-requests \
 python3-stevedore \
 "
RDEPENDS:python3-keystoneclient-tests = " \
 python3 \
 python3-keystoneclient \
 "
