# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-json"
PV = "1.3.4"
PR = "8.el10_0"
PACKAGES = " \
 lua-json \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-json-1.3.4-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c8b5f0ba2d44337d3e3da0ce80a47679ae9691e6abe3f7f993a58059da27418"

URI_x86_64_v2_lua-json = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-json-1.3.4-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lua-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-json}"
SRC_URI[x86_64_v2_lua-json.sha256sum] = "bb6295c15e80a4a2185205de6656eed0bbf2b525691dbc4f51197fc41f880561"

URI_aarch64_lua-json = "${EPEL_MIRROR}/aarch64/Packages/l/lua-json-1.3.4-8.el10_0.noarch.rpm;name=aarch64_lua-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-json}"
SRC_URI[aarch64_lua-json.sha256sum] = "6042a9ec65f52d19e4d3463974bd6a8ce1f1e0cbae846a6f1cae9f94f946555d"

RDEPENDS:lua-json = " \
 lua-libs \
 lua-lpeg \
 "
