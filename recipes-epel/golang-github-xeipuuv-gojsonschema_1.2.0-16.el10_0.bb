# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-xeipuuv-gojsonschema"
PV = "1.2.0"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-xeipuuv-gojsonschema-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-xeipuuv-gojsonschema-1.2.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1948231e9b0676166830a6e8ad6201a8d1ea945e247665324137f5d5d4d45d9a"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-xeipuuv-gojsonschema-devel: golang(github.com/xeipuuv/gojsonreference)

URI_x86_64_v2_golang-github-xeipuuv-gojsonschema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-xeipuuv-gojsonschema-devel-1.2.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-xeipuuv-gojsonschema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-xeipuuv-gojsonschema-devel}"
SRC_URI[x86_64_v2_golang-github-xeipuuv-gojsonschema-devel.sha256sum] = "98d101a82a5b99dc0a608236af16dbcb3e85004f0587917f899cdc1a48a120fe"

URI_aarch64_golang-github-xeipuuv-gojsonschema-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-xeipuuv-gojsonschema-devel-1.2.0-16.el10_0.noarch.rpm;name=aarch64_golang-github-xeipuuv-gojsonschema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-xeipuuv-gojsonschema-devel}"
SRC_URI[aarch64_golang-github-xeipuuv-gojsonschema-devel.sha256sum] = "2ed8529f8308cd7473456c6db6ecfdc600ac74fd592ff5a7fda161d96caa5f63"

RDEPENDS:golang-github-xeipuuv-gojsonschema-devel:x86_64_v2 = " \
 go-filesystem \
"
RDEPENDS:golang-github-xeipuuv-gojsonschema-devel:aarch64 = " \
 go-filesystem \
 golang-github-xeipuuv-gojsonreference-devel \
"
