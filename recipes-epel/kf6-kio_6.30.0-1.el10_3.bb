# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kio"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kio \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kio-devel \
 kf6-kio-doc \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-html \
 kf6-kio-qch-doc \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kio-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4a4b43f0817ad3600f06c5e29eb6ba1f645f519c4f8a253c4e1f41914b1d15e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio;unpack=0"
SRC_URI[x86_64_v2_kf6-kio.sha256sum] = "c591ff61dec5f8ab04f8d0ed3b59de66a216f92f2164c77326ff16cfb79765e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-core-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-core;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-core.sha256sum] = "cf73c5dd6cae5ec3421e09c6f97e817ba467622cba1ac5c889397b4610c55f3d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-core-libs-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-core-libs;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-core-libs.sha256sum] = "af72189b7a6347bb2d8655eb639e7f8c0201e3fc24962d224c560758e6dfc8f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-devel.sha256sum] = "04530e1329e26eb06bc537f87f3e501fa6ddaf51805a99e379861e2dfd373526"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-doc.sha256sum] = "0a4b46188be52b28446bbf76aa6c1b29ddd05628248a76a424aba9f9c50e03f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-file-widgets-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-file-widgets;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-file-widgets.sha256sum] = "21902c6113169adc767e8339c40e3e240041d3ea578b987ad56e9f1c84c74045"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-gui-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-gui;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-gui.sha256sum] = "c189c8b02bad42c80e836c1f8feda5ce1a86a0effab694e1b01da4c454d22f4f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-html.sha256sum] = "9e9f6e3c34688f7bbae561d31db3a2f19b98449d24a2bec67fa404067662667c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-qch-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-qch-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-qch-doc.sha256sum] = "8c6d365f55383a2c334f99fafc76aee26ea9e82c7c5a1dc51c63f6c9871a6bb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-widgets-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-widgets;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-widgets.sha256sum] = "1a67adface0c859c6d85d75a6f0ee14f1933039d77da5178ca59054a27efc36d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-widgets-libs-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-widgets-libs;unpack=0"
SRC_URI[x86_64_v2_kf6-kio-widgets-libs.sha256sum] = "d40172957b0de4dd4f2332962f2c72bb87ee396dff06fbb04188f50d9c897b28"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio;unpack=0"
SRC_URI[aarch64_kf6-kio.sha256sum] = "ea324d4ca57f298f7d692c0fd6cb60b94b7f5e15874ea49fdd60c1c37cde6b6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-core-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-core;unpack=0"
SRC_URI[aarch64_kf6-kio-core.sha256sum] = "7927270a1dd3e6dc884242fe4f25f40ca00cf010de86d35c19746ad8e1d7d27c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-core-libs-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-core-libs;unpack=0"
SRC_URI[aarch64_kf6-kio-core-libs.sha256sum] = "927f7219f2286a47f9b22f27fd9e57ce1446723773661e4c2fcf92f5fff014c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-devel;unpack=0"
SRC_URI[aarch64_kf6-kio-devel.sha256sum] = "b037730cf06d0251850023fcf36999ab4bc0e155015aa0b55be347e27f3659dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kio-doc;unpack=0"
SRC_URI[aarch64_kf6-kio-doc.sha256sum] = "44826dc778add649f576a8fae1fed7cd7f225984bfed0dfbb250d093463b5e86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-file-widgets-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-file-widgets;unpack=0"
SRC_URI[aarch64_kf6-kio-file-widgets.sha256sum] = "107743557e192f266c662ea8605dcf5b547db046886f063d07cbd75465accbf7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-gui-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-gui;unpack=0"
SRC_URI[aarch64_kf6-kio-gui.sha256sum] = "38904527d1661827cd1e05476410712608e53ee1c030e3b1635314991f859c63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kio-html;unpack=0"
SRC_URI[aarch64_kf6-kio-html.sha256sum] = "3dcec9bc65e32c416b009d127f429d78ecec37c63a922342c6886050fc7291b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-qch-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kio-qch-doc;unpack=0"
SRC_URI[aarch64_kf6-kio-qch-doc.sha256sum] = "98d8d2fbfaaf440fbc342e36c82db41e90b204021c685039d6ac9097ee14d921"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-widgets-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-widgets;unpack=0"
SRC_URI[aarch64_kf6-kio-widgets.sha256sum] = "7e13c9a8a5b10dba681fe1d50673c02e3ce5d705388b4654a469f99bbde6b7be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-widgets-libs-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-widgets-libs;unpack=0"
SRC_URI[aarch64_kf6-kio-widgets-libs.sha256sum] = "b22b8504192e1a58e17cb830f68ffee3a7957deed117d28dc571c3689980209c"

RDEPENDS:kf6-kio = " \
 kf6-kded \
 kf6-kio-core \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets \
 "
RDEPENDS:kf6-kio-core = " \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdoctools \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-doc \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libacl \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-core-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kservice \
 libacl \
 libmount \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kio-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kbookmarks-devel \
 kf6-kcompletion-devel \
 kf6-kconfig-devel \
 kf6-kcoreaddons-devel \
 kf6-kio \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemviews-devel \
 kf6-kjobwidgets-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 kf6-kxmlgui-devel \
 kf6-solid-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-doc = " \
 kf6-kio-core \
 "
RDEPENDS:kf6-kio-file-widgets = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-gui = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-html = " \
 "
RDEPENDS:kf6-kio-qch-doc = " \
 "
RDEPENDS:kf6-kio-widgets = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kio-widgets-libs = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
