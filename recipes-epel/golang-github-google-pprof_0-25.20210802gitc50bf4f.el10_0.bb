# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-google-pprof"
PV = "0"
PR = "25.20210802gitc50bf4f.el10_0"
PACKAGES = " \
 golang-github-google-pprof \
 golang-github-google-pprof-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-google-pprof-0-25.20210802gitc50bf4f.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cdc223a5ceacec72911b12a04f4becd09082d4fede15299e6c80cdc28dd08b0"

URI_aarch64_golang-github-google-pprof = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-google-pprof-0-25.20210802gitc50bf4f.el10_0.aarch64.rpm;name=aarch64_golang-github-google-pprof;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-google-pprof}"
SRC_URI[aarch64_golang-github-google-pprof.sha256sum] = "4b01892c68b2430fd36c69f7b4694a08beeb1225dbc2d9e1d34558d9659b38a0"

URI_aarch64_golang-github-google-pprof-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-google-pprof-devel-0-25.20210802gitc50bf4f.el10_0.noarch.rpm;name=aarch64_golang-github-google-pprof-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-google-pprof-devel}"
SRC_URI[aarch64_golang-github-google-pprof-devel.sha256sum] = "4d226326f4d9de17371ec22ad440829eb7ec942d2904d22a118f4ba10af9a406"

RDEPENDS:golang-github-google-pprof = " \
 glibc \
 "
RDEPENDS:golang-github-google-pprof-devel = " \
 go-filesystem \
 golang-github-chzyer-readline-devel \
 golang-github-ianlancetaylor-demangle-devel \
 "
