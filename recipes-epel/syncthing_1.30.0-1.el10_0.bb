# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syncthing"
PV = "1.30.0"
PR = "1.el10_0"
PACKAGES = " \
 syncthing \
 syncthing-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/syncthing-1.30.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3529365ebab69554ea4038c7d657882f2d3ec7673f1ce7614f3091233348ad2f"

URI_x86_64_v2_syncthing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-1.30.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syncthing}"
SRC_URI[x86_64_v2_syncthing.sha256sum] = "cd2d1992ac9d43175203085b2419ba05633f7a0951083dd6eb3e4323f938fdee"

URI_x86_64_v2_syncthing-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-tools-1.30.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syncthing-tools}"
SRC_URI[x86_64_v2_syncthing-tools.sha256sum] = "bf2e2631c3d7e4ee988b0076638e45519af8d501f0cd19467731f50e635835b9"

URI_aarch64_syncthing = "${EPEL_MIRROR}/aarch64/Packages/s/syncthing-1.30.0-1.el10_0.aarch64.rpm;name=aarch64_syncthing;unpack=0"
SRC_URI:append = " ${URI_aarch64_syncthing}"
SRC_URI[aarch64_syncthing.sha256sum] = "8ebc7cdb538f0861827bb3dbb0e4b2ba5676114d8dc60beed7d88943a2206eb5"

URI_aarch64_syncthing-tools = "${EPEL_MIRROR}/aarch64/Packages/s/syncthing-tools-1.30.0-1.el10_0.aarch64.rpm;name=aarch64_syncthing-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_syncthing-tools}"
SRC_URI[aarch64_syncthing-tools.sha256sum] = "0fea6842f3a8f618519ad91ab0313af57ba92bcd9f8d6cb7bcd7690cbe29c660"

RDEPENDS:syncthing = " \
 bash \
 glibc \
 hicolor-icon-theme \
 "
RDEPENDS:syncthing-tools = " \
 glibc \
 "
