# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-sys"
PV = "0.31.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-wayland-sys+client-devel \
 rust-wayland-sys+cursor-devel \
 rust-wayland-sys+default-devel \
 rust-wayland-sys+dlopen-devel \
 rust-wayland-sys+egl-devel \
 rust-wayland-sys+libc-devel \
 rust-wayland-sys+memoffset-devel \
 rust-wayland-sys+once_cell-devel \
 rust-wayland-sys+server-devel \
 rust-wayland-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-sys-0.31.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63f81490432466307be780b359c03c20bd5c0a7afd5ac1328bfe77d738b94c35"

URI_x86_64_v2_rust-wayland-sys+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+client-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+client-devel.sha256sum] = "032ce2e0a9b087f45565bac4bcd7835fe2063ce6c65f2459fbbfacd53c9e12f2"

URI_x86_64_v2_rust-wayland-sys+cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+cursor-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+cursor-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+cursor-devel.sha256sum] = "2ce1d92dc01dc769a3817e660fdbef4f41a85c9675d481fd8f081464598c063b"

URI_x86_64_v2_rust-wayland-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+default-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+default-devel.sha256sum] = "922397f5d0c6ec7e7d5bc015dc4c5490680adf4da95e870051987a4c385918c6"

URI_x86_64_v2_rust-wayland-sys+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+dlopen-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+dlopen-devel.sha256sum] = "fed4f0c8aebaffe190dff86425893d39a630b14ab37aaaa27501a822c35f7796"

URI_x86_64_v2_rust-wayland-sys+egl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+egl-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+egl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+egl-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+egl-devel.sha256sum] = "bd67eeefc468423ebf1387bb75fdf290339a079531eb9cfb78d80dd422266ab8"

URI_x86_64_v2_rust-wayland-sys+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+libc-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+libc-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+libc-devel.sha256sum] = "ee6bee151e9258ef9d40a6b7f332422ac9a65efd1b8d5ac1d06bfea67f04b8bd"

URI_x86_64_v2_rust-wayland-sys+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+memoffset-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+memoffset-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+memoffset-devel.sha256sum] = "e4f5581c12a175a36501ec26646fcdfb5e89deb317553da9592e1553fbb977a2"

URI_x86_64_v2_rust-wayland-sys+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+once_cell-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+once_cell-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+once_cell-devel.sha256sum] = "68e79e66dd8a48161d72683e2ab9752ec0dcbbd3d557bd2e56b8f3cf2b8ea23b"

URI_x86_64_v2_rust-wayland-sys+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+server-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+server-devel.sha256sum] = "002c2c980d82f8f71c86b2e7d4abc819c9b43b486ea167a45799f3d43ce12e63"

URI_x86_64_v2_rust-wayland-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys-devel.sha256sum] = "3f35b062bbf30ea622067f62ee00f089fe3aff1d5695ae1672f3d2ec5d11f805"

URI_aarch64_rust-wayland-sys+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+client-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-sys+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+client-devel}"
SRC_URI[aarch64_rust-wayland-sys+client-devel.sha256sum] = "7ab4de6dcf40f24a48f72d94315b0904ccd418c49faebb255ec00f333237f3b8"

URI_aarch64_rust-wayland-sys+cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+cursor-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-sys+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+cursor-devel}"
SRC_URI[aarch64_rust-wayland-sys+cursor-devel.sha256sum] = "600b95ed6ab367f0d2fa85be906f4085586f8abacea32b0c28459310bd01078b"

URI_aarch64_rust-wayland-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+default-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+default-devel}"
SRC_URI[aarch64_rust-wayland-sys+default-devel.sha256sum] = "36fbc8de23109694ac54731e983f808f8ed4f7b100292508836f8c6444d2d80d"

URI_aarch64_rust-wayland-sys+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+dlopen-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-sys+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+dlopen-devel}"
SRC_URI[aarch64_rust-wayland-sys+dlopen-devel.sha256sum] = "2f332ef3975618689d30d05adecd3d2ec4781e27b5f8b852e92803b972d7e7e9"

URI_aarch64_rust-wayland-sys+egl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+egl-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-sys+egl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+egl-devel}"
SRC_URI[aarch64_rust-wayland-sys+egl-devel.sha256sum] = "92e52721f2ce6f5bf8632ed584b126fd5e0dc267fde2b1fcd4d8f463155171d8"

URI_aarch64_rust-wayland-sys+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+libc-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+libc-devel}"
SRC_URI[aarch64_rust-wayland-sys+libc-devel.sha256sum] = "4d7f4d50ee8487f076d9056113e7fc2a680580566c3932bf3132bda962f3ecfb"

URI_aarch64_rust-wayland-sys+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+memoffset-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-sys+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+memoffset-devel}"
SRC_URI[aarch64_rust-wayland-sys+memoffset-devel.sha256sum] = "39d60b0f37c0eee77188f0f3ed6db15f720f42e10690e644450a973b001c5424"

URI_aarch64_rust-wayland-sys+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+once_cell-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-sys+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+once_cell-devel}"
SRC_URI[aarch64_rust-wayland-sys+once_cell-devel.sha256sum] = "c366b364e37ea9416ba16f2bbc05e788143197103a55ad362d8608f39bf92a4d"

URI_aarch64_rust-wayland-sys+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+server-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-sys+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+server-devel}"
SRC_URI[aarch64_rust-wayland-sys+server-devel.sha256sum] = "15ccdce5be0bfe66ea216448e4e53843b6299f138398b16c7a7c44f1c0ef8c8d"

URI_aarch64_rust-wayland-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys-devel}"
SRC_URI[aarch64_rust-wayland-sys-devel.sha256sum] = "7a6f328d3310a822f90f18f875fd9cbd4a60a861c0dd226c3b7d49453453af5f"

RDEPENDS:rust-wayland-sys+client-devel = " \
 cargo \
 rust-dlib+default-devel \
 rust-log+default-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+cursor-devel = " \
 cargo \
 rust-wayland-sys+client-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+default-devel = " \
 cargo \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+dlopen-devel = " \
 cargo \
 rust-wayland-sys+once_cell-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+egl-devel = " \
 cargo \
 rust-wayland-sys+client-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+server-devel = " \
 cargo \
 rust-dlib+default-devel \
 rust-log+default-devel \
 rust-wayland-sys+libc-devel \
 rust-wayland-sys+memoffset-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys-devel = " \
 cargo \
 rust \
 rust-pkg-config+default-devel \
 wayland-devel \
 "
