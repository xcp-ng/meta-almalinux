# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Tiny"
PV = "1.008"
PR = "12.el10_0"
PACKAGES = " \
 perl-Class-Tiny \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Tiny-1.008-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00355cb8c54d42e6ecabbeac65ee8b3e797370bbb826fb38d5770e5f876c39d3"

URI_x86_64_v2_perl-Class-Tiny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Tiny-1.008-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Tiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Tiny}"
SRC_URI[x86_64_v2_perl-Class-Tiny.sha256sum] = "03f2d797711c2d4c64bbf535a6a98f8a29dc3a6666e933a6e6e6b26b7ba1b1b0"

URI_aarch64_perl-Class-Tiny = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Tiny-1.008-12.el10_0.noarch.rpm;name=aarch64_perl-Class-Tiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Tiny}"
SRC_URI[aarch64_perl-Class-Tiny.sha256sum] = "e7bf19609ab39488f460aca50bdce572e762f32c5d4357ba5d1fe6a9dc0a1133"

RDEPENDS:perl-Class-Tiny = " \
 perl-Carp \
 perl-libs \
 perl-mro \
 "
