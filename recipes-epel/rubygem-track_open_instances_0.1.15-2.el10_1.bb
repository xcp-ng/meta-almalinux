# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-track_open_instances"
PV = "0.1.15"
PR = "2.el10_1"
PACKAGES = " \
 rubygem-track_open_instances \
 rubygem-track_open_instances-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-track_open_instances-0.1.15-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49182a354121623fff036cb74e12228f748f3770414624e9635b62b6dadcaac4"

URI_x86_64_v2_rubygem-track_open_instances = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-track_open_instances-0.1.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-track_open_instances;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-track_open_instances}"
SRC_URI[x86_64_v2_rubygem-track_open_instances.sha256sum] = "6ba24d02098568e36de051971fac52e4e8fd868769851669a461b8e7f3d5974a"

URI_x86_64_v2_rubygem-track_open_instances-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-track_open_instances-doc-0.1.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-track_open_instances-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-track_open_instances-doc}"
SRC_URI[x86_64_v2_rubygem-track_open_instances-doc.sha256sum] = "9a46371b86bb964ce699fef4b0716c0ce2da678a3c4dd36760c474e4981a2fe7"

URI_aarch64_rubygem-track_open_instances = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-track_open_instances-0.1.15-2.el10_1.noarch.rpm;name=aarch64_rubygem-track_open_instances;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-track_open_instances}"
SRC_URI[aarch64_rubygem-track_open_instances.sha256sum] = "e25884ce68473181feddb7eed057f4f064c236dd10d2a0c37baad51a5d5434d1"

URI_aarch64_rubygem-track_open_instances-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-track_open_instances-doc-0.1.15-2.el10_1.noarch.rpm;name=aarch64_rubygem-track_open_instances-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-track_open_instances-doc}"
SRC_URI[aarch64_rubygem-track_open_instances-doc.sha256sum] = "e86855e18b33de9723d65fca11ee9133b7d8988ca1ae4a1cc5eddb344fb2eeb9"

RDEPENDS:rubygem-track_open_instances = " \
 rubygems \
 "
RDEPENDS:rubygem-track_open_instances-doc = " \
 rubygem-track_open_instances \
 "
