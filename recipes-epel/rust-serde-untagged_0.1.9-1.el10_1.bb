# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde-untagged"
PV = "0.1.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde-untagged+default-devel \
 rust-serde-untagged-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde-untagged-0.1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d796c16f627b47366dd689bae726a71088a031795cebc7c8a661b883da688b08"

URI_x86_64_v2_rust-serde-untagged+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-untagged+default-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-untagged+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-untagged+default-devel}"
SRC_URI[x86_64_v2_rust-serde-untagged+default-devel.sha256sum] = "d10318e33d48888311803e17838139ca5d82e6e32692552dad7632eda4323999"

URI_x86_64_v2_rust-serde-untagged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-untagged-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-untagged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-untagged-devel}"
SRC_URI[x86_64_v2_rust-serde-untagged-devel.sha256sum] = "0cc23db32bae0dd6a25046a8f3c3bdffcb3c58c0811a2625fac0ac2575e68c76"

URI_aarch64_rust-serde-untagged+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-untagged+default-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-serde-untagged+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-untagged+default-devel}"
SRC_URI[aarch64_rust-serde-untagged+default-devel.sha256sum] = "bce06fd94217020930dff0d9c53a40e43b7946d518c731102c0b83b3fcda6ac6"

URI_aarch64_rust-serde-untagged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-untagged-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-serde-untagged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-untagged-devel}"
SRC_URI[aarch64_rust-serde-untagged-devel.sha256sum] = "3abd725526c332706fd09902fbf68ca7d678ae99eac3b66c3349bc362a5335ee"

RDEPENDS:rust-serde-untagged+default-devel = " \
 cargo \
 rust-serde-untagged-devel \
 "
RDEPENDS:rust-serde-untagged-devel = " \
 cargo \
 rust \
 rust-erased-serde+alloc-devel \
 rust-erased-serde-devel \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-typeid+default-devel \
 "
