# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xevd"
PV = "0.5.0"
PR = "5.el10_0"
PACKAGES = " \
 xevd \
 xevd-devel \
 xevd-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/x/xevd-0.5.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3c4dc7d3d7f325eb1bba16756d298a4987c3183a5a2bfae84a931a3f55a1502c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xevd-0.5.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xevd;unpack=0"
SRC_URI[x86_64_v2_xevd.sha256sum] = "5e7e3ac647894cadcd2183208946d60e7f68be6d958ee79e8c31fd92931faa96"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xevd-devel-0.5.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xevd-devel;unpack=0"
SRC_URI[x86_64_v2_xevd-devel.sha256sum] = "9d48067c03c9897fd99f09565a2ec838b5c38c5596e812b93d199cbac3972718"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xevd-libs-0.5.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xevd-libs;unpack=0"
SRC_URI[x86_64_v2_xevd-libs.sha256sum] = "9eb590571a46b823c4ec7908876284651099a49f589e3311a7949c09b7b3826a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xevd-0.5.0-5.el10_0.aarch64.rpm;name=aarch64_xevd;unpack=0"
SRC_URI[aarch64_xevd.sha256sum] = "df0b4516dc7750c92a046b567ca52e63f7e4d09073967d39ed8bb1b376f1f392"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xevd-devel-0.5.0-5.el10_0.aarch64.rpm;name=aarch64_xevd-devel;unpack=0"
SRC_URI[aarch64_xevd-devel.sha256sum] = "282e6206c325c9fe8931423738aee39846ada698c748c41c627647cb5418a392"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xevd-libs-0.5.0-5.el10_0.aarch64.rpm;name=aarch64_xevd-libs;unpack=0"
SRC_URI[aarch64_xevd-libs.sha256sum] = "3b046f761344a0c3c8240a7d95d9336fddb005eed7beb83f15fd7d0db060b6da"

RDEPENDS:xevd = " \
 glibc \
 xevd-libs \
 "
RDEPENDS:xevd-devel = " \
 pkgconf-pkg-config \
 xevd-libs \
 "
RDEPENDS:xevd-libs = " \
 glibc \
 "
