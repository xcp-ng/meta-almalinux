# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-filippo-edwards25519"
PV = "1.1.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-filippo-edwards25519-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-filippo-edwards25519-1.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d86b45292c16d4b752379062bd8f20d130f144cdffff58d046ab2779fb0c70d7"

URI_x86_64_v2_golang-filippo-edwards25519-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-filippo-edwards25519-devel-1.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-filippo-edwards25519-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-filippo-edwards25519-devel}"
SRC_URI[x86_64_v2_golang-filippo-edwards25519-devel.sha256sum] = "a442e7c23da1fbf214d4740e9e25fc020fc746b1dbe0835aa386d8bbab467d75"

URI_aarch64_golang-filippo-edwards25519-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-filippo-edwards25519-devel-1.1.0-2.el10_0.noarch.rpm;name=aarch64_golang-filippo-edwards25519-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-filippo-edwards25519-devel}"
SRC_URI[aarch64_golang-filippo-edwards25519-devel.sha256sum] = "4ed837426fe4e1abb0b3b9be41f9e029159bac1265a66155d270a00fc4da0967"

RDEPENDS:golang-filippo-edwards25519-devel = " \
 go-filesystem \
 "
