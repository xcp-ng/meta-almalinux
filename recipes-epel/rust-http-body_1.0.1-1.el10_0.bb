# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-body"
PV = "1.0.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-http-body+default-devel \
 rust-http-body-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-body-1.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7f3ca8fa790239fac228e809109470be57ca22dbca61263f52d7e5c54377ba8"

URI_x86_64_v2_rust-http-body+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body+default-devel-1.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body+default-devel}"
SRC_URI[x86_64_v2_rust-http-body+default-devel.sha256sum] = "04ec0073459a06983cb8004d200d6ad2b6d862a0e528cddcbc696bd4b1538e28"

URI_x86_64_v2_rust-http-body-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-devel-1.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-devel}"
SRC_URI[x86_64_v2_rust-http-body-devel.sha256sum] = "15eb5b03f4266670f582e70f467437edc5497b125605dc413d7d176d5c3974d3"

URI_aarch64_rust-http-body+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body+default-devel-1.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-http-body+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body+default-devel}"
SRC_URI[aarch64_rust-http-body+default-devel.sha256sum] = "a8c3073524e0371615b4407b2abdd117f8158ab905e978301b3e03388d7a96f1"

URI_aarch64_rust-http-body-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-devel-1.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-http-body-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-devel}"
SRC_URI[aarch64_rust-http-body-devel.sha256sum] = "2f1fb7de2ee37f53b5b429501c45d605c2ace49a37a34d2dc3b9ee1fa8be55fc"

RDEPENDS:rust-http-body+default-devel = " \
 cargo \
 rust-http-body-devel \
 "
RDEPENDS:rust-http-body-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 "
