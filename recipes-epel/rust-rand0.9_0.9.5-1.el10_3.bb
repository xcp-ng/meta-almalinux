# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand0.9"
PV = "0.9.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-rand0.9+alloc-devel \
 rust-rand0.9+default-devel \
 rust-rand0.9+log-devel \
 rust-rand0.9+os_rng-devel \
 rust-rand0.9+serde-devel \
 rust-rand0.9+small_rng-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9+thread_rng-devel \
 rust-rand0.9+unbiased-devel \
 rust-rand0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand0.9-0.9.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "445f9b955adecc1ea0a1577bc0035c1d5e74631846ad7078be7a076e86646e5b"

URI_x86_64_v2_rust-rand0.9+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+alloc-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+alloc-devel.sha256sum] = "cc04ea00b2b0ac8f7cd10faeadb3ed98c61842794c6be92bae3534c2f909c4fc"

URI_x86_64_v2_rust-rand0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+default-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+default-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+default-devel.sha256sum] = "ebec810f8bac1db937a04c90637a8d517db98b446d349d0c5db8dd6a869fde0f"

URI_x86_64_v2_rust-rand0.9+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+log-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+log-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+log-devel.sha256sum] = "483b56728e0681f91f450be46229860acbabb24e6d70dd0c059c33a2e71f6ba8"

URI_x86_64_v2_rust-rand0.9+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+os_rng-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+os_rng-devel.sha256sum] = "ed6aad510416db604368ac8579d32bd26418213f4338a4ae3c83646b04afe365"

URI_x86_64_v2_rust-rand0.9+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+serde-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+serde-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+serde-devel.sha256sum] = "12b00bfd8366a6053223160c86de24e72f3cd35bc6dd8b1a47dda2ccabbad375"

URI_x86_64_v2_rust-rand0.9+small_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+small_rng-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+small_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+small_rng-devel.sha256sum] = "f3126c2010c24df8eb5d22f60cc6fb8eb0d77ee87d93f52a66bc19572142c49c"

URI_x86_64_v2_rust-rand0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+std-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+std-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+std-devel.sha256sum] = "015b1ee70a5ad133dfa36e8e9d379b731c3745e8f9e40438b1535c036383159b"

URI_x86_64_v2_rust-rand0.9+std_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+std_rng-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+std_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+std_rng-devel.sha256sum] = "98b559d9231c0fccc16e461df4e60409a4117d4f17078e7eff8a853dcf433589"

URI_x86_64_v2_rust-rand0.9+thread_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+thread_rng-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+thread_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+thread_rng-devel.sha256sum] = "af2bcb9277a62e8e5cd15e0e67b8fb31ac13202e4063bc106666046a8873a63e"
RPROVIDES:rust-rand0.9+thread_rng-devel:x86_64_v2 = "virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

URI_x86_64_v2_rust-rand0.9+unbiased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+unbiased-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+unbiased-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+unbiased-devel.sha256sum] = "4645ce414712a51178bf11fc6f0c96495c98f9525285c70a2725c12d22e31665"

URI_x86_64_v2_rust-rand0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9-devel}"
SRC_URI[x86_64_v2_rust-rand0.9-devel.sha256sum] = "38b8fdc68cfb6681bf5eafdb37bfa9e8b74974bdefb57ba42356ffd3ff5c1497"
RPROVIDES:rust-rand0.9-devel:x86_64_v2 = "virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

URI_aarch64_rust-rand0.9+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+alloc-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+alloc-devel}"
SRC_URI[aarch64_rust-rand0.9+alloc-devel.sha256sum] = "d61f9051493f443a4b080bab5a82e1e83618a4814707052b14fe8081883654e3"

URI_aarch64_rust-rand0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+default-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+default-devel}"
SRC_URI[aarch64_rust-rand0.9+default-devel.sha256sum] = "8d45dba2fd829cb815ee202338cab1b5e29513f817dc8a98a63c528ba170e829"

URI_aarch64_rust-rand0.9+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+log-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+log-devel}"
SRC_URI[aarch64_rust-rand0.9+log-devel.sha256sum] = "cc8c7d1e1e15d41c9fddd6f07048741ac89892c7fc083ff861d03eb05f492331"

URI_aarch64_rust-rand0.9+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+os_rng-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+os_rng-devel}"
SRC_URI[aarch64_rust-rand0.9+os_rng-devel.sha256sum] = "9708ef6a41bec2daf22e23abbc04b13a86f6feca8e4dd5227992a7995ac61077"

URI_aarch64_rust-rand0.9+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+serde-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+serde-devel}"
SRC_URI[aarch64_rust-rand0.9+serde-devel.sha256sum] = "ce18a902e2960c3b406bfc97763d8ea129fe24d1afa0afcaa1d20716957f3ef5"

URI_aarch64_rust-rand0.9+small_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+small_rng-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+small_rng-devel}"
SRC_URI[aarch64_rust-rand0.9+small_rng-devel.sha256sum] = "aa997fcc0dda808cdff60cbe6fd1634b07a8d602b909ede744d5a24c436cf686"

URI_aarch64_rust-rand0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+std-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+std-devel}"
SRC_URI[aarch64_rust-rand0.9+std-devel.sha256sum] = "a25d250e228f6098eddf9642704b7c39f0abd13046d5ea9873b16e5e656dd9a8"

URI_aarch64_rust-rand0.9+std_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+std_rng-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+std_rng-devel}"
SRC_URI[aarch64_rust-rand0.9+std_rng-devel.sha256sum] = "a98e23637570251009ce3822754af12fe3645b3435603994cdfb689b97438816"

URI_aarch64_rust-rand0.9+thread_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+thread_rng-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+thread_rng-devel}"
SRC_URI[aarch64_rust-rand0.9+thread_rng-devel.sha256sum] = "5ad875935e10c1f85cfd883b45d7fea923e137d20dc8cd52db9205992ed38b52"
RPROVIDES:rust-rand0.9+thread_rng-devel:aarch64 = "virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

URI_aarch64_rust-rand0.9+unbiased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+unbiased-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+unbiased-devel}"
SRC_URI[aarch64_rust-rand0.9+unbiased-devel.sha256sum] = "fdc319545743a3b67693ab28e727d65fb37667b8d1182fa0db43e0d8614b06ae"

URI_aarch64_rust-rand0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9-devel}"
SRC_URI[aarch64_rust-rand0.9-devel.sha256sum] = "89fe89895cda957d3f137cd2404f2dfa05a3956cbc2058380e52288475dcacc6"
RPROVIDES:rust-rand0.9-devel:aarch64 = "virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

RDEPENDS:rust-rand0.9+alloc-devel = " \
 cargo \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9+default-devel = " \
 cargo \
 rust-rand0.9+os_rng-devel \
 rust-rand0.9+small_rng-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9+thread_rng-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9+log-devel = " \
 cargo \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9+os_rng-devel = " \
 cargo \
 rust-rand0.9-devel \
 rust-rand_core0.9+os_rng-devel \
 "
RDEPENDS:rust-rand0.9+serde-devel = " \
 cargo \
 rust-rand0.9-devel \
 rust-rand_core0.9+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand0.9+small_rng-devel = " \
 cargo \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9+std-devel = " \
 cargo \
 rust-rand0.9+alloc-devel \
 rust-rand0.9-devel \
 rust-rand_chacha0.9+std-devel \
 rust-rand_chacha0.9-devel \
 rust-rand_core0.9+std-devel \
 "
RDEPENDS:rust-rand0.9+std_rng-devel = " \
 cargo \
 rust-rand0.9-devel \
 rust-rand_chacha0.9-devel \
 "
RDEPENDS:rust-rand0.9+thread_rng-devel = " \
 cargo \
 rust-rand0.9+os_rng-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9+unbiased-devel = " \
 cargo \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9-devel = " \
 cargo \
 rust \
 rust-rand_core0.9-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 rpm/virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

PROVIDES:append:aarch64 = " rpm/virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 rpm/virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"
