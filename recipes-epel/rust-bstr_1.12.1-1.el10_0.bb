# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bstr"
PV = "1.12.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-bstr+alloc-devel \
 rust-bstr+default-devel \
 rust-bstr+serde-devel \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-bstr-1.12.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d4a6e4fdb4fc83cb9465e8a9b823e49c65b21e873d9bb29465a682b2cfc33a33"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+alloc-devel-1.12.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+alloc-devel.sha256sum] = "c1e0ad6cd393f27bac6c9ce743c73782a33308cde152706797a28bed9e193bdc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+default-devel-1.12.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+default-devel.sha256sum] = "73a568ab548ac84b0f819b363220359922317209ee6928993abe2b75f73b302b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+serde-devel-1.12.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+serde-devel.sha256sum] = "029cf6f5bb93dc552cb27fbe5d794909f535998a9c4ebf01dc758ae7fed68184"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+std-devel-1.12.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+std-devel.sha256sum] = "5a07b6f9f9c7a8e6ac5c0921d2cd073245bbef31325d8583a7b5816a2f3fc606"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+unicode-devel-1.12.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+unicode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr+unicode-devel.sha256sum] = "eff326f49e89a184324072038890401061aa7215e4670a331bf202a4d3bb2ffd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr-devel-1.12.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bstr-devel.sha256sum] = "4c2d87fc4dc346b7bdba18c1eb3a3200a8e091a0ecd52410a0e583f4dc41895b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+alloc-devel-1.12.1-1.el10_0.noarch.rpm;name=aarch64_rust-bstr+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+alloc-devel.sha256sum] = "db99a73c4190994fc375c673ae24d88a7aa33214f7ab9f63d012daba2fea33fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+default-devel-1.12.1-1.el10_0.noarch.rpm;name=aarch64_rust-bstr+default-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+default-devel.sha256sum] = "275cbcd140f70fe923bf0f7342428e8de82384f51f23dc28f4cc3b872c31180b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+serde-devel-1.12.1-1.el10_0.noarch.rpm;name=aarch64_rust-bstr+serde-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+serde-devel.sha256sum] = "20a21a375b5b03adcbdeb57475df38fe1aef89ffcd3f1e52a8b40c0c69e301ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+std-devel-1.12.1-1.el10_0.noarch.rpm;name=aarch64_rust-bstr+std-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+std-devel.sha256sum] = "671094aa2f0da00ad45f155f7098e81d88da0a5476b3823d22743354a97a9c33"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+unicode-devel-1.12.1-1.el10_0.noarch.rpm;name=aarch64_rust-bstr+unicode-devel;unpack=0"
SRC_URI[aarch64_rust-bstr+unicode-devel.sha256sum] = "7ce5a0dac07e77cc481f01c4fdc61151e152636e77e76433ced2f40092b08631"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr-devel-1.12.1-1.el10_0.noarch.rpm;name=aarch64_rust-bstr-devel;unpack=0"
SRC_URI[aarch64_rust-bstr-devel.sha256sum] = "764cb22c45458ff6b4c84c061168746bfcc26827cff5b8ac877075aaa36bc0a8"

RDEPENDS:rust-bstr+alloc-devel = " \
 cargo \
 rust-bstr-devel \
 rust-memchr+alloc-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bstr+default-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "
RDEPENDS:rust-bstr+serde-devel = " \
 cargo \
 rust-bstr-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bstr+std-devel = " \
 cargo \
 rust-bstr+alloc-devel \
 rust-bstr-devel \
 rust-memchr+std-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bstr+unicode-devel = " \
 cargo \
 rust-bstr-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-bstr-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
