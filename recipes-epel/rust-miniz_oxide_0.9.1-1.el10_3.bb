# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-miniz_oxide"
PV = "0.9.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-miniz_oxide+block-boundary-devel \
 rust-miniz_oxide+default-devel \
 rust-miniz_oxide+serde-devel \
 rust-miniz_oxide+simd-adler32-devel \
 rust-miniz_oxide+simd-devel \
 rust-miniz_oxide+std-devel \
 rust-miniz_oxide+with-alloc-devel \
 rust-miniz_oxide-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-miniz_oxide-0.9.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1d14418e14d80afc785dc5c3cf06d01a1f7fcf0149e05bc87565e45b847cfd4f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+block-boundary-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+block-boundary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-miniz_oxide+block-boundary-devel.sha256sum] = "f536d6c7120b9e00e71885adbe98ff3d2620d7ed72cd85f9c380d062a4301689"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+default-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-miniz_oxide+default-devel.sha256sum] = "03139b1848a549193be362339c70c5d525842b0a81f6ff0a638d2f872b4046e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+serde-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-miniz_oxide+serde-devel.sha256sum] = "389f50cf5f311b176d7d56555235bd158487ff398f7b08e836b2713c9e77b5d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+simd-adler32-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+simd-adler32-devel;unpack=0"
SRC_URI[x86_64_v2_rust-miniz_oxide+simd-adler32-devel.sha256sum] = "4a8a35b6578e113cbe808018a27f6db7769670ef6d0dea27da276a5f648edc37"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+simd-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+simd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-miniz_oxide+simd-devel.sha256sum] = "c43466786512c796aee6b8d0a0634bfa17ca2511558ea1d2f62cee1af1ac24cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+std-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-miniz_oxide+std-devel.sha256sum] = "452f239d1f156849d5bd705da93ce03a373013aa46ef6fcfd1fee164f47a1d49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+with-alloc-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+with-alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-miniz_oxide+with-alloc-devel.sha256sum] = "2b4194417e48e5b8ff3954e1ea44908d1bb77106bc224ff0b112a1b88e68162e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide-devel;unpack=0"
SRC_URI[x86_64_v2_rust-miniz_oxide-devel.sha256sum] = "55b921d38b25bc9dfa0f860d2434b59872c6629d368d7d699e38b428c2c125f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+block-boundary-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide+block-boundary-devel;unpack=0"
SRC_URI[aarch64_rust-miniz_oxide+block-boundary-devel.sha256sum] = "91dd56ecae4f9652d5cfddd7471a1523e81ae1215161a86c0b94ad40b07150fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+default-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide+default-devel;unpack=0"
SRC_URI[aarch64_rust-miniz_oxide+default-devel.sha256sum] = "744613332603b29278e2f6f7e6cda2844b27ddef44783f177b6b4fa506e90758"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+serde-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide+serde-devel;unpack=0"
SRC_URI[aarch64_rust-miniz_oxide+serde-devel.sha256sum] = "f32041dad5178663df5fde26e3d5d8bbefae8e99c3e1712df5eece2693e02aa1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+simd-adler32-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide+simd-adler32-devel;unpack=0"
SRC_URI[aarch64_rust-miniz_oxide+simd-adler32-devel.sha256sum] = "0b88d1a6cd6917ef01d5805f89c5276d377830b578e0cf7dcf4fee7ad414d9d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+simd-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide+simd-devel;unpack=0"
SRC_URI[aarch64_rust-miniz_oxide+simd-devel.sha256sum] = "0d4e13f86091f497044f3f6b3ffc2d4b3a0c63d40f327ce9e9e02ab8a3073b9a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+std-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide+std-devel;unpack=0"
SRC_URI[aarch64_rust-miniz_oxide+std-devel.sha256sum] = "60e1ee110b2325dbcb9d1843cabba514a0104feef4ed5457529676c0b2f890a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+with-alloc-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide+with-alloc-devel;unpack=0"
SRC_URI[aarch64_rust-miniz_oxide+with-alloc-devel.sha256sum] = "ede233ea2ca24fb7f4aefa2efc9a3ab9c640426a28e8a47127d84b3e9dfdcb04"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-miniz_oxide-devel;unpack=0"
SRC_URI[aarch64_rust-miniz_oxide-devel.sha256sum] = "e80cb737ee7207dfc7ba97c12e25f109efef9ec6b49b00db69e1375b78bb8a51"

RDEPENDS:rust-miniz_oxide+block-boundary-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+default-devel = " \
 cargo \
 rust-miniz_oxide+with-alloc-devel \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+serde-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-miniz_oxide+simd-adler32-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-miniz_oxide+simd-devel = " \
 cargo \
 rust-miniz_oxide+simd-adler32-devel \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+std-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-miniz_oxide+with-alloc-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide-devel = " \
 cargo \
 rust-adler2-devel \
 "
