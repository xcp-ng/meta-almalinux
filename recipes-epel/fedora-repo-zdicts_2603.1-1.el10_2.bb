# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-repo-zdicts"
PV = "2603.1"
PR = "1.el10_2"
PACKAGES = " \
 fedora-repo-zdicts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-repo-zdicts-2603.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d174e695f4fae09c53bc702c7d5276d0e526c8bda281cd6f70d9f8a228985a9"

URI_x86_64_v2_fedora-repo-zdicts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-repo-zdicts-2603.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-repo-zdicts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-repo-zdicts}"
SRC_URI[x86_64_v2_fedora-repo-zdicts.sha256sum] = "2b5480c058d3284d675acab885b80c86308a91b4f537730d3ea0711836cfe8bf"

URI_aarch64_fedora-repo-zdicts = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-repo-zdicts-2603.1-1.el10_2.noarch.rpm;name=aarch64_fedora-repo-zdicts;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-repo-zdicts}"
SRC_URI[aarch64_fedora-repo-zdicts.sha256sum] = "cf96cca96767a0a2e035b28d1d5421bade4c35f1171bb1c9a3035fd794ea514a"

RDEPENDS:fedora-repo-zdicts = " \
 "
