# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-i18n"
PV = "1.0"
PR = "0.37.b10.4.el10_3"
PACKAGES = " \
 plexus-i18n \
 plexus-i18n-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plexus-i18n-1.0-0.37.b10.4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c5c57df765dc695bbcbc560de530f803703c1fe99068c748a7847f3ae545622"

URI_x86_64_v2_plexus-i18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plexus-i18n-1.0-0.37.b10.4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plexus-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-i18n}"
SRC_URI[x86_64_v2_plexus-i18n.sha256sum] = "41fba8826f4144a62b56063039ed2de09fc186daf7418e66a9e5a18471273282"

URI_x86_64_v2_plexus-i18n-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plexus-i18n-javadoc-1.0-0.37.b10.4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plexus-i18n-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-i18n-javadoc}"
SRC_URI[x86_64_v2_plexus-i18n-javadoc.sha256sum] = "564ee758e01603b02ff0534fc2b1e11c66da8aa5c92c36d22549eaa08f4004d3"

URI_aarch64_plexus-i18n = "${EPEL_MIRROR}/aarch64/Packages/p/plexus-i18n-1.0-0.37.b10.4.el10_3.noarch.rpm;name=aarch64_plexus-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-i18n}"
SRC_URI[aarch64_plexus-i18n.sha256sum] = "25f9b5fef37fa891f23b26d62a08ab2417f597662a9a619644a055bf9e57d3c6"

URI_aarch64_plexus-i18n-javadoc = "${EPEL_MIRROR}/aarch64/Packages/p/plexus-i18n-javadoc-1.0-0.37.b10.4.el10_3.noarch.rpm;name=aarch64_plexus-i18n-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-i18n-javadoc}"
SRC_URI[aarch64_plexus-i18n-javadoc.sha256sum] = "26f61a89006a49d4a0ac2d5165d365660f9e5170df78b3cc229dbac05b105826"

RDEPENDS:plexus-i18n = " \
 javapackages-filesystem \
 plexus-utils \
 "
RDEPENDS:plexus-i18n-javadoc = " \
 javapackages-filesystem \
 "
