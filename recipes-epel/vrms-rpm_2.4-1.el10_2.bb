# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vrms-rpm"
PV = "2.4"
PR = "1.el10_2"
PACKAGES = " \
 vrms-rpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vrms-rpm-2.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "289ecd0d1b2067021625b9e932aa43cd302d5ba9c7f6036d7b940e2f95611fc1"

URI_x86_64_v2_vrms-rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vrms-rpm-2.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vrms-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vrms-rpm}"
SRC_URI[x86_64_v2_vrms-rpm.sha256sum] = "cdbdcec0da68bf993325b5da0cdcc796276720552fa75791604f67a6132ac4be"

URI_aarch64_vrms-rpm = "${EPEL_MIRROR}/aarch64/Packages/v/vrms-rpm-2.4-1.el10_2.aarch64.rpm;name=aarch64_vrms-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_vrms-rpm}"
SRC_URI[aarch64_vrms-rpm.sha256sum] = "9a86794d11f6e8e5d00678dc380041f4e176f352b4f14da4161e9e4f49b3a459"

RDEPENDS:vrms-rpm = " \
 glibc \
 rpm-libs \
 "
