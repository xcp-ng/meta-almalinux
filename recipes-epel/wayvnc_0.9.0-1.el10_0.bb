# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wayvnc"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 wayvnc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wayvnc-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d96b08b05de41277366d3358c7afcc3079cf9d88e4caf56efa062eb6ad73d6f9"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - wayvnc: (sway >= 1.6 if sway)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - wayvnc: (sway >= 1.6 if sway)

URI_x86_64_v2_wayvnc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wayvnc-0.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wayvnc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wayvnc}"
SRC_URI[x86_64_v2_wayvnc.sha256sum] = "ab9ef203b3d05af8b6a3f3e920221707013cad2c5441939fa16cf14219ae93a7"

URI_aarch64_wayvnc = "${EPEL_MIRROR}/aarch64/Packages/w/wayvnc-0.9.0-1.el10_0.aarch64.rpm;name=aarch64_wayvnc;unpack=0"
SRC_URI:append = " ${URI_aarch64_wayvnc}"
SRC_URI[aarch64_wayvnc.sha256sum] = "7dcd2fc144d83209c237aa6f802c55c11787bf7108c806035690b2996e0d534c"

RDEPENDS:wayvnc = " \
 aml \
 glibc \
 jansson \
 libdrm \
 libwayland-client \
 libxkbcommon \
 mesa-libgbm \
 neatvnc \
 pam-libs \
 pixman \
 "
