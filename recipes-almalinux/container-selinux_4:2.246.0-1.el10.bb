# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "container-selinux"
PE = "4"
PV = "2.246.0"
PR = "1.el10"
PACKAGES = " \
 container-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/container-selinux-2.246.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67167a94a0144e2fe7ef607232ad5490e96191caa30730c044adb4ccc7f914fd"

URI_x86_64_v2_container-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/container-selinux-2.246.0-1.el10.noarch.rpm;name=x86_64_v2_container-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_container-selinux}"
SRC_URI[x86_64_v2_container-selinux.sha256sum] = "1db12afc707f5d79c1e1f5596e5664ace54bf461092fed48072bac3f560461f5"

URI_aarch64_container-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/container-selinux-2.246.0-1.el10.noarch.rpm;name=aarch64_container-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_container-selinux}"
SRC_URI[aarch64_container-selinux.sha256sum] = "1db12afc707f5d79c1e1f5596e5664ace54bf461092fed48072bac3f560461f5"

RDEPENDS:container-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 sed \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.17 \
 "
