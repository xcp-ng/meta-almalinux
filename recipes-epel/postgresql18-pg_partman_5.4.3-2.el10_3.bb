# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql18-pg_partman"
PV = "5.4.3"
PR = "2.el10_3"
PACKAGES = " \
 postgresql18-pg_partman \
 postgresql18-pg_partman-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/postgresql18-pg_partman-5.4.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c2bc1fbbb5746f52ec8ab85b947cb7cf4cfd3ec01aa14149e6d72484a23fc0b"

URI_x86_64_v2_postgresql18-pg_partman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/postgresql18-pg_partman-5.4.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_postgresql18-pg_partman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-pg_partman}"
SRC_URI[x86_64_v2_postgresql18-pg_partman.sha256sum] = "2844790c3edba46bfbfc5f5c1a0172fea7b466fc63d443ba7128c4277489e9a3"

URI_x86_64_v2_postgresql18-pg_partman-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/postgresql18-pg_partman-doc-5.4.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_postgresql18-pg_partman-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-pg_partman-doc}"
SRC_URI[x86_64_v2_postgresql18-pg_partman-doc.sha256sum] = "7095cd408989a28b6b735460993b7fa37022c0476f30849c7237ada615d1368f"

URI_aarch64_postgresql18-pg_partman = "${EPEL_MIRROR}/aarch64/Packages/p/postgresql18-pg_partman-5.4.3-2.el10_3.aarch64.rpm;name=aarch64_postgresql18-pg_partman;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-pg_partman}"
SRC_URI[aarch64_postgresql18-pg_partman.sha256sum] = "4dacd0c4d64c81aff7766cf6194282a5c7b08ed516174d73093f2f761795892a"

URI_aarch64_postgresql18-pg_partman-doc = "${EPEL_MIRROR}/aarch64/Packages/p/postgresql18-pg_partman-doc-5.4.3-2.el10_3.noarch.rpm;name=aarch64_postgresql18-pg_partman-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-pg_partman-doc}"
SRC_URI[aarch64_postgresql18-pg_partman-doc.sha256sum] = "d74669eb7599a16a115bbd6d0c334109f09939ac1b20eb9b590482077d80b3b8"

RDEPENDS:postgresql18-pg_partman = " \
 glibc \
 postgresql18-server \
 python3 \
 "
RDEPENDS:postgresql18-pg_partman-doc = " \
 postgresql18-pg_partman \
 "
