# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-just-perfection"
PV = "35.0"
PR = "1.el10_2"
PACKAGES = " \
 gnome-shell-extension-just-perfection \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-just-perfection-35.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1ad556333725c7e80a8b080eb6e157a6ce3926c8d9010b9479538a0b1c7dd96"

URI_x86_64_v2_gnome-shell-extension-just-perfection = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-just-perfection-35.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-just-perfection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-just-perfection}"
SRC_URI[x86_64_v2_gnome-shell-extension-just-perfection.sha256sum] = "258de1449744c6d114fd973952571aab7d6ec782a6eb9bd50c6d53c8cc7f908d"

URI_aarch64_gnome-shell-extension-just-perfection = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-just-perfection-35.0-1.el10_2.noarch.rpm;name=aarch64_gnome-shell-extension-just-perfection;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-just-perfection}"
SRC_URI[aarch64_gnome-shell-extension-just-perfection.sha256sum] = "3e23f57f5e5a0221a58818c9402c55c87784411477eedd5eb839670052f3892e"

RDEPENDS:gnome-shell-extension-just-perfection = " \
 gnome-shell \
 "
