# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-version-compare"
PV = "0.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-version-compare+default-devel \
 rust-version-compare-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-version-compare-0.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07fb7639b3afe04817af7bc5e9e493e2ab739fd6e096e860fb01d904b5357fb7"

URI_x86_64_v2_rust-version-compare+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-compare+default-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-compare+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-compare+default-devel}"
SRC_URI[x86_64_v2_rust-version-compare+default-devel.sha256sum] = "61643ce284586465e5de20a66c92fc3d7d735c3331ea4894aba0506ac5c4a043"

URI_x86_64_v2_rust-version-compare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-compare-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-compare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-compare-devel}"
SRC_URI[x86_64_v2_rust-version-compare-devel.sha256sum] = "70d4904931010470f1f1a0eaa46232798df3bbe199eece0cbd00424cc6d0cb1d"

URI_aarch64_rust-version-compare+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-compare+default-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-version-compare+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-compare+default-devel}"
SRC_URI[aarch64_rust-version-compare+default-devel.sha256sum] = "bc84f2f31c9a79a2cba83534ec65d269c00737353f627e19ce1837861dff1e78"

URI_aarch64_rust-version-compare-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-compare-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-version-compare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-compare-devel}"
SRC_URI[aarch64_rust-version-compare-devel.sha256sum] = "e89523833db8de5df933168f0ecd6f1c7dd124501430a9c515071268e62da230"

RDEPENDS:rust-version-compare+default-devel = " \
 cargo \
 rust-version-compare-devel \
 "
RDEPENDS:rust-version-compare-devel = " \
 cargo \
 rust \
 "
