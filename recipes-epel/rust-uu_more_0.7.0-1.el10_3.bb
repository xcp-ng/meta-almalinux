# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_more"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_more+default-devel \
 rust-uu_more-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_more-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58df7a5f5c88282454493ce2d8e02689b8461b3dd65a653b8c0e86fa2392b058"

URI_x86_64_v2_rust-uu_more+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_more+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_more+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_more+default-devel}"
SRC_URI[x86_64_v2_rust-uu_more+default-devel.sha256sum] = "3bf36d0d2f4b4d4cd8f3d4a0fa686c8c37d67de712913eefeb481a0d73b5590d"

URI_x86_64_v2_rust-uu_more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_more-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_more-devel}"
SRC_URI[x86_64_v2_rust-uu_more-devel.sha256sum] = "93e1e80925886343f57033bd13f333dc5166a9c81f9477c598b45ff648a145fc"

URI_aarch64_rust-uu_more+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_more+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_more+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_more+default-devel}"
SRC_URI[aarch64_rust-uu_more+default-devel.sha256sum] = "d84c9b0e7018a7c935c400339e09866b2e8257bd730dbf535cdfa10018f471b7"

URI_aarch64_rust-uu_more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_more-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_more-devel}"
SRC_URI[aarch64_rust-uu_more-devel.sha256sum] = "386ed425f53290fa332af987fe5e298f722d854ecfdacf5bd6b9495487905e25"

RDEPENDS:rust-uu_more+default-devel = " \
 cargo \
 rust-uu_more-devel \
 "
RDEPENDS:rust-uu_more-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-crossterm+events-devel \
 rust-crossterm-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 "
