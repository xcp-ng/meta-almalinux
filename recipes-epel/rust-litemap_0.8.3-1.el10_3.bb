# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-litemap"
PV = "0.8.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-litemap+alloc-devel \
 rust-litemap+databake-devel \
 rust-litemap+default-devel \
 rust-litemap+serde-devel \
 rust-litemap+testing-devel \
 rust-litemap+yoke-devel \
 rust-litemap-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-litemap-0.8.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4445035536cfe1fdbdf9d8513fcb03867d8feefc72026785ceb5acf21c8f03be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+alloc-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-litemap+alloc-devel.sha256sum] = "a1b35034cb8fd1527e0728b96ff180e142e957a91c5833332618e180d6616a96"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+databake-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+databake-devel;unpack=0"
SRC_URI[x86_64_v2_rust-litemap+databake-devel.sha256sum] = "580fbc991b9220d17d70a725083fce604e18b1f284e6dac0b1431e5661d64c81"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+default-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-litemap+default-devel.sha256sum] = "0da282b94a674b222cc7ea94c2cfcfb72032a531026845ded98bbc910537f946"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+serde-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-litemap+serde-devel.sha256sum] = "66d0aa919602533981a3f336be00631bb536abf8f875e421e0bff9722965b66f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+testing-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+testing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-litemap+testing-devel.sha256sum] = "4487dfa5b0c709ca76cf0d171063a78b1f373a49896f1ef16918a3c966d7edcd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+yoke-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+yoke-devel;unpack=0"
SRC_URI[x86_64_v2_rust-litemap+yoke-devel.sha256sum] = "1f015471be81383b02cd28687325043a9aada2c61470b54cc8d5c94693ea73a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap-devel-0.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-litemap-devel.sha256sum] = "806736dbe68bfe145e2ecd3f2a3e1328998a2b9065970dbf98da879fc3d6f94f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+alloc-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-litemap+alloc-devel.sha256sum] = "2a528d4d9c3a9afccd805f4ec42f3c83c9b6a6d0e5ca0fc3021819dd87421873"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+databake-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+databake-devel;unpack=0"
SRC_URI[aarch64_rust-litemap+databake-devel.sha256sum] = "2ff07d86c32210504be33bb412183c993c837290a68479c04b45483526f8dd81"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+default-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+default-devel;unpack=0"
SRC_URI[aarch64_rust-litemap+default-devel.sha256sum] = "f5c5ffc22b7b82d41c186109e5007a8dc522dd12b3aedad8bbb488a31d21735b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+serde-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+serde-devel;unpack=0"
SRC_URI[aarch64_rust-litemap+serde-devel.sha256sum] = "f6f882ee807e1a69136b41c7969b56ac919ddbc9d0153aa96431c3010ef5d845"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+testing-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+testing-devel;unpack=0"
SRC_URI[aarch64_rust-litemap+testing-devel.sha256sum] = "d0b5f64f8813bf9d0461d979bd21304f4f34d5d83ac32b778a4b98d7e08f6fc9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+yoke-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+yoke-devel;unpack=0"
SRC_URI[aarch64_rust-litemap+yoke-devel.sha256sum] = "d31815a4c638f3d3f73f94ba359a5315f90f2a1dfe161edfaaa766f250b534be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap-devel-0.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-litemap-devel;unpack=0"
SRC_URI[aarch64_rust-litemap-devel.sha256sum] = "fa0c4e1ce05648122e049734dce444e1604ca9699b794c90093856bd540dac45"

RDEPENDS:rust-litemap+alloc-devel = " \
 cargo \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+default-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+serde-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-litemap+testing-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+yoke-devel = " \
 cargo \
 rust-litemap-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-litemap-devel = " \
 cargo \
 rust \
 "
