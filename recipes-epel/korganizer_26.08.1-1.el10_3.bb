# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "korganizer"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 korganizer \
 korganizer-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/korganizer-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7009a7f9a81c4ef911e1e1172f29555ad56761e0c2e116ba3b05a1a91347b05d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/korganizer-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_korganizer;unpack=0"
SRC_URI[x86_64_v2_korganizer.sha256sum] = "7727c9b5dd506468649c05312eafa0a58b10a5c626157139946f4fb7960be66e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/korganizer-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_korganizer-libs;unpack=0"
SRC_URI[x86_64_v2_korganizer-libs.sha256sum] = "3882a7c4e95d3db3659967735e117339c1c6209fcbe54fbcd4a717d1d98c9f26"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/korganizer-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_korganizer;unpack=0"
SRC_URI[aarch64_korganizer.sha256sum] = "dd214b8cce2faa4a206839499842fcfe3dafefbc692773027e7dfcb5cabd1687"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/korganizer-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_korganizer-libs;unpack=0"
SRC_URI[aarch64_korganizer-libs.sha256sum] = "90436c1217feb755c0ba5bfd0ce73b7b9e30d689f93034411043510942eaeff9"

RDEPENDS:korganizer = " \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontactinterface \
 korganizer-libs \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:korganizer-libs = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-server \
 calendarsupport \
 eventviews \
 glibc \
 incidenceeditor \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kmime \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kmailtransport \
 kontactinterface \
 korganizer \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
