# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mlt"
PV = "7.36.1"
PR = "4.el10_2"
PACKAGES = " \
 mlt \
 mlt-devel \
 mlt-php \
 mlt-qt6 \
 mlt-ruby \
 python3-mlt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mlt-7.36.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95eaf2701021bd4c2a65d7f9cf509f2864044f3b591bdba3ce7143f3b4be8135"

URI_x86_64_v2_mlt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlt-7.36.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mlt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlt}"
SRC_URI[x86_64_v2_mlt.sha256sum] = "26a56338097d7ce042d81e5d9806a9ec5917b0d178eccef0db55e473aca4f6d1"

URI_x86_64_v2_mlt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlt-devel-7.36.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mlt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlt-devel}"
SRC_URI[x86_64_v2_mlt-devel.sha256sum] = "d68a6ec12f98db31949347560dc628f484068482d7211948422c14461600dd7a"

URI_x86_64_v2_mlt-php = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlt-php-7.36.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mlt-php;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlt-php}"
SRC_URI[x86_64_v2_mlt-php.sha256sum] = "d7e533affc2278d193e3c7123dbc8a4c1000842325cf4c18ded06db9126d2937"

URI_x86_64_v2_mlt-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlt-qt6-7.36.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mlt-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlt-qt6}"
SRC_URI[x86_64_v2_mlt-qt6.sha256sum] = "2cdaf4ce33131c93d15aeca7b035c76ec9d9879e5fa0835597585b44339a7ae8"

URI_x86_64_v2_mlt-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlt-ruby-7.36.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mlt-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlt-ruby}"
SRC_URI[x86_64_v2_mlt-ruby.sha256sum] = "6301fac88a8bfe0fb698f9e53a350971065921178206047ac7f253cf7dc94d01"

URI_x86_64_v2_python3-mlt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mlt-7.36.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-mlt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mlt}"
SRC_URI[x86_64_v2_python3-mlt.sha256sum] = "b4c7befd032fdcf2f1a3ce85f820f187444377429c376b61cbcf4a69462dbe5c"

URI_aarch64_mlt = "${EPEL_MIRROR}/aarch64/Packages/m/mlt-7.36.1-4.el10_2.aarch64.rpm;name=aarch64_mlt;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlt}"
SRC_URI[aarch64_mlt.sha256sum] = "40c1534fed3795ff8504a46e01cb3a03ed1ab6fe6d31df470dd5dfce6d588d2f"

URI_aarch64_mlt-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mlt-devel-7.36.1-4.el10_2.aarch64.rpm;name=aarch64_mlt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlt-devel}"
SRC_URI[aarch64_mlt-devel.sha256sum] = "f9f75b73110babecae351d0342d8eeb5bc92e2d5899e9a058e1cf78b21ebad87"

URI_aarch64_mlt-php = "${EPEL_MIRROR}/aarch64/Packages/m/mlt-php-7.36.1-4.el10_2.aarch64.rpm;name=aarch64_mlt-php;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlt-php}"
SRC_URI[aarch64_mlt-php.sha256sum] = "feb562c1f4aff885a00f1a8c4f436d94b1521beab9adc2891fd2d3b8109d5700"

URI_aarch64_mlt-qt6 = "${EPEL_MIRROR}/aarch64/Packages/m/mlt-qt6-7.36.1-4.el10_2.aarch64.rpm;name=aarch64_mlt-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlt-qt6}"
SRC_URI[aarch64_mlt-qt6.sha256sum] = "b723090ca1f54370cf818c214941dd75124cd39ce59a23c028dd34b9e3c3a7da"

URI_aarch64_mlt-ruby = "${EPEL_MIRROR}/aarch64/Packages/m/mlt-ruby-7.36.1-4.el10_2.aarch64.rpm;name=aarch64_mlt-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlt-ruby}"
SRC_URI[aarch64_mlt-ruby.sha256sum] = "bb3ed771845a869a15d4773d0e2e66392dcdd71d9b16f7396862d985d59464c2"

URI_aarch64_python3-mlt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mlt-7.36.1-4.el10_2.aarch64.rpm;name=aarch64_python3-mlt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mlt}"
SRC_URI[aarch64_python3-mlt.sha256sum] = "a864039c77892b5796f4d757f78098c4637c4190517868123caab6e75bd25537"

RDEPENDS:mlt = " \
 alsa-lib \
 fftw-libs-double \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libX11 \
 libavcodec-free \
 libavdevice-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libebur128 \
 libepoxy \
 libexif \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libsamplerate \
 libstdc++ \
 libswresample-free \
 libswscale-free \
 libvorbis \
 libxml2 \
 mlt-qt6 \
 movit \
 opencv-core \
 opencv-imgproc \
 opencv-tracking \
 opencv-video \
 pipewire-jack-audio-connection-kit-libs \
 pulseaudio-libs \
 rubberband \
 sox \
 vid.stab \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:mlt-devel = " \
 cmake-filesystem \
 mlt \
 mlt-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mlt-php = " \
 glibc \
 libgcc \
 libstdc++ \
 mlt \
 php8.4-common \
 "
RDEPENDS:mlt-qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 mlt \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 zlib-ng-compat \
 "
RDEPENDS:mlt-ruby = " \
 glibc \
 libgcc \
 libstdc++ \
 mlt \
 "
RDEPENDS:python3-mlt = " \
 glibc \
 libgcc \
 libstdc++ \
 mlt \
 python3 \
 "
