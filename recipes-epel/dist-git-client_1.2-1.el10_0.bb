# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dist-git-client"
PV = "1.2"
PR = "1.el10_0"
PACKAGES = " \
 dist-git-client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dist-git-client-1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e7ad6fb8fe22aedeeaf140e2809c52ef4f2db588f8ea6adcf82b583fb7f178a"

URI_x86_64_v2_dist-git-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dist-git-client-1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dist-git-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dist-git-client}"
SRC_URI[x86_64_v2_dist-git-client.sha256sum] = "c724b7733f90fba13d7b29d7ba8c381289d225c53dc71c4c0e32aabcadfcea73"

URI_aarch64_dist-git-client = "${EPEL_MIRROR}/aarch64/Packages/d/dist-git-client-1.2-1.el10_0.noarch.rpm;name=aarch64_dist-git-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_dist-git-client}"
SRC_URI[aarch64_dist-git-client.sha256sum] = "7fc5e77718dccebdea8187889517c93ebf7e73ae86a3f9f260614ec971219e72"

RDEPENDS:dist-git-client = " \
 curl \
 git-core \
 python3 \
 python3-rpmautospec \
 "
