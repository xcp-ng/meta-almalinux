# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zabbix7.0"
PV = "7.0.28"
PR = "1.el10_3"
PACKAGES = " \
 zabbix7.0 \
 zabbix7.0-agent \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-dbfiles-sqlite3 \
 zabbix7.0-proxy \
 zabbix7.0-proxy-mysql \
 zabbix7.0-proxy-pgsql \
 zabbix7.0-proxy-sqlite3 \
 zabbix7.0-selinux \
 zabbix7.0-server \
 zabbix7.0-server-mysql \
 zabbix7.0-server-pgsql \
 zabbix7.0-web \
 zabbix7.0-web-mysql \
 zabbix7.0-web-pgsql \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zabbix7.0-7.0.28-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74ec2975c9618c6be73fda4ac6277de9434e0e641c859f9bb5bec8bb1e6e5b24"

URI_x86_64_v2_zabbix7.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-7.0.28-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0}"
SRC_URI[x86_64_v2_zabbix7.0.sha256sum] = "0ed915a15a11e8e6f0a476f17f227731f011e60588f54a039cd90f782ada7158"

URI_x86_64_v2_zabbix7.0-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-agent-7.0.28-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-agent}"
SRC_URI[x86_64_v2_zabbix7.0-agent.sha256sum] = "9530989c4f16ac167f29b6a5904e421d8c5bc4ce91d6130e911c3364faa9d6d0"

URI_x86_64_v2_zabbix7.0-dbfiles-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-mysql-7.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-mysql.sha256sum] = "11ae045ade2484bc59109bc233ec6a9c26b6444b9d161698d864aa5a7e294ec8"

URI_x86_64_v2_zabbix7.0-dbfiles-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-pgsql-7.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-pgsql.sha256sum] = "622aadd733d95c2cb056cb4af513396bd4e0d4c72823c2be79abdbe35346b9dc"

URI_x86_64_v2_zabbix7.0-dbfiles-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-sqlite3-7.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-sqlite3}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-sqlite3.sha256sum] = "e4b75685c67e920520735c76cede654dd3cb9a93732811038275f4cd2679cb53"

URI_x86_64_v2_zabbix7.0-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-7.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy}"
SRC_URI[x86_64_v2_zabbix7.0-proxy.sha256sum] = "de05e930c54fb1f5eaa7350b4fe7e2ec1cc82e50777cbccccb5072edd322c710"

URI_x86_64_v2_zabbix7.0-proxy-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-mysql-7.0.28-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-mysql.sha256sum] = "e64716c05c94c87f4bae7f2e92a21d106fbc20a946a31f851fabd06f6f9319a3"
RPROVIDES:zabbix7.0-proxy-mysql:x86_64_v2 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_3.alma_altarch"

URI_x86_64_v2_zabbix7.0-proxy-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-pgsql-7.0.28-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-pgsql.sha256sum] = "3ff32356182347b9e7f0320454b900d9e933c2c17b293201e6a1dcf6fcfad5f2"
RPROVIDES:zabbix7.0-proxy-pgsql:x86_64_v2 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_3.alma_altarch"

URI_x86_64_v2_zabbix7.0-proxy-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-sqlite3-7.0.28-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-sqlite3}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-sqlite3.sha256sum] = "b63088dade1162f88d3bf497e218a068deddd978339a417902166243440160fd"
RPROVIDES:zabbix7.0-proxy-sqlite3:x86_64_v2 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_3.alma_altarch"

URI_x86_64_v2_zabbix7.0-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-selinux-7.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-selinux}"
SRC_URI[x86_64_v2_zabbix7.0-selinux.sha256sum] = "40a05b7bb2f3ad94f161f237612c138eac7d1717f7b460aaa26757a07ae49f7f"

URI_x86_64_v2_zabbix7.0-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-7.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server}"
SRC_URI[x86_64_v2_zabbix7.0-server.sha256sum] = "77df41b39a38ac536c1d93fa743cdc29e3997220ea9e2fe73081133f87a573b8"

URI_x86_64_v2_zabbix7.0-server-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-mysql-7.0.28-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-server-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-server-mysql.sha256sum] = "5198756335f935442f13676fdba55f98d249693cc5ee7a76e8cbd8ab07948668"
RPROVIDES:zabbix7.0-server-mysql:x86_64_v2 = "virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_3.alma_altarch"

URI_x86_64_v2_zabbix7.0-server-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-pgsql-7.0.28-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-server-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-server-pgsql.sha256sum] = "75d3d7c2aab1b9345c95877a3badcb6ae656bae9b4a0adc2105e04ed3c60977d"
RPROVIDES:zabbix7.0-server-pgsql:x86_64_v2 = "virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_3.alma_altarch"

URI_x86_64_v2_zabbix7.0-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-7.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web}"
SRC_URI[x86_64_v2_zabbix7.0-web.sha256sum] = "ba71e40f309b72064c97088f97c408973efb63aba08a949d85c74631debbd39e"

URI_x86_64_v2_zabbix7.0-web-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-mysql-7.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-web-mysql.sha256sum] = "59c771ef5f35a6fee9b1ba8ba5ec026ec44111738e15d813291907d7aaf79f44"
RPROVIDES:zabbix7.0-web-mysql:x86_64_v2 = "virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_3.alma_altarch"

URI_x86_64_v2_zabbix7.0-web-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-pgsql-7.0.28-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-web-pgsql.sha256sum] = "61d4ff1a37f3925ad81d09f564060335b457f5cb8d9f25e1d67c555b70f9c1fb"
RPROVIDES:zabbix7.0-web-pgsql:x86_64_v2 = "virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_3.alma_altarch"

URI_aarch64_zabbix7.0 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-7.0.28-1.el10_3.aarch64.rpm;name=aarch64_zabbix7.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0}"
SRC_URI[aarch64_zabbix7.0.sha256sum] = "9531ee067faa9300db5d822ef40392d56ab6ee7e5698c4d280a4680f87d81baa"

URI_aarch64_zabbix7.0-agent = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-agent-7.0.28-1.el10_3.aarch64.rpm;name=aarch64_zabbix7.0-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-agent}"
SRC_URI[aarch64_zabbix7.0-agent.sha256sum] = "6010418e74c391ff1f0348fbd2bd333644192403388789562304d23839366824"

URI_aarch64_zabbix7.0-dbfiles-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-mysql-7.0.28-1.el10_3.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-mysql}"
SRC_URI[aarch64_zabbix7.0-dbfiles-mysql.sha256sum] = "dc9b3be30a8fb34692a78197dc1a586014fbe9e176f93c1c683cc5feb593b673"

URI_aarch64_zabbix7.0-dbfiles-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-pgsql-7.0.28-1.el10_3.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-pgsql}"
SRC_URI[aarch64_zabbix7.0-dbfiles-pgsql.sha256sum] = "0f636145f6d28a6470448fe6d2f6eff4a879e8cf3d2ee4f286d9bfd7d52052a8"

URI_aarch64_zabbix7.0-dbfiles-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-sqlite3-7.0.28-1.el10_3.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-sqlite3}"
SRC_URI[aarch64_zabbix7.0-dbfiles-sqlite3.sha256sum] = "868db6ac4dbcda730e49ab057da8927b23caad3d23e95f62833652f0325bc107"

URI_aarch64_zabbix7.0-proxy = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-7.0.28-1.el10_3.noarch.rpm;name=aarch64_zabbix7.0-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy}"
SRC_URI[aarch64_zabbix7.0-proxy.sha256sum] = "4978db6d431691a5b1752a555a96453124079b5ae31816a41fd5beb6e8d8078d"

URI_aarch64_zabbix7.0-proxy-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-mysql-7.0.28-1.el10_3.aarch64.rpm;name=aarch64_zabbix7.0-proxy-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-mysql}"
SRC_URI[aarch64_zabbix7.0-proxy-mysql.sha256sum] = "a64941035328d1f73f8a6ef9a1ff88fe1837ebbbb2aa0efd3c0ea4db6809ef89"
RPROVIDES:zabbix7.0-proxy-mysql:aarch64 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_3"

URI_aarch64_zabbix7.0-proxy-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-pgsql-7.0.28-1.el10_3.aarch64.rpm;name=aarch64_zabbix7.0-proxy-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-pgsql}"
SRC_URI[aarch64_zabbix7.0-proxy-pgsql.sha256sum] = "154f71a34c60dce0b394f23fa618dadcec155cba7779483b9ca81c08adcda198"
RPROVIDES:zabbix7.0-proxy-pgsql:aarch64 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_3"

URI_aarch64_zabbix7.0-proxy-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-sqlite3-7.0.28-1.el10_3.aarch64.rpm;name=aarch64_zabbix7.0-proxy-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-sqlite3}"
SRC_URI[aarch64_zabbix7.0-proxy-sqlite3.sha256sum] = "44698f558a0d95aad23049977dcb2fe2074ef3c47863584ff361cb39f3b43725"
RPROVIDES:zabbix7.0-proxy-sqlite3:aarch64 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_3"

URI_aarch64_zabbix7.0-selinux = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-selinux-7.0.28-1.el10_3.noarch.rpm;name=aarch64_zabbix7.0-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-selinux}"
SRC_URI[aarch64_zabbix7.0-selinux.sha256sum] = "86248abc73f0b0fb95f4771710abe2b5449f1ce9209ea931cb5794abef26c32c"

URI_aarch64_zabbix7.0-server = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-7.0.28-1.el10_3.noarch.rpm;name=aarch64_zabbix7.0-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server}"
SRC_URI[aarch64_zabbix7.0-server.sha256sum] = "5bb497ba5f84f7a5759c113b5121415e9118635c8fd6c9d4c13158075d472b35"

URI_aarch64_zabbix7.0-server-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-mysql-7.0.28-1.el10_3.aarch64.rpm;name=aarch64_zabbix7.0-server-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server-mysql}"
SRC_URI[aarch64_zabbix7.0-server-mysql.sha256sum] = "bc6b6169cb28ceebd9408c361627f54d0e0dc956dd9293cf3ddd50467574d07c"
RPROVIDES:zabbix7.0-server-mysql:aarch64 = "virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_3"

URI_aarch64_zabbix7.0-server-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-pgsql-7.0.28-1.el10_3.aarch64.rpm;name=aarch64_zabbix7.0-server-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server-pgsql}"
SRC_URI[aarch64_zabbix7.0-server-pgsql.sha256sum] = "7d72bb75c12eda48a27f873fe42eda92964e8f085106533d60afe4b20408a0ea"
RPROVIDES:zabbix7.0-server-pgsql:aarch64 = "virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_3"

URI_aarch64_zabbix7.0-web = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-7.0.28-1.el10_3.noarch.rpm;name=aarch64_zabbix7.0-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web}"
SRC_URI[aarch64_zabbix7.0-web.sha256sum] = "63c2881eb2a03b011f3eeb8e6175cae44279cb41523a357ec63e466ffd227f01"

URI_aarch64_zabbix7.0-web-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-mysql-7.0.28-1.el10_3.noarch.rpm;name=aarch64_zabbix7.0-web-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web-mysql}"
SRC_URI[aarch64_zabbix7.0-web-mysql.sha256sum] = "ac5838fe7f2b8d17d9a1e78e50eee21085a27b716a81bdf9d06335d0b9d7e87f"
RPROVIDES:zabbix7.0-web-mysql:aarch64 = "virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_3"

URI_aarch64_zabbix7.0-web-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-pgsql-7.0.28-1.el10_3.noarch.rpm;name=aarch64_zabbix7.0-web-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web-pgsql}"
SRC_URI[aarch64_zabbix7.0-web-pgsql.sha256sum] = "bbc0b6e2fb8f41c356b3e787b730f53a0ec258220e0b7e669b0460d50389d5fd"
RPROVIDES:zabbix7.0-web-pgsql:aarch64 = "virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_3"

RDEPENDS:zabbix7.0 = " \
 glibc \
 libxml2 \
 logrotate \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-selinux \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-agent = " \
 bash \
 glibc \
 openldap \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-dbfiles-mysql = " \
 "
RDEPENDS:zabbix7.0-dbfiles-pgsql = " \
 "
RDEPENDS:zabbix7.0-dbfiles-sqlite3 = " \
 "
RDEPENDS:zabbix7.0-proxy:x86_64_v2 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_3.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-proxy:aarch64 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_3 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-proxy-mysql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 mariadb-connector-c \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-proxy-pgsql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libpq \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-proxy-sqlite3 = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 sqlite-libs \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-sqlite3 \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:zabbix7.0-server:x86_64_v2 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 traceroute \
 virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_3.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-server:aarch64 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 traceroute \
 virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_3 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-server-mysql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 mariadb-connector-c \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-server \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-server-pgsql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libpq \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-server \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-web:x86_64_v2 = " \
 bash \
 dejavu-sans-fonts \
 js-jquery \
 virtual/php-bcmath \
 virtual/php-fpm_ge_8.0 \
 virtual/php-gd \
 virtual/php-gettext \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-xml \
 virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_3.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-web:aarch64 = " \
 bash \
 dejavu-sans-fonts \
 js-jquery \
 virtual/php-bcmath \
 virtual/php-fpm_ge_8.0 \
 virtual/php-gd \
 virtual/php-gettext \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-xml \
 virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_3 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-web-mysql = " \
 virtual/php-mysqli \
 zabbix7.0-web \
 "
RDEPENDS:zabbix7.0-web-pgsql = " \
 virtual/php-pgsql \
 zabbix7.0-web \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_3.alma_altarch rpm/virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_3.alma_altarch rpm/virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_3.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/zabbix7.0-proxy-implementation_eq_7.0.28-1.el10_3 rpm/virtual/zabbix7.0-server-implementation_eq_7.0.28-1.el10_3 rpm/virtual/zabbix7.0-web-database_eq_7.0.28-1.el10_3"
