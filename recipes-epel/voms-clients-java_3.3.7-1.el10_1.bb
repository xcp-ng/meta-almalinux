# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voms-clients-java"
PV = "3.3.7"
PR = "1.el10_1"
PACKAGES = " \
 voms-clients-java \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/voms-clients-java-3.3.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ad15b46c3ea0c3e74e0de928120509e4bd5269bc995741b9d4239334ea247d7"

URI_x86_64_v2_voms-clients-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-clients-java-3.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_voms-clients-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-clients-java}"
SRC_URI[x86_64_v2_voms-clients-java.sha256sum] = "90bbb2d97fcceade593a5c58a9c1b98e8736041a2098128fda1135399746ba2d"
RPROVIDES:voms-clients-java:append:x86_64_v2 = " virtual/voms-clients"

URI_aarch64_voms-clients-java = "${EPEL_MIRROR}/aarch64/Packages/v/voms-clients-java-3.3.7-1.el10_1.noarch.rpm;name=aarch64_voms-clients-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-clients-java}"
SRC_URI[aarch64_voms-clients-java.sha256sum] = "5e2cdaaa0afd73e9f0b20a93755cea13b162335248da108827fc9242e5a553c3"
RPROVIDES:voms-clients-java:append:aarch64 = " virtual/voms-clients"

RDEPENDS:voms-clients-java = " \
 alternatives \
 apache-commons-cli \
 apache-commons-io \
 bash \
 javapackages-filesystem \
 javapackages-tools \
 virtual/java-headless_or_java-21-headless_or_java-25-headless \
 voms-api-java \
 "
