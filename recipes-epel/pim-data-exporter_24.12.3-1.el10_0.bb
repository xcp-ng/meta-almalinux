# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pim-data-exporter"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 pim-data-exporter \
 pim-data-exporter-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pim-data-exporter-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c2f91e6a9f6b5f51402db27e83a96013276d8dcbe3f276a1abb664368f8ba1c"

URI_x86_64_v2_pim-data-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-data-exporter-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-data-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-data-exporter}"
SRC_URI[x86_64_v2_pim-data-exporter.sha256sum] = "0b30d65d1aafcf9356ee47a0ba59e61e41b308027fa62b77fb867971005a16fd"

URI_x86_64_v2_pim-data-exporter-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-data-exporter-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-data-exporter-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-data-exporter-libs}"
SRC_URI[x86_64_v2_pim-data-exporter-libs.sha256sum] = "7e82b18a8e2fc4f9ceeedbd913b73aa72bff36cbe1fe4b91d71050081a2042b8"

URI_aarch64_pim-data-exporter = "${EPEL_MIRROR}/aarch64/Packages/p/pim-data-exporter-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_pim-data-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-data-exporter}"
SRC_URI[aarch64_pim-data-exporter.sha256sum] = "d1189d77687fb4fb09cced1985afaa8ef19ea68df8300bf5fcbc9e3b2810e5e9"

URI_aarch64_pim-data-exporter-libs = "${EPEL_MIRROR}/aarch64/Packages/p/pim-data-exporter-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_pim-data-exporter-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-data-exporter-libs}"
SRC_URI[aarch64_pim-data-exporter-libs.sha256sum] = "011bffaca5883522e03beac75c581a6ced9bc1c2e50839b9ad44051ee705db34"

RDEPENDS:pim-data-exporter = " \
 akonadi-server \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 mailcommon \
 pim-data-exporter-libs \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pim-data-exporter-libs = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libstdc++ \
 mailcommon \
 pim-data-exporter \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
