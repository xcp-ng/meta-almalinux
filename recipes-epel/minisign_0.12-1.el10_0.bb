# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "minisign"
PV = "0.12"
PR = "1.el10_0"
PACKAGES = " \
 minisign \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/minisign-0.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c66dea6a8319eef5d9e7fad4a90c3eb9f4da8a3470f6e7c80b434caf3fcf4452"

URI_x86_64_v2_minisign = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minisign-0.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minisign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minisign}"
SRC_URI[x86_64_v2_minisign.sha256sum] = "5653bb1b8ff48b5fd9bb9e50e7c3fc6cb23802200e72513492ebe448f3e2b16d"

URI_aarch64_minisign = "${EPEL_MIRROR}/aarch64/Packages/m/minisign-0.12-1.el10_0.aarch64.rpm;name=aarch64_minisign;unpack=0"
SRC_URI:append = " ${URI_aarch64_minisign}"
SRC_URI[aarch64_minisign.sha256sum] = "0d98c29722eb4ec6afa8fcf658c229aecddc8ef0bbae38008bb487a3a28b3c6a"

RDEPENDS:minisign = " \
 glibc \
 libsodium \
 "
