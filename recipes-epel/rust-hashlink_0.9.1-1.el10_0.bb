# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashlink"
PV = "0.9.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-hashlink+default-devel \
 rust-hashlink+serde-devel \
 rust-hashlink+serde_impl-devel \
 rust-hashlink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashlink-0.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "716fcfd5376861220a2c73d564367291413d5aa00f92f32056e1d968ef478f1f"

URI_x86_64_v2_rust-hashlink+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+default-devel-0.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+default-devel}"
SRC_URI[x86_64_v2_rust-hashlink+default-devel.sha256sum] = "7b506172dcedf7d1bab183b999d825c0bfa9a7ee2a13c02887cfd3c494f39b4b"

URI_x86_64_v2_rust-hashlink+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+serde-devel-0.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+serde-devel}"
SRC_URI[x86_64_v2_rust-hashlink+serde-devel.sha256sum] = "d21614391482770b5606776bb2db5fa5dd7bf61154e2eb1db24a99a24cbc092f"

URI_x86_64_v2_rust-hashlink+serde_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+serde_impl-devel-0.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+serde_impl-devel}"
SRC_URI[x86_64_v2_rust-hashlink+serde_impl-devel.sha256sum] = "ceda43b992c14010c9f906cf4341b71af50521ca9e9d792d563b3853ef2cb880"

URI_x86_64_v2_rust-hashlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink-devel-0.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink-devel}"
SRC_URI[x86_64_v2_rust-hashlink-devel.sha256sum] = "29e3a39d88d25a8e6edf8321d2755215fa1ca2d5df832f2514b56d9cc8747e27"

URI_aarch64_rust-hashlink+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+default-devel-0.9.1-1.el10_0.noarch.rpm;name=aarch64_rust-hashlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+default-devel}"
SRC_URI[aarch64_rust-hashlink+default-devel.sha256sum] = "21fea47d0798991bb471080e531d128329dface74b6a08f271afb6a0038a178c"

URI_aarch64_rust-hashlink+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+serde-devel-0.9.1-1.el10_0.noarch.rpm;name=aarch64_rust-hashlink+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+serde-devel}"
SRC_URI[aarch64_rust-hashlink+serde-devel.sha256sum] = "a44a39a1f62d401e2ef0f117f6189115cdf4b183b7c3e61ce8f47c8520b1a39b"

URI_aarch64_rust-hashlink+serde_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+serde_impl-devel-0.9.1-1.el10_0.noarch.rpm;name=aarch64_rust-hashlink+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+serde_impl-devel}"
SRC_URI[aarch64_rust-hashlink+serde_impl-devel.sha256sum] = "ef143896a1a155f496fed5767b5f40900658da21e16cedcfd5daa0f41a560081"

URI_aarch64_rust-hashlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink-devel-0.9.1-1.el10_0.noarch.rpm;name=aarch64_rust-hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink-devel}"
SRC_URI[aarch64_rust-hashlink-devel.sha256sum] = "3e70bdb88cba010314a4c43e8652fd96aa6e36b851c720b5bcc514d1c7a48e84"

RDEPENDS:rust-hashlink+default-devel = " \
 cargo \
 rust-hashlink-devel \
 "
RDEPENDS:rust-hashlink+serde-devel = " \
 cargo \
 rust-hashlink-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashlink+serde_impl-devel = " \
 cargo \
 rust-hashlink+serde-devel \
 rust-hashlink-devel \
 "
RDEPENDS:rust-hashlink-devel = " \
 cargo \
 rust-hashbrown0.14+ahash-devel \
 rust-hashbrown0.14+inline-more-devel \
 rust-hashbrown0.14-devel \
 "
