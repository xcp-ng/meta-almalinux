# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-merge3"
PV = "0.0.16"
PR = "17.el10_3"
PACKAGES = " \
 python3-merge3 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-merge3-0.0.16-17.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "12ca529897914085b83e8db6119986f7ab1dee6a947b1a53923a9a92e4e7d317"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-merge3-0.0.16-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-merge3;unpack=0"
SRC_URI[x86_64_v2_python3-merge3.sha256sum] = "ff424e2f09d9a60920b6440ac42d0284c88d52e10b8094e9f5f92435b413b202"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-merge3-0.0.16-17.el10_3.noarch.rpm;name=aarch64_python3-merge3;unpack=0"
SRC_URI[aarch64_python3-merge3.sha256sum] = "3d03e1da30ee35e09d0cf37e99fde45809a813d4d7c4844a411a4487bbe58011"

RDEPENDS:python3-merge3 = " \
 python3 \
 "
