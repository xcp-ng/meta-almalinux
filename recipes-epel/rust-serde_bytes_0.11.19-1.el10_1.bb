# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_bytes"
PV = "0.11.19"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde_bytes+alloc-devel \
 rust-serde_bytes+default-devel \
 rust-serde_bytes+std-devel \
 rust-serde_bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_bytes-0.11.19-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f32ee50e082a4f47b7d340580c6f5821cd700f7abc01a34a90365afc451689c"

URI_x86_64_v2_rust-serde_bytes+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes+alloc-devel-0.11.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_bytes+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_bytes+alloc-devel.sha256sum] = "2be8e39f0f265bc2afe901dd0e2900000e0e86ed71e18de04f5f33a2183b5bda"

URI_x86_64_v2_rust-serde_bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes+default-devel-0.11.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_bytes+default-devel}"
SRC_URI[x86_64_v2_rust-serde_bytes+default-devel.sha256sum] = "2059b9cc16facb932af3dd878baa096d9db09f67ec0596505c4d747e36fd0148"

URI_x86_64_v2_rust-serde_bytes+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes+std-devel-0.11.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_bytes+std-devel}"
SRC_URI[x86_64_v2_rust-serde_bytes+std-devel.sha256sum] = "3177ceedc7522bd845c6ff28425c0001daa174947055f7375be376c23404931e"

URI_x86_64_v2_rust-serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_bytes-devel-0.11.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-serde_bytes-devel.sha256sum] = "d832a0dc14cc47b5c232706ab11b4946365dea054e1c1b2570fda0e5f15a70b2"

URI_aarch64_rust-serde_bytes+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes+alloc-devel-0.11.19-1.el10_1.noarch.rpm;name=aarch64_rust-serde_bytes+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_bytes+alloc-devel}"
SRC_URI[aarch64_rust-serde_bytes+alloc-devel.sha256sum] = "c722e7fead4dc55fa8dbb5eda2851575156187a0022022833aec2aaf54ed3207"

URI_aarch64_rust-serde_bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes+default-devel-0.11.19-1.el10_1.noarch.rpm;name=aarch64_rust-serde_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_bytes+default-devel}"
SRC_URI[aarch64_rust-serde_bytes+default-devel.sha256sum] = "7d42c4d58409de079f2b309c8ff399dc18a1f1041fb1470f458d9e0051e60954"

URI_aarch64_rust-serde_bytes+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes+std-devel-0.11.19-1.el10_1.noarch.rpm;name=aarch64_rust-serde_bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_bytes+std-devel}"
SRC_URI[aarch64_rust-serde_bytes+std-devel.sha256sum] = "9f85227f38059fa52562f85f71c5a52b65b199452e65ea73f7e3c826fce6b19d"

URI_aarch64_rust-serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_bytes-devel-0.11.19-1.el10_1.noarch.rpm;name=aarch64_rust-serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_bytes-devel}"
SRC_URI[aarch64_rust-serde_bytes-devel.sha256sum] = "2b32a945b868b8b838169ec2e42e02a3eabe12cdbb33a5504556a48b77298da6"

RDEPENDS:rust-serde_bytes+alloc-devel = " \
 cargo \
 rust-serde_bytes-devel \
 rust-serde_core+alloc-devel \
 "
RDEPENDS:rust-serde_bytes+default-devel = " \
 cargo \
 rust-serde_bytes+std-devel \
 rust-serde_bytes-devel \
 "
RDEPENDS:rust-serde_bytes+std-devel = " \
 cargo \
 rust-serde_bytes-devel \
 rust-serde_core+std-devel \
 "
RDEPENDS:rust-serde_bytes-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core-devel \
 "
