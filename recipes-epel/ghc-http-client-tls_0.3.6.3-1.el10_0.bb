# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-http-client-tls"
PV = "0.3.6.3"
PR = "1.el10_0"
PACKAGES = " \
 ghc-http-client-tls \
 ghc-http-client-tls-devel \
 ghc-http-client-tls-doc \
 ghc-http-client-tls-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-http-client-tls-0.3.6.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec4e3f9d76799a95c917d1fd22f07bcb2026e3342e79f422de529ea4b4f248b4"

URI_x86_64_v2_ghc-http-client-tls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-client-tls-0.3.6.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-client-tls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-client-tls}"
SRC_URI[x86_64_v2_ghc-http-client-tls.sha256sum] = "c3ad4023391695378f4ccee24dc82a2598c2e76ed426fc0f8bd042fe38198f33"

URI_x86_64_v2_ghc-http-client-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-client-tls-devel-0.3.6.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-client-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-client-tls-devel}"
SRC_URI[x86_64_v2_ghc-http-client-tls-devel.sha256sum] = "d084f32bda01826b73476a9f66aaa5fcf85bf688533aaf59342ec2193bbffe33"

URI_x86_64_v2_ghc-http-client-tls-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-client-tls-doc-0.3.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-http-client-tls-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-client-tls-doc}"
SRC_URI[x86_64_v2_ghc-http-client-tls-doc.sha256sum] = "c1c154ff514cc58ebd9537706e83f20d9d8195357c5603fbad145f77ea644ca5"

URI_x86_64_v2_ghc-http-client-tls-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-client-tls-prof-0.3.6.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-client-tls-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-client-tls-prof}"
SRC_URI[x86_64_v2_ghc-http-client-tls-prof.sha256sum] = "b8a9527748192e56f478045f0de71fe1e639e8a48b6178135d80eba9689c5505"

URI_aarch64_ghc-http-client-tls = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-client-tls-0.3.6.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-http-client-tls;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-client-tls}"
SRC_URI[aarch64_ghc-http-client-tls.sha256sum] = "11ffa25237f605b83881dc403ab8221ceb322d16c5edb4ecee1fb9d01d2fb3b3"

URI_aarch64_ghc-http-client-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-client-tls-devel-0.3.6.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-http-client-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-client-tls-devel}"
SRC_URI[aarch64_ghc-http-client-tls-devel.sha256sum] = "e03121aa8c45b8944db5d961a2951cfea944f90c18635432153851f9674ada38"

URI_aarch64_ghc-http-client-tls-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-client-tls-doc-0.3.6.3-1.el10_0.noarch.rpm;name=aarch64_ghc-http-client-tls-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-client-tls-doc}"
SRC_URI[aarch64_ghc-http-client-tls-doc.sha256sum] = "fb7558d8343f95bad360c4d896da05a74d12c9bc17b8045268b6d0798ad21e90"

URI_aarch64_ghc-http-client-tls-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-client-tls-prof-0.3.6.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-http-client-tls-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-client-tls-prof}"
SRC_URI[aarch64_ghc-http-client-tls-prof.sha256sum] = "fce035a70752a698fccbc44dd51ae3827023f686fdba6c1acbc2247d0609f66d"

RDEPENDS:ghc-http-client-tls = " \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-async \
 ghc-base \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-binary \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-containers \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-types \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-process \
 ghc-random \
 ghc-socks \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-text \
 ghc-th-compat \
 ghc-time \
 ghc-tls \
 ghc-transformers \
 ghc-unix \
 ghc-unix-time \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-http-client-tls-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-crypton-connection-devel \
 ghc-crypton-devel \
 ghc-data-default-class-devel \
 ghc-exceptions-devel \
 ghc-http-client-devel \
 ghc-http-client-tls \
 ghc-http-types-devel \
 ghc-memory-devel \
 ghc-network-devel \
 ghc-network-uri-devel \
 ghc-text-devel \
 ghc-tls-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-http-client-tls-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-http-client-tls-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-containers-prof \
 ghc-crypton-connection-prof \
 ghc-crypton-prof \
 ghc-data-default-class-prof \
 ghc-exceptions-prof \
 ghc-http-client-prof \
 ghc-http-client-tls-devel \
 ghc-http-types-prof \
 ghc-memory-prof \
 ghc-network-prof \
 ghc-network-uri-prof \
 ghc-text-prof \
 ghc-tls-prof \
 ghc-transformers-prof \
 "
