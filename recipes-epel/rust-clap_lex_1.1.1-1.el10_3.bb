# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_lex"
PV = "1.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap_lex+default-devel \
 rust-clap_lex-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-clap_lex-1.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ecfd2aa16789a47ef7f72df9ce2ed2148e5cc606e248cb0e3bc4a48821c1d796"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex+default-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_lex+default-devel.sha256sum] = "13bf7e8f8f564e54e266f18285b31f5e0af9d088e1058621edd74a6019b5e536"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_lex-devel.sha256sum] = "58cc86a1ed1eac0c4d75060020fb6fb5603b957a93a44480ad0ca28f1f049ac8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex+default-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-clap_lex+default-devel;unpack=0"
SRC_URI[aarch64_rust-clap_lex+default-devel.sha256sum] = "a2834810c0f99eff5e38520c4adc3ab7a55c3c0db92e52dc0c11d6bd6733cfbc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-clap_lex-devel;unpack=0"
SRC_URI[aarch64_rust-clap_lex-devel.sha256sum] = "fbfb3809c5af552d9db3322881efe2e7703dd668c7b5d6414f0481adf40494b2"

RDEPENDS:rust-clap_lex+default-devel = " \
 cargo \
 rust-clap_lex-devel \
 "
RDEPENDS:rust-clap_lex-devel = " \
 cargo \
 rust \
 "
