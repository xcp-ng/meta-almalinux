# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memo-map"
PV = "0.3.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-memo-map+default-devel \
 rust-memo-map-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memo-map-0.3.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06d75fc894a173faa867c7426bca1a44566801661293de63e92e426b7160a79e"

URI_x86_64_v2_rust-memo-map+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memo-map+default-devel-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memo-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memo-map+default-devel}"
SRC_URI[x86_64_v2_rust-memo-map+default-devel.sha256sum] = "b81edffa2dd30e28cbfd701fb9cb37a4153b84d4fd24c06d7db57e01fe3bd38b"

URI_x86_64_v2_rust-memo-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memo-map-devel-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memo-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memo-map-devel}"
SRC_URI[x86_64_v2_rust-memo-map-devel.sha256sum] = "0e5250d0ee58fd418d09b8f10f2355096f528a93461037f54d47f28c402b3ae5"

URI_aarch64_rust-memo-map+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memo-map+default-devel-0.3.3-1.el10_2.noarch.rpm;name=aarch64_rust-memo-map+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memo-map+default-devel}"
SRC_URI[aarch64_rust-memo-map+default-devel.sha256sum] = "7dc2898f7019bf7cd1749eeae800766193ef53e89f44275c5c16e3ffeb64d084"

URI_aarch64_rust-memo-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memo-map-devel-0.3.3-1.el10_2.noarch.rpm;name=aarch64_rust-memo-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memo-map-devel}"
SRC_URI[aarch64_rust-memo-map-devel.sha256sum] = "c4a8928cf586130ff87ed51ee38e9b4e86ce1cbaa692548dbc107d42e0b8c368"

RDEPENDS:rust-memo-map+default-devel = " \
 cargo \
 rust-memo-map-devel \
 "
RDEPENDS:rust-memo-map-devel = " \
 cargo \
 rust \
 "
