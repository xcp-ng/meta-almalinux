# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-idna"
PV = "1.1.0"
PR = "3.el10_1"
PACKAGES = " \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna+default-devel \
 rust-idna+std-devel \
 rust-idna-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-idna-1.1.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e75cf74bf3bc3a8b128ad3f17bcb6347b651748d5b2449441c73f6d8e68df75a"

URI_x86_64_v2_rust-idna+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+alloc-devel-1.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+alloc-devel}"
SRC_URI[x86_64_v2_rust-idna+alloc-devel.sha256sum] = "752274d629e29541db942aea9e33f4f7efec6f9638262ad9554aa9967176f989"

URI_x86_64_v2_rust-idna+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+compiled_data-devel-1.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-idna+compiled_data-devel.sha256sum] = "29071388ace7c75728098fa9491c66cbba7f7a762c63ebc1032b0fc7f1eb69ac"

URI_x86_64_v2_rust-idna+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+default-devel-1.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+default-devel}"
SRC_URI[x86_64_v2_rust-idna+default-devel.sha256sum] = "efa2868b81ef309714d7496e1128791c8d914ffed98c8dd2ff1a361b836638cb"

URI_x86_64_v2_rust-idna+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+std-devel-1.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+std-devel}"
SRC_URI[x86_64_v2_rust-idna+std-devel.sha256sum] = "0b1e3835c29a7fe521573aceb7b7b424cfc4325ba594989a6a9fa93fc92b7bbe"

URI_x86_64_v2_rust-idna-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna-devel-1.1.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna-devel}"
SRC_URI[x86_64_v2_rust-idna-devel.sha256sum] = "772f3fed9e13650046687de6a2a9bb45f5a62e34bb7c6ff55edd24696bc13a84"

URI_aarch64_rust-idna+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+alloc-devel-1.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-idna+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+alloc-devel}"
SRC_URI[aarch64_rust-idna+alloc-devel.sha256sum] = "51246376b5911e3c7323a3abdc8020fcc74a8cb753cc82865e3102c5ccb8b4a7"

URI_aarch64_rust-idna+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+compiled_data-devel-1.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-idna+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+compiled_data-devel}"
SRC_URI[aarch64_rust-idna+compiled_data-devel.sha256sum] = "b9531a3fb3f68af647d463cdcbc118ff74c7da9d8c7382c094afa7c30c17ca1c"

URI_aarch64_rust-idna+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+default-devel-1.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-idna+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+default-devel}"
SRC_URI[aarch64_rust-idna+default-devel.sha256sum] = "8a52f81a6b58af7bf884e6ec09143d67074d6c3cf5c7880e67cdc0b16883d2cd"

URI_aarch64_rust-idna+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+std-devel-1.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-idna+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+std-devel}"
SRC_URI[aarch64_rust-idna+std-devel.sha256sum] = "5d3c52e6cd838c192fc7f5485135e79866fc3c3a0dae6a10d2c6199513a70e30"

URI_aarch64_rust-idna-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna-devel-1.1.0-3.el10_1.noarch.rpm;name=aarch64_rust-idna-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna-devel}"
SRC_URI[aarch64_rust-idna-devel.sha256sum] = "d0b3fe93701556913180bcd389d7a91d3df941de61d2f744388ff98fbbee758f"

RDEPENDS:rust-idna+alloc-devel = " \
 cargo \
 rust-idna-devel \
 "
RDEPENDS:rust-idna+compiled_data-devel = " \
 cargo \
 rust-idna-devel \
 rust-idna_adapter+compiled_data-devel \
 "
RDEPENDS:rust-idna+default-devel = " \
 cargo \
 rust-idna+compiled_data-devel \
 rust-idna+std-devel \
 rust-idna-devel \
 "
RDEPENDS:rust-idna+std-devel = " \
 cargo \
 rust-idna+alloc-devel \
 rust-idna-devel \
 "
RDEPENDS:rust-idna-devel = " \
 cargo \
 rust \
 rust-idna_adapter+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+default-devel \
 rust-utf8_iter+default-devel \
 "
