# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shell-words"
PV = "1.1.0"
PR = "7.el10_0"
PACKAGES = " \
 rust-shell-words+default-devel \
 rust-shell-words+std-devel \
 rust-shell-words-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-shell-words-1.1.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2d79dfd48117a7f7d943b6b1c86e5abeebcdac7ad98baa9d57d12964bc81b06"

URI_x86_64_v2_rust-shell-words+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-words+default-devel-1.1.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-words+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-words+default-devel}"
SRC_URI[x86_64_v2_rust-shell-words+default-devel.sha256sum] = "ded9518028b780bf0a2cf0ce3632eda484f649b9b425c10cfb850fb15351d1bf"

URI_x86_64_v2_rust-shell-words+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-words+std-devel-1.1.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-words+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-words+std-devel}"
SRC_URI[x86_64_v2_rust-shell-words+std-devel.sha256sum] = "7369a54032ec157d6cd18ce659943bf8bcd2f6ac34e4eea71cb17f9da8ef498c"

URI_x86_64_v2_rust-shell-words-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shell-words-devel-1.1.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shell-words-devel}"
SRC_URI[x86_64_v2_rust-shell-words-devel.sha256sum] = "b1c7a4320bb1fd236e00a1a347cf059fae9fc203075451a8a5ff53f8d7ac8b6a"

URI_aarch64_rust-shell-words+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-words+default-devel-1.1.0-7.el10_0.noarch.rpm;name=aarch64_rust-shell-words+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-words+default-devel}"
SRC_URI[aarch64_rust-shell-words+default-devel.sha256sum] = "5221fbf36b296ad29578448b84b78512f1e4dd6befa688a66f311698b21eaf55"

URI_aarch64_rust-shell-words+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-words+std-devel-1.1.0-7.el10_0.noarch.rpm;name=aarch64_rust-shell-words+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-words+std-devel}"
SRC_URI[aarch64_rust-shell-words+std-devel.sha256sum] = "0a3e371b613b8a1e37c508e84b67ecf748476457aad5b56a677f7d770144769f"

URI_aarch64_rust-shell-words-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shell-words-devel-1.1.0-7.el10_0.noarch.rpm;name=aarch64_rust-shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shell-words-devel}"
SRC_URI[aarch64_rust-shell-words-devel.sha256sum] = "c105504f8ee9b07b50aa4a61ce90a3db2df4719b3cc5c76cc8ea4972a0b3273a"

RDEPENDS:rust-shell-words+default-devel = " \
 cargo \
 rust-shell-words+std-devel \
 rust-shell-words-devel \
 "
RDEPENDS:rust-shell-words+std-devel = " \
 cargo \
 rust-shell-words-devel \
 "
RDEPENDS:rust-shell-words-devel = " \
 cargo \
 "
