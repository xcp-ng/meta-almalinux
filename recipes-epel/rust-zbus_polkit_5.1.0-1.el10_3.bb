# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zbus_polkit"
PV = "5.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-zbus_polkit+blocking-api-devel \
 rust-zbus_polkit+default-devel \
 rust-zbus_polkit+tokio-devel \
 rust-zbus_polkit-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zbus_polkit-5.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0bd0c877de0cfc58936a4041f6f1fc3d4b9b1b09b1659393bfec3197f80a6049"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_polkit+blocking-api-devel-5.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_polkit+blocking-api-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zbus_polkit+blocking-api-devel.sha256sum] = "054dade5764c26966b6b58263dcf425116f8876d1c34093e718bc586b932c897"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_polkit+default-devel-5.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_polkit+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zbus_polkit+default-devel.sha256sum] = "265a4a26a147c7abfb0d9007145b2241f35e078187063fe2cffd6e7c2f0c0f67"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_polkit+tokio-devel-5.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_polkit+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zbus_polkit+tokio-devel.sha256sum] = "f387c212cc4c6e1039599778bb69dc940a468c4ba9e87ebdbce58e3bf34eee8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_polkit-devel-5.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_polkit-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zbus_polkit-devel.sha256sum] = "5db1b8419948d23308596056888a194d1e41239ad552ec1552e9d8daa75be545"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_polkit+blocking-api-devel-5.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus_polkit+blocking-api-devel;unpack=0"
SRC_URI[aarch64_rust-zbus_polkit+blocking-api-devel.sha256sum] = "f960ae42021bf9fc80350f98fe18328c3e483cbc53addc416d1b5ba04651b2ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_polkit+default-devel-5.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus_polkit+default-devel;unpack=0"
SRC_URI[aarch64_rust-zbus_polkit+default-devel.sha256sum] = "fd5030b7364228f0636b4d54a6dcc7e27ec2626b1fbc390657bedd0a7e6eeb45"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_polkit+tokio-devel-5.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus_polkit+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-zbus_polkit+tokio-devel.sha256sum] = "8d6168596925ce6a31dfe48e9aa51f338d7a8246eaf2dd872d07ef1d9b8c6ba8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_polkit-devel-5.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus_polkit-devel;unpack=0"
SRC_URI[aarch64_rust-zbus_polkit-devel.sha256sum] = "bb5b52f59a50848267e3d8d48632a3ebe768db5d7ed377834d11a71cb815d5ee"

RDEPENDS:rust-zbus_polkit+blocking-api-devel = " \
 cargo \
 rust-zbus+blocking-api-devel \
 rust-zbus_polkit-devel \
 "
RDEPENDS:rust-zbus_polkit+default-devel = " \
 cargo \
 rust-zbus+async-io-devel \
 rust-zbus_polkit+blocking-api-devel \
 rust-zbus_polkit-devel \
 "
RDEPENDS:rust-zbus_polkit+tokio-devel = " \
 cargo \
 rust-zbus+tokio-devel \
 rust-zbus_polkit-devel \
 "
RDEPENDS:rust-zbus_polkit-devel = " \
 cargo \
 rust \
 rust-enumflags2+default-devel \
 rust-enumflags2+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_repr+default-devel \
 rust-static_assertions+default-devel \
 rust-zbus-devel \
 "
