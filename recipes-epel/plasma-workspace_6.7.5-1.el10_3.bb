# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-workspace"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 libkworkspace6 \
 plasma-lookandfeel-fedora \
 plasma-workspace \
 plasma-workspace-common \
 plasma-workspace-devel \
 plasma-workspace-doc \
 plasma-workspace-libs \
 sddm-wayland-plasma \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-workspace-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4d71d9f102c11721e74933d7cbca788bdeb3668d52cc4afd53be191ea4c14f39"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkworkspace6-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkworkspace6;unpack=0"
SRC_URI[x86_64_v2_libkworkspace6.sha256sum] = "23af4454b9c33d55fc53f5bce7c7f844a17bcb160e44b94d997206a7a846dfd9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-lookandfeel-fedora-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-lookandfeel-fedora;unpack=0"
SRC_URI[x86_64_v2_plasma-lookandfeel-fedora.sha256sum] = "3d3e3e4ae54ddbe11e5986952fd692c0165bc53809a02a964d0e12df488e3f0d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace;unpack=0"
SRC_URI[x86_64_v2_plasma-workspace.sha256sum] = "7f90be099e702697243c258feb69b2d826667192a133c5e7123f5100e5ed54e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-common-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-common;unpack=0"
SRC_URI[x86_64_v2_plasma-workspace-common.sha256sum] = "fac7c08bda93b8422f41da47001f3df4418c521d7bfa64ecade4909ab60faf2f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-devel;unpack=0"
SRC_URI[x86_64_v2_plasma-workspace-devel.sha256sum] = "8399ea38308b891c751992d7f3f3d4b48826441010c679d62e7fd93549428319"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-doc-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-workspace-doc;unpack=0"
SRC_URI[x86_64_v2_plasma-workspace-doc.sha256sum] = "a5134678339317852ecfdaa4dd4ee43c43dc0e93edeeb2c547edeab1353cd851"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-libs-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-libs;unpack=0"
SRC_URI[x86_64_v2_plasma-workspace-libs.sha256sum] = "0f41a54f03d65fcea162ea25fd93b1f78c613190e5ae8b1a47ce0bb1a70af50e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-wayland-plasma-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-wayland-plasma;unpack=0"
SRC_URI[x86_64_v2_sddm-wayland-plasma.sha256sum] = "1acb5fb21a0e90f89e9252e7bf0cbf5d20856d320b99e8f07d5d71eb035342d3"
RPROVIDES:sddm-wayland-plasma:append:x86_64_v2 = " virtual/sddm-greeter-displayserver"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkworkspace6-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_libkworkspace6;unpack=0"
SRC_URI[aarch64_libkworkspace6.sha256sum] = "609c423d742916a876e741d2047a7272a7f34142ad0c0ef2e6985d6a19149048"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-lookandfeel-fedora-6.7.5-1.el10_3.noarch.rpm;name=aarch64_plasma-lookandfeel-fedora;unpack=0"
SRC_URI[aarch64_plasma-lookandfeel-fedora.sha256sum] = "b4b0c1e3bff686c84a024336c075192ac00fb98559effebdbeeca587bc77541b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-workspace;unpack=0"
SRC_URI[aarch64_plasma-workspace.sha256sum] = "d21d0ee9b38e1c20c72d9a8225777fc771a56926d406503061371824250db111"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-common-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-workspace-common;unpack=0"
SRC_URI[aarch64_plasma-workspace-common.sha256sum] = "7b5c9d2d481030868ea2655a8585843a131b86f7a429ce184b41deb010ed9cfe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-workspace-devel;unpack=0"
SRC_URI[aarch64_plasma-workspace-devel.sha256sum] = "9b93724a77b0bb5d4d4e2ed3ac47e83915dd6f39b0f9c91aa007918e609b326f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-doc-6.7.5-1.el10_3.noarch.rpm;name=aarch64_plasma-workspace-doc;unpack=0"
SRC_URI[aarch64_plasma-workspace-doc.sha256sum] = "326dcb7193600f1484c1cabd41a0430de0bec14e60a8422b58d3acce8b115288"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-libs-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-workspace-libs;unpack=0"
SRC_URI[aarch64_plasma-workspace-libs.sha256sum] = "6866a9485cb73592a8d6f7698c4f1805d800a95afbda172a11c87915a130515f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sddm-wayland-plasma-6.7.5-1.el10_3.noarch.rpm;name=aarch64_sddm-wayland-plasma;unpack=0"
SRC_URI[aarch64_sddm-wayland-plasma.sha256sum] = "d4d0fc642c57689612debab25c2131117c50609a73574cbc20d348fbf0411271"
RPROVIDES:sddm-wayland-plasma:append:aarch64 = " virtual/sddm-greeter-displayserver"

RDEPENDS:libkworkspace6 = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 libXau \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-workspace-common \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-lookandfeel-fedora = " \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 "
RDEPENDS:plasma-workspace = " \
 PackageKit-Qt6 \
 appstream-qt \
 bash \
 dbus \
 dbus-libs \
 dbus-tools \
 fontconfig \
 glibc \
 gnome-menus \
 iso-codes \
 kactivitymanagerd \
 kde-settings-plasma \
 kf6-baloo \
 kf6-baloo-libs \
 kf6-frameworkintegration \
 kf6-karchive \
 kf6-kauth \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kded \
 kf6-kdoctools \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kparts \
 kf6-kquickcharts \
 kf6-krunner \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 kio-extras \
 kio-fuse \
 knighttime \
 kscreenlocker \
 ksystemstats \
 kwayland \
 kwin \
 layer-shell-qt \
 libICE \
 libSM \
 libX11 \
 libXcursor \
 libXfixes \
 libXtst \
 libcanberra \
 libicu \
 libkexiv2-qt6 \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 ocean-sound-theme \
 plasma-activities \
 plasma-activities-stats \
 plasma-desktop \
 plasma-keyboard \
 plasma-lookandfeel-fedora \
 plasma-workspace-common \
 plasma-workspace-libs \
 policycoreutils \
 polkit-kde \
 powerdevil \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 qt6-qttools \
 qt6-qtvirtualkeyboard \
 qt6-qtwayland \
 socat \
 systemd \
 unity-gtk3-module \
 uresourced \
 virtual/coreutils \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 xcb-util-wm \
 xdg-desktop-portal-kde \
 xmessage \
 xorg-x11-server-Xwayland \
 xprop \
 xrdb \
 zlib-ng-compat \
 "
RDEPENDS:plasma-workspace-common = " \
 "
RDEPENDS:plasma-workspace-devel = " \
 cmake-filesystem \
 libkworkspace6 \
 plasma-workspace-libs \
 "
RDEPENDS:plasma-workspace-doc = " \
 plasma-workspace-common \
 "
RDEPENDS:plasma-workspace-libs = " \
 appstream-qt \
 fontconfig \
 freetype \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kparts \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kuserfeedback \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-networkmanager-qt \
 kf6-solid \
 knighttime \
 kwayland \
 libX11 \
 libXcursor \
 libXfixes \
 libXft \
 libcanberra \
 libgcc \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libqalculate \
 libstdc++ \
 libwayland-client \
 libxcb \
 libxcrypt \
 plasma-activities \
 plasma-activities-stats \
 plasma-workspace-common \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 qt6-qtsvg \
 systemd-libs \
 xcb-util \
 xcb-util-cursor \
 "
RDEPENDS:sddm-wayland-plasma = " \
 kwin \
 layer-shell-qt \
 plasma-keyboard \
 "
