# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libev-epel"
PV = "4.33"
PR = "15~1.el10_2"
PACKAGES = " \
 libev-libevent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libev-epel-4.33-15~1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5456332b7389e5a6fdedd96bf05a3557cba7b1855e362b400d7247d84c9deb4"

URI_x86_64_v2_libev-libevent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libev-libevent-devel-4.33-15~1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libev-libevent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libev-libevent-devel}"
SRC_URI[x86_64_v2_libev-libevent-devel.sha256sum] = "290b76143ff1d4fcac72687523ff676db4cd4767db4d4ce3bdd85bd10f803417"

URI_aarch64_libev-libevent-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libev-libevent-devel-4.33-15~1.el10_2.aarch64.rpm;name=aarch64_libev-libevent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libev-libevent-devel}"
SRC_URI[aarch64_libev-libevent-devel.sha256sum] = "a2378ce4e141618ee56dba5c6930b20325dfa55c24e0a3925029792188e2cf96"

RDEPENDS:libev-libevent-devel = " \
 libev-devel \
 "
