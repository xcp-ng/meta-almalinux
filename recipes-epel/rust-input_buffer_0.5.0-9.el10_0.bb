# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-input_buffer"
PV = "0.5.0"
PR = "9.el10_0"
PACKAGES = " \
 rust-input_buffer+default-devel \
 rust-input_buffer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-input_buffer-0.5.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54cfc67c0a901caf9d558a12ce32fa8e9d835daaad967f0e86b135788e808645"

URI_x86_64_v2_rust-input_buffer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-input_buffer+default-devel-0.5.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-input_buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-input_buffer+default-devel}"
SRC_URI[x86_64_v2_rust-input_buffer+default-devel.sha256sum] = "578d2d4959b5771317e42b8c35d438029799d1d29c159e41e6555fcbc21e4b70"

URI_x86_64_v2_rust-input_buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-input_buffer-devel-0.5.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-input_buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-input_buffer-devel}"
SRC_URI[x86_64_v2_rust-input_buffer-devel.sha256sum] = "8cdc853bd333f4f3b50abafaa9653a45e5de0e749874b2cfe03973e70fac52ed"

URI_aarch64_rust-input_buffer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-input_buffer+default-devel-0.5.0-9.el10_0.noarch.rpm;name=aarch64_rust-input_buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-input_buffer+default-devel}"
SRC_URI[aarch64_rust-input_buffer+default-devel.sha256sum] = "5dc5a27e75182467b5e4a5d09e2367b1b441cc94d1fdc617f916d991b23c689d"

URI_aarch64_rust-input_buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-input_buffer-devel-0.5.0-9.el10_0.noarch.rpm;name=aarch64_rust-input_buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-input_buffer-devel}"
SRC_URI[aarch64_rust-input_buffer-devel.sha256sum] = "fad95574657db18a941d8d20ff7baecb281ea51f29aab89231c0c031b512f14f"

RDEPENDS:rust-input_buffer+default-devel = " \
 cargo \
 rust-input_buffer-devel \
 "
RDEPENDS:rust-input_buffer-devel = " \
 cargo \
 rust-bytes+default-devel \
 "
