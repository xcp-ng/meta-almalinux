# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocwmma"
PV = "6.4.0"
PR = "3.el10_1"
PACKAGES:x86_64_v2 = " \
 rocwmma-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocwmma-6.4.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ef5001c15eee2a0f55e3764f276cd225cf35a7d73947f2a35ee253c560a085c"

URI_x86_64_v2_rocwmma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocwmma-devel-6.4.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocwmma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocwmma-devel}"
SRC_URI[x86_64_v2_rocwmma-devel.sha256sum] = "5512caef18e1d9672497439873f6226c6aa592b9af40d156226b0046eba2afdc"

RDEPENDS:rocwmma-devel = " \
 "
