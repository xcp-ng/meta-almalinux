# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-vbatts-tar-split"
PV = "0.11.2"
PR = "7.el10_0"
PACKAGES = " \
 golang-github-vbatts-tar-split \
 golang-github-vbatts-tar-split-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-vbatts-tar-split-0.11.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ce6fe5e22c1ffbc7f2c412025055369813700b98e7e59333582efa6b2922783"

URI_x86_64_v2_golang-github-vbatts-tar-split = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-vbatts-tar-split-0.11.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-vbatts-tar-split;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-vbatts-tar-split}"
SRC_URI[x86_64_v2_golang-github-vbatts-tar-split.sha256sum] = "ec35df30e3fee488d27d2b47065719a20d5b9a7885318a3f52230ecf3b95a031"

URI_x86_64_v2_golang-github-vbatts-tar-split-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-vbatts-tar-split-devel-0.11.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-vbatts-tar-split-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-vbatts-tar-split-devel}"
SRC_URI[x86_64_v2_golang-github-vbatts-tar-split-devel.sha256sum] = "4f4f4ffda1a44afc74746a9d2b39d0bad52d229951e878c5979ba51d9e84c2db"

URI_aarch64_golang-github-vbatts-tar-split = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-vbatts-tar-split-0.11.2-7.el10_0.aarch64.rpm;name=aarch64_golang-github-vbatts-tar-split;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-vbatts-tar-split}"
SRC_URI[aarch64_golang-github-vbatts-tar-split.sha256sum] = "b3221f68105dc6a9bd17c7e89148684b86f35fdc75e9147c3d2eb9622c890937"

URI_aarch64_golang-github-vbatts-tar-split-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-vbatts-tar-split-devel-0.11.2-7.el10_0.noarch.rpm;name=aarch64_golang-github-vbatts-tar-split-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-vbatts-tar-split-devel}"
SRC_URI[aarch64_golang-github-vbatts-tar-split-devel.sha256sum] = "b3325d13b512fbd0e09d14fbfee861976c7b0c1d5b7e7d9aaeb67c0da2da582e"

RDEPENDS:golang-github-vbatts-tar-split = " \
 glibc \
 "
RDEPENDS:golang-github-vbatts-tar-split-devel = " \
 go-filesystem \
 golang-github-sirupsen-logrus-devel \
 golang-github-urfave-cli-devel \
 "
