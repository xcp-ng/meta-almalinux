# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_core"
PV = "1.0.228"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde_core+alloc-devel \
 rust-serde_core+default-devel \
 rust-serde_core+rc-devel \
 rust-serde_core+result-devel \
 rust-serde_core+std-devel \
 rust-serde_core+unstable-devel \
 rust-serde_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_core-1.0.228-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "080714069f60236d3ae1a7bc254aa4d58e7fa95f4df734df37b3f81e08fbbff0"

URI_x86_64_v2_rust-serde_core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+alloc-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_core+alloc-devel.sha256sum] = "f4dc37bfdab8f63128f85d3d684fa9babf0f930f440fd031f39fcee1d1517b61"

URI_x86_64_v2_rust-serde_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+default-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+default-devel}"
SRC_URI[x86_64_v2_rust-serde_core+default-devel.sha256sum] = "04fa319ea1968f4d38a99435c585a66f05a14da7991522af5845c46c4b65c55b"

URI_x86_64_v2_rust-serde_core+rc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+rc-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+rc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+rc-devel}"
SRC_URI[x86_64_v2_rust-serde_core+rc-devel.sha256sum] = "25eb04347c70683e85380f1acda31acfa82839d45cb4d2f73e23f8990674f090"

URI_x86_64_v2_rust-serde_core+result-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+result-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+result-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+result-devel}"
SRC_URI[x86_64_v2_rust-serde_core+result-devel.sha256sum] = "d2f9107b6715e174947182e2b0937c8127fd882103a905fc42098d09b162c659"

URI_x86_64_v2_rust-serde_core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+std-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+std-devel}"
SRC_URI[x86_64_v2_rust-serde_core+std-devel.sha256sum] = "0222579d69b228f77c0f0b38f199069e4cd9eddbfb0ddef084e6efe5c6b31e55"

URI_x86_64_v2_rust-serde_core+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core+unstable-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core+unstable-devel}"
SRC_URI[x86_64_v2_rust-serde_core+unstable-devel.sha256sum] = "605dd88e6de1fadb3297f7b954938937d66627a0c2540db4c5802fb8574f7266"

URI_x86_64_v2_rust-serde_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_core-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_core-devel}"
SRC_URI[x86_64_v2_rust-serde_core-devel.sha256sum] = "6575cf1c07685008bd3ff561677cb7500535c18dcb5c41b0aef1214eb54dc835"

URI_aarch64_rust-serde_core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+alloc-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+alloc-devel}"
SRC_URI[aarch64_rust-serde_core+alloc-devel.sha256sum] = "fe664f168c9095fd61794cc89e6fc2ac454d10874ecd17d40493e722a5533036"

URI_aarch64_rust-serde_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+default-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+default-devel}"
SRC_URI[aarch64_rust-serde_core+default-devel.sha256sum] = "a08a33e7a04f49d638bcc95121710641413c317ca6305b14b263749f4279724c"

URI_aarch64_rust-serde_core+rc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+rc-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde_core+rc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+rc-devel}"
SRC_URI[aarch64_rust-serde_core+rc-devel.sha256sum] = "d9bc080747e76ce120189b75b80d517e2f52bce1e0f72e8dabc4ac334b840d83"

URI_aarch64_rust-serde_core+result-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+result-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde_core+result-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+result-devel}"
SRC_URI[aarch64_rust-serde_core+result-devel.sha256sum] = "ef7530c68c2d41ba542783f5c8a4d40bf230887ce418a97ca43d29928b1d1f32"

URI_aarch64_rust-serde_core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+std-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde_core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+std-devel}"
SRC_URI[aarch64_rust-serde_core+std-devel.sha256sum] = "bff1db8a7c3363ee49b2531da98416942aa6514dfc984cf2d15d1e0d935d3854"

URI_aarch64_rust-serde_core+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core+unstable-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde_core+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core+unstable-devel}"
SRC_URI[aarch64_rust-serde_core+unstable-devel.sha256sum] = "7d2128e824aca234675d8c9694e1426ab58084d9360458b73f9588f0974887b5"

URI_aarch64_rust-serde_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_core-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_core-devel}"
SRC_URI[aarch64_rust-serde_core-devel.sha256sum] = "6c21f0c349425f8567e7f36f9a79bc179564ad5b4ab44c2143639cd9ca50a910"

RDEPENDS:rust-serde_core+alloc-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+default-devel = " \
 cargo \
 rust-serde_core+result-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+rc-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+result-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+std-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core+unstable-devel = " \
 cargo \
 rust-serde_core-devel \
 "
RDEPENDS:rust-serde_core-devel = " \
 cargo \
 rust \
 rust-serde_derive+default-devel \
 "
