# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wlcs"
PV = "1.7.0"
PR = "6.el10_0"
PACKAGES = " \
 wlcs \
 wlcs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wlcs-1.7.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9c5b3f0fe7eaa5792c8285457bd7a698af8592ac473459e192752803979a68b"

URI_x86_64_v2_wlcs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wlcs-1.7.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wlcs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wlcs}"
SRC_URI[x86_64_v2_wlcs.sha256sum] = "2ff8d4cf100c178a33373b1aedc27a4f1c3665ec849934d6f21fb36ca98056ca"

URI_x86_64_v2_wlcs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wlcs-devel-1.7.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wlcs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wlcs-devel}"
SRC_URI[x86_64_v2_wlcs-devel.sha256sum] = "f8c578b5b0399fe79291a5da0f6b7b4e03b68dc827037e7680117439e00818ff"

URI_aarch64_wlcs = "${EPEL_MIRROR}/aarch64/Packages/w/wlcs-1.7.0-6.el10_0.aarch64.rpm;name=aarch64_wlcs;unpack=0"
SRC_URI:append = " ${URI_aarch64_wlcs}"
SRC_URI[aarch64_wlcs.sha256sum] = "6b550b1c57ff20653ba7706082a57b477f92fc70a7912f4c16822eff342204fc"

URI_aarch64_wlcs-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wlcs-devel-1.7.0-6.el10_0.aarch64.rpm;name=aarch64_wlcs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wlcs-devel}"
SRC_URI[aarch64_wlcs-devel.sha256sum] = "e4e356cc53d25250760e8c381062ab28846dc357190606d24e4d3dace3c2ff56"

RDEPENDS:wlcs = " \
 glibc \
 gmock \
 gtest \
 libasan \
 libgcc \
 libstdc++ \
 libtsan \
 libubsan \
 libwayland-client \
 libwayland-server \
 "
RDEPENDS:wlcs-devel = " \
 pkgconf-pkg-config \
 wayland-devel \
 wlcs \
 "
