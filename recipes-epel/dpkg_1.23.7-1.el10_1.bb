# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dpkg"
PV = "1.23.7"
PR = "1.el10_1"
PACKAGES = " \
 dpkg \
 dpkg-dev \
 dpkg-devel \
 dpkg-perl \
 dselect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dpkg-1.23.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f56fafe5b66bd49cb6e0c048447acef4e07ec05e204f371c21f0af4509fdf750"

URI_x86_64_v2_dpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-1.23.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg}"
SRC_URI[x86_64_v2_dpkg.sha256sum] = "4bd9c69a31d9cc2f2206d5f46de10247f5215fa58cbfb1a209d5181edbe613ac"

URI_x86_64_v2_dpkg-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-dev-1.23.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dpkg-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-dev}"
SRC_URI[x86_64_v2_dpkg-dev.sha256sum] = "7c4e07b926ba54296bf471035dcb8c52edfde63dfeb58ccbdfab8377cccb0d86"

URI_x86_64_v2_dpkg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-devel-1.23.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dpkg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-devel}"
SRC_URI[x86_64_v2_dpkg-devel.sha256sum] = "8801b4c17ec63563389f4d5772d862b25d505b5fb4ffc8e1eb0bb5bf641f5dde"

URI_x86_64_v2_dpkg-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-perl-1.23.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dpkg-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-perl}"
SRC_URI[x86_64_v2_dpkg-perl.sha256sum] = "40dc79b226a1de6d8c2d65340341de08a3283c27035553f49a12b36f5846ff92"

URI_x86_64_v2_dselect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dselect-1.23.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dselect}"
SRC_URI[x86_64_v2_dselect.sha256sum] = "ecddd692c178970eefda48e5d38485182e47687278fc9c201dcabfaca64986c8"

URI_aarch64_dpkg = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-1.23.7-1.el10_1.aarch64.rpm;name=aarch64_dpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg}"
SRC_URI[aarch64_dpkg.sha256sum] = "d8475cb0c6b2e95b338c17b7ccdc41191bf50a4c5f6dddca71aaae012614426d"

URI_aarch64_dpkg-dev = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-dev-1.23.7-1.el10_1.noarch.rpm;name=aarch64_dpkg-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-dev}"
SRC_URI[aarch64_dpkg-dev.sha256sum] = "d1182c023f3d01c0ba24f7c20340c1d4a755c7d158afba010ba2bc31fdc11cfc"

URI_aarch64_dpkg-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-devel-1.23.7-1.el10_1.aarch64.rpm;name=aarch64_dpkg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-devel}"
SRC_URI[aarch64_dpkg-devel.sha256sum] = "3839c16d539447e45c8d5813f1ef970a295a7a1aa9fe118277d6f8b35e2b5d53"

URI_aarch64_dpkg-perl = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-perl-1.23.7-1.el10_1.noarch.rpm;name=aarch64_dpkg-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-perl}"
SRC_URI[aarch64_dpkg-perl.sha256sum] = "4f1ec54ba09c7243363ddaf6967bc720ddf71d0b88969a999c76c65fd57589ca"

URI_aarch64_dselect = "${EPEL_MIRROR}/aarch64/Packages/d/dselect-1.23.7-1.el10_1.aarch64.rpm;name=aarch64_dselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_dselect}"
SRC_URI[aarch64_dselect.sha256sum] = "59c06cb0dbc2dce4a1096521a61ca24eb36e0d1d67442abd4048700579caa9b9"

RDEPENDS:dpkg = " \
 bash \
 bzip2-libs \
 glibc \
 libmd \
 libselinux \
 libzstd \
 tar \
 xz-libs \
 zlib-ng \
 "
RDEPENDS:dpkg-dev = " \
 binutils \
 bzip2 \
 dpkg-perl \
 gcc \
 make \
 patch \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-interpreter \
 perl-libs \
 xz \
 xz-lzma-compat \
 zstd \
 "
RDEPENDS:dpkg-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:dpkg-perl = " \
 dpkg \
 dpkg-perl \
 perl-Carp \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Digest-SHA1 \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-IO \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Tie \
 perl-Time-HiRes \
 perl-Time-Piece \
 perl-TimeDate \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-parent \
 "
RDEPENDS:dselect = " \
 bash \
 dpkg \
 dpkg-perl \
 dselect \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Path \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-parent \
 "
