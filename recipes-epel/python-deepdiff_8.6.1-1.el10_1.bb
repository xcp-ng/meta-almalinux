# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-deepdiff"
PV = "8.6.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-deepdiff \
 python3-deepdiff+cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-deepdiff-8.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0706e725bc5f20234a93cce1fa068d460115f7dfa6ff2e176eee18e14000f78c"

URI_x86_64_v2_python3-deepdiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-deepdiff-8.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-deepdiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-deepdiff}"
SRC_URI[x86_64_v2_python3-deepdiff.sha256sum] = "924cdd9c6d80522f1b718d58f349aaf49af842c4d5e028a2b7230efe3d6e69a5"

URI_x86_64_v2_python3-deepdiff+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-deepdiff+cli-8.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-deepdiff+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-deepdiff+cli}"
SRC_URI[x86_64_v2_python3-deepdiff+cli.sha256sum] = "57dc112de9ea0e6647e3decf6b05af3c955298f4b1c5cbf94902ab161a0c8dda"

URI_aarch64_python3-deepdiff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-deepdiff-8.6.1-1.el10_1.noarch.rpm;name=aarch64_python3-deepdiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-deepdiff}"
SRC_URI[aarch64_python3-deepdiff.sha256sum] = "00957a1595cce9986c30cf33ac830544c2ac847b6825342706480787aa80f112"

URI_aarch64_python3-deepdiff+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-deepdiff+cli-8.6.1-1.el10_1.noarch.rpm;name=aarch64_python3-deepdiff+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-deepdiff+cli}"
SRC_URI[aarch64_python3-deepdiff+cli.sha256sum] = "862f0898df8e06922c1738dee9e6db825caba9bd4fc4c2dc9a0ffbdbfa66d60f"

RDEPENDS:python3-deepdiff = " \
 python3 \
 python3-orderly-set \
 "
RDEPENDS:python3-deepdiff+cli = " \
 python3 \
 python3-click \
 python3-deepdiff \
 python3-pyyaml \
 "
