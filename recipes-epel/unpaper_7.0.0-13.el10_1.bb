# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unpaper"
PV = "7.0.0"
PR = "13.el10_1"
PACKAGES = " \
 unpaper \
 unpaper-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/unpaper-7.0.0-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce0f773ebd0077ed22fe47bdcd19df9053c99dd01ec5e12c6d3e828d72469f8f"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - unpaper: libavcodec.so.61()(64bit)
# - unpaper: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - unpaper: libavformat.so.61()(64bit)
# - unpaper: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - unpaper: libavutil.so.59()(64bit)
# - unpaper: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_unpaper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unpaper-7.0.0-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unpaper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unpaper}"
SRC_URI[x86_64_v2_unpaper.sha256sum] = "695801a12a0736ec2f2ef3ce9df797d6c4ce0f7c7ccc0f1839e76ce6a0190df1"

URI_x86_64_v2_unpaper-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unpaper-tests-7.0.0-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_unpaper-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unpaper-tests}"
SRC_URI[x86_64_v2_unpaper-tests.sha256sum] = "3fc3e0dc39fd53a671f9e3529330e5c7270391522266489971ef841ac0214f5b"

URI_aarch64_unpaper = "${EPEL_MIRROR}/aarch64/Packages/u/unpaper-7.0.0-13.el10_1.aarch64.rpm;name=aarch64_unpaper;unpack=0"
SRC_URI:append = " ${URI_aarch64_unpaper}"
SRC_URI[aarch64_unpaper.sha256sum] = "727db278469d9a8f51021fa6c794af73440c7e3f08a2e5e9fd088c4a44a64982"

URI_aarch64_unpaper-tests = "${EPEL_MIRROR}/aarch64/Packages/u/unpaper-tests-7.0.0-13.el10_1.noarch.rpm;name=aarch64_unpaper-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_unpaper-tests}"
SRC_URI[aarch64_unpaper-tests.sha256sum] = "62433295d6c5ccccf2db169e48ba5a3a4a177da31ba6b985fd327ea18668bbe1"

RDEPENDS:unpaper:x86_64_v2 = " \
 glibc \
"
RDEPENDS:unpaper:aarch64 = " \
 glibc \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
"
RDEPENDS:unpaper-tests = " \
 bash \
 python3-pillow \
 python3-pytest \
 python3-pytest-xdist \
 unpaper \
 "
