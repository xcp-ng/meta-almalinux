# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nordugrid-arc7"
PV = "7.2.0"
PR = "1.el10_2"
PACKAGES = " \
 nordugrid-arc7 \
 nordugrid-arc7-arc-exporter \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-archery-manage \
 nordugrid-arc7-arex \
 nordugrid-arc7-arex-lrms-contrib \
 nordugrid-arc7-client \
 nordugrid-arc7-community-rtes \
 nordugrid-arc7-datadelivery-service \
 nordugrid-arc7-devel \
 nordugrid-arc7-hed \
 nordugrid-arc7-infosys-ldap \
 nordugrid-arc7-monitor \
 nordugrid-arc7-plugins-gfal \
 nordugrid-arc7-plugins-globus \
 nordugrid-arc7-plugins-globus-common \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-internal \
 nordugrid-arc7-plugins-lcas-lcmaps \
 nordugrid-arc7-plugins-needed \
 nordugrid-arc7-plugins-python \
 nordugrid-arc7-plugins-s3 \
 nordugrid-arc7-plugins-xrootd \
 nordugrid-arc7-test-utils \
 nordugrid-arc7-wn \
 python3-arcrest \
 python3-nordugrid-arc7 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nordugrid-arc7-7.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f6166dbe4e7de63ac250a4cde19a372d0eef2a099034d898077c4168ed4d4385"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7.sha256sum] = "7837a5ac773efc2b15e6429d18e53be3db2781386d66ed973e473e16404e61ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arc-exporter-7.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-arc-exporter.sha256sum] = "d90fc687d3fb82a47ccb5ac9b6bb6d01a0dd117fa1ad4195d5867dce5d8ad7dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl.sha256sum] = "3d4804e16467e0c760f5ba53054972533a429b0713fdd21f3053260b4bc794bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-service-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl-service.sha256sum] = "b00f6e4c9a0e5aeb048a01448cee2a8eb75a2e537222a2a6660d622c18cc9464"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-archery-manage-7.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-archery-manage.sha256sum] = "4a7e7fde15f97f8d8a548ecb369f09405ee3307b16c0d8e02f5c32bc918f77be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arex;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-arex.sha256sum] = "637e9574ec248a686bde4bef0b1a8d2a39b2a89df1b24cf51164ba04bfb5f046"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-lrms-contrib-7.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "14c5c794d1317b76274b6ad5e05d0a979bff27b028e4a440649b44d768667e52"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-client-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-client;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-client.sha256sum] = "e1a875042f55ac33e1aab2ceeaa4ed9bb461319de381984e5259d0d59731149c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-community-rtes-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-community-rtes.sha256sum] = "87d584cda9049810d16a9ea482873742174c460ea268466e9f5befcf98fa32c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-datadelivery-service-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-datadelivery-service.sha256sum] = "c7ba3dd79a53ebd73088a8aecdea2d1ca072e3d4fa78bd51d2288c224a4724a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-devel-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-devel;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-devel.sha256sum] = "244f7a06b3d6dd0150579c9899d0f421ea3b158422e1693cdc39f10a3128d124"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-hed-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-hed;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-hed.sha256sum] = "c4d2312800e957fe177faa0f1dda1424d2343e73f2dcb4d621276a16b842ec4c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-infosys-ldap-7.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-infosys-ldap.sha256sum] = "53a0e21abe574ee9cfd3442bc4182a5bebc9ca26c10eef1f40f6dd60ddb3d225"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-monitor-7.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-monitor;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-monitor.sha256sum] = "0cee166a23338cf92dee94f675398514594617cfc40cfd1b3923dd91ae264a2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gfal-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gfal;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gfal.sha256sum] = "9d3aa8c37e8da54869c0348caf2409bdbe16aaa7032fa681e11c0cd7f8ef87b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus.sha256sum] = "f622b1d797d3a504340e96f2bee3c7acac0992dbac7438a127829ed442861cbc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-common-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus-common.sha256sum] = "e870caa0061f78778b31e07c5efb44afbe1a712954c407cea1f5eb583a6c5221"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gridftp-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gridftp.sha256sum] = "4c4384075d82428acb2c1ab83cb71ad9f7537e56a86060ace014d95496721fb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-internal-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-internal.sha256sum] = "117c63701094d8032a4443366017332cc79ab47deaf63e680271e2ee6a675699"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-lcas-lcmaps-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "2936854120be13a22d04987c6a5d88fdd44892dc734ee2bebafbf139b7e51488"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-needed-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-needed.sha256sum] = "c15cdafa1382004992e0befa672e1d70437b1cf4d202dbe66dcb88ff79077a62"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-python-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-python.sha256sum] = "e317ee40cf5bac19490e5d0c3a465f493553c9033ca3acc6ea23e4092ed55a6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-s3-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-s3.sha256sum] = "1bb491fee54df4eea7a2ab8d89fa2b42105cb087b6fbd30f4c5c86ebbc95df5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-xrootd-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-xrootd.sha256sum] = "d22920ff83857649cbfe090428ab2c186e809eceff47b4c0a587a1d9b24caba8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-test-utils-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-test-utils;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-test-utils.sha256sum] = "18374d1a7e95447a8861a4235cdedea376b12946566577a9bf32f3a3c7c29543"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-wn-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-wn;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-wn.sha256sum] = "7397e0938bdc2aff44c096385e88bec931c0ad4801295c01fcb05e306dcea6ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-arcrest-7.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-arcrest;unpack=0"
SRC_URI[x86_64_v2_python3-arcrest.sha256sum] = "a65b113d39f78f0435512826c97fc3deefe46b8d24b4a4034e98a8d493425dff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nordugrid-arc7-7.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-nordugrid-arc7;unpack=0"
SRC_URI[x86_64_v2_python3-nordugrid-arc7.sha256sum] = "f995c511b5a50a31684864eea88407e9db8bcf030349d6361758c3a07e875947"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7;unpack=0"
SRC_URI[aarch64_nordugrid-arc7.sha256sum] = "6aba4a2b12011416666e2af3b798c1bab5b9587a36d216c8f856554476785271"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arc-exporter-7.2.0-1.el10_2.noarch.rpm;name=aarch64_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-arc-exporter.sha256sum] = "2f65bb55191b9f2d13a5a674eaf470c5c10561fb5ca8b8d910a475211c27df59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-arcctl.sha256sum] = "76109e0034d75d9048e3db3279eeba3bab886c242d171894372b90047734895a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-service-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-arcctl-service.sha256sum] = "751ca2067c77383f7668e7c6690d42c9a29b53ce83b109c09af44a34c8ad064e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-archery-manage-7.2.0-1.el10_2.noarch.rpm;name=aarch64_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-archery-manage.sha256sum] = "5ce38236f2bc25d256d4ccd947c9ca6a6935411a296751cc0a8ea6d633a7ac38"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-arex;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-arex.sha256sum] = "dd86ed3402aba0ea53b0554190d4b7af0b963cb27cffc810de010d6c4b7c398f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-lrms-contrib-7.2.0-1.el10_2.noarch.rpm;name=aarch64_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "1d4e43b98e33ad59eb1f15eea8159f3781cdbd4f1cc617389e9d1858f16b9485"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-client-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-client;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-client.sha256sum] = "1e0651e2d664758412166df25ec27089ca2157e9b8fc6a006db17ae30c1a1e99"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-community-rtes-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-community-rtes.sha256sum] = "ea4677c2781b2767ebecc660e6dd04471f950bf83e0fcb3edd37b74a5cdfafb0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-datadelivery-service-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-datadelivery-service.sha256sum] = "24844343512d079fd33d1d9a8e4e3c01945cffe68aada4450b2d57d8efa51591"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-devel-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-devel;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-devel.sha256sum] = "1242202de26ab905c5c59873d878defef7a811dbeaec2509ca1d2f1dd325e44b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-hed-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-hed;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-hed.sha256sum] = "dab1ebb3ef5b69f08270f5dc7613a3866ac325fd74c19263fc96f2712ac87e6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-infosys-ldap-7.2.0-1.el10_2.noarch.rpm;name=aarch64_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-infosys-ldap.sha256sum] = "46767f25fc28c6e2001fc2fd8d01547972da9bbbe67865082ac0afb223ac5f26"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-monitor-7.2.0-1.el10_2.noarch.rpm;name=aarch64_nordugrid-arc7-monitor;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-monitor.sha256sum] = "6b5a6f947ef5fb7d9b0221d2b8d208565f5e07afdb3302de02bc7160fbfa8ad3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gfal-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gfal;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-gfal.sha256sum] = "dd36d11459ba26e79b747152b5a3bc18160b3a40a634f5712fecbca08b659464"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus.sha256sum] = "341a9c7d9da53279f74726941dbc892e270a9486308aefdfd2d19aaaede8762e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-common-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus-common.sha256sum] = "a61b5816ea49596e4c6eee398411759884c7bceac9e5eb0da2098633eb7824af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gridftp-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-gridftp.sha256sum] = "a25251044d9748c008772b7743ab7a6559b2197dd084607e2173e8a723ba6bf6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-internal-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-internal.sha256sum] = "0ec4071e1afe39835d987813923ab8048ba0fe9a36dbac8f59ca5d7b5f529ed9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-lcas-lcmaps-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "62e2964d25bc1ea9dbce0a47b191b7f8fda45b7b2d1d96250e2cf04c4b0f2e83"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-needed-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-needed.sha256sum] = "4eb8d32e0ea41d3e4572cbab8b59dba497a65233fb53d415b57b095e741d85d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-python-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-python.sha256sum] = "22d29cb9c4862266231336d6976d08af934c61b7f7e9a20d5582fdec909bdf47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-s3-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-s3.sha256sum] = "453601c43c377cf8a6fee8d354ac7efcd209e8e55709b39220411806fc3c0a0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-xrootd-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-xrootd.sha256sum] = "956e9e68d7a5858a92c3eef91a9a90d0b16be988e1ab87ce3bfc16f1ba31cb29"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-test-utils-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-test-utils;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-test-utils.sha256sum] = "b5f6425e5b67649a5c00f4b1760a66ac38e3718788bd36f756ddbc53db2ff3e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-wn-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_nordugrid-arc7-wn;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-wn.sha256sum] = "1fa86659f7342a4f87595042a6a38c3a0fc9a82718d0c2562c25eea2224dc5f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-arcrest-7.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-arcrest;unpack=0"
SRC_URI[aarch64_python3-arcrest.sha256sum] = "e25d899459e6addd6524e02abb6b9204d5afe05ac789b3abec13a49fcfd37337"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-nordugrid-arc7-7.2.0-1.el10_2.aarch64.rpm;name=aarch64_python3-nordugrid-arc7;unpack=0"
SRC_URI[aarch64_python3-nordugrid-arc7.sha256sum] = "0687758124269dd0d285b32a47bb6032b5c0a325f8ffad761e06ba2f7d5bcb4b"

RDEPENDS:nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 python3 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arc-exporter = " \
 python3 \
 python3-prometheus_client \
 "
RDEPENDS:nordugrid-arc7-arcctl = " \
 nordugrid-arc7 \
 python3 \
 python3-jwcrypto \
 "
RDEPENDS:nordugrid-arc7-arcctl-service = " \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 python3 \
 "
RDEPENDS:nordugrid-arc7-archery-manage = " \
 python3 \
 python3-dns \
 python3-ldap \
 "
RDEPENDS:nordugrid-arc7-arex = " \
 bash \
 findutils \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 perl-Data-Dumper \
 perl-Digest-SHA1 \
 perl-DirHandle \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-JSON-XS \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-XML-Simple \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-vars \
 procps-ng \
 python3 \
 sqlite-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arex-lrms-contrib = " \
 bash \
 nordugrid-arc7-arex \
 perl-DBI \
 perl-Data-Dumper \
 perl-Exporter \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-XML-Simple \
 perl-libs \
 "
RDEPENDS:nordugrid-arc7-client = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-community-rtes = " \
 gnupg2 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arex \
 python3 \
 python3-dns \
 "
RDEPENDS:nordugrid-arc7-datadelivery-service = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-devel = " \
 glib2 \
 glibc \
 glibmm2.68 \
 glibmm2.68-devel \
 libgcc \
 libstdc++ \
 libxml2-devel \
 nordugrid-arc7 \
 openssl-devel \
 "
RDEPENDS:nordugrid-arc7-hed = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 systemd-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-infosys-ldap = " \
 bash \
 bdii \
 glue-schema \
 logrotate \
 nordugrid-arc7-arcctl-service \
 openldap-servers \
 policycoreutils-python-utils \
 systemd \
 "
RDEPENDS:nordugrid-arc7-monitor = " \
 nordugrid-arc7 \
 virtual/php \
 virtual/php-gd \
 virtual/php-ldap \
 "
RDEPENDS:nordugrid-arc7-plugins-gfal = " \
 gfal2 \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-globus = " \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-lcas-lcmaps \
 "
RDEPENDS:nordugrid-arc7-plugins-globus-common = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-callback \
 globus-gssapi-gsi \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-gridftp = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-ftp-client \
 globus-ftp-control \
 globus-io \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-internal = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nordugrid-arc7-arex \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-lcas-lcmaps = " \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gssapi-gsi \
 libgcc \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-plugins-needed = " \
 glib2 \
 glibc \
 glibmm2.68 \
 ldns \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-python = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3-libs \
 python3-nordugrid-arc7 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-s3 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libs3 \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-xrootd = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 xrootd-client-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-test-utils = " \
 glibc \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 "
RDEPENDS:nordugrid-arc7-wn = " \
 glibc \
 "
RDEPENDS:python3-arcrest = " \
 python3 \
 python3-cryptography \
 "
RDEPENDS:python3-nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3 \
 python3-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
