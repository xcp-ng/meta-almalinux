# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isoimagewriter"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 isoimagewriter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/isoimagewriter-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3bb38f3ea9ed03056f9dc0b9779125be10fde5e65c27c752600ad88633ef82ab"

URI_x86_64_v2_isoimagewriter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isoimagewriter-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isoimagewriter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isoimagewriter}"
SRC_URI[x86_64_v2_isoimagewriter.sha256sum] = "a8ccdcd4c97efca04937874bdb2157310d4c88043f9f7f2b955d3405c0d0c1c7"

URI_aarch64_isoimagewriter = "${EPEL_MIRROR}/aarch64/Packages/i/isoimagewriter-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_isoimagewriter;unpack=0"
SRC_URI:append = " ${URI_aarch64_isoimagewriter}"
SRC_URI[aarch64_isoimagewriter.sha256sum] = "8de8b281bee31a43914f496f59b8ed646506d039d80652b82a089430d97ad10f"

RDEPENDS:isoimagewriter = " \
 glibc \
 gpgmepp \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-solid \
 libgcc \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
