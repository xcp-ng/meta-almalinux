# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "suitesparse"
PV = "7.11.0"
PR = "1.el10_1"
PACKAGES = " \
 suitesparse \
 suitesparse-devel \
 suitesparse-doc \
 suitesparse-static \
 suitesparse64 \
 suitesparse64-devel \
 suitesparse64-static \
 suitesparse64_ \
 suitesparse64_-devel \
 suitesparse64_-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/suitesparse-7.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c853b10167bfb9d3ec52d7ab3b5967a576602c9a78de01bebb4de65282c2cd7"

URI_x86_64_v2_suitesparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse-7.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suitesparse}"
SRC_URI[x86_64_v2_suitesparse.sha256sum] = "a2fb6a7c361f650898931eb6345f4c24b23fb98fbf8d1b5a27fcac8f47e4e0ae"

URI_x86_64_v2_suitesparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse-devel-7.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suitesparse-devel}"
SRC_URI[x86_64_v2_suitesparse-devel.sha256sum] = "3406b8aa833cc6fade6727260277f561dbd59fcd794a75a3dd71c42e75d65b5c"

URI_x86_64_v2_suitesparse-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse-doc-7.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_suitesparse-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suitesparse-doc}"
SRC_URI[x86_64_v2_suitesparse-doc.sha256sum] = "a4bb6f9f735dd399092a61d3cfe3e85ef3821c21bc4a871cdbf660001bbe70d0"

URI_x86_64_v2_suitesparse-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse-static-7.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suitesparse-static}"
SRC_URI[x86_64_v2_suitesparse-static.sha256sum] = "43d784f59ac7b5c348987415d95787d03afd79de7daadf215c5dc2f080bb015e"

URI_x86_64_v2_suitesparse64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64-7.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suitesparse64}"
SRC_URI[x86_64_v2_suitesparse64.sha256sum] = "3b669ffd39ed389367af32de30dc0894c6e85c5d71635fe8b710ff1852568279"

URI_x86_64_v2_suitesparse64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64-devel-7.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suitesparse64-devel}"
SRC_URI[x86_64_v2_suitesparse64-devel.sha256sum] = "97ff27845aab8a84c7cd6bb6259ac7008263617d8d7b922dd458eb6b64beef4b"

URI_x86_64_v2_suitesparse64-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64-static-7.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suitesparse64-static}"
SRC_URI[x86_64_v2_suitesparse64-static.sha256sum] = "1f0827590f2dc507ed0d382e011ad77a4fc556f830e3b99e1415152601046449"

URI_x86_64_v2_suitesparse64_ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64_-7.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64_;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suitesparse64_}"
SRC_URI[x86_64_v2_suitesparse64_.sha256sum] = "21d5cfa3650a125aa211efffaf04411ac9d31b6e6ff3e7dd881a603252908830"

URI_x86_64_v2_suitesparse64_-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64_-devel-7.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64_-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suitesparse64_-devel}"
SRC_URI[x86_64_v2_suitesparse64_-devel.sha256sum] = "6db80c9e7a04456a30548ceda80af2950356412a7954352a1249ac9141940f55"

URI_x86_64_v2_suitesparse64_-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suitesparse64_-static-7.11.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suitesparse64_-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suitesparse64_-static}"
SRC_URI[x86_64_v2_suitesparse64_-static.sha256sum] = "7cc969ba195d2388f025cff5df08c5b7bc71c28f7c75d5af1ac0b248c1b58dff"

URI_aarch64_suitesparse = "${EPEL_MIRROR}/aarch64/Packages/s/suitesparse-7.11.0-1.el10_1.aarch64.rpm;name=aarch64_suitesparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_suitesparse}"
SRC_URI[aarch64_suitesparse.sha256sum] = "2ea826de405e28bf687274c5843776c9267b08d791fc324b7b3781f32e13b3cd"

URI_aarch64_suitesparse-devel = "${EPEL_MIRROR}/aarch64/Packages/s/suitesparse-devel-7.11.0-1.el10_1.aarch64.rpm;name=aarch64_suitesparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_suitesparse-devel}"
SRC_URI[aarch64_suitesparse-devel.sha256sum] = "6fc8ab130e3cfc381ac7f12b2548c4d61758d15ad388d45a084ed44bddb1fb52"

URI_aarch64_suitesparse-doc = "${EPEL_MIRROR}/aarch64/Packages/s/suitesparse-doc-7.11.0-1.el10_1.noarch.rpm;name=aarch64_suitesparse-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_suitesparse-doc}"
SRC_URI[aarch64_suitesparse-doc.sha256sum] = "8548e9db0961e7800188f97fec2d6b22767075b5a953162b14aaa6dbb1eba715"

URI_aarch64_suitesparse-static = "${EPEL_MIRROR}/aarch64/Packages/s/suitesparse-static-7.11.0-1.el10_1.aarch64.rpm;name=aarch64_suitesparse-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_suitesparse-static}"
SRC_URI[aarch64_suitesparse-static.sha256sum] = "52c997390f19e179a9f8b1ca1d1b4285d02384db32cbc7ea6f894155ad9a5e4e"

URI_aarch64_suitesparse64 = "${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64-7.11.0-1.el10_1.aarch64.rpm;name=aarch64_suitesparse64;unpack=0"
SRC_URI:append = " ${URI_aarch64_suitesparse64}"
SRC_URI[aarch64_suitesparse64.sha256sum] = "dab83461e144c2ad6134a762bcc9d3f31bd18e50b1244e6e0119d3767cc56469"

URI_aarch64_suitesparse64-devel = "${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64-devel-7.11.0-1.el10_1.aarch64.rpm;name=aarch64_suitesparse64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_suitesparse64-devel}"
SRC_URI[aarch64_suitesparse64-devel.sha256sum] = "5980bd6f158fc0a51e977a20ffa41a9d4f8823d73fa824a6a59d9ee4d0c33401"

URI_aarch64_suitesparse64-static = "${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64-static-7.11.0-1.el10_1.aarch64.rpm;name=aarch64_suitesparse64-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_suitesparse64-static}"
SRC_URI[aarch64_suitesparse64-static.sha256sum] = "8390452cb20f8b2823865be887e5e3e8a70045dafa99ce78ea0b8892ae4dae91"

URI_aarch64_suitesparse64_ = "${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64_-7.11.0-1.el10_1.aarch64.rpm;name=aarch64_suitesparse64_;unpack=0"
SRC_URI:append = " ${URI_aarch64_suitesparse64_}"
SRC_URI[aarch64_suitesparse64_.sha256sum] = "0a69fe0e75eecb4beba710d505bad422272d7aec7c4c7fce16c65469c6b510c9"

URI_aarch64_suitesparse64_-devel = "${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64_-devel-7.11.0-1.el10_1.aarch64.rpm;name=aarch64_suitesparse64_-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_suitesparse64_-devel}"
SRC_URI[aarch64_suitesparse64_-devel.sha256sum] = "4bb3c363515cec52d24b54e79a95f41d58704391c05f2be643f12c3d3f8b865a"

URI_aarch64_suitesparse64_-static = "${EPEL_MIRROR}/aarch64/Packages/s/suitesparse64_-static-7.11.0-1.el10_1.aarch64.rpm;name=aarch64_suitesparse64_-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_suitesparse64_-static}"
SRC_URI[aarch64_suitesparse64_-static.sha256sum] = "d78182dc1f2237ffdea37108bd224416eead25c1b5a24438f9e7c1e8c9808780"

RDEPENDS:suitesparse = " \
 flexiblas-netlib \
 glibc \
 gmp \
 libgcc \
 libgomp \
 libstdc++ \
 mpfr \
 "
RDEPENDS:suitesparse-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 suitesparse \
 suitesparse-devel \
 "
RDEPENDS:suitesparse-doc = " \
 suitesparse \
 "
RDEPENDS:suitesparse-static = " \
 suitesparse-devel \
 "
RDEPENDS:suitesparse64 = " \
 glibc \
 gmp \
 libgcc \
 libgomp \
 libstdc++ \
 mpfr \
 openblas-serial \
 "
RDEPENDS:suitesparse64-devel = " \
 suitesparse-devel \
 suitesparse64 \
 "
RDEPENDS:suitesparse64-static = " \
 suitesparse-devel \
 "
RDEPENDS:suitesparse64_ = " \
 glibc \
 gmp \
 libgcc \
 libgomp \
 libstdc++ \
 mpfr \
 openblas-serial \
 "
RDEPENDS:suitesparse64_-devel = " \
 suitesparse-devel \
 suitesparse64_ \
 "
RDEPENDS:suitesparse64_-static = " \
 suitesparse-devel \
 "
