# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lemonldap-ng"
PV = "2.22.0"
PR = "1.el10_0"
PACKAGES = " \
 lemonldap-ng \
 lemonldap-ng-common \
 lemonldap-ng-doc \
 lemonldap-ng-fastcgi-server \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 lemonldap-ng-selinux \
 lemonldap-ng-test \
 lemonldap-ng-uwsgi-app \
 perl-Lemonldap-NG-SSOaaS-Apache-Client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lemonldap-ng-2.22.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ba6206cb5ede8a628b6fd9988df289f898965ed3bc8db25c7b20c1e3060c2db"

URI_x86_64_v2_lemonldap-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng}"
SRC_URI[x86_64_v2_lemonldap-ng.sha256sum] = "d468dfa77dcec7277b93e6ab3df6ba44a1c0f1384fb0ab18ed36827dae1d6d00"

URI_x86_64_v2_lemonldap-ng-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-common-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-common}"
SRC_URI[x86_64_v2_lemonldap-ng-common.sha256sum] = "ec1bf94faebf79ebbc7e4cc01c0c486476ffd77268709af8b1643b596b43f492"
RPROVIDES:lemonldap-ng-common:x86_64_v2 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_x86_64_v2_lemonldap-ng-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-doc-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-doc}"
SRC_URI[x86_64_v2_lemonldap-ng-doc.sha256sum] = "bf82707668920151f4247cd505d098526e3c8a03bdaa6d982ad998299f5e16c3"

URI_x86_64_v2_lemonldap-ng-fastcgi-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-fastcgi-server-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-fastcgi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-fastcgi-server}"
SRC_URI[x86_64_v2_lemonldap-ng-fastcgi-server.sha256sum] = "dc9d48e69db600a1ebeb9cf2100669f978387fbef0d95feb887bceb810bc340d"

URI_x86_64_v2_lemonldap-ng-handler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-handler-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-handler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-handler}"
SRC_URI[x86_64_v2_lemonldap-ng-handler.sha256sum] = "175216b9b6d5e5b46920974a392631f40c4dc484ddf06d9e5847216cda065cce"

URI_x86_64_v2_lemonldap-ng-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-manager-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-manager}"
SRC_URI[x86_64_v2_lemonldap-ng-manager.sha256sum] = "d6108650d74cf9dd485bfc71c170d1bc653a1150a33c6d574520eebcf8b503f3"
RPROVIDES:lemonldap-ng-manager:x86_64_v2 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_x86_64_v2_lemonldap-ng-portal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-portal-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-portal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-portal}"
SRC_URI[x86_64_v2_lemonldap-ng-portal.sha256sum] = "5bbee61d515490b67ce9a104ed73145beb858afb1915fef537b0ff39bdedb609"

URI_x86_64_v2_lemonldap-ng-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-selinux-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-selinux}"
SRC_URI[x86_64_v2_lemonldap-ng-selinux.sha256sum] = "01f85f2b64e6cd788fd866e8cfa076f9cc8eddcd979d9dd3049138ea359a86a0"

URI_x86_64_v2_lemonldap-ng-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-test-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-test}"
SRC_URI[x86_64_v2_lemonldap-ng-test.sha256sum] = "b306e8e254ae6dafb660edd7d0445d93fa1fe94acf20f26ad43fa8d8792cf4fb"

URI_x86_64_v2_lemonldap-ng-uwsgi-app = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-uwsgi-app-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-uwsgi-app;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-uwsgi-app}"
SRC_URI[x86_64_v2_lemonldap-ng-uwsgi-app.sha256sum] = "0cc17b26c76770c60f6dcbe08d4c4423f1f493ea235d56cb0ced542d0c8874b2"

URI_x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lemonldap-NG-SSOaaS-Apache-Client-2.22.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client}"
SRC_URI[x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client.sha256sum] = "c0d02fa961976dcd0e0f3596fe2702dd4d5687a1245dc8192f5921731d89d39e"

URI_aarch64_lemonldap-ng = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-2.22.0-1.el10_0.noarch.rpm;name=aarch64_lemonldap-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng}"
SRC_URI[aarch64_lemonldap-ng.sha256sum] = "40c04a888c85202f2047df0335569be566813796f63b4e22ea67d47f19e71ba1"

URI_aarch64_lemonldap-ng-common = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-common-2.22.0-1.el10_0.noarch.rpm;name=aarch64_lemonldap-ng-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-common}"
SRC_URI[aarch64_lemonldap-ng-common.sha256sum] = "1aca3d4eec17e532ee7dbf974e972cfc6777a3a895f46d4d222a4fac58a867bb"
RPROVIDES:lemonldap-ng-common:aarch64 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_aarch64_lemonldap-ng-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-doc-2.22.0-1.el10_0.noarch.rpm;name=aarch64_lemonldap-ng-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-doc}"
SRC_URI[aarch64_lemonldap-ng-doc.sha256sum] = "1d3dc7ce3bde9c0cb90a2966904d4ae4402dd08fb83f689e21127d72639d66ca"

URI_aarch64_lemonldap-ng-fastcgi-server = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-fastcgi-server-2.22.0-1.el10_0.noarch.rpm;name=aarch64_lemonldap-ng-fastcgi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-fastcgi-server}"
SRC_URI[aarch64_lemonldap-ng-fastcgi-server.sha256sum] = "dac4e700ed1cd0bdfdf332cf588213d67f7594d0ac15fb593e015b03578d803e"

URI_aarch64_lemonldap-ng-handler = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-handler-2.22.0-1.el10_0.noarch.rpm;name=aarch64_lemonldap-ng-handler;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-handler}"
SRC_URI[aarch64_lemonldap-ng-handler.sha256sum] = "34637b63ed23c6efbf6f981d24672dc4ca372b9bde32d3f9beee7245e6b5398b"

URI_aarch64_lemonldap-ng-manager = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-manager-2.22.0-1.el10_0.noarch.rpm;name=aarch64_lemonldap-ng-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-manager}"
SRC_URI[aarch64_lemonldap-ng-manager.sha256sum] = "fcbc104cd057d6532bda3b31a05a94eec428ceb7fd7e71ea32087294743d83e0"
RPROVIDES:lemonldap-ng-manager:aarch64 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_aarch64_lemonldap-ng-portal = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-portal-2.22.0-1.el10_0.noarch.rpm;name=aarch64_lemonldap-ng-portal;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-portal}"
SRC_URI[aarch64_lemonldap-ng-portal.sha256sum] = "5b58abace0a0c021a0ed8dd99c94bb3b08d70ff09eef076b97357a34c42d400e"

URI_aarch64_lemonldap-ng-selinux = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-selinux-2.22.0-1.el10_0.noarch.rpm;name=aarch64_lemonldap-ng-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-selinux}"
SRC_URI[aarch64_lemonldap-ng-selinux.sha256sum] = "ac5f45a391579d48887c50bf1621dad3a477e7c47cca31e9c9fdc002e4ec162f"

URI_aarch64_lemonldap-ng-test = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-test-2.22.0-1.el10_0.noarch.rpm;name=aarch64_lemonldap-ng-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-test}"
SRC_URI[aarch64_lemonldap-ng-test.sha256sum] = "4ae78b87578313e3063c770dedaf584819be23092f25b6f78e0de54a4fd5b736"

URI_aarch64_lemonldap-ng-uwsgi-app = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-uwsgi-app-2.22.0-1.el10_0.noarch.rpm;name=aarch64_lemonldap-ng-uwsgi-app;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-uwsgi-app}"
SRC_URI[aarch64_lemonldap-ng-uwsgi-app.sha256sum] = "56f2d3fa1e688805c41e5301237ba3a03f8fdaa2e1a7800de2e07a6f4a90bba4"

URI_aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Lemonldap-NG-SSOaaS-Apache-Client-2.22.0-1.el10_0.noarch.rpm;name=aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client}"
SRC_URI[aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client.sha256sum] = "4a10e896e227e387259979c928751334711b958e66096b0063793af3346ffcd7"

RDEPENDS:lemonldap-ng = " \
 lemonldap-ng-common \
 lemonldap-ng-doc \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 lemonldap-ng-selinux \
 lemonldap-ng-test \
 "
RDEPENDS:lemonldap-ng-common = " \
 bash \
 httpd-filesystem \
 lemonldap-ng-common \
 lemonldap-ng-portal \
 mod_fcgid \
 mod_perl \
 nginx-filesystem \
 perl-Apache-Session \
 perl-Apache-Session-Browseable \
 perl-AutoLoader \
 perl-Cache-Cache \
 perl-Config-IniFiles \
 perl-Convert-Base32 \
 perl-Convert-PEM \
 perl-Crypt-OpenSSL-RSA \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-Rijndael \
 perl-Crypt-URandom \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-HMAC \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Email-Date-Format \
 perl-Email-Sender \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-HTML-Template \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-IO-String \
 perl-JSON \
 perl-JSON-XS \
 perl-LDAP \
 perl-Log-Log4perl \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mouse \
 perl-Net-CIDR \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Plack \
 perl-Pod-Usage \
 perl-SOAP-Lite \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Sentry-Raven \
 perl-String-Random \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-TimeDate \
 perl-URI \
 perl-XML-LibXML \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 virtual/httpd_or_nginx \
 virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_ \
 "
RDEPENDS:lemonldap-ng-doc = " \
 lemonldap-ng-common \
 "
RDEPENDS:lemonldap-ng-fastcgi-server = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 mod_fcgid \
 perl-FCGI-ProcManager \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Plack \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-handler = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 mod_perl \
 perl-Apache-Session \
 perl-AutoLoader \
 perl-Cache-Memcached \
 perl-Digest-HMAC \
 perl-Digest-SHA \
 perl-Exporter \
 perl-Getopt-Std \
 perl-HTTP-Message \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Mouse \
 perl-Plack \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-URI \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-manager = " \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 perl-Crypt-URandom \
 perl-Data-Dumper \
 perl-English \
 perl-Exporter \
 perl-File-Compare \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-Hash-Merge-Simple \
 perl-Hash-MultiValue \
 perl-IO-String \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Mouse \
 perl-POSIX \
 perl-Plack-Handler-FCGI \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-Regexp-Common \
 perl-Safe \
 perl-URI \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-portal = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-portal \
 perl-Authen-PAM \
 perl-Authen-Radius \
 perl-Cache-Cache \
 perl-Carp \
 perl-Clone \
 perl-Crypt-JWT \
 perl-Crypt-OpenSSL-RSA \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-URandom \
 perl-DBI \
 perl-DateTime-Format-RFC3339 \
 perl-Digest-SHA \
 perl-Email-Date-Format \
 perl-Email-Sender \
 perl-Encode \
 perl-Exporter \
 perl-File-Temp \
 perl-GD-SecurityImage \
 perl-GSSAPI \
 perl-Getopt-Long \
 perl-HTML-FormatText-WithLinks \
 perl-HTML-Parser \
 perl-HTML-Template \
 perl-HTTP-Message \
 perl-Hash-MultiValue \
 perl-IO-Socket-Timeout \
 perl-IO-String \
 perl-IPC-Run \
 perl-JSON \
 perl-LDAP \
 perl-List-MoreUtils \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mouse \
 perl-Net-CIDR \
 perl-Net-OpenID-Server \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Plack-Handler-FCGI \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-SOAP-Lite \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-String-Random \
 perl-Text-Unidecode \
 perl-Time-Local \
 perl-TimeDate \
 perl-URI \
 perl-Web-ID \
 perl-XML-LibXML \
 perl-XML-LibXSLT \
 perl-base \
 perl-constant \
 perl-fields \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:lemonldap-ng-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:lemonldap-ng-test = " \
 lemonldap-ng-common \
 perl-CGI \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-JSON \
 perl-MIME-Base64 \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:lemonldap-ng-uwsgi-app = " \
 uwsgi-plugin-psgi \
 "
RDEPENDS:perl-Lemonldap-NG-SSOaaS-Apache-Client = " \
 perl-FCGI-Client \
 perl-IO \
 perl-URI \
 perl-constant \
 perl-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

PROVIDES:append:aarch64 = " rpm/virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"
