# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libselinux"
PV = "3.8"
PR = "2.el10_0"
PACKAGES = " \
 libselinux \
 libselinux-devel \
 libselinux-ruby \
 libselinux-static \
 libselinux-utils \
 python3-libselinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libselinux-3.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1f4c0b55efbf029104d7217e568dc582a81d1f3f2cc4f2cd2649932baea919c"

URI_x86_64_v2_libselinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libselinux-3.8-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_libselinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux}"
SRC_URI[x86_64_v2_libselinux.sha256sum] = "f6fa5062497c4385a0974581d8adfc9cb368e06e04fa547ff9bccf707a81a322"

URI_x86_64_v2_libselinux-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libselinux-devel-3.8-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_libselinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-devel}"
SRC_URI[x86_64_v2_libselinux-devel.sha256sum] = "d0caebe72f4d8c9a492b935c682f3321d077d26ca6c48c1238fbcc5262a10e35"

URI_x86_64_v2_libselinux-ruby = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libselinux-ruby-3.8-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_libselinux-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-ruby}"
SRC_URI[x86_64_v2_libselinux-ruby.sha256sum] = "76ead062374fdeef789e89426a96a8149e74653ca911765ff1e7afbcae126489"

URI_x86_64_v2_libselinux-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libselinux-static-3.8-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_libselinux-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-static}"
SRC_URI[x86_64_v2_libselinux-static.sha256sum] = "4e909128e2e5e6cbcd7561fb8196d2fd68f23e849cabacc6bed0e6bbc8952945"

URI_x86_64_v2_libselinux-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libselinux-utils-3.8-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_libselinux-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-utils}"
SRC_URI[x86_64_v2_libselinux-utils.sha256sum] = "925b0e4a2ea0997dcc2666d6f3bc8a2b370ad6f44a36b5fea07917cfe862e750"

URI_x86_64_v2_python3-libselinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libselinux-3.8-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-libselinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libselinux}"
SRC_URI[x86_64_v2_python3-libselinux.sha256sum] = "203f4e974f99e8dc2d7b382a41ec075327b25bbd00075729b39c3bafbc6ed6d5"

URI_aarch64_libselinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libselinux-3.8-2.el10_0.aarch64.rpm;name=aarch64_libselinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux}"
SRC_URI[aarch64_libselinux.sha256sum] = "ec6e99cc46735bf34a9885b736eaf68bd7f1036e09b902ec25f8c97acc053200"

URI_aarch64_libselinux-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libselinux-devel-3.8-2.el10_0.aarch64.rpm;name=aarch64_libselinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-devel}"
SRC_URI[aarch64_libselinux-devel.sha256sum] = "53f6ab30db35ff2ab660983cc8a194eae7f8ab4ca584cf18e1e45258bc0a8c48"

URI_aarch64_libselinux-ruby = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libselinux-ruby-3.8-2.el10_0.aarch64.rpm;name=aarch64_libselinux-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-ruby}"
SRC_URI[aarch64_libselinux-ruby.sha256sum] = "6959705636b36c5620c67be146259c5a7c037b0cfda2ada0b6bddd0cc0aa5a57"

URI_aarch64_libselinux-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libselinux-static-3.8-2.el10_0.aarch64.rpm;name=aarch64_libselinux-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-static}"
SRC_URI[aarch64_libselinux-static.sha256sum] = "d0f2e78aae5c56ff5c88ba5ae61a50dd4cc5acd67d519c529363e4ac4c30ef3d"

URI_aarch64_libselinux-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libselinux-utils-3.8-2.el10_0.aarch64.rpm;name=aarch64_libselinux-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-utils}"
SRC_URI[aarch64_libselinux-utils.sha256sum] = "60dbd1dc90c97305117a388cc546a2fb5f64eca5fe43fbe85922929d29aaa611"

URI_aarch64_python3-libselinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libselinux-3.8-2.el10_0.aarch64.rpm;name=aarch64_python3-libselinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libselinux}"
SRC_URI[aarch64_python3-libselinux.sha256sum] = "d5c969078366ef3ab16545d7e26d163c6fe5e7a641ce85b3812871d677549982"

RDEPENDS:libselinux = " \
 glibc \
 libsepol \
 pcre2 \
 "
RDEPENDS:libselinux-devel = " \
 libselinux \
 libsepol-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libselinux-ruby = " \
 glibc \
 libselinux \
 ruby-libs \
 "
RDEPENDS:libselinux-static = " \
 libselinux-devel \
 "
RDEPENDS:libselinux-utils = " \
 glibc \
 libselinux \
 libsepol \
 pcre2 \
 "
RDEPENDS:python3-libselinux = " \
 glibc \
 libselinux \
 python3 \
 "
