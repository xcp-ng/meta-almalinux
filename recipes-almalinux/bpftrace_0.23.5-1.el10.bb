# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bpftrace"
PV = "0.23.5"
PR = "1.el10"
PACKAGES = " \
 bpftrace \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bpftrace-0.23.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ebeed8dd3edb9647f598fd9ad2a900828f4410798e29a8a50338f38c247d994"

URI_x86_64_v2_bpftrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bpftrace-0.23.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_bpftrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpftrace}"
SRC_URI[x86_64_v2_bpftrace.sha256sum] = "36bc5194f459ec7224cb2cf4f54dbb782210d565f3e47aa1201ffbe62bd58d7a"

URI_aarch64_bpftrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bpftrace-0.23.5-1.el10.aarch64.rpm;name=aarch64_bpftrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpftrace}"
SRC_URI[aarch64_bpftrace.sha256sum] = "43ee4e95b828b2a2d60aaed739bbc3ec1eba74168171f7f2e0c474f4a34970e4"

RDEPENDS:bpftrace = " \
 bcc \
 clang-libs \
 elfutils-libelf \
 glibc \
 libbpf \
 libgcc \
 libstdc++ \
 lldb \
 llvm-libs \
 zlib-ng-compat \
 "
