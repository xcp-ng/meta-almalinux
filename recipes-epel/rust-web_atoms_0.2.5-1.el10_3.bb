# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-web_atoms"
PV = "0.2.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-web_atoms+default-devel \
 rust-web_atoms+serde-devel \
 rust-web_atoms-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-web_atoms-0.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffb42995f107d3bb1040b4fd785355c56305dd60e3be78d9c3d56d025a2ec70f"

URI_x86_64_v2_rust-web_atoms+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-web_atoms+default-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-web_atoms+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-web_atoms+default-devel}"
SRC_URI[x86_64_v2_rust-web_atoms+default-devel.sha256sum] = "42ff0eacfda9c116925f4e94dfb8da6ded6b9210cc9b45e9dd88e34d708fa822"

URI_x86_64_v2_rust-web_atoms+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-web_atoms+serde-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-web_atoms+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-web_atoms+serde-devel}"
SRC_URI[x86_64_v2_rust-web_atoms+serde-devel.sha256sum] = "1c49b1c72e61ba49658345510f48afa479bbed12826eb8e64dc03ee62be7a454"

URI_x86_64_v2_rust-web_atoms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-web_atoms-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-web_atoms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-web_atoms-devel}"
SRC_URI[x86_64_v2_rust-web_atoms-devel.sha256sum] = "1eb50cf472f6810995e15295049eeeaee7a44832f48d831750cf438fbae652cb"

URI_aarch64_rust-web_atoms+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-web_atoms+default-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-web_atoms+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-web_atoms+default-devel}"
SRC_URI[aarch64_rust-web_atoms+default-devel.sha256sum] = "d103cbfda230d4429cdf5845c61507806dca777e03058bc90e421306beaaa858"

URI_aarch64_rust-web_atoms+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-web_atoms+serde-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-web_atoms+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-web_atoms+serde-devel}"
SRC_URI[aarch64_rust-web_atoms+serde-devel.sha256sum] = "5f1b3dfde87a2414fb2a5857c5fcd1946fe99103c612d3c7c8af352d5cac2484"

URI_aarch64_rust-web_atoms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-web_atoms-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-web_atoms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-web_atoms-devel}"
SRC_URI[aarch64_rust-web_atoms-devel.sha256sum] = "1a572e05509751c9d64a081da7cc24c42f23d544a9eb4497e4ff0e2b73c496ea"

RDEPENDS:rust-web_atoms+default-devel = " \
 cargo \
 rust-web_atoms-devel \
 "
RDEPENDS:rust-web_atoms+serde-devel = " \
 cargo \
 rust-string_cache+serde_support-devel \
 rust-web_atoms-devel \
 "
RDEPENDS:rust-web_atoms-devel = " \
 cargo \
 rust \
 rust-phf+default-devel \
 rust-phf_codegen+default-devel \
 rust-string_cache-devel \
 rust-string_cache_codegen+default-devel \
 "
