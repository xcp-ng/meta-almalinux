# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtscxml"
PV = "6.9.1"
PR = "3.el10"
PACKAGES = " \
 qt6-qtscxml \
 qt6-qtscxml-devel \
 qt6-qtscxml-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtscxml-6.9.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26677efb81d0eea2b9d78dc14285e1139697dbbaa0e148fd6e4ac8118d317ca1"

URI_x86_64_v2_qt6-qtscxml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtscxml-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtscxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtscxml}"
SRC_URI[x86_64_v2_qt6-qtscxml.sha256sum] = "6a3bffcbc67148901e0d8d648e7625141c759ea1be4d6734fafdf0a38eaea590"

URI_x86_64_v2_qt6-qtscxml-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtscxml-devel-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtscxml-devel}"
SRC_URI[x86_64_v2_qt6-qtscxml-devel.sha256sum] = "470ec163bf219f5f2bb8ff5dbb5670f01ac7ff1286d72c8663921158953e47d0"

URI_x86_64_v2_qt6-qtscxml-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtscxml-examples-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtscxml-examples}"
SRC_URI[x86_64_v2_qt6-qtscxml-examples.sha256sum] = "0f80fc0484aa31a2a45a5269b8b24fc86d00388dbaf3baa4d15c143858e1b2a8"

URI_aarch64_qt6-qtscxml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtscxml-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtscxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtscxml}"
SRC_URI[aarch64_qt6-qtscxml.sha256sum] = "0a745d31f71ac872272b79e05eea52a2044d64196ee0149834c31a566909b076"

URI_aarch64_qt6-qtscxml-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtscxml-devel-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtscxml-devel}"
SRC_URI[aarch64_qt6-qtscxml-devel.sha256sum] = "99e0b748fca4b66f9cab92ff2a64751f21f9d91188a972b6672169dac41735d8"

URI_aarch64_qt6-qtscxml-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtscxml-examples-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtscxml-examples}"
SRC_URI[aarch64_qt6-qtscxml-examples.sha256sum] = "0254873b1e2b64620ee5a4c4abbcda40a1d44506264b6e06551fb2ad8edff71f"

RDEPENDS:qt6-qtscxml = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtscxml-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtscxml \
 qt6-qtscxml-devel \
 "
RDEPENDS:qt6-qtscxml-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtscxml \
 "
