# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nvme-cli"
PV = "2.13"
PR = "2.el10"
PACKAGES = " \
 nvme-cli \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nvme-cli-2.13-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5388d20d1bc116afef8d250f6df20305826ff035f9a3f723047edfd3241e3553"

URI_x86_64_v2_nvme-cli = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nvme-cli-2.13-2.el10.x86_64_v2.rpm;name=x86_64_v2_nvme-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nvme-cli}"
SRC_URI[x86_64_v2_nvme-cli.sha256sum] = "67c9a2e3312106a14115ff69c5cde2a4e3d79c10246a48b6d5be19905dbe2613"

URI_aarch64_nvme-cli = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nvme-cli-2.13-2.el10.aarch64.rpm;name=aarch64_nvme-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_nvme-cli}"
SRC_URI[aarch64_nvme-cli.sha256sum] = "54b7a7f9f7303eef861c9e8bf54652f1cc770248a352ff22da561ec08adb9182"

RDEPENDS:nvme-cli = " \
 bash \
 glibc \
 json-c \
 libgcc \
 libnvme \
 util-linux \
 "
