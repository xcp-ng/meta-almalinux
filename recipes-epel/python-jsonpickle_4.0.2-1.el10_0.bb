# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jsonpickle"
PV = "4.0.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-jsonpickle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jsonpickle-4.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "195f566c0b44b5710e52aa229a307733d2b8afaf77176bea2a0d43cf711d0366"

URI_x86_64_v2_python3-jsonpickle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsonpickle-4.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jsonpickle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsonpickle}"
SRC_URI[x86_64_v2_python3-jsonpickle.sha256sum] = "16afcdf4147eac6a395fa3b4335b59390d8a829a525fc76fdc197576166c885d"

URI_aarch64_python3-jsonpickle = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsonpickle-4.0.2-1.el10_0.noarch.rpm;name=aarch64_python3-jsonpickle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsonpickle}"
SRC_URI[aarch64_python3-jsonpickle.sha256sum] = "06be3789d166445844a5710bb5ee2384452f4967cacfdc2c40f1ede238d663d9"

RDEPENDS:python3-jsonpickle = " \
 python3 \
 "
