# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accessibility-inspector"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 accessibility-inspector \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/accessibility-inspector-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af2dc5b5a7cd4aead1d2bf051ef78a4020895522d2728a47190a2f76707d61fa"

URI_x86_64_v2_accessibility-inspector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/accessibility-inspector-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_accessibility-inspector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accessibility-inspector}"
SRC_URI[x86_64_v2_accessibility-inspector.sha256sum] = "814ab7635efd1435ef7619f6a823b26b4d463cd4ee59250ed6688da921840e37"

URI_aarch64_accessibility-inspector = "${EPEL_MIRROR}/aarch64/Packages/a/accessibility-inspector-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_accessibility-inspector;unpack=0"
SRC_URI:append = " ${URI_aarch64_accessibility-inspector}"
SRC_URI[aarch64_accessibility-inspector.sha256sum] = "4e121c558292d4b496e05c0ae23a1ccedf8d043f99a1992e736663ce74d17da4"

RDEPENDS:accessibility-inspector = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
