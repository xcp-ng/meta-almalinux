# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-BerkeleyDB"
PV = "0.66"
PR = "1.el10_0"
PACKAGES = " \
 perl-BerkeleyDB \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-BerkeleyDB-0.66-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b51540e775eb3864567f9b91abf00bc2481a75dece04d0f520099d6a32953d0b"

URI_x86_64_v2_perl-BerkeleyDB = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-BerkeleyDB-0.66-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-BerkeleyDB;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-BerkeleyDB}"
SRC_URI[x86_64_v2_perl-BerkeleyDB.sha256sum] = "e6810f46db95f43116f6ce05a617d90ebc6e911af5468be45c790e6d1fb7f54d"

URI_aarch64_perl-BerkeleyDB = "${EPEL_MIRROR}/aarch64/Packages/p/perl-BerkeleyDB-0.66-1.el10_0.aarch64.rpm;name=aarch64_perl-BerkeleyDB;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-BerkeleyDB}"
SRC_URI[aarch64_perl-BerkeleyDB.sha256sum] = "9676af4a87c9af2b5589aed0bf88d61dfaf5ca1c64444266891558a42fb46a89"

RDEPENDS:perl-BerkeleyDB = " \
 glibc \
 libdb \
 perl-BerkeleyDB \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
