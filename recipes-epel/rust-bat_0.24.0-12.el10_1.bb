# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bat"
PV = "0.24.0"
PR = "12.el10_1"
PACKAGES = " \
 bat \
 rust-bat+application-devel \
 rust-bat+bugreport-devel \
 rust-bat+build-assets-devel \
 rust-bat+clap-devel \
 rust-bat+default-devel \
 rust-bat+etcetera-devel \
 rust-bat+git-devel \
 rust-bat+git2-devel \
 rust-bat+grep-cli-devel \
 rust-bat+minimal-application-devel \
 rust-bat+paging-devel \
 rust-bat+regex-devel \
 rust-bat+regex-fancy-devel \
 rust-bat+regex-onig-devel \
 rust-bat+shell-words-devel \
 rust-bat+walkdir-devel \
 rust-bat+wild-devel \
 rust-bat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bat-0.24.0-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c6857c0b3265cd75ad66abc659f2aa951f7471183faac17b53a158af33409a9"

URI_x86_64_v2_bat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bat-0.24.0-12.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bat}"
SRC_URI[x86_64_v2_bat.sha256sum] = "e28e3ef9e0e4a30977a59d0423a0823de8befb85d66514388d4c44e679e30905"

URI_x86_64_v2_rust-bat+application-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+application-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+application-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+application-devel}"
SRC_URI[x86_64_v2_rust-bat+application-devel.sha256sum] = "c5000ba2fc3a40699c270cf1b1a7c698152d6b5d2d2a6691b1ac8fb8282dc2d6"

URI_x86_64_v2_rust-bat+bugreport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+bugreport-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+bugreport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+bugreport-devel}"
SRC_URI[x86_64_v2_rust-bat+bugreport-devel.sha256sum] = "5a823aceb2f5ab6750d24676004ddda960f07fe2667a98a13f22c2a89af068d4"

URI_x86_64_v2_rust-bat+build-assets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+build-assets-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+build-assets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+build-assets-devel}"
SRC_URI[x86_64_v2_rust-bat+build-assets-devel.sha256sum] = "bff1d984cde4eeef2c71ec1dddd42d52cfa590e35f420d9ea3dd97365b8eb472"

URI_x86_64_v2_rust-bat+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+clap-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+clap-devel}"
SRC_URI[x86_64_v2_rust-bat+clap-devel.sha256sum] = "960589e335e99fd754ba86014ed29b7e913d698d347ba150ab8a1e91033d270d"

URI_x86_64_v2_rust-bat+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+default-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+default-devel}"
SRC_URI[x86_64_v2_rust-bat+default-devel.sha256sum] = "4bca99608ff9ce500dafd24b54faba05b6374607bc6930784f9e103b14178ccc"

URI_x86_64_v2_rust-bat+etcetera-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+etcetera-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+etcetera-devel}"
SRC_URI[x86_64_v2_rust-bat+etcetera-devel.sha256sum] = "f068343cf2b380556998966fb13be729614ba4a6297932759380629e792f02a1"

URI_x86_64_v2_rust-bat+git-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+git-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+git-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+git-devel}"
SRC_URI[x86_64_v2_rust-bat+git-devel.sha256sum] = "6bf1eed55dd200f9f99ffaac50018911873990f8e423dd053aad866ad5bea11b"

URI_x86_64_v2_rust-bat+git2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+git2-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+git2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+git2-devel}"
SRC_URI[x86_64_v2_rust-bat+git2-devel.sha256sum] = "6bac6813243d12b4f38b69dd5b0760d70a022850fe031826acc17ba10151a51c"

URI_x86_64_v2_rust-bat+grep-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+grep-cli-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+grep-cli-devel}"
SRC_URI[x86_64_v2_rust-bat+grep-cli-devel.sha256sum] = "8c01af3e27d7456b6683bfa671adb8cd1135088a0259e2903db3bb0c837b33e3"

URI_x86_64_v2_rust-bat+minimal-application-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+minimal-application-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+minimal-application-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+minimal-application-devel}"
SRC_URI[x86_64_v2_rust-bat+minimal-application-devel.sha256sum] = "ba7ecfd420f01207c62a92aa0d27f3767dc36fc08a146a75fcd556e32624c05d"

URI_x86_64_v2_rust-bat+paging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+paging-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+paging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+paging-devel}"
SRC_URI[x86_64_v2_rust-bat+paging-devel.sha256sum] = "5e2afdb5b9ccdd09995292c717559f4afcf97bc6b5f77d2add47e721ae52f002"

URI_x86_64_v2_rust-bat+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+regex-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+regex-devel}"
SRC_URI[x86_64_v2_rust-bat+regex-devel.sha256sum] = "6fa3d10637b4dd1d28b25785484c1398ff5fc14686c6e61403d1e45ff3528651"

URI_x86_64_v2_rust-bat+regex-fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+regex-fancy-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+regex-fancy-devel}"
SRC_URI[x86_64_v2_rust-bat+regex-fancy-devel.sha256sum] = "314876f8e73a6fa7f1718652b53236625561a4125ff2a9d5ca4ddf997907222b"

URI_x86_64_v2_rust-bat+regex-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+regex-onig-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+regex-onig-devel}"
SRC_URI[x86_64_v2_rust-bat+regex-onig-devel.sha256sum] = "b43db1b025e2d5a7b0975021d4d4798de0d2749a809a6b639bb7defca3b5d443"

URI_x86_64_v2_rust-bat+shell-words-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+shell-words-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+shell-words-devel}"
SRC_URI[x86_64_v2_rust-bat+shell-words-devel.sha256sum] = "7f7a218ccb4b07165230ba4256e5168f07e77b30b3d4202f2b5f04725f1e11a2"

URI_x86_64_v2_rust-bat+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+walkdir-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+walkdir-devel}"
SRC_URI[x86_64_v2_rust-bat+walkdir-devel.sha256sum] = "4591b8142225a1364e79156563cadc8a67e395b9929d75dc6c91e9eaf22d3673"

URI_x86_64_v2_rust-bat+wild-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+wild-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+wild-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+wild-devel}"
SRC_URI[x86_64_v2_rust-bat+wild-devel.sha256sum] = "55509b95516fdd2cc6d077856898e6fc8ee1e6d55666677d73a5a28669fce2da"

URI_x86_64_v2_rust-bat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat-devel-0.24.0-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat-devel}"
SRC_URI[x86_64_v2_rust-bat-devel.sha256sum] = "0ccb858ebf3954b3142456e671fadface13c955297c6480b0652d39bc068af60"

URI_aarch64_bat = "${EPEL_MIRROR}/aarch64/Packages/b/bat-0.24.0-12.el10_1.aarch64.rpm;name=aarch64_bat;unpack=0"
SRC_URI:append = " ${URI_aarch64_bat}"
SRC_URI[aarch64_bat.sha256sum] = "be8efed6953dfe945859259ef7b07e7a66df6e12a29202a583db2a78ca2dca9c"

URI_aarch64_rust-bat+application-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+application-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+application-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+application-devel}"
SRC_URI[aarch64_rust-bat+application-devel.sha256sum] = "57ef135a2069815e88f591984356cc255d38fe816049d00f0a591cb30545ea56"

URI_aarch64_rust-bat+bugreport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+bugreport-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+bugreport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+bugreport-devel}"
SRC_URI[aarch64_rust-bat+bugreport-devel.sha256sum] = "3f664d4b59f93088ef72697c59239aa0d3b941359aea6fc68292fe5259d364f9"

URI_aarch64_rust-bat+build-assets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+build-assets-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+build-assets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+build-assets-devel}"
SRC_URI[aarch64_rust-bat+build-assets-devel.sha256sum] = "8238de5f027cb2527ebc90f23eb1f9011a348ba0aa9ee097e222b253886d0206"

URI_aarch64_rust-bat+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+clap-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+clap-devel}"
SRC_URI[aarch64_rust-bat+clap-devel.sha256sum] = "6772517ef6041997ed117a647ae1c5bdb3aa159d774b42b78a62beb5ef0081df"

URI_aarch64_rust-bat+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+default-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+default-devel}"
SRC_URI[aarch64_rust-bat+default-devel.sha256sum] = "b4b9c877a780a178786c09af98130f43d88d504c2663dca86466fb8dfd78805b"

URI_aarch64_rust-bat+etcetera-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+etcetera-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+etcetera-devel}"
SRC_URI[aarch64_rust-bat+etcetera-devel.sha256sum] = "6e63b86d88ec497d68383167bda7e5efa3e769cf6586690b7f1f9d8f570d046f"

URI_aarch64_rust-bat+git-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+git-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+git-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+git-devel}"
SRC_URI[aarch64_rust-bat+git-devel.sha256sum] = "008b1f878c7bda40bca39636e8f455593483a8e3ee877cd8b3df89524ceed82a"

URI_aarch64_rust-bat+git2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+git2-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+git2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+git2-devel}"
SRC_URI[aarch64_rust-bat+git2-devel.sha256sum] = "26009801b05a1cf5f81ece3c5a1697041147e90580845fca1db0b9d6d4d3b9ff"

URI_aarch64_rust-bat+grep-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+grep-cli-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+grep-cli-devel}"
SRC_URI[aarch64_rust-bat+grep-cli-devel.sha256sum] = "8cf301271346c13120000cfa78d6ce7f92fc06050fd39458af582b99a5418d15"

URI_aarch64_rust-bat+minimal-application-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+minimal-application-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+minimal-application-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+minimal-application-devel}"
SRC_URI[aarch64_rust-bat+minimal-application-devel.sha256sum] = "66397ed19661de0d24c9fcbc4f40b0211a20c1ed2c0a2512e6bb1acf32f9564d"

URI_aarch64_rust-bat+paging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+paging-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+paging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+paging-devel}"
SRC_URI[aarch64_rust-bat+paging-devel.sha256sum] = "073f9437a478cd94c002048129312e289f3cc087e87b8fcb1d8a018161c35619"

URI_aarch64_rust-bat+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+regex-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+regex-devel}"
SRC_URI[aarch64_rust-bat+regex-devel.sha256sum] = "18317af1b5207b81cbfa614df69b63b7ad1e43c88b2b4a6adc8ccb379a749eb8"

URI_aarch64_rust-bat+regex-fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+regex-fancy-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+regex-fancy-devel}"
SRC_URI[aarch64_rust-bat+regex-fancy-devel.sha256sum] = "6a45960b9f61338f71abfc7197b7b14c72462a7aade808bd292f83ad5369abe0"

URI_aarch64_rust-bat+regex-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+regex-onig-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+regex-onig-devel}"
SRC_URI[aarch64_rust-bat+regex-onig-devel.sha256sum] = "f60dc3ed3037bf85b38b5a9338c35ac938a5ac5ff3ea5537bc1c5e4e12bc088c"

URI_aarch64_rust-bat+shell-words-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+shell-words-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+shell-words-devel}"
SRC_URI[aarch64_rust-bat+shell-words-devel.sha256sum] = "1f8830393df3ead0c6a1c994a0361600ceda9be55ade42f8601babf65e561b8c"

URI_aarch64_rust-bat+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+walkdir-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+walkdir-devel}"
SRC_URI[aarch64_rust-bat+walkdir-devel.sha256sum] = "9b124649f5b0e75b85388165535a0801275237212235b539ec5a129ecb8529b0"

URI_aarch64_rust-bat+wild-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+wild-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat+wild-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+wild-devel}"
SRC_URI[aarch64_rust-bat+wild-devel.sha256sum] = "4a0321bf8eba74ba53bd04ba457ebffdc6e75c979157306b3a69f9ccfd8328d5"

URI_aarch64_rust-bat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat-devel-0.24.0-12.el10_1.noarch.rpm;name=aarch64_rust-bat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat-devel}"
SRC_URI[aarch64_rust-bat-devel.sha256sum] = "bdf82ed4ebda690641a56511c957934ee4b639e0cd4b0376eeb0cf7cc7aad98e"

RDEPENDS:bat = " \
 glibc \
 libgcc \
 oniguruma \
 zlib-ng-compat \
 "
RDEPENDS:rust-bat+application-devel = " \
 cargo \
 rust-bat+bugreport-devel \
 rust-bat+build-assets-devel \
 rust-bat+git-devel \
 rust-bat+minimal-application-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+bugreport-devel = " \
 cargo \
 rust-bat-devel \
 rust-bugreport+default-devel \
 "
RDEPENDS:rust-bat+build-assets-devel = " \
 cargo \
 rust-bat+regex-devel \
 rust-bat+walkdir-devel \
 rust-bat-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+yaml-load-devel \
 "
RDEPENDS:rust-bat+clap-devel = " \
 cargo \
 rust-bat-devel \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 "
RDEPENDS:rust-bat+default-devel = " \
 cargo \
 rust-bat+application-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+etcetera-devel = " \
 cargo \
 rust-bat-devel \
 rust-etcetera0.8+default-devel \
 "
RDEPENDS:rust-bat+git-devel = " \
 cargo \
 rust-bat+git2-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+git2-devel = " \
 cargo \
 rust-bat-devel \
 rust-git2_0.19-devel \
 "
RDEPENDS:rust-bat+grep-cli-devel = " \
 cargo \
 rust-bat-devel \
 rust-grep-cli+default-devel \
 "
RDEPENDS:rust-bat+minimal-application-devel = " \
 cargo \
 rust-bat+clap-devel \
 rust-bat+etcetera-devel \
 rust-bat+paging-devel \
 rust-bat+regex-onig-devel \
 rust-bat+wild-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+paging-devel = " \
 cargo \
 rust-bat+grep-cli-devel \
 rust-bat+shell-words-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+regex-devel = " \
 cargo \
 rust-bat-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-bat+regex-fancy-devel = " \
 cargo \
 rust-bat-devel \
 rust-syntect+regex-fancy-devel \
 "
RDEPENDS:rust-bat+regex-onig-devel = " \
 cargo \
 rust-bat-devel \
 rust-syntect+regex-onig-devel \
 "
RDEPENDS:rust-bat+shell-words-devel = " \
 cargo \
 rust-bat-devel \
 rust-shell-words+default-devel \
 "
RDEPENDS:rust-bat+walkdir-devel = " \
 cargo \
 rust-bat-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-bat+wild-devel = " \
 cargo \
 rust-bat-devel \
 rust-wild+default-devel \
 "
RDEPENDS:rust-bat-devel = " \
 bash \
 cargo \
 python3 \
 rust \
 rust-ansi_colours+default-devel \
 rust-bincode1+default-devel \
 rust-bytesize1+default-devel \
 rust-clircle+default-devel \
 rust-console+default-devel \
 rust-content_inspector+default-devel \
 rust-encoding_rs+default-devel \
 rust-flate2+default-devel \
 rust-globset+default-devel \
 rust-nu-ansi-term+default-devel \
 rust-once_cell+default-devel \
 rust-path-absolutize+default-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_yaml+default-devel \
 rust-syntect+parsing-devel \
 rust-syntect-devel \
 rust-thiserror1+default-devel \
 rust-unicode-width0.1+default-devel \
 "
