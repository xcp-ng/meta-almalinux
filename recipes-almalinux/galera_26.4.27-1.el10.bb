# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "galera"
PV = "26.4.27"
PR = "1.el10"
PACKAGES = " \
 galera \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/galera-26.4.27-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "897569feb788ba3fece6888906c20b1133073de342c5985388ea0dea98522eca"

URI_x86_64_v2_galera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/galera-26.4.27-1.el10.x86_64_v2.rpm;name=x86_64_v2_galera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_galera}"
SRC_URI[x86_64_v2_galera.sha256sum] = "05574cd8876b40471503154fe82a95ddd4057931d7049ace6bbcd5cd2b79e525"

URI_aarch64_galera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/galera-26.4.27-1.el10.aarch64.rpm;name=aarch64_galera;unpack=0"
SRC_URI:append = " ${URI_aarch64_galera}"
SRC_URI[aarch64_galera.sha256sum] = "8e2a2fba12b61de7dd39f6df3754a938f43451f5fff24304ddccf5e36d7d4ed1"

RDEPENDS:galera = " \
 bash \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 nmap-ncat \
 openssl-libs \
 procps-ng \
 systemd \
 "
