# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-no-panic"
PV = "0.1.36"
PR = "1.el10_2"
PACKAGES = " \
 rust-no-panic+default-devel \
 rust-no-panic-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-no-panic-0.1.36-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df3e0c5ba43fc66823c230c6c330850fbf487d2dbbf334e40b9bcfe5930e6fb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-panic+default-devel-0.1.36-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-panic+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-no-panic+default-devel.sha256sum] = "732e00757093a1915370fb5f2204c495ce49b0557832b7b985996313621b4753"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-panic-devel-0.1.36-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-panic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-no-panic-devel.sha256sum] = "0ffad4742f781e13690466cc3d47bb1107d3eb44cc322ddab8b39bedd2f76e67"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-no-panic+default-devel-0.1.36-1.el10_2.noarch.rpm;name=aarch64_rust-no-panic+default-devel;unpack=0"
SRC_URI[aarch64_rust-no-panic+default-devel.sha256sum] = "ef85d89343bed47d56fabab37d7c281ddb25006b909110dd8a0e445e2afa85a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-no-panic-devel-0.1.36-1.el10_2.noarch.rpm;name=aarch64_rust-no-panic-devel;unpack=0"
SRC_URI[aarch64_rust-no-panic-devel.sha256sum] = "ed484de35b34deca510651cc431e496dc40c4261882cab06a41f9d743934efe6"

RDEPENDS:rust-no-panic+default-devel = " \
 cargo \
 rust-no-panic-devel \
 "
RDEPENDS:rust-no-panic-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
