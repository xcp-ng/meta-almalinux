# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rospkg"
PV = "1.6.3"
PR = "1.el10_3"
PACKAGES = " \
 python-rospkg-doc \
 python3-rospkg \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-rospkg-1.6.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "977512dfc5d97c7c150c77e422886f140db81f9cfed3ae2d42cbd269601d2caa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-rospkg-doc-1.6.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-rospkg-doc;unpack=0"
SRC_URI[x86_64_v2_python-rospkg-doc.sha256sum] = "6ea659bbacca43d6ac40abe584c43f9075a8a442b85ba41a6515bf6a74b0de34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rospkg-1.6.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rospkg;unpack=0"
SRC_URI[x86_64_v2_python3-rospkg.sha256sum] = "dfb9e8ac7f1328dc72fafd3d45a033e1b04e441f126cc01fde21f74ac4d0147b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-rospkg-doc-1.6.3-1.el10_3.noarch.rpm;name=aarch64_python-rospkg-doc;unpack=0"
SRC_URI[aarch64_python-rospkg-doc.sha256sum] = "608fd3dfd97f57b24c170f85d4d71f93bf2270b3aa86d1e1161d7c0345854fba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-rospkg-1.6.3-1.el10_3.noarch.rpm;name=aarch64_python3-rospkg;unpack=0"
SRC_URI[aarch64_python3-rospkg.sha256sum] = "33f342d86dacb4390a3187d2343d7116812d0342e9f9a3ed2475a092a46b1b89"

RDEPENDS:python-rospkg-doc = " \
 "
RDEPENDS:python3-rospkg = " \
 python3 \
 python3-catkin_pkg \
 python3-distro \
 python3-pyyaml \
 "
