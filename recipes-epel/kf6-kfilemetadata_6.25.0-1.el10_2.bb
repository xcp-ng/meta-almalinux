# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kfilemetadata"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kfilemetadata \
 kf6-kfilemetadata-devel \
 kf6-kfilemetadata-doc \
 kf6-kfilemetadata-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kfilemetadata-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d87345b81ecf9056e876fb38f07b24890f2453de0854caf0ebc9cb445f9b3a51"

URI_x86_64_v2_kf6-kfilemetadata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kfilemetadata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata}"
SRC_URI[x86_64_v2_kf6-kfilemetadata.sha256sum] = "707f0d10c961eeb36971b43a81d080a3a967c26fd3964fbb6fdcff215615135b"

URI_x86_64_v2_kf6-kfilemetadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kfilemetadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-devel}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-devel.sha256sum] = "b9fdf0c57806d8b7a3d5faf74c2821b5f160b96183306410d337823ff0939150"

URI_x86_64_v2_kf6-kfilemetadata-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kfilemetadata-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-doc}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-doc.sha256sum] = "26ed5f959034ed65c9f264f278d82cf1385bafb68250643f3e2da9fe441d5191"

URI_x86_64_v2_kf6-kfilemetadata-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kfilemetadata-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-html}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-html.sha256sum] = "57421a6535e0669e76a20495080138b2ac87ebb73fa3ff05a27c939fbc88dc0c"

URI_aarch64_kf6-kfilemetadata = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kfilemetadata;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata}"
SRC_URI[aarch64_kf6-kfilemetadata.sha256sum] = "dce429a8cb1cdedc01afc1ba01c5860c1d690909bddcf156d2f0753ca40f8121"

URI_aarch64_kf6-kfilemetadata-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kfilemetadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-devel}"
SRC_URI[aarch64_kf6-kfilemetadata-devel.sha256sum] = "149b154f8979207ee19b179c474eed996516ad8f57802b7c2e27cceb4123aa28"

URI_aarch64_kf6-kfilemetadata-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kfilemetadata-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-doc}"
SRC_URI[aarch64_kf6-kfilemetadata-doc.sha256sum] = "5535f33bc5259603d72a82f579dee1570eb976311233a98e02e44e7640084617"

URI_aarch64_kf6-kfilemetadata-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kfilemetadata-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-html}"
SRC_URI[aarch64_kf6-kfilemetadata-html.sha256sum] = "24f35b3ab7c80724fd72b270daecbcfbffe8797293d7f75d48015d898f23c865"

RDEPENDS:kf6-kfilemetadata = " \
 ebook-tools-libs \
 exiv2-libs \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libstdc++ \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 taglib \
 "
RDEPENDS:kf6-kfilemetadata-devel = " \
 cmake-filesystem \
 kf6-kfilemetadata \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kfilemetadata-doc = " \
 "
RDEPENDS:kf6-kfilemetadata-html = " \
 "
