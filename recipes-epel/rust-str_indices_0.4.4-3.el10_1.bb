# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-str_indices"
PV = "0.4.4"
PR = "3.el10_1"
PACKAGES = " \
 rust-str_indices+default-devel \
 rust-str_indices+simd-devel \
 rust-str_indices-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-str_indices-0.4.4-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "737f04a54b820bf62db9b95ec94410969ed6b755ea1be5dff0d818282e3d13b3"

URI_x86_64_v2_rust-str_indices+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-str_indices+default-devel-0.4.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-str_indices+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-str_indices+default-devel}"
SRC_URI[x86_64_v2_rust-str_indices+default-devel.sha256sum] = "2d268884b57803895b7d0fef2e7d66f59f0d4624b23dc6c2bde3c0f879fda71f"

URI_x86_64_v2_rust-str_indices+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-str_indices+simd-devel-0.4.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-str_indices+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-str_indices+simd-devel}"
SRC_URI[x86_64_v2_rust-str_indices+simd-devel.sha256sum] = "08683ccbada7b7c9a24e8becb7e2c67c2403317a638841504ce7d92d8d733904"

URI_x86_64_v2_rust-str_indices-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-str_indices-devel-0.4.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-str_indices-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-str_indices-devel}"
SRC_URI[x86_64_v2_rust-str_indices-devel.sha256sum] = "68f6d9035fb9d4872145a9cf2828ca59f17df08b9090459e13f722c25d3699fd"

URI_aarch64_rust-str_indices+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-str_indices+default-devel-0.4.4-3.el10_1.noarch.rpm;name=aarch64_rust-str_indices+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-str_indices+default-devel}"
SRC_URI[aarch64_rust-str_indices+default-devel.sha256sum] = "5b6b49ca0bbc8685a86aa7331a3c63588938a0d2ce10695d4e3e827b99a1e64d"

URI_aarch64_rust-str_indices+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-str_indices+simd-devel-0.4.4-3.el10_1.noarch.rpm;name=aarch64_rust-str_indices+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-str_indices+simd-devel}"
SRC_URI[aarch64_rust-str_indices+simd-devel.sha256sum] = "fa8c8a7dc51a96c992be9d73d6307d6177deb93cca9db03740b6826ace454e24"

URI_aarch64_rust-str_indices-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-str_indices-devel-0.4.4-3.el10_1.noarch.rpm;name=aarch64_rust-str_indices-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-str_indices-devel}"
SRC_URI[aarch64_rust-str_indices-devel.sha256sum] = "8d76d7bf7f21d1fc5aa1e3866407a0b10b3b3d5857e96f915fa2658eb863721f"

RDEPENDS:rust-str_indices+default-devel = " \
 cargo \
 rust-str_indices+simd-devel \
 rust-str_indices-devel \
 "
RDEPENDS:rust-str_indices+simd-devel = " \
 cargo \
 rust-str_indices-devel \
 "
RDEPENDS:rust-str_indices-devel = " \
 cargo \
 "
