# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pulp-glue"
PV = "0.37.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-pulp-glue \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pulp-glue-0.37.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b31430a53803505055077700fdf856e5b6cfb1bdff76e58abafe91092e7c9f58"

URI_x86_64_v2_python3-pulp-glue = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pulp-glue-0.37.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pulp-glue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pulp-glue}"
SRC_URI[x86_64_v2_python3-pulp-glue.sha256sum] = "0b291c6682389a3d728b523fd23cdab7e066c5ceaa46f667bf78c59e0da0e425"

URI_aarch64_python3-pulp-glue = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pulp-glue-0.37.0-1.el10_2.noarch.rpm;name=aarch64_python3-pulp-glue;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pulp-glue}"
SRC_URI[aarch64_python3-pulp-glue.sha256sum] = "438b97f5def702a6696e0ad764eab8bbd6ef5d057ed675e22fa1907d4231e11a"

RDEPENDS:python3-pulp-glue = " \
 python3 \
 python3-multidict \
 python3-packaging \
 python3-requests \
 "
