# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nikto"
PE = "1"
PV = "2.5.0"
PR = "5.el10_0"
PACKAGES = " \
 nikto \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nikto-2.5.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f4ebcb1071cb77f45c3422fbd97eb150babe5dcbd8ad840384270b5e4270d88"

URI_x86_64_v2_nikto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nikto-2.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nikto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nikto}"
SRC_URI[x86_64_v2_nikto.sha256sum] = "7559948b1be00c3fd8545cd2da742dc6a83816da78ed74be54342262f047e319"

URI_aarch64_nikto = "${EPEL_MIRROR}/aarch64/Packages/n/nikto-2.5.0-5.el10_0.noarch.rpm;name=aarch64_nikto;unpack=0"
SRC_URI:append = " ${URI_aarch64_nikto}"
SRC_URI[aarch64_nikto.sha256sum] = "48d26cf2fe034a310f2dc91134b8c74ea77391606d3fc18d0a4c9215028030af"

RDEPENDS:nikto = " \
 perl-Getopt-Long \
 perl-JSON-PP \
 perl-Net \
 perl-Net-SSLeay \
 perl-Scalar-List-Utils \
 perl-Text-ParseWords \
 perl-Time-HiRes \
 perl-bignum \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
