# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-localserver"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-pytest-localserver \
 python3-pytest-localserver+smtp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-localserver-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80bae76c3db67894e27fca8b3982d1db4e31d70a4520190476ff116222bfd796"

URI_x86_64_v2_python3-pytest-localserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-localserver-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-localserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-localserver}"
SRC_URI[x86_64_v2_python3-pytest-localserver.sha256sum] = "581ce7141dab46c25d13a63752022317a8aadd42853472d700f1b2fe149756fd"

URI_x86_64_v2_python3-pytest-localserver+smtp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-localserver+smtp-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-localserver+smtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-localserver+smtp}"
SRC_URI[x86_64_v2_python3-pytest-localserver+smtp.sha256sum] = "16ee0fc9bdb7e4e652872ea5460791afa21483106035241bfbea73ca8a6d4eb2"

URI_aarch64_python3-pytest-localserver = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-localserver-0.10.0-1.el10_2.noarch.rpm;name=aarch64_python3-pytest-localserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-localserver}"
SRC_URI[aarch64_python3-pytest-localserver.sha256sum] = "bb4500d5fae326cf0e7a898b371c96747453ce6997827a3e21c5a4f4cf996fc1"

URI_aarch64_python3-pytest-localserver+smtp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-localserver+smtp-0.10.0-1.el10_2.noarch.rpm;name=aarch64_python3-pytest-localserver+smtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-localserver+smtp}"
SRC_URI[aarch64_python3-pytest-localserver+smtp.sha256sum] = "e9d6c9329ecec73754eaf5ecba0d5c6e76a15425cb35c58c2b76559a9d0d1437"

RDEPENDS:python3-pytest-localserver = " \
 python3 \
 python3-werkzeug \
 "
RDEPENDS:python3-pytest-localserver+smtp = " \
 python3 \
 python3-aiosmtpd \
 python3-pytest-localserver \
 "
