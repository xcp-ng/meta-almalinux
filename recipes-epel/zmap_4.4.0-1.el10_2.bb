# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zmap"
PV = "4.4.0"
PR = "1.el10_2"
PACKAGES = " \
 zmap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zmap-4.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b1e08b4df01178a632dba114e60d8e7551ff577639640e0e9a56381651040b4"

URI_x86_64_v2_zmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zmap-4.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zmap}"
SRC_URI[x86_64_v2_zmap.sha256sum] = "1e26e60b03e8223f085132fd649349240768ac197d426d6a80b468d5082011a4"

URI_aarch64_zmap = "${EPEL_MIRROR}/aarch64/Packages/z/zmap-4.4.0-1.el10_2.aarch64.rpm;name=aarch64_zmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_zmap}"
SRC_URI[aarch64_zmap.sha256sum] = "c40be3980c44569664ede437311ab63e3d0655b7a4ff3f05dd0d7d546493f4da"

RDEPENDS:zmap = " \
 Judy \
 glibc \
 gmp \
 json-c \
 libpcap \
 libunistring \
 "
