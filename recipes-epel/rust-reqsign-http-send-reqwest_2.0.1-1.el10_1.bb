# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-http-send-reqwest"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-reqsign-http-send-reqwest+default-devel \
 rust-reqsign-http-send-reqwest-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-http-send-reqwest-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dead0ea430b45e4ae0c80b462f933e5ae3c4943f41154c84c5a1473c591bae4c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-http-send-reqwest+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-http-send-reqwest+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-http-send-reqwest+default-devel.sha256sum] = "a017de98db810ed68a44931e8c339f4b03ff6632f3026dafadb6059963ef98bf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-http-send-reqwest-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-http-send-reqwest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-http-send-reqwest-devel.sha256sum] = "82c64bc21393e83929c9714efcef5cfec6da8efdadfb737c28045adc9cc8ab70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-http-send-reqwest+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-http-send-reqwest+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-http-send-reqwest+default-devel.sha256sum] = "51d827ca7cfdd4521860962e3d82975b4102a73efcb72a14da641b1302517263"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-http-send-reqwest-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-http-send-reqwest-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-http-send-reqwest-devel.sha256sum] = "6dd13fb121fb741006ed53423fbcef7a12b019f2702b9ff14543de4557e46668"

RDEPENDS:rust-reqsign-http-send-reqwest+default-devel = " \
 cargo \
 rust-reqsign-http-send-reqwest-devel \
 "
RDEPENDS:rust-reqsign-http-send-reqwest-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body-util+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqwest-devel \
 "
