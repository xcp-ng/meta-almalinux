# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kfourinline"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kfourinline \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kfourinline-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50aee24f6278acd8a9ee182a784de4b7857af69a7ef26c7c461c2699ea3f4661"

URI_x86_64_v2_kfourinline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfourinline-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfourinline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kfourinline}"
SRC_URI[x86_64_v2_kfourinline.sha256sum] = "33ef7978b6cb472a5beea99b3dde0728fa036a7611b345447f4d908acc771fe9"

URI_aarch64_kfourinline = "${EPEL_MIRROR}/aarch64/Packages/k/kfourinline-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kfourinline;unpack=0"
SRC_URI:append = " ${URI_aarch64_kfourinline}"
SRC_URI[aarch64_kfourinline.sha256sum] = "db675f40b2b9de7a2ed63f7037254fd23b2fd77bfb6a348e252499dab703c814"

RDEPENDS:kfourinline = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
