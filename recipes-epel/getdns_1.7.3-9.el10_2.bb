# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "getdns"
PV = "1.7.3"
PR = "9.el10_2"
PACKAGES = " \
 getdns \
 getdns-devel \
 getdns-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/getdns-1.7.3-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efa07d014871c02bf9dc7a6699eb031fa73221bcb4aa36c887c089b82b2b5a77"

URI_x86_64_v2_getdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/getdns-1.7.3-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_getdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_getdns}"
SRC_URI[x86_64_v2_getdns.sha256sum] = "fe5958d6f64e075309a2fcbc8c0e9b9e7a4a6c9678ab8d0522298704f035f937"

URI_x86_64_v2_getdns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/getdns-devel-1.7.3-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_getdns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_getdns-devel}"
SRC_URI[x86_64_v2_getdns-devel.sha256sum] = "dfc67cfbd9a0a5f0e1134066dbbec15505fe2674d638149ee3f6521c5be37463"

URI_x86_64_v2_getdns-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/getdns-utils-1.7.3-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_getdns-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_getdns-utils}"
SRC_URI[x86_64_v2_getdns-utils.sha256sum] = "b1c089e1c4c6383714e61f02eb26a1c0ca6dd420026df0fc1c765b8f5f3cf19d"

URI_aarch64_getdns = "${EPEL_MIRROR}/aarch64/Packages/g/getdns-1.7.3-9.el10_2.aarch64.rpm;name=aarch64_getdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_getdns}"
SRC_URI[aarch64_getdns.sha256sum] = "9a8b729e292aebe55f359a58a0d8d71278073b2b002ee8213b08fc5e20bffaae"

URI_aarch64_getdns-devel = "${EPEL_MIRROR}/aarch64/Packages/g/getdns-devel-1.7.3-9.el10_2.aarch64.rpm;name=aarch64_getdns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_getdns-devel}"
SRC_URI[aarch64_getdns-devel.sha256sum] = "3f3bbafecd6534bfd78e98cba585907e0045f612419a9e4e834982f79d7c54ca"

URI_aarch64_getdns-utils = "${EPEL_MIRROR}/aarch64/Packages/g/getdns-utils-1.7.3-9.el10_2.aarch64.rpm;name=aarch64_getdns-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_getdns-utils}"
SRC_URI[aarch64_getdns-utils.sha256sum] = "34ade47ab24028895046da676def10d936b36b134860515398792e10a3851d83"

RDEPENDS:getdns = " \
 bash \
 glibc \
 libev \
 libevent \
 libidn2 \
 libuv \
 openssl-libs \
 unbound-libs \
 "
RDEPENDS:getdns-devel = " \
 getdns \
 pkgconf-pkg-config \
 "
RDEPENDS:getdns-utils = " \
 getdns \
 glibc \
 openssl-libs \
 "
