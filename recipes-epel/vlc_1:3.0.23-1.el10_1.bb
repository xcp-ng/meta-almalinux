# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc"
PE = "1"
PV = "3.0.23"
PR = "1.el10_1"
PACKAGES = " \
 vlc \
 vlc-cli \
 vlc-devel \
 vlc-gui-ncurses \
 vlc-gui-qt \
 vlc-gui-skins2 \
 vlc-libs \
 vlc-plugin-ffmpeg \
 vlc-plugin-fluidsynth \
 vlc-plugin-gnome \
 vlc-plugin-gstreamer \
 vlc-plugin-ieee1394 \
 vlc-plugin-jack \
 vlc-plugin-kde \
 vlc-plugin-lua \
 vlc-plugin-notify \
 vlc-plugin-pulseaudio \
 vlc-plugin-rdp \
 vlc-plugin-samba \
 vlc-plugin-svg \
 vlc-plugin-visualization \
 vlc-plugin-vnc \
 vlc-plugins-all \
 vlc-plugins-base \
 vlc-plugins-extra \
 vlc-plugins-video-out \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vlc-3.0.23-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea18566e965d4b9af554c7ec35baf32d6fb81dbdf18068884e4f3c412ee1cb3b"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - vlc-plugin-ffmpeg: libavcodec.so.61()(64bit)
# - vlc-plugin-ffmpeg: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - vlc-plugin-ffmpeg: libavformat.so.61()(64bit)
# - vlc-plugin-ffmpeg: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - vlc-plugin-ffmpeg: libavutil.so.59()(64bit)
# - vlc-plugin-ffmpeg: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - vlc-plugin-ffmpeg: libpostproc.so.58()(64bit)
# - vlc-plugin-ffmpeg: libpostproc.so.58(LIBPOSTPROC_58)(64bit)
# - vlc-plugin-ffmpeg: libswscale.so.8()(64bit)
# - vlc-plugin-ffmpeg: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_vlc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc}"
SRC_URI[x86_64_v2_vlc.sha256sum] = "4cb696c965192dd1180f8cc6255cdf1498b49a8f02a435ec8f6860cfc4ae6f30"

URI_x86_64_v2_vlc-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-cli-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-cli}"
SRC_URI[x86_64_v2_vlc-cli.sha256sum] = "e90d638f658c0040f7ea670ae25348c0ea1cd05a43663beecb71079dcfed9c6f"

URI_x86_64_v2_vlc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-devel-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-devel}"
SRC_URI[x86_64_v2_vlc-devel.sha256sum] = "9f1a27c862bd0c90190a9c73a1c0646d59308ace9f1524a5f8e9e6846079a418"

URI_x86_64_v2_vlc-gui-ncurses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-ncurses-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-ncurses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-gui-ncurses}"
SRC_URI[x86_64_v2_vlc-gui-ncurses.sha256sum] = "8ab284e65c953c747e1322c22126b51e44ace7636463b1f50bea54212c02ff90"

URI_x86_64_v2_vlc-gui-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-qt-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-gui-qt}"
SRC_URI[x86_64_v2_vlc-gui-qt.sha256sum] = "e7b61984fe3aee51b44dbbc11c7ec0c3d070ede1809caa30de47738c1aee739b"

URI_x86_64_v2_vlc-gui-skins2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-skins2-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-skins2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-gui-skins2}"
SRC_URI[x86_64_v2_vlc-gui-skins2.sha256sum] = "fe6492c229086d0a09b2996ba5b9157450d18bc617e1adde1b1f0cecb8d018c4"

URI_x86_64_v2_vlc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-libs-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-libs}"
SRC_URI[x86_64_v2_vlc-libs.sha256sum] = "34a88c09c5b97422f81dc40dd6f9901066104a5b416814e4ab5dc8d312985276"

URI_x86_64_v2_vlc-plugin-ffmpeg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-ffmpeg-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-ffmpeg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-ffmpeg}"
SRC_URI[x86_64_v2_vlc-plugin-ffmpeg.sha256sum] = "f391995db33d5ea3617bf60eed94591855eb923c5e4ebec8432737350f520f29"

URI_x86_64_v2_vlc-plugin-fluidsynth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-fluidsynth-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-fluidsynth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-fluidsynth}"
SRC_URI[x86_64_v2_vlc-plugin-fluidsynth.sha256sum] = "6645c36ce27425abeb66249300174054cea299b6a5907589ebd35acae543c4c1"

URI_x86_64_v2_vlc-plugin-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-gnome-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-gnome}"
SRC_URI[x86_64_v2_vlc-plugin-gnome.sha256sum] = "8487654c44a097db20903afcaeb5a59b51dce740bfa4b838c0760d8efa0ef2a7"

URI_x86_64_v2_vlc-plugin-gstreamer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-gstreamer-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-gstreamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-gstreamer}"
SRC_URI[x86_64_v2_vlc-plugin-gstreamer.sha256sum] = "c18a9ef4cb8f1c545bb4d328451adacccaccf476a0d21ab51e538ee64e308e21"

URI_x86_64_v2_vlc-plugin-ieee1394 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-ieee1394-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-ieee1394;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-ieee1394}"
SRC_URI[x86_64_v2_vlc-plugin-ieee1394.sha256sum] = "310b62bb9bd7aa73590b0b7e701f62f17e9ff1e0c5f856f9d4bd8f5fd8a293b4"

URI_x86_64_v2_vlc-plugin-jack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-jack-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-jack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-jack}"
SRC_URI[x86_64_v2_vlc-plugin-jack.sha256sum] = "94dd74e6bce2d5453eeff34ba3a0bbb61c03b281bb000ab8872c0a8d84ce58f5"

URI_x86_64_v2_vlc-plugin-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-kde-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-kde}"
SRC_URI[x86_64_v2_vlc-plugin-kde.sha256sum] = "56b537abcb1c786cf2504dfedc2f07a6eb45b8551f253cb0f422c7708e81039b"

URI_x86_64_v2_vlc-plugin-lua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-lua-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-lua}"
SRC_URI[x86_64_v2_vlc-plugin-lua.sha256sum] = "0a8aabffb373c72ddc5b5e8aa83f69c3d34eba66297e7c9d11eb4ae2465d8965"

URI_x86_64_v2_vlc-plugin-notify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-notify-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-notify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-notify}"
SRC_URI[x86_64_v2_vlc-plugin-notify.sha256sum] = "bf42c39509f4b7783ecc42b496406d05626fb33a47b9b8bdbdc67c76103a5844"

URI_x86_64_v2_vlc-plugin-pulseaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-pulseaudio-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-pulseaudio}"
SRC_URI[x86_64_v2_vlc-plugin-pulseaudio.sha256sum] = "6a16fd0e03b35a30dc021e5ffcd9317d7f7761fcfac9f2b98663488ba1f00c83"

URI_x86_64_v2_vlc-plugin-rdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-rdp-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-rdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-rdp}"
SRC_URI[x86_64_v2_vlc-plugin-rdp.sha256sum] = "9739166d9653259edab0ebfc103ea2c372371af91eca516620415e2e01d26638"

URI_x86_64_v2_vlc-plugin-samba = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-samba-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-samba}"
SRC_URI[x86_64_v2_vlc-plugin-samba.sha256sum] = "fa71763ac322ac31c563423c631abb8dbd8e6c5ea14092c38907a1d5ab604c46"

URI_x86_64_v2_vlc-plugin-svg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-svg-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-svg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-svg}"
SRC_URI[x86_64_v2_vlc-plugin-svg.sha256sum] = "c6103e1f3b38b1486ddf1f2f09d18a9305586376838edad6be45a8ba6e968f0c"

URI_x86_64_v2_vlc-plugin-visualization = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-visualization-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-visualization;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-visualization}"
SRC_URI[x86_64_v2_vlc-plugin-visualization.sha256sum] = "c3fdc268782e3ddfd0f5e4350c352dd74e4915b956b1dce2fd53e89e10f5323b"

URI_x86_64_v2_vlc-plugin-vnc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-vnc-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-vnc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-vnc}"
SRC_URI[x86_64_v2_vlc-plugin-vnc.sha256sum] = "f353f79d6d241329ab9e1ea59ed597420bf67320b87535f59465e6938afd4196"

URI_x86_64_v2_vlc-plugins-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-all-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-all}"
SRC_URI[x86_64_v2_vlc-plugins-all.sha256sum] = "15392921e2fc42d153552e4bf3305e7053fc69651132a40cecdb41a2142e83cf"

URI_x86_64_v2_vlc-plugins-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-base-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-base}"
SRC_URI[x86_64_v2_vlc-plugins-base.sha256sum] = "776a2989be49932f8ca69765faae6e2703a7c6a970e4c54338d5ab43acfd3023"

URI_x86_64_v2_vlc-plugins-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-extra-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-extra}"
SRC_URI[x86_64_v2_vlc-plugins-extra.sha256sum] = "221f70cac1ece508bdbf836992ab4a9da3bee73f2b1961b75ee4aedeeb6687f0"

URI_x86_64_v2_vlc-plugins-video-out = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-video-out-3.0.23-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-video-out;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-video-out}"
SRC_URI[x86_64_v2_vlc-plugins-video-out.sha256sum] = "b71f713514cec81a1eb015715f2d32cab8780056e5178f33a72c5713bfaeeae0"

URI_aarch64_vlc = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc}"
SRC_URI[aarch64_vlc.sha256sum] = "85185b7cdd5b3f3bcbf460cd68be97bf37640285b61acd332b9687befdbeb7fc"

URI_aarch64_vlc-cli = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-cli-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-cli}"
SRC_URI[aarch64_vlc-cli.sha256sum] = "3da953d1bba93da8dc79841d49af1132cf12e718b8603191524e4b8d8ede9975"

URI_aarch64_vlc-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-devel-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-devel}"
SRC_URI[aarch64_vlc-devel.sha256sum] = "6614a2af0e220164daad213007cb0c83e9e897246d5c9a28af0f29456fdb3da5"

URI_aarch64_vlc-gui-ncurses = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-ncurses-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-gui-ncurses;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-gui-ncurses}"
SRC_URI[aarch64_vlc-gui-ncurses.sha256sum] = "9f3e8de06eba439a3c9dad2a41c80317820d453791194024ebb54c2f7223abd9"

URI_aarch64_vlc-gui-qt = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-qt-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-gui-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-gui-qt}"
SRC_URI[aarch64_vlc-gui-qt.sha256sum] = "96dda547784456bed8b433e6154c5d14aaedf8c125e5c7da25496293fba9ee45"

URI_aarch64_vlc-gui-skins2 = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-skins2-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-gui-skins2;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-gui-skins2}"
SRC_URI[aarch64_vlc-gui-skins2.sha256sum] = "7596e21d6e624de9958d949d00327344ecc0ca34bab5b0b7f064de80091d69ad"

URI_aarch64_vlc-libs = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-libs-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-libs}"
SRC_URI[aarch64_vlc-libs.sha256sum] = "389b51d757e4449efaaae01022ed82ac1be95666f0034327157b36fa63c656fd"

URI_aarch64_vlc-plugin-ffmpeg = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-ffmpeg-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-ffmpeg;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-ffmpeg}"
SRC_URI[aarch64_vlc-plugin-ffmpeg.sha256sum] = "3be940aa6d8ecb794dc4d85a72eefa12e9f6da9ab84526a249f530d753be7bda"

URI_aarch64_vlc-plugin-fluidsynth = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-fluidsynth-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-fluidsynth;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-fluidsynth}"
SRC_URI[aarch64_vlc-plugin-fluidsynth.sha256sum] = "3a4b10dc0a14f5cc1ac023fb273e4cfba5c94cf7a1650a2d4befbd20c980d274"

URI_aarch64_vlc-plugin-gnome = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-gnome-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-gnome}"
SRC_URI[aarch64_vlc-plugin-gnome.sha256sum] = "7742ee9fb107c8e56ecd2373c92faa5e3d38339577f98ee4969e733af934fc01"

URI_aarch64_vlc-plugin-gstreamer = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-gstreamer-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-gstreamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-gstreamer}"
SRC_URI[aarch64_vlc-plugin-gstreamer.sha256sum] = "6488433dd683ab0a616a8942128b81efd7f89c1a26e1ae810c664e684e0bae38"

URI_aarch64_vlc-plugin-ieee1394 = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-ieee1394-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-ieee1394;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-ieee1394}"
SRC_URI[aarch64_vlc-plugin-ieee1394.sha256sum] = "690b50ac6eb14494d1c96e5fcae0b3d494f3509e310611bd375094e7edaa011e"

URI_aarch64_vlc-plugin-jack = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-jack-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-jack;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-jack}"
SRC_URI[aarch64_vlc-plugin-jack.sha256sum] = "2ff1dc12427de0e35e53af8588bf83a0f38eb14b9530a8bad35d46a33f7c0651"

URI_aarch64_vlc-plugin-kde = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-kde-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-kde}"
SRC_URI[aarch64_vlc-plugin-kde.sha256sum] = "52c221bb2005dafdc18e60999a11df85dd62eb121fcfaf366ef83f721d28e54e"

URI_aarch64_vlc-plugin-lua = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-lua-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-lua}"
SRC_URI[aarch64_vlc-plugin-lua.sha256sum] = "7ee2f10875a07f06f34e4132384beba4c77ae463258ca6d5e4882393e5ab14b8"

URI_aarch64_vlc-plugin-notify = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-notify-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-notify;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-notify}"
SRC_URI[aarch64_vlc-plugin-notify.sha256sum] = "d796b9c8fa0fa3d9c23f99b57e47abe903e61f599f458f858b658d2501fda676"

URI_aarch64_vlc-plugin-pulseaudio = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-pulseaudio-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-pulseaudio}"
SRC_URI[aarch64_vlc-plugin-pulseaudio.sha256sum] = "fec7c518ab9d97bb26d16c5433e8fdf721f321d10743528088b8e93236d80d48"

URI_aarch64_vlc-plugin-rdp = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-rdp-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-rdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-rdp}"
SRC_URI[aarch64_vlc-plugin-rdp.sha256sum] = "59f76c6b4f1e1bc2dcc49093c618fe5beac996bcfec836735e63811119cae6f2"

URI_aarch64_vlc-plugin-samba = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-samba-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-samba}"
SRC_URI[aarch64_vlc-plugin-samba.sha256sum] = "1d7d4ff1fac95332038fe45a09b75e78367d7c15bbca201ea5eaae1458791a1a"

URI_aarch64_vlc-plugin-svg = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-svg-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-svg;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-svg}"
SRC_URI[aarch64_vlc-plugin-svg.sha256sum] = "484e457041e6f6b0293de730731f27fc843725a790158ce4b5acccb169c10e7e"

URI_aarch64_vlc-plugin-visualization = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-visualization-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-visualization;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-visualization}"
SRC_URI[aarch64_vlc-plugin-visualization.sha256sum] = "ed8118b84d61044754b144982c8b7560b8d7ddee11e0588529691fe38428857c"

URI_aarch64_vlc-plugin-vnc = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-vnc-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-vnc;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-vnc}"
SRC_URI[aarch64_vlc-plugin-vnc.sha256sum] = "ec9731ce1bfc9daa55c6125a2920a9bb913c90040cbcdee25d4f179b8fcc3e27"

URI_aarch64_vlc-plugins-all = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-all-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugins-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-all}"
SRC_URI[aarch64_vlc-plugins-all.sha256sum] = "24eba13249ad9058b0ce7457ca7a7cd370e97096b4888f2247b69ebc73d428bf"

URI_aarch64_vlc-plugins-base = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-base-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugins-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-base}"
SRC_URI[aarch64_vlc-plugins-base.sha256sum] = "f39472e8ed378b819595ef9c03ef223ae8dc90690f5f9e80a9badf4b68f5b479"

URI_aarch64_vlc-plugins-extra = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-extra-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugins-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-extra}"
SRC_URI[aarch64_vlc-plugins-extra.sha256sum] = "e97ce5654f31988f00a4abc0150d037c60bc23b363b31849cd100de5d83fbced"

URI_aarch64_vlc-plugins-video-out = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-video-out-3.0.23-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugins-video-out;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-video-out}"
SRC_URI[aarch64_vlc-plugins-video-out.sha256sum] = "95f82824f9edce388cab1e0c66b7767a73163ea3ca25a682608f66e9e0cbd49f"

RDEPENDS:vlc = " \
 bash \
 hicolor-icon-theme \
 kde-filesystem \
 vlc-gui-qt \
 "
RDEPENDS:vlc-cli = " \
 bash \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-devel = " \
 pkgconf-pkg-config \
 vlc-libs \
 "
RDEPENDS:vlc-gui-ncurses = " \
 bash \
 glibc \
 ncurses-libs \
 vlc-cli \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-gui-qt = " \
 bash \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 libwayland-client \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 qt5-qtwayland \
 qt5-qtx11extras \
 vlc-cli \
 vlc-libs \
 vlc-plugin-lua \
 vlc-plugin-pipewire \
 vlc-plugin-pulseaudio \
 vlc-plugins-base \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-gui-skins2 = " \
 bash \
 freetype \
 fribidi \
 glibc \
 gnu-free-sans-fonts \
 libX11 \
 libXext \
 libXinerama \
 libXpm \
 libgcc \
 libstdc++ \
 vlc-cli \
 vlc-gui-qt \
 vlc-libs \
 "
RDEPENDS:vlc-libs = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libidn2 \
 "
RDEPENDS:vlc-plugin-ffmpeg:x86_64_v2 = " \
 glibc \
 libX11 \
 libchromaprint \
 libva \
 vlc-libs \
 vlc-plugins-base \
 vlc-plugins-video-out \
"
RDEPENDS:vlc-plugin-ffmpeg:aarch64 = " \
 glibc \
 libX11 \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libchromaprint \
 libpostproc-free \
 libswscale-free \
 libva \
 vlc-libs \
 vlc-plugins-base \
 vlc-plugins-video-out \
"
RDEPENDS:vlc-plugin-fluidsynth = " \
 fluidsynth-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-gnome = " \
 glib2 \
 glibc \
 libsecret \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-ieee1394 = " \
 glibc \
 libavc1394 \
 libdc1394 \
 libgcc \
 libraw1394 \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-jack = " \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-kde = " \
 dbus-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-lua = " \
 glibc \
 libgcc \
 lua-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-notify = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libnotify \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-pulseaudio = " \
 glibc \
 pulseaudio-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-rdp = " \
 freerdp2-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-samba = " \
 glibc \
 libsmbclient \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-svg = " \
 cairo \
 glib2 \
 glibc \
 librsvg2 \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-visualization = " \
 glibc \
 libglvnd-glx \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-vnc = " \
 glibc \
 libvncserver \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugins-all = " \
 vlc-plugin-bittorrent \
 vlc-plugin-ffmpeg \
 vlc-plugin-fluidsynth \
 vlc-plugin-gnome \
 vlc-plugin-gstreamer \
 vlc-plugin-ieee1394 \
 vlc-plugin-jack \
 vlc-plugin-kde \
 vlc-plugin-lua \
 vlc-plugin-notify \
 vlc-plugin-pause-click \
 vlc-plugin-pipewire \
 vlc-plugin-pulseaudio \
 vlc-plugin-rdp \
 vlc-plugin-samba \
 vlc-plugin-svg \
 vlc-plugin-visualization \
 vlc-plugin-vnc \
 vlc-plugins-base \
 vlc-plugins-extra \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-plugins-base = " \
 alsa-lib \
 dbus-libs \
 faad2-libs \
 fdk-aac-free \
 flac-libs \
 glibc \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 libdav1d \
 libgcc \
 libgcrypt \
 libgpg-error \
 libjpeg-turbo \
 libogg \
 libpng \
 libshout \
 libstdc++ \
 libtheora \
 libvorbis \
 libvpx \
 libxml2 \
 mpg123-libs \
 opus \
 speex \
 systemd-libs \
 taglib \
 twolame-libs \
 vlc-libs \
 zlib-ng-compat \
 "
RDEPENDS:vlc-plugins-extra:x86_64_v2 = " \
 aalib-libs \
 alsa-lib \
 aribb24 \
 aribb25 \
 avahi-libs \
 daala-libs \
 fontconfig \
 freetype \
 fribidi \
 game-music-emu \
 glibc \
 harfbuzz \
 libX11 \
 libaom \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcddb \
 libdvbpsi \
 libdvdnav \
 libdvdread \
 libebml \
 libgcc \
 libgcrypt \
 libkate \
 libmad \
 libmatroska \
 libmicrodns \
 libmodplug \
 libmpcdec \
 libmtp \
 libnfs \
 libsamplerate \
 libspatialaudio \
 libssh2 \
 libstdc++ \
 libtiger \
 libupnp \
 libvpl \
 libxcb \
 lirc-libs \
 live555 \
 pcsc-lite-libs \
 protobuf-lite \
 soxr \
 speexdsp \
 srt-libs \
 systemd-libs \
 vlc-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:vlc-plugins-extra:aarch64 = " \
 aalib-libs \
 alsa-lib \
 aribb24 \
 aribb25 \
 avahi-libs \
 daala-libs \
 fontconfig \
 freetype \
 fribidi \
 game-music-emu \
 glibc \
 harfbuzz \
 libX11 \
 libaom \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcddb \
 libdvbpsi \
 libdvdnav \
 libdvdread \
 libebml \
 libgcc \
 libgcrypt \
 libkate \
 libmad \
 libmatroska \
 libmicrodns \
 libmodplug \
 libmpcdec \
 libmtp \
 libnfs \
 libsamplerate \
 libspatialaudio \
 libssh2 \
 libstdc++ \
 libtiger \
 libupnp \
 libxcb \
 lirc-libs \
 live555 \
 pcsc-lite-libs \
 protobuf-lite \
 soxr \
 speexdsp \
 srt-libs \
 systemd-libs \
 vlc-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:vlc-plugins-video-out = " \
 glibc \
 libX11 \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libva \
 libwayland-client \
 libwayland-egl \
 libxcb \
 vlc-libs \
 vlc-plugins-base \
 xcb-util-keysyms \
 "
