# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdevelop-php"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdevelop-php \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdevelop-php-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bf50127fb2b8432b3d85f1ca03a1b6265e0c1f372fe65c5867b67cd4aaca559"

URI_x86_64_v2_kdevelop-php = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-php-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop-php;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdevelop-php}"
SRC_URI[x86_64_v2_kdevelop-php.sha256sum] = "bb72ecad1d484454a42ef01b4712143f06a050eee7765f405074a5ac7e437e2f"

URI_aarch64_kdevelop-php = "${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-php-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdevelop-php;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdevelop-php}"
SRC_URI[aarch64_kdevelop-php.sha256sum] = "40efcc1783ff49f23cc7a045b7a67394534e5189b7d19bbc5c970eb783897aff"

RDEPENDS:kdevelop-php = " \
 cmake-filesystem \
 glibc \
 kdevelop \
 kdevelop-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-threadweaver \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
