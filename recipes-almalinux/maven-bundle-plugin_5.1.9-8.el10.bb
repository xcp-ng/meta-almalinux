# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-bundle-plugin"
PV = "5.1.9"
PR = "8.el10"
PACKAGES = " \
 maven-bundle-plugin \
 maven-bundle-plugin-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-bundle-plugin-5.1.9-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b4bf2260b18fdf8c66dc27c012753117297f2d3e7af8d0757e91bb093bbd43b"

URI_x86_64_v2_maven-bundle-plugin = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-bundle-plugin-5.1.9-8.el10.noarch.rpm;name=x86_64_v2_maven-bundle-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-bundle-plugin}"
SRC_URI[x86_64_v2_maven-bundle-plugin.sha256sum] = "60c5e315e76a262c4cb9c8e9b8bc77bb89b941719a8bbca45e0cc712ba7d38ef"

URI_x86_64_v2_maven-bundle-plugin-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-bundle-plugin-javadoc-5.1.9-8.el10.noarch.rpm;name=x86_64_v2_maven-bundle-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-bundle-plugin-javadoc}"
SRC_URI[x86_64_v2_maven-bundle-plugin-javadoc.sha256sum] = "8b04bd85d42933dc6b14f01017e92fdb216ae7e136ee62e1dbc9182950ae93ba"

URI_aarch64_maven-bundle-plugin = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-bundle-plugin-5.1.9-8.el10.noarch.rpm;name=aarch64_maven-bundle-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-bundle-plugin}"
SRC_URI[aarch64_maven-bundle-plugin.sha256sum] = "60c5e315e76a262c4cb9c8e9b8bc77bb89b941719a8bbca45e0cc712ba7d38ef"

URI_aarch64_maven-bundle-plugin-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-bundle-plugin-javadoc-5.1.9-8.el10.noarch.rpm;name=aarch64_maven-bundle-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-bundle-plugin-javadoc}"
SRC_URI[aarch64_maven-bundle-plugin-javadoc.sha256sum] = "8b04bd85d42933dc6b14f01017e92fdb216ae7e136ee62e1dbc9182950ae93ba"

RDEPENDS:maven-bundle-plugin = " \
 aqute-bndlib \
 felix-utils \
 javapackages-filesystem \
 maven-archiver \
 maven-dependency-tree \
 plexus-build-api0 \
 plexus-utils \
 slf4j \
 "
RDEPENDS:maven-bundle-plugin-javadoc = " \
 javapackages-filesystem \
 "
