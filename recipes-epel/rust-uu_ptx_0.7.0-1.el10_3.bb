# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_ptx"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_ptx+default-devel \
 rust-uu_ptx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_ptx-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c1cda2f4a9d2e391712382671ae32b701482cb585ec1b098ae2df27e304b93d"

URI_x86_64_v2_rust-uu_ptx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_ptx+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_ptx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_ptx+default-devel}"
SRC_URI[x86_64_v2_rust-uu_ptx+default-devel.sha256sum] = "3f2d7d33425fbf93a95483c1d625ca5bb10125a212b3d469bdbf5d1cfa4466ad"

URI_x86_64_v2_rust-uu_ptx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_ptx-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_ptx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_ptx-devel}"
SRC_URI[x86_64_v2_rust-uu_ptx-devel.sha256sum] = "b6721c81a9e057691f9bbb1ec8f8827aaf9b1b8a703f3e3cc235bd165e245066"

URI_aarch64_rust-uu_ptx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_ptx+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_ptx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_ptx+default-devel}"
SRC_URI[aarch64_rust-uu_ptx+default-devel.sha256sum] = "5fe4e767c3139cfe758480bba201ba22ddc1508318f916ae98ed94c5c23564bf"

URI_aarch64_rust-uu_ptx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_ptx-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_ptx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_ptx-devel}"
SRC_URI[aarch64_rust-uu_ptx-devel.sha256sum] = "3100b1bf656b1f8e9b8a0c6a5f4fd6e02493a4a8e1a5d264be7928e089df174c"

RDEPENDS:rust-uu_ptx+default-devel = " \
 cargo \
 rust-uu_ptx-devel \
 "
RDEPENDS:rust-uu_ptx-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-regex+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 "
