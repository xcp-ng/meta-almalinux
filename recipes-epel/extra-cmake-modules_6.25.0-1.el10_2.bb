# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "extra-cmake-modules"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 extra-cmake-modules \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/extra-cmake-modules-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af12697abc165842f9456ba98abdb1029a1ffc6f90b870d1156be27123eb78ed"

URI_x86_64_v2_extra-cmake-modules = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/extra-cmake-modules-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_extra-cmake-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_extra-cmake-modules}"
SRC_URI[x86_64_v2_extra-cmake-modules.sha256sum] = "948afbd521cc416000ecc99fc40511ff00c5ede64280bbd293219465523a3c85"

URI_aarch64_extra-cmake-modules = "${EPEL_MIRROR}/aarch64/Packages/e/extra-cmake-modules-6.25.0-1.el10_2.noarch.rpm;name=aarch64_extra-cmake-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_extra-cmake-modules}"
SRC_URI[aarch64_extra-cmake-modules.sha256sum] = "1488ea1c8452d7e509484980072b8daafab9ca25370afa6b4fd97d9ff63c8c8d"

RDEPENDS:extra-cmake-modules = " \
 bash \
 kf6-rpm-macros \
 python3 \
 "
