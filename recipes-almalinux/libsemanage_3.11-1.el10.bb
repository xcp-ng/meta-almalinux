# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsemanage"
PV = "3.11"
PR = "1.el10"
PACKAGES = " \
 libsemanage \
 libsemanage-devel \
 python3-libsemanage \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsemanage-3.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32cae71489f84cf461c1ca6ed86545df25044599b80a12002a1857ac1e0dcd93"

URI_x86_64_v2_libsemanage = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsemanage-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsemanage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsemanage}"
SRC_URI[x86_64_v2_libsemanage.sha256sum] = "8de7672b5b1b855a76a3a5c25dfd43eec8ef3fe2f747e0c3c59e4bbe6ed984be"

URI_x86_64_v2_libsemanage-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsemanage-devel-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsemanage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsemanage-devel}"
SRC_URI[x86_64_v2_libsemanage-devel.sha256sum] = "c128867d595970842eb947cfa525fb4edff1d8aa50409456f8335bf574c33b60"

URI_x86_64_v2_python3-libsemanage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libsemanage-3.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libsemanage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libsemanage}"
SRC_URI[x86_64_v2_python3-libsemanage.sha256sum] = "9e7545c9dfc1abfdbf5f66b4578a1482a415e7841f777a8d90e8dcc8a4290963"

URI_aarch64_libsemanage = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsemanage-3.11-1.el10.aarch64.rpm;name=aarch64_libsemanage;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsemanage}"
SRC_URI[aarch64_libsemanage.sha256sum] = "fce01ab1bab7effbd3042116217c9413358f6d0c63fdfa832677634aae591a96"

URI_aarch64_libsemanage-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsemanage-devel-3.11-1.el10.aarch64.rpm;name=aarch64_libsemanage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsemanage-devel}"
SRC_URI[aarch64_libsemanage-devel.sha256sum] = "6d3485bb755ebb4f09003e02a608fc1b5ddd60a56c81c337c97c77449a13df0c"

URI_aarch64_python3-libsemanage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libsemanage-3.11-1.el10.aarch64.rpm;name=aarch64_python3-libsemanage;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libsemanage}"
SRC_URI[aarch64_python3-libsemanage.sha256sum] = "581bff36d03f39d341bacde15d6572f17ebe279f80af225be9fe50672f28d333"

RDEPENDS:libsemanage = " \
 audit-libs \
 bzip2-libs \
 glibc \
 libselinux \
 libsepol \
 "
RDEPENDS:libsemanage-devel = " \
 libselinux-devel \
 libsemanage \
 libsepol-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libsemanage = " \
 glibc \
 libsemanage \
 python3 \
 python3-libselinux \
 "
