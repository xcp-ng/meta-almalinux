# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-discover"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-discover \
 plasma-discover-flatpak \
 plasma-discover-kns \
 plasma-discover-libs \
 plasma-discover-notifier \
 plasma-discover-offline-updates \
 plasma-discover-packagekit \
 plasma-discover-snap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-discover-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbb9c04b7ead5259e3d1a5ff221e62d943b13c0b60c8f12c3b3db60cb21f5891"

URI_x86_64_v2_plasma-discover = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover}"
SRC_URI[x86_64_v2_plasma-discover.sha256sum] = "9c2bd6d068d53f72b40ee8ddc29a74e89ffc45078b387a92ee0018b91029386c"

URI_x86_64_v2_plasma-discover-flatpak = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-flatpak-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-flatpak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-flatpak}"
SRC_URI[x86_64_v2_plasma-discover-flatpak.sha256sum] = "95e45c17060c2a0177f246ab8c6cfe5ae0c767513c5bdc56da47ea4ddca7a894"

URI_x86_64_v2_plasma-discover-kns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-kns-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-kns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-kns}"
SRC_URI[x86_64_v2_plasma-discover-kns.sha256sum] = "3acfb32f730cf86e7d192d9aca46c70d72dee1c9e43df3c7e91cae860ccf574e"

URI_x86_64_v2_plasma-discover-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-libs-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-libs}"
SRC_URI[x86_64_v2_plasma-discover-libs.sha256sum] = "d40c71dc1879bcc5edfd18eb0c365c9237a9f097671d25642b526e716ef78211"

URI_x86_64_v2_plasma-discover-notifier = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-notifier-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-notifier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-notifier}"
SRC_URI[x86_64_v2_plasma-discover-notifier.sha256sum] = "6123124f9a2ba07c1bfc11845856c16146f973a3e44736af9034db67b3fb10f6"

URI_x86_64_v2_plasma-discover-offline-updates = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-offline-updates-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-offline-updates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-offline-updates}"
SRC_URI[x86_64_v2_plasma-discover-offline-updates.sha256sum] = "1f5c8ea62d1a684ad6635947684e57818072454cb65bb725ae4875e8213c0386"

URI_x86_64_v2_plasma-discover-packagekit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-packagekit-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-packagekit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-packagekit}"
SRC_URI[x86_64_v2_plasma-discover-packagekit.sha256sum] = "eabafaa7d1b600ac35b2915eeef7eda314872fd573b385f7de0c7a753b950627"

URI_x86_64_v2_plasma-discover-snap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-snap-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-snap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-snap}"
SRC_URI[x86_64_v2_plasma-discover-snap.sha256sum] = "7551fba0f9ce257b262be0c62dfa4a057cc96aa0a601e0aad824a6b075109d8d"

URI_aarch64_plasma-discover = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover}"
SRC_URI[aarch64_plasma-discover.sha256sum] = "c2b2ccc09e45c2dfbfcbd248e8672b08a201406c789e15a8fcffb6c708cf18d0"

URI_aarch64_plasma-discover-flatpak = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-flatpak-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-flatpak;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-flatpak}"
SRC_URI[aarch64_plasma-discover-flatpak.sha256sum] = "5d95dd34c3e548a645f2abfd65d20346e47f57ba9c7a83ad955160794f099cb1"

URI_aarch64_plasma-discover-kns = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-kns-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-kns;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-kns}"
SRC_URI[aarch64_plasma-discover-kns.sha256sum] = "df9fb7285d2445c04d16ef2c1f22aeff63232102338cd4edf7abecbf633b0c76"

URI_aarch64_plasma-discover-libs = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-libs-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-libs}"
SRC_URI[aarch64_plasma-discover-libs.sha256sum] = "3b86cdbe5ccf95a4892816ad5ece21037281829392024d5b33b4df52bcf8e13a"

URI_aarch64_plasma-discover-notifier = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-notifier-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-notifier;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-notifier}"
SRC_URI[aarch64_plasma-discover-notifier.sha256sum] = "d7e4ee3fca939a5d40fa17743cd1ad89d617d6e32dc65765b56e18b6e7671c82"

URI_aarch64_plasma-discover-offline-updates = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-offline-updates-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-offline-updates;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-offline-updates}"
SRC_URI[aarch64_plasma-discover-offline-updates.sha256sum] = "26cfc75bec4ad1aba2fc6301efffeeee8ee4d369dad3d068d49d16f01564e856"

URI_aarch64_plasma-discover-packagekit = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-packagekit-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-packagekit;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-packagekit}"
SRC_URI[aarch64_plasma-discover-packagekit.sha256sum] = "1d9d4dad569ab4267fdcf640ad4c2b6fd85f3d85382c40317885ed3f35a6526d"

URI_aarch64_plasma-discover-snap = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-snap-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-snap;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-snap}"
SRC_URI[aarch64_plasma-discover-snap.sha256sum] = "4216b33e8700cf7c172c26a5b055dbc6c8b6e86e027022c298a218a2fe500fe0"

RDEPENDS:plasma-discover = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 libstdc++ \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebview \
 "
RDEPENDS:plasma-discover-flatpak = " \
 appstream-qt \
 flatpak \
 flatpak-kcm \
 flatpak-libs \
 glib2 \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kservice \
 libgcc \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-kns = " \
 glibc \
 kf6-attica \
 kf6-kconfig \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-libs = " \
 appstream-qt \
 fwupd \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 libgcc \
 libstdc++ \
 plasma-discover \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-discover-notifier = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-offline-updates = " \
 plasma-discover \
 "
RDEPENDS:plasma-discover-packagekit = " \
 PackageKit \
 PackageKit-Qt6 \
 appstream-qt \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kservice \
 libgcc \
 libmarkdown \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-snap = " \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 snapd \
 snapd-qt \
 "
