# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-DES_EDE3"
PV = "0.01"
PR = "52.el10_0"
PACKAGES = " \
 perl-Crypt-DES_EDE3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-DES_EDE3-0.01-52.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6dc75769dcab8cf5f6bcab643de1e499f18a3f2e2961a2fed3a9234a00e350dc"

URI_x86_64_v2_perl-Crypt-DES_EDE3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-DES_EDE3-0.01-52.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-DES_EDE3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-DES_EDE3}"
SRC_URI[x86_64_v2_perl-Crypt-DES_EDE3.sha256sum] = "50f4df38389cea4f4316e4aea15243a9b2df1cdbd437236bc5a4127b34ae1fd8"

URI_aarch64_perl-Crypt-DES_EDE3 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-DES_EDE3-0.01-52.el10_0.noarch.rpm;name=aarch64_perl-Crypt-DES_EDE3;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-DES_EDE3}"
SRC_URI[aarch64_perl-Crypt-DES_EDE3.sha256sum] = "fd1a9a8190608b3f53a79568a3350b094c76f52e12ac0bf68da49771be9ef0c7"

RDEPENDS:perl-Crypt-DES_EDE3 = " \
 perl-Crypt-DES \
 perl-libs \
 perl-vars \
 "
