# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netavark"
PE = "2"
PV = "2.0.0"
PR = "1.el10"
PACKAGES = " \
 netavark \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/netavark-2.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd6df0209989b166a2e29ad9cca12820a2a1908ec1146c68b292b8ad8322ec8d"

URI_x86_64_v2_netavark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netavark-2.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_netavark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netavark}"
SRC_URI[x86_64_v2_netavark.sha256sum] = "c1daed8c5944f405329732fe6bc8753a1adf7272abc4bd3c83357c2104105b9b"

URI_aarch64_netavark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netavark-2.0.0-1.el10.aarch64.rpm;name=aarch64_netavark;unpack=0"
SRC_URI:append = " ${URI_aarch64_netavark}"
SRC_URI[aarch64_netavark.sha256sum] = "cdb768ca6a863b7ac7184ec12a4f04225a6b5358e79a15a862e87b769cc85a63"

RDEPENDS:netavark = " \
 aardvark-dns \
 bash \
 glibc \
 libgcc \
 nftables \
 "
