# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcalutils"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kcalutils \
 kcalutils-devel \
 kcalutils-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kcalutils-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "130ef97ee09a34add8ed968b19e9a68d9ddb6622a02502fe2f6b32d13f5d713b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalutils;unpack=0"
SRC_URI[x86_64_v2_kcalutils.sha256sum] = "4b12f73271544f2e4b81686c246a6093ac6378ff7a3dcc4fbbe08fafd9473bef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalutils-devel;unpack=0"
SRC_URI[x86_64_v2_kcalutils-devel.sha256sum] = "3fb169e693985a23505f1f23c2f9ef60392325745ce43756905eb24fdd138175"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kcalutils-doc;unpack=0"
SRC_URI[x86_64_v2_kcalutils-doc.sha256sum] = "513469e78ed317b542a769547618afb6a35086c8ba59e215dd1d470470f8ce31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kcalutils;unpack=0"
SRC_URI[aarch64_kcalutils.sha256sum] = "40134367bddcea6b95c1c32cbc495492aebfdb3af58d4a6a2005cdf2de578192"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kcalutils-devel;unpack=0"
SRC_URI[aarch64_kcalutils-devel.sha256sum] = "eddf438aec55b801c96953a1703976d8657f1527839ff6f7b89101c8698c304c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kcalutils-doc;unpack=0"
SRC_URI[aarch64_kcalutils-doc.sha256sum] = "6e7988d0ad169020d280ebfcd30a0d4af22c27c16440089628d6afffeaba32fe"

RDEPENDS:kcalutils = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcalutils-devel = " \
 cmake-filesystem \
 kcalutils \
 kf6-kcalendarcore-devel \
 kf6-kcoreaddons-devel \
 "
RDEPENDS:kcalutils-doc = " \
 "
