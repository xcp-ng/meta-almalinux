# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yarnpkg"
PV = "1.22.22"
PR = "5.el10_0"
PACKAGES = " \
 yarnpkg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yarnpkg-1.22.22-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f2789106264b724d1c84eea69cd6622b09146fbf9c7893041b90b5cc4ed1976"

URI_x86_64_v2_yarnpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yarnpkg-1.22.22-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yarnpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yarnpkg}"
SRC_URI[x86_64_v2_yarnpkg.sha256sum] = "7e2e250a7d716f45c33180528884a3ec23c98da13cf8ffdffad16ccb70af493a"

URI_aarch64_yarnpkg = "${EPEL_MIRROR}/aarch64/Packages/y/yarnpkg-1.22.22-5.el10_0.aarch64.rpm;name=aarch64_yarnpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_yarnpkg}"
SRC_URI[aarch64_yarnpkg.sha256sum] = "355c1595752c736cc0303ec429990b7068337be7eddaacf15010268e14b800f1"

RDEPENDS:yarnpkg = " \
 bash \
 nodejs \
 "
