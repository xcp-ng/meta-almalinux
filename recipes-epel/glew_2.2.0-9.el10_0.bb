# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glew"
PV = "2.2.0"
PR = "9.el10_0"
PACKAGES = " \
 glew \
 glew-devel \
 libGLEW \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glew-2.2.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d699dd389e7324df740a048084c0d26c8765691665d39c97fe26fb7c285a2d3"

URI_x86_64_v2_glew = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glew-2.2.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glew;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glew}"
SRC_URI[x86_64_v2_glew.sha256sum] = "196fef062f327cfc2f1c1014f598436e1a404ed5da05c4c5f7653761c924da7e"

URI_x86_64_v2_glew-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glew-devel-2.2.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glew-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glew-devel}"
SRC_URI[x86_64_v2_glew-devel.sha256sum] = "c5e1f97dd22fe51801bba850499360f18b56ea9aef4764ae8544fcbafc7e1e25"

URI_x86_64_v2_libGLEW = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libGLEW-2.2.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libGLEW;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libGLEW}"
SRC_URI[x86_64_v2_libGLEW.sha256sum] = "4aa2affab8a119bb8a7c48ee3cb83039ed204abfb6b54fbadd00575266927bbd"

URI_aarch64_glew = "${EPEL_MIRROR}/aarch64/Packages/g/glew-2.2.0-9.el10_0.aarch64.rpm;name=aarch64_glew;unpack=0"
SRC_URI:append = " ${URI_aarch64_glew}"
SRC_URI[aarch64_glew.sha256sum] = "b6f95718347e6e22727234b7c12839df4a07c5c0938748a61a5f421c9f81dee3"

URI_aarch64_glew-devel = "${EPEL_MIRROR}/aarch64/Packages/g/glew-devel-2.2.0-9.el10_0.aarch64.rpm;name=aarch64_glew-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glew-devel}"
SRC_URI[aarch64_glew-devel.sha256sum] = "4ee98b1bd7d0e00444a7247fb81a5c2b1124714a9bd6f7ecd275a8b976108fca"

URI_aarch64_libGLEW = "${EPEL_MIRROR}/aarch64/Packages/l/libGLEW-2.2.0-9.el10_0.aarch64.rpm;name=aarch64_libGLEW;unpack=0"
SRC_URI:append = " ${URI_aarch64_libGLEW}"
SRC_URI[aarch64_libGLEW.sha256sum] = "bca520e486d0f735f7d7324ca6d516f281ba3ffec7996d12c415cf826a831803"

RDEPENDS:glew = " \
 glibc \
 libGLEW \
 libX11 \
 libglvnd-glx \
 "
RDEPENDS:glew-devel = " \
 libGLEW \
 mesa-libGLU-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libGLEW = " \
 glibc \
 libX11 \
 libglvnd-glx \
 "
