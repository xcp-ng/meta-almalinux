# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf-plugins-core"
PV = "4.7.0"
PR = "8.el10"
PACKAGES = " \
 dnf-plugins-core \
 python3-dnf-plugin-leaves \
 python3-dnf-plugin-modulesync \
 python3-dnf-plugin-post-transaction-actions \
 python3-dnf-plugin-pre-transaction-actions \
 python3-dnf-plugin-show-leaves \
 python3-dnf-plugin-versionlock \
 python3-dnf-plugins-core \
 yum-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dnf-plugins-core-4.7.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1331731f086876f1552ca41c5e9c56c2c5aad55a49fbf4c08bb01ef2a1a39fc"

URI_x86_64_v2_dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-plugins-core-4.7.0-8.el10.noarch.rpm;name=x86_64_v2_dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-plugins-core}"
SRC_URI[x86_64_v2_dnf-plugins-core.sha256sum] = "12e7ab6847c85e74e07bcd073440ad005de3703f82fb5f464486685bb62c34b4"

URI_x86_64_v2_python3-dnf-plugin-leaves = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-leaves-4.7.0-8.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-leaves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-leaves}"
SRC_URI[x86_64_v2_python3-dnf-plugin-leaves.sha256sum] = "abd8ef8996fddf20a2f4b53b006f330131d25c94535131dbb6c6c56fa40afdc6"

URI_x86_64_v2_python3-dnf-plugin-modulesync = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-modulesync-4.7.0-8.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-modulesync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-modulesync}"
SRC_URI[x86_64_v2_python3-dnf-plugin-modulesync.sha256sum] = "8bc7709c79787f3af6f7506795527b6aefee3d7de29ac19bd72b6501f461661a"

URI_x86_64_v2_python3-dnf-plugin-post-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-post-transaction-actions-4.7.0-8.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-post-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-post-transaction-actions}"
SRC_URI[x86_64_v2_python3-dnf-plugin-post-transaction-actions.sha256sum] = "bd99c8690c3963ffc414c7a9f3f42c79cf7703537a5a5807ecef6c25be1f4866"

URI_x86_64_v2_python3-dnf-plugin-pre-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-pre-transaction-actions-4.7.0-8.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-pre-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-pre-transaction-actions}"
SRC_URI[x86_64_v2_python3-dnf-plugin-pre-transaction-actions.sha256sum] = "1ea9f054b2f66047b06269b49fb31a4e9cc86f6f4838a933979db9edb20c7b4c"

URI_x86_64_v2_python3-dnf-plugin-show-leaves = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dnf-plugin-show-leaves-4.7.0-8.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-show-leaves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-show-leaves}"
SRC_URI[x86_64_v2_python3-dnf-plugin-show-leaves.sha256sum] = "dcea29f810c5bb453fbeab05edd809ad2ff0afd7fc2aa679b400aced64e98d89"

URI_x86_64_v2_python3-dnf-plugin-versionlock = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugin-versionlock-4.7.0-8.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-versionlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-versionlock}"
SRC_URI[x86_64_v2_python3-dnf-plugin-versionlock.sha256sum] = "5460ec6b12d4f50667773ab08689b22b4049317a65b7020cad27da329c72113c"

URI_x86_64_v2_python3-dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-plugins-core-4.7.0-8.el10.noarch.rpm;name=x86_64_v2_python3-dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugins-core}"
SRC_URI[x86_64_v2_python3-dnf-plugins-core.sha256sum] = "db3483bca16a51056975327e697fd49a09db9b9cfed3269c2688c67939edca95"

URI_x86_64_v2_yum-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/yum-utils-4.7.0-8.el10.noarch.rpm;name=x86_64_v2_yum-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yum-utils}"
SRC_URI[x86_64_v2_yum-utils.sha256sum] = "aa1c70ace5fe16ae2c70877f2ae20894821d08194ceb41583dd09d9dcb439d2c"

URI_aarch64_dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-plugins-core-4.7.0-8.el10.noarch.rpm;name=aarch64_dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-plugins-core}"
SRC_URI[aarch64_dnf-plugins-core.sha256sum] = "12e7ab6847c85e74e07bcd073440ad005de3703f82fb5f464486685bb62c34b4"

URI_aarch64_python3-dnf-plugin-leaves = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-leaves-4.7.0-8.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-leaves;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-leaves}"
SRC_URI[aarch64_python3-dnf-plugin-leaves.sha256sum] = "abd8ef8996fddf20a2f4b53b006f330131d25c94535131dbb6c6c56fa40afdc6"

URI_aarch64_python3-dnf-plugin-modulesync = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-modulesync-4.7.0-8.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-modulesync;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-modulesync}"
SRC_URI[aarch64_python3-dnf-plugin-modulesync.sha256sum] = "8bc7709c79787f3af6f7506795527b6aefee3d7de29ac19bd72b6501f461661a"

URI_aarch64_python3-dnf-plugin-post-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-post-transaction-actions-4.7.0-8.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-post-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-post-transaction-actions}"
SRC_URI[aarch64_python3-dnf-plugin-post-transaction-actions.sha256sum] = "bd99c8690c3963ffc414c7a9f3f42c79cf7703537a5a5807ecef6c25be1f4866"

URI_aarch64_python3-dnf-plugin-pre-transaction-actions = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-pre-transaction-actions-4.7.0-8.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-pre-transaction-actions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-pre-transaction-actions}"
SRC_URI[aarch64_python3-dnf-plugin-pre-transaction-actions.sha256sum] = "1ea9f054b2f66047b06269b49fb31a4e9cc86f6f4838a933979db9edb20c7b4c"

URI_aarch64_python3-dnf-plugin-show-leaves = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dnf-plugin-show-leaves-4.7.0-8.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-show-leaves;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-show-leaves}"
SRC_URI[aarch64_python3-dnf-plugin-show-leaves.sha256sum] = "dcea29f810c5bb453fbeab05edd809ad2ff0afd7fc2aa679b400aced64e98d89"

URI_aarch64_python3-dnf-plugin-versionlock = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugin-versionlock-4.7.0-8.el10.noarch.rpm;name=aarch64_python3-dnf-plugin-versionlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-versionlock}"
SRC_URI[aarch64_python3-dnf-plugin-versionlock.sha256sum] = "5460ec6b12d4f50667773ab08689b22b4049317a65b7020cad27da329c72113c"

URI_aarch64_python3-dnf-plugins-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-plugins-core-4.7.0-8.el10.noarch.rpm;name=aarch64_python3-dnf-plugins-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugins-core}"
SRC_URI[aarch64_python3-dnf-plugins-core.sha256sum] = "db3483bca16a51056975327e697fd49a09db9b9cfed3269c2688c67939edca95"

URI_aarch64_yum-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/yum-utils-4.7.0-8.el10.noarch.rpm;name=aarch64_yum-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_yum-utils}"
SRC_URI[aarch64_yum-utils.sha256sum] = "aa1c70ace5fe16ae2c70877f2ae20894821d08194ceb41583dd09d9dcb439d2c"

RDEPENDS:dnf-plugins-core = " \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-leaves = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-modulesync = " \
 createrepo_c \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-post-transaction-actions = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-pre-transaction-actions = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-show-leaves = " \
 python3 \
 python3-dnf-plugin-leaves \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugin-versionlock = " \
 python3 \
 python3-dnf-plugins-core \
 "
RDEPENDS:python3-dnf-plugins-core = " \
 python3 \
 python3-dateutil \
 python3-dbus \
 python3-dnf \
 python3-hawkey \
 python3-systemd \
 "
RDEPENDS:yum-utils = " \
 dnf-plugins-core \
 python3 \
 python3-dnf \
 "
