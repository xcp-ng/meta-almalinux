# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trycmd"
PV = "1.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-trycmd+color-auto-devel \
 rust-trycmd+color-devel \
 rust-trycmd+debug-devel \
 rust-trycmd+default-devel \
 rust-trycmd+diff-devel \
 rust-trycmd+escargot-devel \
 rust-trycmd+examples-devel \
 rust-trycmd+filesystem-devel \
 rust-trycmd+schema-devel \
 rust-trycmd-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-trycmd-1.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7b32d1fc059dcd655c627ab5b18d1ff5c63f5af06f96a77910d52c2813ecad02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+color-auto-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+color-auto-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trycmd+color-auto-devel.sha256sum] = "95575811a79d3af4de0d7766235b540798a5b2691535de47fd59f9983ae60024"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+color-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+color-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trycmd+color-devel.sha256sum] = "b906680cb0ec6af36d9006b52c30b47f1088dc314905dbd6526d5bc1cb66fc43"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+debug-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trycmd+debug-devel.sha256sum] = "ecbcdff4bb8c461876536d961cedfa1adbdbe8799eac6c93b37a354e92cab92f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+default-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trycmd+default-devel.sha256sum] = "5d06f3cd955f450ab398e264dfab4d2d86149d0b2afbbe6c3398d46c602be62e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+diff-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+diff-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trycmd+diff-devel.sha256sum] = "23845ed8bcf8e7091b08382b8569409ca75dff7334c87049a3b2f601fd1bd6d0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+escargot-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+escargot-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trycmd+escargot-devel.sha256sum] = "1a527a2dd07bdb6cbd0c8f7094b991afa6c22286e506c7c8fe355ca8ab5890aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+examples-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+examples-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trycmd+examples-devel.sha256sum] = "4b1214c35c59690ac793800ab0c17c5d825290114fe790b2ece5bb3f6f12079c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+filesystem-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+filesystem-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trycmd+filesystem-devel.sha256sum] = "8d44ef3fb5c196db0d5cd2da17ab55c924f6ad5061bec37658335f4a7ebb7853"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+schema-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+schema-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trycmd+schema-devel.sha256sum] = "859df146fd49ba21c1d97c2f413830e96c9ebe1afd6884daf61d1bc734158bc2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trycmd-devel.sha256sum] = "d5997712fe02a941c97c6762741159062dd090c3a7ccf012a0ec7596fb1949bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+color-auto-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-trycmd+color-auto-devel;unpack=0"
SRC_URI[aarch64_rust-trycmd+color-auto-devel.sha256sum] = "9c3c7f75b9137f2bb30e4cb7de0c8973ecc92a52c9bd4553f30828fe9938ec53"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+color-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-trycmd+color-devel;unpack=0"
SRC_URI[aarch64_rust-trycmd+color-devel.sha256sum] = "9ab6496f12c9224219c82cb90bfb4ed61b5b7a26b0a06dd519c563d80ecda22c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+debug-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-trycmd+debug-devel;unpack=0"
SRC_URI[aarch64_rust-trycmd+debug-devel.sha256sum] = "cf870b142f462ce5004b31da5cf4062a2c5288f9b59f20bc3bda2c1aed649b5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+default-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-trycmd+default-devel;unpack=0"
SRC_URI[aarch64_rust-trycmd+default-devel.sha256sum] = "5f1170cfdaa349e0e621bafb30517255d4967ce529ec5daf1eab332a7849895f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+diff-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-trycmd+diff-devel;unpack=0"
SRC_URI[aarch64_rust-trycmd+diff-devel.sha256sum] = "1be2fc76f7d91473104c07d945f480df8d775a6639286eb799c89fb53611b1ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+escargot-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-trycmd+escargot-devel;unpack=0"
SRC_URI[aarch64_rust-trycmd+escargot-devel.sha256sum] = "5f043b5a14543df971a07a0a1ab74e199b40f809e0c670bd17aba2ea0f272dc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+examples-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-trycmd+examples-devel;unpack=0"
SRC_URI[aarch64_rust-trycmd+examples-devel.sha256sum] = "c47eaf38a61aa0ed0d3710a874b116c93a72c59875bde84a1b0d9ef46645d2e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+filesystem-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-trycmd+filesystem-devel;unpack=0"
SRC_URI[aarch64_rust-trycmd+filesystem-devel.sha256sum] = "4d226e6a32a7ac9a8d471bd1d7913c44be3f07009a8d3d27e5d1aa247c91255b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+schema-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-trycmd+schema-devel;unpack=0"
SRC_URI[aarch64_rust-trycmd+schema-devel.sha256sum] = "10ec21d665774cfaa5d54f807decd00b9b93c014d3c86d4f5d6f5f8f9528c911"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-trycmd-devel;unpack=0"
SRC_URI[aarch64_rust-trycmd-devel.sha256sum] = "391e51852914ffb9d526921b2ae8fe7a9bb0f0812f01028a53c3eed986d8fb42"

RDEPENDS:rust-trycmd+color-auto-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-trycmd+color-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox+color-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+debug-devel = " \
 cargo \
 rust-snapbox+debug-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+default-devel = " \
 cargo \
 rust-trycmd+color-auto-devel \
 rust-trycmd+diff-devel \
 rust-trycmd+filesystem-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+diff-devel = " \
 cargo \
 rust-snapbox+diff-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+escargot-devel = " \
 cargo \
 rust-escargot+default-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+examples-devel = " \
 cargo \
 rust-snapbox+examples-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+filesystem-devel = " \
 cargo \
 rust-snapbox+dir-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+schema-devel = " \
 cargo \
 rust-schemars+default-devel \
 rust-schemars+preserve_order-devel \
 rust-serde_json+default-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd-devel = " \
 cargo \
 rust \
 rust-glob+default-devel \
 rust-humantime+default-devel \
 rust-humantime-serde+default-devel \
 rust-rayon+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-shlex+default-devel \
 rust-snapbox+cmd-devel \
 rust-snapbox-devel \
 rust-toml_edit+default-devel \
 rust-toml_edit+serde-devel \
 "
