# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdcm"
PV = "3.0.24"
PR = "4.el10_0"
PACKAGES = " \
 gdcm \
 gdcm-applications \
 gdcm-devel \
 gdcm-doc \
 python3-gdcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gdcm-3.0.24-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac6f151672cae4d95d9de93bc06c71cf705690e71015552833e681c058ff3eab"

URI_x86_64_v2_gdcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdcm-3.0.24-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdcm}"
SRC_URI[x86_64_v2_gdcm.sha256sum] = "5a5cc9a981e29c2295d334f419c177056eb0b5f5ccb195250ebe89698192f9ae"

URI_x86_64_v2_gdcm-applications = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdcm-applications-3.0.24-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdcm-applications;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdcm-applications}"
SRC_URI[x86_64_v2_gdcm-applications.sha256sum] = "99eaeb6642012c8144d826a4dc84ae3598ecf5423ad6787a7fd0658edb39e4db"

URI_x86_64_v2_gdcm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdcm-devel-3.0.24-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdcm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdcm-devel}"
SRC_URI[x86_64_v2_gdcm-devel.sha256sum] = "f7f32f6885bb30aad983da1ace7de3ad5794d3095f890f265c7a3f2c7fc2d2d3"

URI_x86_64_v2_gdcm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdcm-doc-3.0.24-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gdcm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdcm-doc}"
SRC_URI[x86_64_v2_gdcm-doc.sha256sum] = "d563884cddfa9f038b8d55babaa6306564836881c1a430aec23c14f28d83c26c"

URI_x86_64_v2_python3-gdcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gdcm-3.0.24-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-gdcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gdcm}"
SRC_URI[x86_64_v2_python3-gdcm.sha256sum] = "b52d01ec0829bbaee2eebf8f871e4e242394dcf803fa17b84704ba10d7115ea2"

URI_aarch64_gdcm = "${EPEL_MIRROR}/aarch64/Packages/g/gdcm-3.0.24-4.el10_0.aarch64.rpm;name=aarch64_gdcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdcm}"
SRC_URI[aarch64_gdcm.sha256sum] = "b6cfa5ad408aba63002f0ae9934c06d13d1810cb1b446752ba9c03012d004bfc"

URI_aarch64_gdcm-applications = "${EPEL_MIRROR}/aarch64/Packages/g/gdcm-applications-3.0.24-4.el10_0.aarch64.rpm;name=aarch64_gdcm-applications;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdcm-applications}"
SRC_URI[aarch64_gdcm-applications.sha256sum] = "687c498ff51f46762e352139dcb855368c64742bf87f63b661785a054dd24da6"

URI_aarch64_gdcm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gdcm-devel-3.0.24-4.el10_0.aarch64.rpm;name=aarch64_gdcm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdcm-devel}"
SRC_URI[aarch64_gdcm-devel.sha256sum] = "e6ea1f3077caf61f0b9ffbb3af3b37d626de61f4356d29068fb72aeabbb00923"

URI_aarch64_gdcm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gdcm-doc-3.0.24-4.el10_0.noarch.rpm;name=aarch64_gdcm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdcm-doc}"
SRC_URI[aarch64_gdcm-doc.sha256sum] = "02ca11d36d2011eab9a1040d11021ee82193e561520c9943e8beb20b779bd64a"

URI_aarch64_python3-gdcm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gdcm-3.0.24-4.el10_0.aarch64.rpm;name=aarch64_python3-gdcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gdcm}"
SRC_URI[aarch64_python3-gdcm.sha256sum] = "945803955f879f1aee593b334460b6f289cdbdc9aa264d2dfc73872e08e25d4d"

RDEPENDS:gdcm = " \
 CharLS \
 expat \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libuuid \
 openjpeg2 \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gdcm-applications = " \
 gdcm \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 poppler \
 zlib-ng-compat \
 "
RDEPENDS:gdcm-devel = " \
 cmake-filesystem \
 gdcm \
 gdcm-applications \
 "
RDEPENDS:gdcm-doc = " \
 "
RDEPENDS:python3-gdcm = " \
 gdcm \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 "
