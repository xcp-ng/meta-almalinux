# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-version_check"
PV = "0.9.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-version_check+default-devel \
 rust-version_check-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-version_check-0.9.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f14ea8334c8cf5df4eb7244c4b7f990199ec393195c4f16a9bd857ff9e8c69f3"

URI_x86_64_v2_rust-version_check+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version_check+default-devel-0.9.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version_check+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version_check+default-devel}"
SRC_URI[x86_64_v2_rust-version_check+default-devel.sha256sum] = "b1860d42b689f59b6e8aa4243015abd890229dd72539bba0afc63cd91571528f"

URI_x86_64_v2_rust-version_check-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version_check-devel-0.9.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version_check-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version_check-devel}"
SRC_URI[x86_64_v2_rust-version_check-devel.sha256sum] = "b67c788c932eacb4d52edccd03bd56229e2e1e8c1889bf4d244ff00f0a9f31b8"

URI_aarch64_rust-version_check+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version_check+default-devel-0.9.5-1.el10_0.noarch.rpm;name=aarch64_rust-version_check+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version_check+default-devel}"
SRC_URI[aarch64_rust-version_check+default-devel.sha256sum] = "0fe7e7d6d6c14068e2398821bf985a9b203604fa91f2cb3e22f0b8b2347cf76b"

URI_aarch64_rust-version_check-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version_check-devel-0.9.5-1.el10_0.noarch.rpm;name=aarch64_rust-version_check-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version_check-devel}"
SRC_URI[aarch64_rust-version_check-devel.sha256sum] = "ebe08f50b453f1d23a30432bf3838a1c4acd981daa2a7018067267412ce01316"

RDEPENDS:rust-version_check+default-devel = " \
 cargo \
 rust-version_check-devel \
 "
RDEPENDS:rust-version_check-devel = " \
 cargo \
 "
