# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openat"
PV = "0.1.21"
PR = "11.el10_1"
PACKAGES = " \
 rust-openat+default-devel \
 rust-openat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openat-0.1.21-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a976364991f891d17fea8d826d0a6f4e79a22eaf91c7d43132e6dbef1721bac"

URI_x86_64_v2_rust-openat+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openat+default-devel-0.1.21-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openat+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openat+default-devel}"
SRC_URI[x86_64_v2_rust-openat+default-devel.sha256sum] = "cc1d0d439192ed721afcae8ef84ba8d2a7d588abe7403fb1a18409de7c39bc45"

URI_x86_64_v2_rust-openat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openat-devel-0.1.21-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openat-devel}"
SRC_URI[x86_64_v2_rust-openat-devel.sha256sum] = "4df8e845e0c086a76d0b1c370170cc5bcf7c1b6f9476259ff9a0fda0ab2fb481"

URI_aarch64_rust-openat+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openat+default-devel-0.1.21-11.el10_1.noarch.rpm;name=aarch64_rust-openat+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openat+default-devel}"
SRC_URI[aarch64_rust-openat+default-devel.sha256sum] = "891d3fadd287f1effcd12a70265a8049cc3c93fbc033c2edaeb8b104f93abeed"

URI_aarch64_rust-openat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openat-devel-0.1.21-11.el10_1.noarch.rpm;name=aarch64_rust-openat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openat-devel}"
SRC_URI[aarch64_rust-openat-devel.sha256sum] = "3266b321e036939b73c623bc4e3c25023511ccc3d1693d97dd5414f3f4932f89"

RDEPENDS:rust-openat+default-devel = " \
 cargo \
 rust-openat-devel \
 "
RDEPENDS:rust-openat-devel = " \
 cargo \
 rust-libc+default-devel \
 "
