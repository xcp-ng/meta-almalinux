# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-fgl"
PV = "5.8.2.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-fgl \
 ghc-fgl-devel \
 ghc-fgl-doc \
 ghc-fgl-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-fgl-5.8.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1524f773ad25f13544bb1d68fc2016a53e15a0bb8acf26974af859665116120"

URI_x86_64_v2_ghc-fgl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fgl-5.8.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fgl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fgl}"
SRC_URI[x86_64_v2_ghc-fgl.sha256sum] = "6f554af8bf927576f80b5e11b4033ecf75e421cd00f5961f0d3b442bca7b7600"

URI_x86_64_v2_ghc-fgl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fgl-devel-5.8.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fgl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fgl-devel}"
SRC_URI[x86_64_v2_ghc-fgl-devel.sha256sum] = "e34693614d0429139dc7e3f51ef59ee2540db48bfb83e20ebf472af7d586ffab"

URI_x86_64_v2_ghc-fgl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fgl-doc-5.8.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-fgl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fgl-doc}"
SRC_URI[x86_64_v2_ghc-fgl-doc.sha256sum] = "eb7b2b3caa122774b9b714d7c2f674dc8fc8bcfa5a798b58a80910c396d336f1"

URI_x86_64_v2_ghc-fgl-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fgl-prof-5.8.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fgl-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fgl-prof}"
SRC_URI[x86_64_v2_ghc-fgl-prof.sha256sum] = "1aab80ad2df7fec054420bc963dddacf4702e0364569e6086644a8cecb35b3a0"

URI_aarch64_ghc-fgl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fgl-5.8.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-fgl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fgl}"
SRC_URI[aarch64_ghc-fgl.sha256sum] = "2417f7eeac02c30a4d35edd2af12eedab54bc157ab2663124b2333e26d5847cc"

URI_aarch64_ghc-fgl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fgl-devel-5.8.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-fgl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fgl-devel}"
SRC_URI[aarch64_ghc-fgl-devel.sha256sum] = "c4541c8a55723fa3a6268f81741a5d59e37de88808eb2ba1cedf08b9ced9d201"

URI_aarch64_ghc-fgl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fgl-doc-5.8.2.0-1.el10_0.noarch.rpm;name=aarch64_ghc-fgl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fgl-doc}"
SRC_URI[aarch64_ghc-fgl-doc.sha256sum] = "944c4f35dfa995c187149e2ea872531d453b0f6714271a1dff9fa9d29f447ee4"

URI_aarch64_ghc-fgl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fgl-prof-5.8.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-fgl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fgl-prof}"
SRC_URI[aarch64_ghc-fgl-prof.sha256sum] = "bf0a735fa31e5d938db6d7d74888a1398d1c8bdea9adf458c7d22f0cdc836329"

RDEPENDS:ghc-fgl = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-fgl-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-fgl \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-fgl-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-fgl-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-fgl-devel \
 ghc-transformers-prof \
 "
