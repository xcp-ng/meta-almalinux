# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-srpm-macros"
PV = "1.9.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-srpm-macros-1.9.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83ebd5c00cf48eae416401b4ad184fe8c9a682cb0105ca4b7c998faaf7b5a223"

URI_x86_64_v2_ghc-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-srpm-macros-1.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-srpm-macros}"
SRC_URI[x86_64_v2_ghc-srpm-macros.sha256sum] = "426508811e8032c31c71940c6ca0f2dfe732956100778010793a895f6a284055"

URI_aarch64_ghc-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-srpm-macros-1.9.2-1.el10_0.noarch.rpm;name=aarch64_ghc-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-srpm-macros}"
SRC_URI[aarch64_ghc-srpm-macros.sha256sum] = "bd91bde587216c7bf9b03d24266696761c95dc6228b4a76e07c747acd7243176"

RDEPENDS:ghc-srpm-macros = " \
 "
