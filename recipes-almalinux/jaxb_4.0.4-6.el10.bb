# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jaxb"
PV = "4.0.4"
PR = "6.el10"
PACKAGES = " \
 jaxb-codemodel \
 jaxb-codemodel-annotation-compiler \
 jaxb-core \
 jaxb-relaxng-datatype \
 jaxb-rngom \
 jaxb-runtime \
 jaxb-txw2 \
 jaxb-txwc2 \
 jaxb-xjc \
 jaxb-xsom \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jaxb-4.0.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "042930238ef08b648d63272bb612585b5bc280fd808bfee9bb644927973d8f88"

URI_x86_64_v2_jaxb-codemodel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-codemodel-4.0.4-6.el10.noarch.rpm;name=x86_64_v2_jaxb-codemodel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-codemodel}"
SRC_URI[x86_64_v2_jaxb-codemodel.sha256sum] = "49748689daa445821e3da4d6b1a4e850bc1719cd85ef1694e3b77db94366bc1c"

URI_x86_64_v2_jaxb-codemodel-annotation-compiler = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jaxb-codemodel-annotation-compiler-4.0.4-6.el10.noarch.rpm;name=x86_64_v2_jaxb-codemodel-annotation-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-codemodel-annotation-compiler}"
SRC_URI[x86_64_v2_jaxb-codemodel-annotation-compiler.sha256sum] = "5fc469ed4c1afecd22cda5c70d9dd7ea40619b9d8e7a3b7c2bdc4a453ba9c9ae"

URI_x86_64_v2_jaxb-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-core-4.0.4-6.el10.noarch.rpm;name=x86_64_v2_jaxb-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-core}"
SRC_URI[x86_64_v2_jaxb-core.sha256sum] = "378ebd749dacddbcbe56c870aa6e5821a2c8912ce083f3c7178a94001e9194b2"

URI_x86_64_v2_jaxb-relaxng-datatype = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-relaxng-datatype-4.0.4-6.el10.noarch.rpm;name=x86_64_v2_jaxb-relaxng-datatype;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-relaxng-datatype}"
SRC_URI[x86_64_v2_jaxb-relaxng-datatype.sha256sum] = "bf6e65a6d85f3741431c1cb45d94c46fe8b75f026f25276ce7f61ed3eaa11962"

URI_x86_64_v2_jaxb-rngom = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-rngom-4.0.4-6.el10.noarch.rpm;name=x86_64_v2_jaxb-rngom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-rngom}"
SRC_URI[x86_64_v2_jaxb-rngom.sha256sum] = "4f68766c705b64e5d59622bb53a7a4983b985b432cfb736bf2947d601b5ca6bb"

URI_x86_64_v2_jaxb-runtime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-runtime-4.0.4-6.el10.noarch.rpm;name=x86_64_v2_jaxb-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-runtime}"
SRC_URI[x86_64_v2_jaxb-runtime.sha256sum] = "21bf94855f211f3e23117897eb4fb6d375ff08213b558b808011e6914a042658"

URI_x86_64_v2_jaxb-txw2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-txw2-4.0.4-6.el10.noarch.rpm;name=x86_64_v2_jaxb-txw2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-txw2}"
SRC_URI[x86_64_v2_jaxb-txw2.sha256sum] = "5db67aae4693fbbabca9b39a60fa3a2c43aa2688e6906a02e3f0283effd78147"

URI_x86_64_v2_jaxb-txwc2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jaxb-txwc2-4.0.4-6.el10.noarch.rpm;name=x86_64_v2_jaxb-txwc2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-txwc2}"
SRC_URI[x86_64_v2_jaxb-txwc2.sha256sum] = "cb296e791f39d0548ddeac55e72ae44adc57b023aaa48cdfc0c29671d3a15156"

URI_x86_64_v2_jaxb-xjc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-xjc-4.0.4-6.el10.noarch.rpm;name=x86_64_v2_jaxb-xjc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-xjc}"
SRC_URI[x86_64_v2_jaxb-xjc.sha256sum] = "3e380614c1c90df140987a4273aeafe9aede4657d552ae64ee11f3cc8dd4769c"

URI_x86_64_v2_jaxb-xsom = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-xsom-4.0.4-6.el10.noarch.rpm;name=x86_64_v2_jaxb-xsom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-xsom}"
SRC_URI[x86_64_v2_jaxb-xsom.sha256sum] = "468e6d095f5542b4115453d87d9c0ca48e5a8741c533ce8e8413c84b21f7a056"

URI_aarch64_jaxb-codemodel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-codemodel-4.0.4-6.el10.noarch.rpm;name=aarch64_jaxb-codemodel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-codemodel}"
SRC_URI[aarch64_jaxb-codemodel.sha256sum] = "49748689daa445821e3da4d6b1a4e850bc1719cd85ef1694e3b77db94366bc1c"

URI_aarch64_jaxb-codemodel-annotation-compiler = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jaxb-codemodel-annotation-compiler-4.0.4-6.el10.noarch.rpm;name=aarch64_jaxb-codemodel-annotation-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-codemodel-annotation-compiler}"
SRC_URI[aarch64_jaxb-codemodel-annotation-compiler.sha256sum] = "5fc469ed4c1afecd22cda5c70d9dd7ea40619b9d8e7a3b7c2bdc4a453ba9c9ae"

URI_aarch64_jaxb-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-core-4.0.4-6.el10.noarch.rpm;name=aarch64_jaxb-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-core}"
SRC_URI[aarch64_jaxb-core.sha256sum] = "378ebd749dacddbcbe56c870aa6e5821a2c8912ce083f3c7178a94001e9194b2"

URI_aarch64_jaxb-relaxng-datatype = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-relaxng-datatype-4.0.4-6.el10.noarch.rpm;name=aarch64_jaxb-relaxng-datatype;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-relaxng-datatype}"
SRC_URI[aarch64_jaxb-relaxng-datatype.sha256sum] = "bf6e65a6d85f3741431c1cb45d94c46fe8b75f026f25276ce7f61ed3eaa11962"

URI_aarch64_jaxb-rngom = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-rngom-4.0.4-6.el10.noarch.rpm;name=aarch64_jaxb-rngom;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-rngom}"
SRC_URI[aarch64_jaxb-rngom.sha256sum] = "4f68766c705b64e5d59622bb53a7a4983b985b432cfb736bf2947d601b5ca6bb"

URI_aarch64_jaxb-runtime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-runtime-4.0.4-6.el10.noarch.rpm;name=aarch64_jaxb-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-runtime}"
SRC_URI[aarch64_jaxb-runtime.sha256sum] = "21bf94855f211f3e23117897eb4fb6d375ff08213b558b808011e6914a042658"

URI_aarch64_jaxb-txw2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-txw2-4.0.4-6.el10.noarch.rpm;name=aarch64_jaxb-txw2;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-txw2}"
SRC_URI[aarch64_jaxb-txw2.sha256sum] = "5db67aae4693fbbabca9b39a60fa3a2c43aa2688e6906a02e3f0283effd78147"

URI_aarch64_jaxb-txwc2 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jaxb-txwc2-4.0.4-6.el10.noarch.rpm;name=aarch64_jaxb-txwc2;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-txwc2}"
SRC_URI[aarch64_jaxb-txwc2.sha256sum] = "cb296e791f39d0548ddeac55e72ae44adc57b023aaa48cdfc0c29671d3a15156"

URI_aarch64_jaxb-xjc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-xjc-4.0.4-6.el10.noarch.rpm;name=aarch64_jaxb-xjc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-xjc}"
SRC_URI[aarch64_jaxb-xjc.sha256sum] = "3e380614c1c90df140987a4273aeafe9aede4657d552ae64ee11f3cc8dd4769c"

URI_aarch64_jaxb-xsom = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-xsom-4.0.4-6.el10.noarch.rpm;name=aarch64_jaxb-xsom;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-xsom}"
SRC_URI[aarch64_jaxb-xsom.sha256sum] = "468e6d095f5542b4115453d87d9c0ca48e5a8741c533ce8e8413c84b21f7a056"

RDEPENDS:jaxb-codemodel = " \
 javapackages-filesystem \
 "
RDEPENDS:jaxb-codemodel-annotation-compiler = " \
 javapackages-filesystem \
 jaxb-codemodel \
 "
RDEPENDS:jaxb-core = " \
 jakarta-activation \
 javapackages-filesystem \
 jaxb-api \
 jaxb-istack-commons-runtime \
 jaxb-txw2 \
 "
RDEPENDS:jaxb-relaxng-datatype = " \
 javapackages-filesystem \
 "
RDEPENDS:jaxb-rngom = " \
 javapackages-filesystem \
 jaxb-relaxng-datatype \
 "
RDEPENDS:jaxb-runtime = " \
 javapackages-filesystem \
 jaxb-core \
 "
RDEPENDS:jaxb-txw2 = " \
 javapackages-filesystem \
 "
RDEPENDS:jaxb-txwc2 = " \
 javapackages-filesystem \
 jaxb-codemodel \
 jaxb-rngom \
 jaxb-txw2 \
 jaxb-xsom \
 "
RDEPENDS:jaxb-xjc = " \
 javapackages-filesystem \
 jaxb-codemodel \
 jaxb-core \
 jaxb-dtd-parser \
 jaxb-istack-commons-tools \
 jaxb-rngom \
 jaxb-xsom \
 "
RDEPENDS:jaxb-xsom = " \
 javapackages-filesystem \
 jaxb-relaxng-datatype \
 "
