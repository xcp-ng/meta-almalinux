# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-mime-types"
PV = "3.4.1"
PR = "7.el10_2"
PACKAGES = " \
 rubygem-mime-types \
 rubygem-mime-types-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-mime-types-3.4.1-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "301ab3774dcaae3765015c0224d4e775925087ecc46dd9de81388cd99faa27ae"

URI_x86_64_v2_rubygem-mime-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-mime-types-3.4.1-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-mime-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mime-types}"
SRC_URI[x86_64_v2_rubygem-mime-types.sha256sum] = "ae0e0ab3ac5816cb3c391be9f065746482b5dff3fb6719103083ae60d147f409"

URI_x86_64_v2_rubygem-mime-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-mime-types-doc-3.4.1-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-mime-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mime-types-doc}"
SRC_URI[x86_64_v2_rubygem-mime-types-doc.sha256sum] = "a5abf0904f2258a33e2433227950d11b4a5633b0a2d0ef94bfe958ac01d3f384"

URI_aarch64_rubygem-mime-types = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-mime-types-3.4.1-7.el10_2.noarch.rpm;name=aarch64_rubygem-mime-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mime-types}"
SRC_URI[aarch64_rubygem-mime-types.sha256sum] = "01a665644fa3cdab55d84ee947bbf33f3071c7fff39db90b9eec8ee3ce3b5d0e"

URI_aarch64_rubygem-mime-types-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-mime-types-doc-3.4.1-7.el10_2.noarch.rpm;name=aarch64_rubygem-mime-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mime-types-doc}"
SRC_URI[aarch64_rubygem-mime-types-doc.sha256sum] = "fc80f130459b5b7adff3f19d3e79094f6060a4b821d55c420b39153811e5097d"

RDEPENDS:rubygem-mime-types = " \
 rubygem-mime-types-data \
 rubygems \
 "
RDEPENDS:rubygem-mime-types-doc = " \
 rubygem-mime-types \
 "
