# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mailparse"
PV = "3.2.0"
PR = "2.el10_2"
PACKAGES = " \
 php-pecl-mailparse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mailparse-3.2.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff7f845d7baf59e25cc14546fb26511957b408c28edf11548e7572257e726130"

URI_x86_64_v2_php-pecl-mailparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mailparse-3.2.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mailparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mailparse}"
SRC_URI[x86_64_v2_php-pecl-mailparse.sha256sum] = "9b38c36aca420516325f87c109e5455a377332c8042bf858794d6f376e3604fc"

URI_aarch64_php-pecl-mailparse = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mailparse-3.2.0-2.el10_2.aarch64.rpm;name=aarch64_php-pecl-mailparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mailparse}"
SRC_URI[aarch64_php-pecl-mailparse.sha256sum] = "8eda41f5cdb0baf207e37b0d32f73a26664b57ac185dc26db1e2e986ead9f366"

RDEPENDS:php-pecl-mailparse = " \
 glibc \
 php-common \
 "
