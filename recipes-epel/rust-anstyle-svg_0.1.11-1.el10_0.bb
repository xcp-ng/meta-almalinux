# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-svg"
PV = "0.1.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-anstyle-svg+default-devel \
 rust-anstyle-svg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-svg-0.1.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de3220dcc945c0fe57515890b2cca0d3d4dfb88d6756b94fec9465d5862f32f9"

URI_x86_64_v2_rust-anstyle-svg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-svg+default-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-svg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-svg+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-svg+default-devel.sha256sum] = "30502a0f96d787a98d4b324a1c86a43bc455390b7f7caa62feebd554b75d48e8"

URI_x86_64_v2_rust-anstyle-svg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-svg-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-svg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-svg-devel}"
SRC_URI[x86_64_v2_rust-anstyle-svg-devel.sha256sum] = "6df7054eb6db65c944930d28c579ab889097423156c5f3a6c7e469e4aad44361"

URI_aarch64_rust-anstyle-svg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-svg+default-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-svg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-svg+default-devel}"
SRC_URI[aarch64_rust-anstyle-svg+default-devel.sha256sum] = "c00ec260446c70cdcc3bbcb514782042f39d460db49c28afffc7dde60f3a9df9"

URI_aarch64_rust-anstyle-svg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-svg-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-svg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-svg-devel}"
SRC_URI[aarch64_rust-anstyle-svg-devel.sha256sum] = "df195090721bb4d45ac87d7b773937dceff784fe4520b9a6c3d1512bd7eed683"

RDEPENDS:rust-anstyle-svg+default-devel = " \
 cargo \
 rust-anstyle-svg-devel \
 "
RDEPENDS:rust-anstyle-svg-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-anstyle-lossy+default-devel \
 rust-anstyle-parse+default-devel \
 rust-html-escape+default-devel \
 rust-unicode-width+default-devel \
 "
