# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librime"
PV = "1.11.2"
PR = "2.el10_3"
PACKAGES = " \
 librime \
 librime-devel \
 librime-lua \
 librime-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/librime-1.11.2-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88d4586db1ec1eedc32f824fdad07b444bf4afe82f1b85d1b840ae5ff7ea02ce"

URI_x86_64_v2_librime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librime-1.11.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librime}"
SRC_URI[x86_64_v2_librime.sha256sum] = "12d8de544245208d3d87bff7cad8d4ee25a74b6dc3496358332e9363f76b0432"

URI_x86_64_v2_librime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librime-devel-1.11.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librime-devel}"
SRC_URI[x86_64_v2_librime-devel.sha256sum] = "fb9406bf88a5b8f5a1fd8450b98b389acb02b020439a1226cf5a7ca5a3b18dde"

URI_x86_64_v2_librime-lua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librime-lua-1.11.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librime-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librime-lua}"
SRC_URI[x86_64_v2_librime-lua.sha256sum] = "be2f21cc4a433a2bd42bd684481073d4677c9c4523bf31f081120d8a32c92523"

URI_x86_64_v2_librime-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librime-tools-1.11.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librime-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librime-tools}"
SRC_URI[x86_64_v2_librime-tools.sha256sum] = "25748e08d81535165c9f9aa4191e2f4d3c590ccaa4c4ad7554762b1c699d2a9d"

URI_aarch64_librime = "${EPEL_MIRROR}/aarch64/Packages/l/librime-1.11.2-2.el10_3.aarch64.rpm;name=aarch64_librime;unpack=0"
SRC_URI:append = " ${URI_aarch64_librime}"
SRC_URI[aarch64_librime.sha256sum] = "999e1e30ea3476ab65b63eb0d9bb284163577dd22b1b43ff68cd9a1c930a5e77"

URI_aarch64_librime-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librime-devel-1.11.2-2.el10_3.aarch64.rpm;name=aarch64_librime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librime-devel}"
SRC_URI[aarch64_librime-devel.sha256sum] = "f1856963385a35172c96dd479a437dc8cad7b1ee42200918bb1a7558d5e795c5"

URI_aarch64_librime-lua = "${EPEL_MIRROR}/aarch64/Packages/l/librime-lua-1.11.2-2.el10_3.aarch64.rpm;name=aarch64_librime-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_librime-lua}"
SRC_URI[aarch64_librime-lua.sha256sum] = "9502ae53a9aa99233d9adc549c5159ff880a7851871b5c2dd849c22b1b3d5bf5"

URI_aarch64_librime-tools = "${EPEL_MIRROR}/aarch64/Packages/l/librime-tools-1.11.2-2.el10_3.aarch64.rpm;name=aarch64_librime-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_librime-tools}"
SRC_URI[aarch64_librime-tools.sha256sum] = "bc7b1626e10cf4f25f7fb6dc5167a7cf49b1793db568a9e76f610af7fce39ef7"

RDEPENDS:librime = " \
 glibc \
 glog \
 leveldb \
 libgcc \
 libstdc++ \
 marisa \
 opencc \
 yaml-cpp \
 "
RDEPENDS:librime-devel = " \
 cmake-filesystem \
 librime \
 pkgconf-pkg-config \
 "
RDEPENDS:librime-lua = " \
 glibc \
 glog \
 libgcc \
 librime \
 libstdc++ \
 lua-libs \
 opencc \
 "
RDEPENDS:librime-tools = " \
 glibc \
 glog \
 libgcc \
 librime \
 libstdc++ \
 "
