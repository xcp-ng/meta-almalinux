# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-secrecy"
PV = "0.10.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-secrecy+default-devel \
 rust-secrecy+serde-devel \
 rust-secrecy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-secrecy-0.10.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88115c3b8010fa282dc6b2bb9926ffb32e577d22bbeee6b02bd0effa6cb6da1c"

URI_x86_64_v2_rust-secrecy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secrecy+default-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secrecy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secrecy+default-devel}"
SRC_URI[x86_64_v2_rust-secrecy+default-devel.sha256sum] = "f1299cf0957ff66eba752b93d32a58707991f6ba231b6e257db30477a88ad7f3"

URI_x86_64_v2_rust-secrecy+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secrecy+serde-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secrecy+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secrecy+serde-devel}"
SRC_URI[x86_64_v2_rust-secrecy+serde-devel.sha256sum] = "e8c53fe3eaf3208dedf6deb38f73eb235bd95b528c9a6a70674ec7f72a17a669"

URI_x86_64_v2_rust-secrecy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secrecy-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secrecy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secrecy-devel}"
SRC_URI[x86_64_v2_rust-secrecy-devel.sha256sum] = "76a01f509f9b536d74044fa5709d5d6112487987cfc280e4c3395fe920558113"

URI_aarch64_rust-secrecy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secrecy+default-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-secrecy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secrecy+default-devel}"
SRC_URI[aarch64_rust-secrecy+default-devel.sha256sum] = "95609a8d0bf6b7e6e955055880a8e83fa6e64be7362eb6f72ed29e5b7f7b9e45"

URI_aarch64_rust-secrecy+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secrecy+serde-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-secrecy+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secrecy+serde-devel}"
SRC_URI[aarch64_rust-secrecy+serde-devel.sha256sum] = "ee9c3ea6d58f15f95a7c0550df91b4c7a16bbea2f0b250794b5151813cdef64e"

URI_aarch64_rust-secrecy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secrecy-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-secrecy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secrecy-devel}"
SRC_URI[aarch64_rust-secrecy-devel.sha256sum] = "524874b843bbdcd280b33dc2aa56ec3ccac9b16bf7b6990269d9b4309b25e130"

RDEPENDS:rust-secrecy+default-devel = " \
 cargo \
 rust-secrecy-devel \
 "
RDEPENDS:rust-secrecy+serde-devel = " \
 cargo \
 rust-secrecy-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-secrecy-devel = " \
 cargo \
 rust \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
