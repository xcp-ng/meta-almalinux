# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uwsgi"
PV = "2.0.28"
PR = "1.el10_0"
PACKAGES = " \
 python3-uwsgidecorators \
 python3.12-uwsgidecorators \
 uwsgi \
 uwsgi-alarm-curl \
 uwsgi-devel \
 uwsgi-docs \
 uwsgi-emperor-amqp \
 uwsgi-emperor-pg \
 uwsgi-log-encoder-msgpack \
 uwsgi-logger-crypto \
 uwsgi-logger-file \
 uwsgi-logger-graylog2 \
 uwsgi-logger-pipe \
 uwsgi-logger-redis \
 uwsgi-logger-rsyslog \
 uwsgi-logger-socket \
 uwsgi-logger-syslog \
 uwsgi-logger-systemd \
 uwsgi-plugin-airbrake \
 uwsgi-plugin-cache \
 uwsgi-plugin-carbon \
 uwsgi-plugin-cheaper-busyness \
 uwsgi-plugin-common \
 uwsgi-plugin-cplusplus \
 uwsgi-plugin-curl-cron \
 uwsgi-plugin-dumbloop \
 uwsgi-plugin-dummy \
 uwsgi-plugin-fiber \
 uwsgi-plugin-ldap \
 uwsgi-plugin-lua \
 uwsgi-plugin-nagios \
 uwsgi-plugin-notfound \
 uwsgi-plugin-pam \
 uwsgi-plugin-php \
 uwsgi-plugin-psgi \
 uwsgi-plugin-pty \
 uwsgi-plugin-python3 \
 uwsgi-plugin-python3-gevent \
 uwsgi-plugin-python3-tornado \
 uwsgi-plugin-python312 \
 uwsgi-plugin-python312-gevent \
 uwsgi-plugin-rack \
 uwsgi-plugin-rbthreads \
 uwsgi-plugin-rpc \
 uwsgi-plugin-rrdtool \
 uwsgi-plugin-ruby \
 uwsgi-plugin-spooler \
 uwsgi-plugin-sqlite3 \
 uwsgi-plugin-ssi \
 uwsgi-plugin-ugreen \
 uwsgi-plugin-webdav \
 uwsgi-plugin-xattr \
 uwsgi-plugin-xslt \
 uwsgi-plugin-zergpool \
 uwsgi-router-basicauth \
 uwsgi-router-cache \
 uwsgi-router-expires \
 uwsgi-router-fast \
 uwsgi-router-forkpty \
 uwsgi-router-hash \
 uwsgi-router-http \
 uwsgi-router-memcached \
 uwsgi-router-metrics \
 uwsgi-router-radius \
 uwsgi-router-raw \
 uwsgi-router-redirect \
 uwsgi-router-redis \
 uwsgi-router-rewrite \
 uwsgi-router-spnego \
 uwsgi-router-ssl \
 uwsgi-router-static \
 uwsgi-router-tuntap \
 uwsgi-router-uwsgi \
 uwsgi-router-xmldir \
 uwsgi-stats-pusher-file \
 uwsgi-stats-pusher-socket \
 uwsgi-stats-pusher-statsd \
 uwsgi-stats-pusher-zabbix \
 uwsgi-transformation-chunked \
 uwsgi-transformation-gzip \
 uwsgi-transformation-offload \
 uwsgi-transformation-template \
 uwsgi-transformation-tofile \
 uwsgi-transformation-toupper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uwsgi-2.0.28-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff89fea06031608be8e574bc5acdb4c01c11c472ef56a0c0b51874a6a40c67bf"

URI_x86_64_v2_python3-uwsgidecorators = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uwsgidecorators-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-uwsgidecorators;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uwsgidecorators}"
SRC_URI[x86_64_v2_python3-uwsgidecorators.sha256sum] = "7be47d79086166e0cdbfdcca3ab3456fcee85f797e6366bdd2d3ac9c0f7a0078"

URI_x86_64_v2_python3.12-uwsgidecorators = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.12-uwsgidecorators-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.12-uwsgidecorators;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.12-uwsgidecorators}"
SRC_URI[x86_64_v2_python3.12-uwsgidecorators.sha256sum] = "792e258941f91ac00003bc2ba60b0c671b10d39a0595ab0d92de5839a89e98b1"

URI_x86_64_v2_uwsgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi}"
SRC_URI[x86_64_v2_uwsgi.sha256sum] = "ee2c613a0effcf6ed8702db6199efe1f52233b4072a31f0c4fab6a1663d2e5c8"

URI_x86_64_v2_uwsgi-alarm-curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-alarm-curl-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-alarm-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-alarm-curl}"
SRC_URI[x86_64_v2_uwsgi-alarm-curl.sha256sum] = "7525560f5c6cc191efb22c2aa709ac83c0bead9b13fee5f8a89b1e8a0f0280ae"

URI_x86_64_v2_uwsgi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-devel-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-devel}"
SRC_URI[x86_64_v2_uwsgi-devel.sha256sum] = "347445dcbb0969a20a008fcca630ac5b90d2d4cc510c2fcb112787f4b8287516"

URI_x86_64_v2_uwsgi-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-docs-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-docs}"
SRC_URI[x86_64_v2_uwsgi-docs.sha256sum] = "8b5438a9ad9b4586c50964960aba26a4aee4cef6b2a80c7075b86ee6c5eb55dd"

URI_x86_64_v2_uwsgi-emperor-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-emperor-amqp-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-emperor-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-emperor-amqp}"
SRC_URI[x86_64_v2_uwsgi-emperor-amqp.sha256sum] = "09e24c72ca37676e49e44ac94ae234a4e6c6d4e05eeb4b22dac0b1f8c785bd59"

URI_x86_64_v2_uwsgi-emperor-pg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-emperor-pg-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-emperor-pg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-emperor-pg}"
SRC_URI[x86_64_v2_uwsgi-emperor-pg.sha256sum] = "177b3e5cde0bc28c6d27acdcfc79a046e3c0ba34baff0d6b5da5bf35e6c99c34"

URI_x86_64_v2_uwsgi-log-encoder-msgpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-log-encoder-msgpack-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-log-encoder-msgpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-log-encoder-msgpack}"
SRC_URI[x86_64_v2_uwsgi-log-encoder-msgpack.sha256sum] = "3d974a5a95671d3b34a4e5c8a4687bab98da0550dc0db8b5a51eae57202d7c06"

URI_x86_64_v2_uwsgi-logger-crypto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-crypto-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-crypto}"
SRC_URI[x86_64_v2_uwsgi-logger-crypto.sha256sum] = "63b36b17a71eca5bdd64f029a3ff837cee444336d049baac49d13a3c051f9900"

URI_x86_64_v2_uwsgi-logger-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-file-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-file}"
SRC_URI[x86_64_v2_uwsgi-logger-file.sha256sum] = "49089bc590c2921dfe0ba34dab7e2efacb8baff83e05be53d92ae5c76dfa25c1"

URI_x86_64_v2_uwsgi-logger-graylog2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-graylog2-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-graylog2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-graylog2}"
SRC_URI[x86_64_v2_uwsgi-logger-graylog2.sha256sum] = "abccf3ad06316b4b5df7e10d5981cee549c433994f3b3f68f9cda77d2cb23f0f"

URI_x86_64_v2_uwsgi-logger-pipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-pipe-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-pipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-pipe}"
SRC_URI[x86_64_v2_uwsgi-logger-pipe.sha256sum] = "4b36ec79cd8f8c63bb16cf09719c402d0ee692c77ff9ef5e58ee3714616f71f4"

URI_x86_64_v2_uwsgi-logger-redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-redis-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-redis}"
SRC_URI[x86_64_v2_uwsgi-logger-redis.sha256sum] = "fc09180f3e823384eba3534a807172ffa701e088165f2aa3bd6b54e550c962db"

URI_x86_64_v2_uwsgi-logger-rsyslog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-rsyslog-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-rsyslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-rsyslog}"
SRC_URI[x86_64_v2_uwsgi-logger-rsyslog.sha256sum] = "cf6cff4a23d56c0509b9c757985228f367a06f8482197372c33e08fdcb76d77b"

URI_x86_64_v2_uwsgi-logger-socket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-socket-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-socket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-socket}"
SRC_URI[x86_64_v2_uwsgi-logger-socket.sha256sum] = "5a235a93e6d0860e9e281a5b66614501e29e6929f1f575e0d7e53268427f3b9b"

URI_x86_64_v2_uwsgi-logger-syslog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-syslog-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-syslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-syslog}"
SRC_URI[x86_64_v2_uwsgi-logger-syslog.sha256sum] = "b80ec254e308bb7dda6a689f73be472a47da0727613fc352a6d5443950def546"

URI_x86_64_v2_uwsgi-logger-systemd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-logger-systemd-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-logger-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-logger-systemd}"
SRC_URI[x86_64_v2_uwsgi-logger-systemd.sha256sum] = "ae0d75b770e13f30a0285140abb42479bd738d411757266d7cafeeac6aeeb7ac"

URI_x86_64_v2_uwsgi-plugin-airbrake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-airbrake-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-airbrake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-airbrake}"
SRC_URI[x86_64_v2_uwsgi-plugin-airbrake.sha256sum] = "f7e0f5246a3f980efa93e422591be638c7c44e80a637eb414e74cabb02daaa43"

URI_x86_64_v2_uwsgi-plugin-cache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-cache-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-cache}"
SRC_URI[x86_64_v2_uwsgi-plugin-cache.sha256sum] = "910370dc80f3827420b30874ff6ca2484478bd414d734435479c2efb83af29f9"

URI_x86_64_v2_uwsgi-plugin-carbon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-carbon-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-carbon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-carbon}"
SRC_URI[x86_64_v2_uwsgi-plugin-carbon.sha256sum] = "4e9dab7868bfb326831138ccf1d4174c790ee555493cf3a834376e2aa7f071a7"

URI_x86_64_v2_uwsgi-plugin-cheaper-busyness = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-cheaper-busyness-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-cheaper-busyness;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-cheaper-busyness}"
SRC_URI[x86_64_v2_uwsgi-plugin-cheaper-busyness.sha256sum] = "bb6ee79ab098fd80eea176966c93d03212ac7f67ef68245f69e6dad741668f7e"

URI_x86_64_v2_uwsgi-plugin-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-common-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-common}"
SRC_URI[x86_64_v2_uwsgi-plugin-common.sha256sum] = "dbc32f2608c4431752c5c79e826ae8288f555ed5664f117f8aad6df523e22d52"

URI_x86_64_v2_uwsgi-plugin-cplusplus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-cplusplus-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-cplusplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-cplusplus}"
SRC_URI[x86_64_v2_uwsgi-plugin-cplusplus.sha256sum] = "2ffcadc785143ae80666bc0ede59074582336e399cb19569bef6c54565673f4a"

URI_x86_64_v2_uwsgi-plugin-curl-cron = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-curl-cron-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-curl-cron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-curl-cron}"
SRC_URI[x86_64_v2_uwsgi-plugin-curl-cron.sha256sum] = "cba701be4cff3d97e3328239396988a5eb2ce338c32f4de96e164f1a887800cc"

URI_x86_64_v2_uwsgi-plugin-dumbloop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-dumbloop-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-dumbloop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-dumbloop}"
SRC_URI[x86_64_v2_uwsgi-plugin-dumbloop.sha256sum] = "2b73644f37f0fbf6ac52a9bfd035490a1a10f1a114a66f7e8b48486b0474a6fd"

URI_x86_64_v2_uwsgi-plugin-dummy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-dummy-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-dummy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-dummy}"
SRC_URI[x86_64_v2_uwsgi-plugin-dummy.sha256sum] = "7910758b54123233ca961e0044f0e1f0f14fcfae2d5addf4d2a0f5e115b5b7e9"

URI_x86_64_v2_uwsgi-plugin-fiber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-fiber-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-fiber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-fiber}"
SRC_URI[x86_64_v2_uwsgi-plugin-fiber.sha256sum] = "417188ac5e3525cc762e561d581d0a956d4a162ce920704af1dec440608277ff"

URI_x86_64_v2_uwsgi-plugin-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-ldap-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-ldap}"
SRC_URI[x86_64_v2_uwsgi-plugin-ldap.sha256sum] = "148bada5880a27d42515f718af27d5b02244eed7e00643cd0886a491d90299f5"

URI_x86_64_v2_uwsgi-plugin-lua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-lua-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-lua}"
SRC_URI[x86_64_v2_uwsgi-plugin-lua.sha256sum] = "ba3089af20d3f0c206812a39ff1ff051601c48ab28844f58b27211c5de40f0b5"

URI_x86_64_v2_uwsgi-plugin-nagios = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-nagios-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-nagios;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-nagios}"
SRC_URI[x86_64_v2_uwsgi-plugin-nagios.sha256sum] = "84667eb94e031ba7c7bb338e8c1e61469a8b8fa0bbe249377b6bd960a4e805f0"

URI_x86_64_v2_uwsgi-plugin-notfound = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-notfound-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-notfound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-notfound}"
SRC_URI[x86_64_v2_uwsgi-plugin-notfound.sha256sum] = "c4589e7be295f4b925876cac0b63ed9f12940addd3a5a94376f9abbdbc7f2e8e"

URI_x86_64_v2_uwsgi-plugin-pam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-pam-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-pam}"
SRC_URI[x86_64_v2_uwsgi-plugin-pam.sha256sum] = "56e65a585d9a63ca46486525099809485e53036bdd5d6d422b024916cb18a6cb"

URI_x86_64_v2_uwsgi-plugin-php = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-php-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-php;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-php}"
SRC_URI[x86_64_v2_uwsgi-plugin-php.sha256sum] = "9d4a9c9e925a7b948acba55ff1bf351f921d43fbf705aae64aa1363dfa6934e4"

URI_x86_64_v2_uwsgi-plugin-psgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-psgi-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-psgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-psgi}"
SRC_URI[x86_64_v2_uwsgi-plugin-psgi.sha256sum] = "026709312ac88f79796c2c7297878ed635b723e66081db1f9993394b7ced8d14"

URI_x86_64_v2_uwsgi-plugin-pty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-pty-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-pty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-pty}"
SRC_URI[x86_64_v2_uwsgi-plugin-pty.sha256sum] = "09274cfaec9125e79c6adcda40511850d252704ac7f342240a79f1592b3e75d3"

URI_x86_64_v2_uwsgi-plugin-python3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-python3-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-python3}"
SRC_URI[x86_64_v2_uwsgi-plugin-python3.sha256sum] = "65a20e34c294a04ffb17b8fce113aa046b5f941f00396e6ac73532ad8e68289c"

URI_x86_64_v2_uwsgi-plugin-python3-gevent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-python3-gevent-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-python3-gevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-python3-gevent}"
SRC_URI[x86_64_v2_uwsgi-plugin-python3-gevent.sha256sum] = "009e0344cdbadf0fee9b112dbaca8728e3d1d6f4f67ab73006fbceac7cde1299"

URI_x86_64_v2_uwsgi-plugin-python3-tornado = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-python3-tornado-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-python3-tornado;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-python3-tornado}"
SRC_URI[x86_64_v2_uwsgi-plugin-python3-tornado.sha256sum] = "f53262569b372a128a56835ab11ae6daf9cf4a0d61993e3fb0f3763a0b6ad9e6"

URI_x86_64_v2_uwsgi-plugin-python312 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-python312-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-python312;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-python312}"
SRC_URI[x86_64_v2_uwsgi-plugin-python312.sha256sum] = "102ca83537bc0469929e9daf2156b4ba530986ab23ddab225274f810f22d487c"

URI_x86_64_v2_uwsgi-plugin-python312-gevent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-python312-gevent-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-python312-gevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-python312-gevent}"
SRC_URI[x86_64_v2_uwsgi-plugin-python312-gevent.sha256sum] = "fe88cad1ab92606495b37919fd885fd14c731cd4f50ed6c91007ad874a873704"

URI_x86_64_v2_uwsgi-plugin-rack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-rack-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-rack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-rack}"
SRC_URI[x86_64_v2_uwsgi-plugin-rack.sha256sum] = "104d2d7370f77e5e9f5e90a6a05f2a4bf4b12c2ad1611f748510b8428c203754"

URI_x86_64_v2_uwsgi-plugin-rbthreads = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-rbthreads-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-rbthreads;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-rbthreads}"
SRC_URI[x86_64_v2_uwsgi-plugin-rbthreads.sha256sum] = "caa59a4f96fe3177cfdb54ac4f61768368695e780d9b9632e711221f84bd3a08"

URI_x86_64_v2_uwsgi-plugin-rpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-rpc-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-rpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-rpc}"
SRC_URI[x86_64_v2_uwsgi-plugin-rpc.sha256sum] = "7c15a5e5c64d6f0d7f898c673f1b9b7d3a0b04ab7cfbb2ee8c51a1c4ce23e92e"

URI_x86_64_v2_uwsgi-plugin-rrdtool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-rrdtool-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-rrdtool}"
SRC_URI[x86_64_v2_uwsgi-plugin-rrdtool.sha256sum] = "dabde27dd360557e2ad92baa3c36293a1c6926d44cc5ea4823ac743362e20689"

URI_x86_64_v2_uwsgi-plugin-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-ruby-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-ruby}"
SRC_URI[x86_64_v2_uwsgi-plugin-ruby.sha256sum] = "0cb6184ab01d9431c3caf1abede069cf1a3e35c8d24194ccaec988f798f32aee"

URI_x86_64_v2_uwsgi-plugin-spooler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-spooler-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-spooler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-spooler}"
SRC_URI[x86_64_v2_uwsgi-plugin-spooler.sha256sum] = "28609f01336048b42e1df992faf8ebf9ad3cb0aa9212e0ef964d0f60b25ff51c"

URI_x86_64_v2_uwsgi-plugin-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-sqlite3-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-sqlite3}"
SRC_URI[x86_64_v2_uwsgi-plugin-sqlite3.sha256sum] = "e8b6866eb5e1353f9becfbc5bbe396093894a94929546099bce67945d89b558c"

URI_x86_64_v2_uwsgi-plugin-ssi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-ssi-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-ssi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-ssi}"
SRC_URI[x86_64_v2_uwsgi-plugin-ssi.sha256sum] = "8a3012cc239ee533067fb8753cd0662c8b16a0cbd69f69404a5616ca43a11167"

URI_x86_64_v2_uwsgi-plugin-ugreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-ugreen-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-ugreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-ugreen}"
SRC_URI[x86_64_v2_uwsgi-plugin-ugreen.sha256sum] = "0f09ebd08641b335c1c64d7ae5c0c3d32053a16f2ee703048902a1084bda4f11"

URI_x86_64_v2_uwsgi-plugin-webdav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-webdav-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-webdav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-webdav}"
SRC_URI[x86_64_v2_uwsgi-plugin-webdav.sha256sum] = "ccf1c52fbd4297d8eafc3e06ef789ae719ea45caf331208f5b346f09c055b7ed"

URI_x86_64_v2_uwsgi-plugin-xattr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-xattr-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-xattr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-xattr}"
SRC_URI[x86_64_v2_uwsgi-plugin-xattr.sha256sum] = "98f017fa0cef279a4b6a73cc5f9b849a51505422d88f9d780eca98a14bcf6d90"

URI_x86_64_v2_uwsgi-plugin-xslt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-xslt-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-xslt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-xslt}"
SRC_URI[x86_64_v2_uwsgi-plugin-xslt.sha256sum] = "60f2a1b4f9078d91e083992fd4c97e10540efeeee64d127612fa34240381a56f"

URI_x86_64_v2_uwsgi-plugin-zergpool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-plugin-zergpool-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-plugin-zergpool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-plugin-zergpool}"
SRC_URI[x86_64_v2_uwsgi-plugin-zergpool.sha256sum] = "0aeaf27a5176bfe44b9e406840acace6ebeec98ed5eaed47f0b92f2ad28ee511"

URI_x86_64_v2_uwsgi-router-basicauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-basicauth-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-basicauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-basicauth}"
SRC_URI[x86_64_v2_uwsgi-router-basicauth.sha256sum] = "ddf3aa0eb4576644f5f8ff99dc4b6260e2631f7f8d134405df88e266f7e3d286"

URI_x86_64_v2_uwsgi-router-cache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-cache-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-cache}"
SRC_URI[x86_64_v2_uwsgi-router-cache.sha256sum] = "91e99c2c25dd939a53c0eadd8c67c2d6f42630fc91eb11dc3ad7361bcdb77d19"

URI_x86_64_v2_uwsgi-router-expires = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-expires-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-expires;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-expires}"
SRC_URI[x86_64_v2_uwsgi-router-expires.sha256sum] = "d627ba88de9b574e95ad141826caa151916823d298828bdf5b754a96009fa46b"

URI_x86_64_v2_uwsgi-router-fast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-fast-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-fast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-fast}"
SRC_URI[x86_64_v2_uwsgi-router-fast.sha256sum] = "2767cb5af55f1e83ec78998ce757fa565dbbe74e57813ac1bba7405885656892"

URI_x86_64_v2_uwsgi-router-forkpty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-forkpty-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-forkpty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-forkpty}"
SRC_URI[x86_64_v2_uwsgi-router-forkpty.sha256sum] = "97d38c808b4c72d085cbb417c0e3c8f189760df4ef88332adebf33e0cf2ebc5a"

URI_x86_64_v2_uwsgi-router-hash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-hash-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-hash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-hash}"
SRC_URI[x86_64_v2_uwsgi-router-hash.sha256sum] = "e78ff67fd3714e58f698c7281c3db709e45dcb986e12219a9dbedc3158585ea3"

URI_x86_64_v2_uwsgi-router-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-http-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-http}"
SRC_URI[x86_64_v2_uwsgi-router-http.sha256sum] = "5f2f2eee77740e76be9897283be37a9b91291906733b4aff16f1caba7aff9902"

URI_x86_64_v2_uwsgi-router-memcached = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-memcached-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-memcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-memcached}"
SRC_URI[x86_64_v2_uwsgi-router-memcached.sha256sum] = "f3ca5188f5aac68adcdc80bcf3f32011f097302329f495cff0c2c082463e3c38"

URI_x86_64_v2_uwsgi-router-metrics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-metrics-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-metrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-metrics}"
SRC_URI[x86_64_v2_uwsgi-router-metrics.sha256sum] = "9d61acddc0daf54e1e7da1b8389966ba4bc27dcd6cf57d1eaf174dffd361e3a2"

URI_x86_64_v2_uwsgi-router-radius = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-radius-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-radius;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-radius}"
SRC_URI[x86_64_v2_uwsgi-router-radius.sha256sum] = "a4ac030f3ef77b0b575579d6b8d276530d8ee52280bd864487cf213b6fad613a"

URI_x86_64_v2_uwsgi-router-raw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-raw-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-raw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-raw}"
SRC_URI[x86_64_v2_uwsgi-router-raw.sha256sum] = "8b9e350b4d4687e654519ca74867ab979eb3bc878ea1b7acd3fe1f502c8e2d63"

URI_x86_64_v2_uwsgi-router-redirect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-redirect-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-redirect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-redirect}"
SRC_URI[x86_64_v2_uwsgi-router-redirect.sha256sum] = "6db6b1775d4d9e42b072115a074cfc3229c20f659f896b462b5c831cfdda8f00"

URI_x86_64_v2_uwsgi-router-redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-redis-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-redis}"
SRC_URI[x86_64_v2_uwsgi-router-redis.sha256sum] = "2754bc122ea14308ffe2c6ee15fb74b2e48b471fcab5db1c60e8f2100506dea3"

URI_x86_64_v2_uwsgi-router-rewrite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-rewrite-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-rewrite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-rewrite}"
SRC_URI[x86_64_v2_uwsgi-router-rewrite.sha256sum] = "9a2d850efade8bda477e591ccc6daf131cd9debf90bf7cbc566a68266b485798"

URI_x86_64_v2_uwsgi-router-spnego = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-spnego-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-spnego;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-spnego}"
SRC_URI[x86_64_v2_uwsgi-router-spnego.sha256sum] = "67b8e86034747a498abbc4958ada036472e63815cc5e01453d11fb024b38a652"

URI_x86_64_v2_uwsgi-router-ssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-ssl-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-ssl}"
SRC_URI[x86_64_v2_uwsgi-router-ssl.sha256sum] = "8ee245063673187f59365774accfa269b5d95ef6e96178f72a336e3867182a11"

URI_x86_64_v2_uwsgi-router-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-static-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-static}"
SRC_URI[x86_64_v2_uwsgi-router-static.sha256sum] = "d8b5dc65ba2d20a90f9a962fa19a73544ad646599e0be95cdefb84ba510b32c4"

URI_x86_64_v2_uwsgi-router-tuntap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-tuntap-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-tuntap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-tuntap}"
SRC_URI[x86_64_v2_uwsgi-router-tuntap.sha256sum] = "f29c544e241d595484f67be1a07952929461b2c8b8590ae634002799789dc42c"

URI_x86_64_v2_uwsgi-router-uwsgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-uwsgi-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-uwsgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-uwsgi}"
SRC_URI[x86_64_v2_uwsgi-router-uwsgi.sha256sum] = "dd25efb185ef5cc6fc96daa8cbb2844083859073eee6a07396229bff2e730051"

URI_x86_64_v2_uwsgi-router-xmldir = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-router-xmldir-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-router-xmldir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-router-xmldir}"
SRC_URI[x86_64_v2_uwsgi-router-xmldir.sha256sum] = "343733039b67e12c6804b2dc13d3013613ed879eea09c1b5b4ebce97a66f69ea"

URI_x86_64_v2_uwsgi-stats-pusher-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-stats-pusher-file-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-stats-pusher-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-stats-pusher-file}"
SRC_URI[x86_64_v2_uwsgi-stats-pusher-file.sha256sum] = "e1275bb588dc96c7ffac526d306d647e6a7a6b463c7e9e16d41273cfac3fb159"

URI_x86_64_v2_uwsgi-stats-pusher-socket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-stats-pusher-socket-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-stats-pusher-socket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-stats-pusher-socket}"
SRC_URI[x86_64_v2_uwsgi-stats-pusher-socket.sha256sum] = "87c9475ec4b3feed046fd3b96c8e136f72291c07b9f575d40b0fe3431fbd97c7"

URI_x86_64_v2_uwsgi-stats-pusher-statsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-stats-pusher-statsd-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-stats-pusher-statsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-stats-pusher-statsd}"
SRC_URI[x86_64_v2_uwsgi-stats-pusher-statsd.sha256sum] = "4c27c75b4edab8397cfd14b75c952dae787cfced574100f20d1b9b0c4540e0ea"

URI_x86_64_v2_uwsgi-stats-pusher-zabbix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-stats-pusher-zabbix-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-stats-pusher-zabbix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-stats-pusher-zabbix}"
SRC_URI[x86_64_v2_uwsgi-stats-pusher-zabbix.sha256sum] = "983a42c6c9887e735e3e9c451d9f4f854d97f219770a5e7d20b9c3d58874eec3"

URI_x86_64_v2_uwsgi-transformation-chunked = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-chunked-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-chunked;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-chunked}"
SRC_URI[x86_64_v2_uwsgi-transformation-chunked.sha256sum] = "2d96162e1d0d1723ee32c729f9eeb68d07728b212493efa0ff746db0ba828679"

URI_x86_64_v2_uwsgi-transformation-gzip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-gzip-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-gzip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-gzip}"
SRC_URI[x86_64_v2_uwsgi-transformation-gzip.sha256sum] = "5c68a3857ecf381ec5a0c4ef7f06705cf1fddbfb929d6b174bb05c0b62ea4fd4"

URI_x86_64_v2_uwsgi-transformation-offload = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-offload-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-offload;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-offload}"
SRC_URI[x86_64_v2_uwsgi-transformation-offload.sha256sum] = "7c9c3f725b021637c3cf653510ef6e0294c8129b11b4fe165f81ce2a45d4bafc"

URI_x86_64_v2_uwsgi-transformation-template = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-template-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-template;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-template}"
SRC_URI[x86_64_v2_uwsgi-transformation-template.sha256sum] = "7096897fab5ea05eea16ea3db4a21ae6d091c8a47f5a637338f719ba4e41a9b6"

URI_x86_64_v2_uwsgi-transformation-tofile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-tofile-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-tofile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-tofile}"
SRC_URI[x86_64_v2_uwsgi-transformation-tofile.sha256sum] = "c465cde5a6c4445e792b77f8ac3c886712feef39dff17d203f9d8ae0afb72687"

URI_x86_64_v2_uwsgi-transformation-toupper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uwsgi-transformation-toupper-2.0.28-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uwsgi-transformation-toupper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uwsgi-transformation-toupper}"
SRC_URI[x86_64_v2_uwsgi-transformation-toupper.sha256sum] = "1d2802641487ea4d68bddb453daed7917e9c49056bddf7f13ebe8d0a7dca0e13"

URI_aarch64_python3-uwsgidecorators = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uwsgidecorators-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_python3-uwsgidecorators;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uwsgidecorators}"
SRC_URI[aarch64_python3-uwsgidecorators.sha256sum] = "8d3c5d5b3d91ddf9c5f6da2c85df744554cb94eaf6954a13c074095c4ff61960"

URI_aarch64_python3.12-uwsgidecorators = "${EPEL_MIRROR}/aarch64/Packages/p/python3.12-uwsgidecorators-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_python3.12-uwsgidecorators;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.12-uwsgidecorators}"
SRC_URI[aarch64_python3.12-uwsgidecorators.sha256sum] = "eb191d9ebc89a269c444f204534b0ec70f65e77d498c13fd933ea4abc50e3c8f"

URI_aarch64_uwsgi = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi}"
SRC_URI[aarch64_uwsgi.sha256sum] = "9a3a3ca67dab7d6c30838bfab37dab47e5d40efb5888bc08510836d7d198c439"

URI_aarch64_uwsgi-alarm-curl = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-alarm-curl-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-alarm-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-alarm-curl}"
SRC_URI[aarch64_uwsgi-alarm-curl.sha256sum] = "2f0b0ef880548d747586fa3625f3c924f507c1f02b373eb29bee22d10e3f7dec"

URI_aarch64_uwsgi-devel = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-devel-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-devel}"
SRC_URI[aarch64_uwsgi-devel.sha256sum] = "bd83526d582d6a96830ef5c3f665a2a6c3041a2628feeee9330d354e129c13d3"

URI_aarch64_uwsgi-docs = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-docs-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-docs}"
SRC_URI[aarch64_uwsgi-docs.sha256sum] = "225fb405afc9eff57586aef8d4806c0620c0183c1c7de6f915d5943dbac05f92"

URI_aarch64_uwsgi-emperor-amqp = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-emperor-amqp-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-emperor-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-emperor-amqp}"
SRC_URI[aarch64_uwsgi-emperor-amqp.sha256sum] = "c6e26b7d654a14436486e0fce1a60e7dbe947ef8aa601f160bdbb04241a5aa3d"

URI_aarch64_uwsgi-emperor-pg = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-emperor-pg-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-emperor-pg;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-emperor-pg}"
SRC_URI[aarch64_uwsgi-emperor-pg.sha256sum] = "27bdb592d6dd9902fda5da9b32298597dbb97a92e40a76d97a67865339b25b48"

URI_aarch64_uwsgi-log-encoder-msgpack = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-log-encoder-msgpack-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-log-encoder-msgpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-log-encoder-msgpack}"
SRC_URI[aarch64_uwsgi-log-encoder-msgpack.sha256sum] = "1de15db81e7a70d81ec35cadd90ab3b4978d159aa882994e6a053fa226e6c48b"

URI_aarch64_uwsgi-logger-crypto = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-crypto-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-logger-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-crypto}"
SRC_URI[aarch64_uwsgi-logger-crypto.sha256sum] = "fb8228b061c8c719d407c0906c7c19724af229017ce137eef8f51c68f0f0e513"

URI_aarch64_uwsgi-logger-file = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-file-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-logger-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-file}"
SRC_URI[aarch64_uwsgi-logger-file.sha256sum] = "268c37c58af126587b25182e66c1636f8ed22a1a1249557e99b2c671889fada4"

URI_aarch64_uwsgi-logger-graylog2 = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-graylog2-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-logger-graylog2;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-graylog2}"
SRC_URI[aarch64_uwsgi-logger-graylog2.sha256sum] = "a35f774d8a5073b021fedf1efa83c7a6cbc29b66d7ad61cbf9674ee835808681"

URI_aarch64_uwsgi-logger-pipe = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-pipe-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-logger-pipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-pipe}"
SRC_URI[aarch64_uwsgi-logger-pipe.sha256sum] = "56cf5d7c2077e6b47bb195f8d041c312bb723868d67897e567ff35ccebbc5377"

URI_aarch64_uwsgi-logger-redis = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-redis-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-logger-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-redis}"
SRC_URI[aarch64_uwsgi-logger-redis.sha256sum] = "065a95926bc02d43fcf12725d474b028a103943c1a2312f5448b52bcd7d344ce"

URI_aarch64_uwsgi-logger-rsyslog = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-rsyslog-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-logger-rsyslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-rsyslog}"
SRC_URI[aarch64_uwsgi-logger-rsyslog.sha256sum] = "71d287d8bb89e3ed9162ef01179fd73fa3384c4403d3656cf5e736f4e4d1a02e"

URI_aarch64_uwsgi-logger-socket = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-socket-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-logger-socket;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-socket}"
SRC_URI[aarch64_uwsgi-logger-socket.sha256sum] = "a75944ce8b4a5ab8e8af46cb619695fa538abbc3b63ebf5d8dac3909aef47556"

URI_aarch64_uwsgi-logger-syslog = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-syslog-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-logger-syslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-syslog}"
SRC_URI[aarch64_uwsgi-logger-syslog.sha256sum] = "3cd0f1313ae1cb9c0615c090542c4e533a8570571f7dd7b36103bed336506a60"

URI_aarch64_uwsgi-logger-systemd = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-logger-systemd-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-logger-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-logger-systemd}"
SRC_URI[aarch64_uwsgi-logger-systemd.sha256sum] = "9d04c7425990253b894d84da56b6b9a6232ad6dbf0f48ccb72f9a2a88b6dfad6"

URI_aarch64_uwsgi-plugin-airbrake = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-airbrake-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-airbrake;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-airbrake}"
SRC_URI[aarch64_uwsgi-plugin-airbrake.sha256sum] = "6b73bab8919ae38bca6ac44a35f9e5a117249fddce1810a9ea96f2cc1922b44b"

URI_aarch64_uwsgi-plugin-cache = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-cache-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-cache}"
SRC_URI[aarch64_uwsgi-plugin-cache.sha256sum] = "7f9f4b1f66075ebd3490678df1167231b27caf9cf1c75cd9db3ab5047c6847ff"

URI_aarch64_uwsgi-plugin-carbon = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-carbon-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-carbon;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-carbon}"
SRC_URI[aarch64_uwsgi-plugin-carbon.sha256sum] = "a53d5d279b8314e5e7c15c4acf21e0283b4f89bbf824c87d61767cbbfc8c3145"

URI_aarch64_uwsgi-plugin-cheaper-busyness = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-cheaper-busyness-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-cheaper-busyness;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-cheaper-busyness}"
SRC_URI[aarch64_uwsgi-plugin-cheaper-busyness.sha256sum] = "9645bee61411e585e2554a568fa964c3ffb1cecde6b852da08ab637550b0027f"

URI_aarch64_uwsgi-plugin-common = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-common-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-common}"
SRC_URI[aarch64_uwsgi-plugin-common.sha256sum] = "b7cc68dfca012e76d464f0f69a309c029f878adfd10c6938653304892a2457ac"

URI_aarch64_uwsgi-plugin-cplusplus = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-cplusplus-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-cplusplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-cplusplus}"
SRC_URI[aarch64_uwsgi-plugin-cplusplus.sha256sum] = "6032e37c599470e0617616bb0b95c4dc24cc5f37d8a2efffb8cea4183109a422"

URI_aarch64_uwsgi-plugin-curl-cron = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-curl-cron-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-curl-cron;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-curl-cron}"
SRC_URI[aarch64_uwsgi-plugin-curl-cron.sha256sum] = "1d9c8be84cf5f0f9c586c0aef32d5fd68bce8779b94e9a0648ab13e28adbded9"

URI_aarch64_uwsgi-plugin-dumbloop = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-dumbloop-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-dumbloop;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-dumbloop}"
SRC_URI[aarch64_uwsgi-plugin-dumbloop.sha256sum] = "3240e4172e2a6131108ce08b5b5f99417a38810ea43cceaead8799890ea44dd9"

URI_aarch64_uwsgi-plugin-dummy = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-dummy-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-dummy;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-dummy}"
SRC_URI[aarch64_uwsgi-plugin-dummy.sha256sum] = "08f03fc7e4296593a11a89b22ee0bb3a51164efb538806069cd98ae921cd404c"

URI_aarch64_uwsgi-plugin-fiber = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-fiber-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-fiber;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-fiber}"
SRC_URI[aarch64_uwsgi-plugin-fiber.sha256sum] = "12e4226a95c9c301bfe6195ae2889fff2380feca4fd579e22e98958f88da3da4"

URI_aarch64_uwsgi-plugin-ldap = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-ldap-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-ldap}"
SRC_URI[aarch64_uwsgi-plugin-ldap.sha256sum] = "84de21f273a7a480cd4bdb6c74a5a4dfe78c84ea9d7b181a19c81082ebeddf8e"

URI_aarch64_uwsgi-plugin-lua = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-lua-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-lua}"
SRC_URI[aarch64_uwsgi-plugin-lua.sha256sum] = "877612f6393d32eed42d776bf50dad56af17168bb772187f969d2dfda2a955bb"

URI_aarch64_uwsgi-plugin-nagios = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-nagios-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-nagios;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-nagios}"
SRC_URI[aarch64_uwsgi-plugin-nagios.sha256sum] = "6d6bb136db195ac8516bf26262b9b1f98b2848aef8cb559a0957ba617e044138"

URI_aarch64_uwsgi-plugin-notfound = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-notfound-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-notfound;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-notfound}"
SRC_URI[aarch64_uwsgi-plugin-notfound.sha256sum] = "e4b275298c168c6b44e8ae9b9a0802bf8c512ae11ed3473c59ff665e6f5b0b27"

URI_aarch64_uwsgi-plugin-pam = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-pam-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-pam}"
SRC_URI[aarch64_uwsgi-plugin-pam.sha256sum] = "99223d10f4ce5a7d50466fd3824e54ebde9b1f37a8bc5b7f89e1874cd173280b"

URI_aarch64_uwsgi-plugin-php = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-php-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-php;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-php}"
SRC_URI[aarch64_uwsgi-plugin-php.sha256sum] = "c0e1af5179d35fb1811793eb46a4c40f653025c158d83f7bcade552748ed24a4"

URI_aarch64_uwsgi-plugin-psgi = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-psgi-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-psgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-psgi}"
SRC_URI[aarch64_uwsgi-plugin-psgi.sha256sum] = "59fa933ab9cb53de98e6d781626953f4e2af810ae5c9547e5605a730b0edcc20"

URI_aarch64_uwsgi-plugin-pty = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-pty-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-pty;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-pty}"
SRC_URI[aarch64_uwsgi-plugin-pty.sha256sum] = "2f3f90d91d6ad6e0dda560c4ed5640b9b1bcf9837e27b739e5e279a9cfbb2e3d"

URI_aarch64_uwsgi-plugin-python3 = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-python3-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-python3}"
SRC_URI[aarch64_uwsgi-plugin-python3.sha256sum] = "338bc6cbe6b9b2b9e20707e17bb08ae9dab0d3940fb9347828786a63620be941"

URI_aarch64_uwsgi-plugin-python3-gevent = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-python3-gevent-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-python3-gevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-python3-gevent}"
SRC_URI[aarch64_uwsgi-plugin-python3-gevent.sha256sum] = "e9b811fe28a8f90210b1520e93788499ca7cdc90e4ccba4f3c0dcea57bfc15ad"

URI_aarch64_uwsgi-plugin-python3-tornado = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-python3-tornado-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-python3-tornado;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-python3-tornado}"
SRC_URI[aarch64_uwsgi-plugin-python3-tornado.sha256sum] = "7e313bddb3d0b76615fea7e7c86e9eac8fd1a0b342d6905a9eb3e9cd38eb4e7b"

URI_aarch64_uwsgi-plugin-python312 = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-python312-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-python312;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-python312}"
SRC_URI[aarch64_uwsgi-plugin-python312.sha256sum] = "a8a29e4e76aa2840e1d7cfccfd08bbb8ca8d12301ae293408c07bbf53a82093b"

URI_aarch64_uwsgi-plugin-python312-gevent = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-python312-gevent-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-python312-gevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-python312-gevent}"
SRC_URI[aarch64_uwsgi-plugin-python312-gevent.sha256sum] = "ea0c7442a1052bc823a8ce917352f9f4730d539c8a63ac696a16cc333a3fbbfe"

URI_aarch64_uwsgi-plugin-rack = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-rack-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-rack;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-rack}"
SRC_URI[aarch64_uwsgi-plugin-rack.sha256sum] = "904f996dc2491e995e6f795235871e7670f2a62b469faf5df428a6e03ceabe81"

URI_aarch64_uwsgi-plugin-rbthreads = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-rbthreads-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-rbthreads;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-rbthreads}"
SRC_URI[aarch64_uwsgi-plugin-rbthreads.sha256sum] = "4b4afeb9b08de7e63841ddd3b8d1c48dfe8076ed795e008dffb72a9623bd57da"

URI_aarch64_uwsgi-plugin-rpc = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-rpc-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-rpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-rpc}"
SRC_URI[aarch64_uwsgi-plugin-rpc.sha256sum] = "24f2d1aad4bef992e2d4275d1aef7c19ec18e4d60dac590f26ba01bc3fa03e5c"

URI_aarch64_uwsgi-plugin-rrdtool = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-rrdtool-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-rrdtool}"
SRC_URI[aarch64_uwsgi-plugin-rrdtool.sha256sum] = "9337e95a3281333b5f97e225f7f0fccd02e1e125d4d9f0be6418d7bf7ce585bb"

URI_aarch64_uwsgi-plugin-ruby = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-ruby-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-ruby}"
SRC_URI[aarch64_uwsgi-plugin-ruby.sha256sum] = "09bc7772c70bfbb6201ccee85fda20f66be20912e02078ddb9a79d1327435255"

URI_aarch64_uwsgi-plugin-spooler = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-spooler-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-spooler;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-spooler}"
SRC_URI[aarch64_uwsgi-plugin-spooler.sha256sum] = "7495784e10f6f9e67683f0f14d89ed93f71658ebf6ae405bce4e2bd981cb1994"

URI_aarch64_uwsgi-plugin-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-sqlite3-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-sqlite3}"
SRC_URI[aarch64_uwsgi-plugin-sqlite3.sha256sum] = "1143011dcee481efa4a3c60574a8729ce01f8941e2e0f4d54c80174916c14d78"

URI_aarch64_uwsgi-plugin-ssi = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-ssi-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-ssi;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-ssi}"
SRC_URI[aarch64_uwsgi-plugin-ssi.sha256sum] = "655dc71a702ed5063bb97b1c7370d39c925908e44bb37f00c115b2db707ed9cc"

URI_aarch64_uwsgi-plugin-ugreen = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-ugreen-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-ugreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-ugreen}"
SRC_URI[aarch64_uwsgi-plugin-ugreen.sha256sum] = "45451b5e462ea84829b1bcdd8c0583f04a51bd195baa5eeabc54a342bda0f1e2"

URI_aarch64_uwsgi-plugin-webdav = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-webdav-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-webdav;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-webdav}"
SRC_URI[aarch64_uwsgi-plugin-webdav.sha256sum] = "f425154c84b7115a3ea1079613eb2f6d7165208a3d3b6ebc4a9eac4141e7df52"

URI_aarch64_uwsgi-plugin-xattr = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-xattr-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-xattr;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-xattr}"
SRC_URI[aarch64_uwsgi-plugin-xattr.sha256sum] = "e008b3cee10ceb199c287b135d5a72e7fd6d9b9b6f445d9157a59298fea9e66a"

URI_aarch64_uwsgi-plugin-xslt = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-xslt-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-xslt;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-xslt}"
SRC_URI[aarch64_uwsgi-plugin-xslt.sha256sum] = "1e24dcda88f6d38afc98010c0fd10655875e47d19aa574ee5bb33852231202eb"

URI_aarch64_uwsgi-plugin-zergpool = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-plugin-zergpool-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-plugin-zergpool;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-plugin-zergpool}"
SRC_URI[aarch64_uwsgi-plugin-zergpool.sha256sum] = "18af6d64d3f985916db80c4077d6175cd0c4678ffc8da605f810995982c5e8ab"

URI_aarch64_uwsgi-router-basicauth = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-basicauth-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-basicauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-basicauth}"
SRC_URI[aarch64_uwsgi-router-basicauth.sha256sum] = "2ec558644fb93e21d1e9f02079c69b879138f776fed4d4b89308b325da7bd549"

URI_aarch64_uwsgi-router-cache = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-cache-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-cache}"
SRC_URI[aarch64_uwsgi-router-cache.sha256sum] = "22e2b98c0216f5f8a8c490d59599c33fef4c54c9a64828c9bfe571db438bac2c"

URI_aarch64_uwsgi-router-expires = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-expires-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-expires;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-expires}"
SRC_URI[aarch64_uwsgi-router-expires.sha256sum] = "cd2b2931343e9e74cbc335c184f5e91027ab87bb1de089b8853ae5e519521067"

URI_aarch64_uwsgi-router-fast = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-fast-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-fast;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-fast}"
SRC_URI[aarch64_uwsgi-router-fast.sha256sum] = "e4e0e0a7a63321c2be3594b8a39b548be3afa9971de9325eafe0e8296adf8734"

URI_aarch64_uwsgi-router-forkpty = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-forkpty-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-forkpty;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-forkpty}"
SRC_URI[aarch64_uwsgi-router-forkpty.sha256sum] = "997e69833687c4be41edf031ed47a13e9e986a76f33e1a3b0adbed72661a62f3"

URI_aarch64_uwsgi-router-hash = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-hash-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-hash;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-hash}"
SRC_URI[aarch64_uwsgi-router-hash.sha256sum] = "cc6933e4bd936c79e0624c7df2fc2ec99e420158486150965edc5e918404eb54"

URI_aarch64_uwsgi-router-http = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-http-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-http}"
SRC_URI[aarch64_uwsgi-router-http.sha256sum] = "0cd091fa3003a648e51c41fc190ec9af0e8936f6cb0f7c9941d0ddfaf5eb8c1a"

URI_aarch64_uwsgi-router-memcached = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-memcached-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-memcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-memcached}"
SRC_URI[aarch64_uwsgi-router-memcached.sha256sum] = "5e1e628d4ae09a6400dc449ed4cc124bd1f25a99731cfc26fbd41fa92b4129c0"

URI_aarch64_uwsgi-router-metrics = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-metrics-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-metrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-metrics}"
SRC_URI[aarch64_uwsgi-router-metrics.sha256sum] = "9d1b5b08f083ff8bc3f0e53c2ee1bce94a8faa143def449eff0c93df858d0ff0"

URI_aarch64_uwsgi-router-radius = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-radius-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-radius;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-radius}"
SRC_URI[aarch64_uwsgi-router-radius.sha256sum] = "cacf9126bb20b03bf56eafe60502ebad55a506903432fedb9e70599ffde18f14"

URI_aarch64_uwsgi-router-raw = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-raw-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-raw;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-raw}"
SRC_URI[aarch64_uwsgi-router-raw.sha256sum] = "e2970dca335e6d46bc6efb1856facda3673125328396882eba6f93ef94079976"

URI_aarch64_uwsgi-router-redirect = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-redirect-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-redirect;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-redirect}"
SRC_URI[aarch64_uwsgi-router-redirect.sha256sum] = "9d082da9d6b99792f13f0dc520d4618e2eff772a13fcef4b2bf53dda052a99d3"

URI_aarch64_uwsgi-router-redis = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-redis-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-redis}"
SRC_URI[aarch64_uwsgi-router-redis.sha256sum] = "6a05f53a483eb81aafd5b9e05adee53d0e3e9b48a2aa608d8aec79ca697f61b3"

URI_aarch64_uwsgi-router-rewrite = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-rewrite-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-rewrite;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-rewrite}"
SRC_URI[aarch64_uwsgi-router-rewrite.sha256sum] = "18e40b94e8c2c150e18ff02c8f5ea89f87579fc25ec5a06bcb49afb8cbea5c09"

URI_aarch64_uwsgi-router-spnego = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-spnego-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-spnego;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-spnego}"
SRC_URI[aarch64_uwsgi-router-spnego.sha256sum] = "52ab7b6d32f4099b965e6cddb68734032e521d21098af745226db14f22e123d3"

URI_aarch64_uwsgi-router-ssl = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-ssl-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-ssl}"
SRC_URI[aarch64_uwsgi-router-ssl.sha256sum] = "b66d84c4326be03241ea3c29723efac99d7564b299005767a80da836f7348568"

URI_aarch64_uwsgi-router-static = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-static-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-static}"
SRC_URI[aarch64_uwsgi-router-static.sha256sum] = "68b1bc8ef61dc405e7fb318ed1f896b0e857397ffe4a9ca1cd8545f91c3fe6a9"

URI_aarch64_uwsgi-router-tuntap = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-tuntap-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-tuntap;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-tuntap}"
SRC_URI[aarch64_uwsgi-router-tuntap.sha256sum] = "53cd9ded01565a78490dfe50da4a5d307dd85b7b5ef4a3673ab3837e04249737"

URI_aarch64_uwsgi-router-uwsgi = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-uwsgi-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-uwsgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-uwsgi}"
SRC_URI[aarch64_uwsgi-router-uwsgi.sha256sum] = "4a123f6ef4d460fa9799ca038b92e909b78ef4999ca4cb1af39b1a954604163e"

URI_aarch64_uwsgi-router-xmldir = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-router-xmldir-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-router-xmldir;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-router-xmldir}"
SRC_URI[aarch64_uwsgi-router-xmldir.sha256sum] = "7068d17a06cb1c257cf79aabe61c60d69c65fddd3b7af6f600bc656181917f42"

URI_aarch64_uwsgi-stats-pusher-file = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-stats-pusher-file-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-stats-pusher-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-stats-pusher-file}"
SRC_URI[aarch64_uwsgi-stats-pusher-file.sha256sum] = "7f619fa637dd0965bbcb5e32ec379809d8182ec9a4cd47652fdb8001f5297ff8"

URI_aarch64_uwsgi-stats-pusher-socket = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-stats-pusher-socket-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-stats-pusher-socket;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-stats-pusher-socket}"
SRC_URI[aarch64_uwsgi-stats-pusher-socket.sha256sum] = "0436d886b4cbfeabba47d71dc5253b83c6c83d6b36080e29158a5b5637bbf80d"

URI_aarch64_uwsgi-stats-pusher-statsd = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-stats-pusher-statsd-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-stats-pusher-statsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-stats-pusher-statsd}"
SRC_URI[aarch64_uwsgi-stats-pusher-statsd.sha256sum] = "44815e3140395f064ba7f5776baf7af7fdf6e941b226742ae9dbcf52f8dfa5b1"

URI_aarch64_uwsgi-stats-pusher-zabbix = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-stats-pusher-zabbix-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-stats-pusher-zabbix;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-stats-pusher-zabbix}"
SRC_URI[aarch64_uwsgi-stats-pusher-zabbix.sha256sum] = "e5d9022624ba3a764e7142116d9f84b7303863136651edf2014e46c8ba562778"

URI_aarch64_uwsgi-transformation-chunked = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-chunked-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-transformation-chunked;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-chunked}"
SRC_URI[aarch64_uwsgi-transformation-chunked.sha256sum] = "0074de4ef9089acbd542bbca484362a99ff83b53a5e557e05ba5a36489da0b9b"

URI_aarch64_uwsgi-transformation-gzip = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-gzip-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-transformation-gzip;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-gzip}"
SRC_URI[aarch64_uwsgi-transformation-gzip.sha256sum] = "930874a5ed7abd9d4ed42ecd2094a1d301dc24ab2af0a60b3aed7fce62000c28"

URI_aarch64_uwsgi-transformation-offload = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-offload-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-transformation-offload;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-offload}"
SRC_URI[aarch64_uwsgi-transformation-offload.sha256sum] = "f0f8976382f1d03e9e38e702817c60be0bd5c90096aedc62ac5579c74959b5a1"

URI_aarch64_uwsgi-transformation-template = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-template-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-transformation-template;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-template}"
SRC_URI[aarch64_uwsgi-transformation-template.sha256sum] = "5876312f4cdf5aa17069db8f78e916ea3fe29fbf1418aee461c5a7663edf9d04"

URI_aarch64_uwsgi-transformation-tofile = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-tofile-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-transformation-tofile;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-tofile}"
SRC_URI[aarch64_uwsgi-transformation-tofile.sha256sum] = "c223e3a321ed6444d03f2f3293d67c4d9be9507d2a88e0b25348091035550411"

URI_aarch64_uwsgi-transformation-toupper = "${EPEL_MIRROR}/aarch64/Packages/u/uwsgi-transformation-toupper-2.0.28-1.el10_0.aarch64.rpm;name=aarch64_uwsgi-transformation-toupper;unpack=0"
SRC_URI:append = " ${URI_aarch64_uwsgi-transformation-toupper}"
SRC_URI[aarch64_uwsgi-transformation-toupper.sha256sum] = "d4dfe836a5868db9a50e9ecce235b17abb5f283764fa66386e9113df3abeca96"

RDEPENDS:python3-uwsgidecorators = " \
 python3 \
 uwsgi \
 uwsgi-plugin-python3 \
 "
RDEPENDS:python3.12-uwsgidecorators = " \
 python3 \
 uwsgi \
 uwsgi-plugin-python312 \
 "
RDEPENDS:uwsgi = " \
 bash \
 glibc \
 jansson \
 libcap \
 libuuid \
 libxml2 \
 libyaml \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
RDEPENDS:uwsgi-alarm-curl = " \
 glibc \
 uwsgi-plugin-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:uwsgi-devel = " \
 uwsgi \
 "
RDEPENDS:uwsgi-docs = " \
 uwsgi \
 "
RDEPENDS:uwsgi-emperor-amqp = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-emperor-pg = " \
 glibc \
 libpq \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-log-encoder-msgpack = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-crypto = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-file = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-graylog2 = " \
 glibc \
 uwsgi-plugin-common \
 zlib-ng-compat \
 "
RDEPENDS:uwsgi-logger-pipe = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-redis = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-rsyslog = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-socket = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-syslog = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-logger-systemd = " \
 glibc \
 systemd-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-airbrake = " \
 glibc \
 libxml2 \
 uwsgi-plugin-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:uwsgi-plugin-cache = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-carbon = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-cheaper-busyness = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-common = " \
 glibc \
 uwsgi \
 "
RDEPENDS:uwsgi-plugin-cplusplus = " \
 glibc \
 libstdc++ \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-curl-cron = " \
 glibc \
 uwsgi-plugin-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:uwsgi-plugin-dumbloop = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-dummy = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-fiber = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-plugin-rack \
 "
RDEPENDS:uwsgi-plugin-ldap = " \
 glibc \
 openldap \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-lua = " \
 glibc \
 lua-libs \
 uwsgi-plugin-common \
 virtual/lua \
 "
RDEPENDS:uwsgi-plugin-nagios = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-notfound = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-pam = " \
 glibc \
 pam \
 pam-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-php = " \
 glibc \
 php-embedded \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-psgi = " \
 glibc \
 perl-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-pty = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-python3 = " \
 glibc \
 python3 \
 python3-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-python3-gevent = " \
 glibc \
 uwsgi-plugin-python3 \
 "
RDEPENDS:uwsgi-plugin-python3-tornado = " \
 glibc \
 python3-tornado \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-python312 = " \
 glibc \
 python3 \
 python3-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-python312-gevent = " \
 glibc \
 libevent \
 uwsgi-plugin-python312 \
 "
RDEPENDS:uwsgi-plugin-rack = " \
 glibc \
 ruby-libs \
 rubygem-rack \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-rbthreads = " \
 glibc \
 ruby \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-rpc = " \
 glibc \
 rrdtool \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-rrdtool = " \
 glibc \
 rrdtool \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-ruby = " \
 glibc \
 ruby \
 ruby-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-spooler = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-sqlite3 = " \
 glibc \
 sqlite \
 sqlite-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-ssi = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-ugreen = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-webdav = " \
 glibc \
 libxml2 \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-xattr = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-xslt = " \
 glibc \
 libxml2 \
 libxslt \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-plugin-zergpool = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-basicauth = " \
 glibc \
 libxcrypt \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-cache = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-expires = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-fast = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-forkpty = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-hash = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-http = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-memcached = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-metrics = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-radius = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-raw = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-redirect = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-redis = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-rewrite = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-spnego = " \
 glibc \
 krb5-libs \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-ssl = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-static = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-tuntap = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-uwsgi = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-router-xmldir = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-stats-pusher-file = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-stats-pusher-socket = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-stats-pusher-statsd = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-stats-pusher-zabbix = " \
 glibc \
 uwsgi-plugin-common \
 "
RDEPENDS:uwsgi-transformation-chunked = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-router-uwsgi \
 "
RDEPENDS:uwsgi-transformation-gzip = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-router-uwsgi \
 "
RDEPENDS:uwsgi-transformation-offload = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-router-uwsgi \
 "
RDEPENDS:uwsgi-transformation-template = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-router-uwsgi \
 "
RDEPENDS:uwsgi-transformation-tofile = " \
 glibc \
 uwsgi-plugin-common \
 uwsgi-router-uwsgi \
 "
RDEPENDS:uwsgi-transformation-toupper = " \
 glibc \
 uwsgi-plugin-common \
 "
