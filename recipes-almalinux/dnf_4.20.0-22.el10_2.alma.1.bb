# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf"
PV = "4.20.0"
PR = "22.el10_2.alma.1"
PACKAGES = " \
 dnf \
 dnf-automatic \
 dnf-bootc \
 dnf-data \
 python3-dnf \
 yum \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dnf-4.20.0-22.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f5ceed1cdf12ace3a5835382a4d369ebad3ba26c71a7930c4fd6e1ac961b19b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-4.20.0-22.el10_2.alma.1.noarch.rpm;name=x86_64_v2_dnf;unpack=0"
SRC_URI[x86_64_v2_dnf.sha256sum] = "84c937f87390c6275c39a8f0a6b7c4b3f754f5179b80c5e1f053f3eb462eefee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-automatic-4.20.0-22.el10_2.alma.1.noarch.rpm;name=x86_64_v2_dnf-automatic;unpack=0"
SRC_URI[x86_64_v2_dnf-automatic.sha256sum] = "c4e4ea5cf02d6131961ac7e74ec375bea75dd85a33389080bd0083d4906c387f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnf-bootc-4.20.0-22.el10_2.alma.1.noarch.rpm;name=x86_64_v2_dnf-bootc;unpack=0"
SRC_URI[x86_64_v2_dnf-bootc.sha256sum] = "55ff15a2c3dbe4fda268c3a5f457ea48cd3d131bea408f5f50cca7ebc7cd407d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-data-4.20.0-22.el10_2.alma.1.noarch.rpm;name=x86_64_v2_dnf-data;unpack=0"
SRC_URI[x86_64_v2_dnf-data.sha256sum] = "6e515727a48b274cb187fd7617ff8516978a8466da8e423275ce3a4c572d103d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-4.20.0-22.el10_2.alma.1.noarch.rpm;name=x86_64_v2_python3-dnf;unpack=0"
SRC_URI[x86_64_v2_python3-dnf.sha256sum] = "f245833ae65c085b2bb313c0272033750c12acfe319a3f2c55d85b1c37588f4c"
RPROVIDES:python3-dnf:append:x86_64_v2 = " virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/yum-4.20.0-22.el10_2.alma.1.noarch.rpm;name=x86_64_v2_yum;unpack=0"
SRC_URI[x86_64_v2_yum.sha256sum] = "ee532b19c95943983ab7515b85d154e9f17de37c89e162a90f6a1a6ba8c1b2ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-4.20.0-22.el10_2.alma.1.noarch.rpm;name=aarch64_dnf;unpack=0"
SRC_URI[aarch64_dnf.sha256sum] = "84c937f87390c6275c39a8f0a6b7c4b3f754f5179b80c5e1f053f3eb462eefee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-automatic-4.20.0-22.el10_2.alma.1.noarch.rpm;name=aarch64_dnf-automatic;unpack=0"
SRC_URI[aarch64_dnf-automatic.sha256sum] = "c4e4ea5cf02d6131961ac7e74ec375bea75dd85a33389080bd0083d4906c387f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnf-bootc-4.20.0-22.el10_2.alma.1.noarch.rpm;name=aarch64_dnf-bootc;unpack=0"
SRC_URI[aarch64_dnf-bootc.sha256sum] = "55ff15a2c3dbe4fda268c3a5f457ea48cd3d131bea408f5f50cca7ebc7cd407d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-data-4.20.0-22.el10_2.alma.1.noarch.rpm;name=aarch64_dnf-data;unpack=0"
SRC_URI[aarch64_dnf-data.sha256sum] = "6e515727a48b274cb187fd7617ff8516978a8466da8e423275ce3a4c572d103d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-4.20.0-22.el10_2.alma.1.noarch.rpm;name=aarch64_python3-dnf;unpack=0"
SRC_URI[aarch64_python3-dnf.sha256sum] = "f245833ae65c085b2bb313c0272033750c12acfe319a3f2c55d85b1c37588f4c"
RPROVIDES:python3-dnf:append:aarch64 = " virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/yum-4.20.0-22.el10_2.alma.1.noarch.rpm;name=aarch64_yum;unpack=0"
SRC_URI[aarch64_yum.sha256sum] = "ee532b19c95943983ab7515b85d154e9f17de37c89e162a90f6a1a6ba8c1b2ef"

RDEPENDS:dnf = " \
 bash \
 python3-dnf \
 virtual/coreutils \
 "
RDEPENDS:dnf-automatic = " \
 bash \
 python3 \
 python3-dnf \
 systemd \
 "
RDEPENDS:dnf-bootc = " \
 ostree \
 ostree-libs \
 python3-dnf \
 python3-gobject-base \
 util-linux-core \
 "
RDEPENDS:dnf-data = " \
 "
RDEPENDS:python3-dnf = " \
 dnf-data \
 libmodulemd \
 python3 \
 python3-hawkey \
 python3-libcomps \
 python3-libdnf \
 python3-rpm \
 "
RDEPENDS:yum = " \
 dnf \
 "
