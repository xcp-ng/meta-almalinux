# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mm-common"
PV = "1.0.6"
PR = "6.el10"
PACKAGES = " \
 mm-common \
 mm-common-docs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mm-common-1.0.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dc3b21e64dcf0275099f759a895930cd163a686a479677136178d626f2d9e44"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - mm-common: graphviz

URI_x86_64_v2_mm-common = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mm-common-1.0.6-6.el10.noarch.rpm;name=x86_64_v2_mm-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mm-common}"
SRC_URI[x86_64_v2_mm-common.sha256sum] = "18004b1b898ea389a4834c51f51f56f9300cc8d9d6c392ebf9914135ecb699af"

URI_x86_64_v2_mm-common-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mm-common-docs-1.0.6-6.el10.noarch.rpm;name=x86_64_v2_mm-common-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mm-common-docs}"
SRC_URI[x86_64_v2_mm-common-docs.sha256sum] = "7e1e691d179c7cf7c8666c7b598077e3c87409ac9a276d4e6b91a14e31da52b6"

URI_aarch64_mm-common = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mm-common-1.0.6-6.el10.noarch.rpm;name=aarch64_mm-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mm-common}"
SRC_URI[aarch64_mm-common.sha256sum] = "18004b1b898ea389a4834c51f51f56f9300cc8d9d6c392ebf9914135ecb699af"

URI_aarch64_mm-common-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mm-common-docs-1.0.6-6.el10.noarch.rpm;name=aarch64_mm-common-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mm-common-docs}"
SRC_URI[aarch64_mm-common-docs.sha256sum] = "7e1e691d179c7cf7c8666c7b598077e3c87409ac9a276d4e6b91a14e31da52b6"

RDEPENDS:mm-common:x86_64_v2 = " \
 bash \
 doxygen \
 graphviz \
 libxslt \
 pkgconf-pkg-config \
 python3 \
"
RDEPENDS:mm-common:aarch64 = " \
 bash \
 doxygen \
 libxslt \
 pkgconf-pkg-config \
 python3 \
"
RDEPENDS:mm-common-docs = " \
 mm-common \
 "
