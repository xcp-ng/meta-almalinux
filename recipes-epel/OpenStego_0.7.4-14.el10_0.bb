# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "OpenStego"
PV = "0.7.4"
PR = "14.el10_0"
PACKAGES = " \
 OpenStego \
 OpenStego-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/OpenStego-0.7.4-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd3b6bf3dd0621a7722a1f45dc38d04ae98e330537ff801e91d5f700e5f8bc43"

URI_x86_64_v2_OpenStego = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/OpenStego-0.7.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_OpenStego;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_OpenStego}"
SRC_URI[x86_64_v2_OpenStego.sha256sum] = "287a338c9b71cbc15688cfe2fea0e0be8be3bd111e84f3aafe9789a5bc49de07"

URI_x86_64_v2_OpenStego-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/OpenStego-javadoc-0.7.4-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_OpenStego-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_OpenStego-javadoc}"
SRC_URI[x86_64_v2_OpenStego-javadoc.sha256sum] = "8047df3cf2359d91ab98c958fa4ca84a8a77ed88c14f9ad0dd40e34a828fb5ea"

URI_aarch64_OpenStego = "${EPEL_MIRROR}/aarch64/Packages/o/OpenStego-0.7.4-14.el10_0.noarch.rpm;name=aarch64_OpenStego;unpack=0"
SRC_URI:append = " ${URI_aarch64_OpenStego}"
SRC_URI[aarch64_OpenStego.sha256sum] = "beacbd03ec8a7996d299559a1d574eaa5a2e01458b5030c4ea2dd68692094562"

URI_aarch64_OpenStego-javadoc = "${EPEL_MIRROR}/aarch64/Packages/o/OpenStego-javadoc-0.7.4-14.el10_0.noarch.rpm;name=aarch64_OpenStego-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_OpenStego-javadoc}"
SRC_URI[aarch64_OpenStego-javadoc.sha256sum] = "94127419fc8a9213743a47f1208f1735738e6e161f7141d01f316b1ce78b5a1b"

RDEPENDS:OpenStego = " \
 bash \
 java-21-openjdk-headless \
 javapackages-tools \
 "
RDEPENDS:OpenStego-javadoc = " \
 javapackages-tools \
 "
