# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontact"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kontact \
 kontact-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontact-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "372eb2565e85c4867d8e543d9baaa43d526b6242c55a81a5a893acb4684a768e"

URI_x86_64_v2_kontact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontact-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontact}"
SRC_URI[x86_64_v2_kontact.sha256sum] = "7e5cd4550a1f11998531910b7327c163074ca4d69748e2a176ba856ac67d647d"

URI_x86_64_v2_kontact-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontact-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontact-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontact-libs}"
SRC_URI[x86_64_v2_kontact-libs.sha256sum] = "bf2c9dd1da32ec6bac1ab827a80edbc1ca62ca59358596cd3f1e618e6e4f6755"

URI_aarch64_kontact = "${EPEL_MIRROR}/aarch64/Packages/k/kontact-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kontact;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontact}"
SRC_URI[aarch64_kontact.sha256sum] = "6757f10af898f3c59d6c82d81380e772314dc672e0f2f8801efc36cfdfff7f65"

URI_aarch64_kontact-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kontact-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kontact-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontact-libs}"
SRC_URI[aarch64_kontact-libs.sha256sum] = "b88f1e55dd2615e3b3d3c2e4378d7c7c4d4c4e9483d98bc2818dc8a4f361c941"

RDEPENDS:kontact = " \
 glibc \
 kaddressbook \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kxmlgui \
 kmail \
 kontact-libs \
 kontactinterface \
 korganizer \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kontact-libs = " \
 glibc \
 grantleetheme \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontact \
 kontactinterface \
 ktextaddons-qt6 \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
