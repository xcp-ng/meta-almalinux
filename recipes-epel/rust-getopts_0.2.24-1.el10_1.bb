# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getopts"
PV = "0.2.24"
PR = "1.el10_1"
PACKAGES = " \
 rust-getopts+default-devel \
 rust-getopts+unicode-devel \
 rust-getopts-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getopts-0.2.24-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91bf70bd9736a1b0d4255279b661afcf8facb6917dcb0cd75f84fd52830ba804"

URI_x86_64_v2_rust-getopts+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getopts+default-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getopts+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getopts+default-devel}"
SRC_URI[x86_64_v2_rust-getopts+default-devel.sha256sum] = "b9ea372979dcbcc7623b3b30979b0ec52042c979b466ad0f889124ad0bce5394"

URI_x86_64_v2_rust-getopts+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getopts+unicode-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getopts+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getopts+unicode-devel}"
SRC_URI[x86_64_v2_rust-getopts+unicode-devel.sha256sum] = "04520ce5d43bdcac4d42caeedf0dec2bab012ea102b0c235b42f1ac37ca007d5"

URI_x86_64_v2_rust-getopts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getopts-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getopts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getopts-devel}"
SRC_URI[x86_64_v2_rust-getopts-devel.sha256sum] = "c68b76c44c29628fe216caad0555a012c5c8ee8b807a96e962b3386a690e6d7a"

URI_aarch64_rust-getopts+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getopts+default-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-getopts+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getopts+default-devel}"
SRC_URI[aarch64_rust-getopts+default-devel.sha256sum] = "92383c3fe010bbfd9f8e11d675d5eb29951b07b40509cfcbd4af1ffd7a246ac7"

URI_aarch64_rust-getopts+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getopts+unicode-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-getopts+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getopts+unicode-devel}"
SRC_URI[aarch64_rust-getopts+unicode-devel.sha256sum] = "4795ed81a2ebcaa64a684f94b93a076b0fbcf90381f326418cc0106921d5f880"

URI_aarch64_rust-getopts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getopts-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-getopts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getopts-devel}"
SRC_URI[aarch64_rust-getopts-devel.sha256sum] = "ddf65fbdbe897f83f78f10ea75161326a1d7c067464321d08f32121ddf2d53ed"

RDEPENDS:rust-getopts+default-devel = " \
 cargo \
 rust-getopts+unicode-devel \
 rust-getopts-devel \
 "
RDEPENDS:rust-getopts+unicode-devel = " \
 cargo \
 rust-getopts-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-getopts-devel = " \
 cargo \
 rust \
 "
