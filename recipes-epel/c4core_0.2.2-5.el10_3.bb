# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c4core"
PV = "0.2.2"
PR = "5.el10_3"
PACKAGES = " \
 c4core \
 c4core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c4core-0.2.2-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3a8972b82a97eada529c157aa17c5ebef6bb9803f0f71b35ec330f090c6aed8"

URI_x86_64_v2_c4core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4core-0.2.2-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4core}"
SRC_URI[x86_64_v2_c4core.sha256sum] = "e16055b930e65a00341b6bb287c3b8faacbafa5ae682fbd0ad76c9bfd4f4e411"

URI_x86_64_v2_c4core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4core-devel-0.2.2-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4core-devel}"
SRC_URI[x86_64_v2_c4core-devel.sha256sum] = "2a1dfa0ac4786a8f4a3a5dbcc809f07d1d76717e982558243d9a03b30476a037"

URI_aarch64_c4core = "${EPEL_MIRROR}/aarch64/Packages/c/c4core-0.2.2-5.el10_3.aarch64.rpm;name=aarch64_c4core;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4core}"
SRC_URI[aarch64_c4core.sha256sum] = "c317797f29569a3f44ccb782d0f09fa8a52a17fc18af14071bbb7c800d4404cc"

URI_aarch64_c4core-devel = "${EPEL_MIRROR}/aarch64/Packages/c/c4core-devel-0.2.2-5.el10_3.aarch64.rpm;name=aarch64_c4core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4core-devel}"
SRC_URI[aarch64_c4core-devel.sha256sum] = "62af08039aa99dcc30b305b0c3217443757f56b41364fa490db708209c512a82"

RDEPENDS:c4core = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:c4core-devel = " \
 c4core \
 cmake-filesystem \
 debugbreak-devel \
 fast_float-devel \
 "
