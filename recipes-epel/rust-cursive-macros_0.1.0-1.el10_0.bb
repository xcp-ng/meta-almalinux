# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive-macros"
PV = "0.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-cursive-macros+builder-devel \
 rust-cursive-macros+default-devel \
 rust-cursive-macros+find-crate-devel \
 rust-cursive-macros+quote-devel \
 rust-cursive-macros+syn-devel \
 rust-cursive-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive-macros-0.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "927bed876e6c3dadf8f17d45eff5932b3d8166a97b99ee06a241e987b89d06d7"

URI_x86_64_v2_rust-cursive-macros+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros+builder-devel-0.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros+builder-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros+builder-devel.sha256sum] = "c2b4bd443858aba977f6ef1b6076a96dec51d6e856c248244d064a8cf08277ec"

URI_x86_64_v2_rust-cursive-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros+default-devel-0.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros+default-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros+default-devel.sha256sum] = "518cd850e0fd338cd8750cb9774913a41dfafe1e0849dc97e5a316268edaa1ac"

URI_x86_64_v2_rust-cursive-macros+find-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros+find-crate-devel-0.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros+find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros+find-crate-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros+find-crate-devel.sha256sum] = "8f4e4b5c8343f55f5bc5fd1f91c8cc0e18daa3ad1e84680ef978d80cf0c1c9b1"

URI_x86_64_v2_rust-cursive-macros+quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros+quote-devel-0.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros+quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros+quote-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros+quote-devel.sha256sum] = "4c48990a8e68f9218731d0c998762d041e4382aa3599827ecf2c63aae6e4ea95"

URI_x86_64_v2_rust-cursive-macros+syn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros+syn-devel-0.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros+syn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros+syn-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros+syn-devel.sha256sum] = "6721f22fd9fc273e8d4b8c9e278e25e88c815b277c5861d8b8f93b9fa91f6886"

URI_x86_64_v2_rust-cursive-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros-devel-0.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros-devel.sha256sum] = "9d9a6e2a9f2b39592e6de26f57dd61b695a1025889be043743ed8c2ecfee51eb"

URI_aarch64_rust-cursive-macros+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros+builder-devel-0.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursive-macros+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros+builder-devel}"
SRC_URI[aarch64_rust-cursive-macros+builder-devel.sha256sum] = "39496e40a0cbdd9f3933445f3e121f6e02157cd112eb7519f4183fa1a4bed093"

URI_aarch64_rust-cursive-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros+default-devel-0.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursive-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros+default-devel}"
SRC_URI[aarch64_rust-cursive-macros+default-devel.sha256sum] = "578472690014ff0d37050c4bd7249c744eea96bc18075e5461da244bdd6afe2b"

URI_aarch64_rust-cursive-macros+find-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros+find-crate-devel-0.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursive-macros+find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros+find-crate-devel}"
SRC_URI[aarch64_rust-cursive-macros+find-crate-devel.sha256sum] = "58b848542350780ef0fac97b4d06b3a13bb3d484ef2016fd978962bddc229413"

URI_aarch64_rust-cursive-macros+quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros+quote-devel-0.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursive-macros+quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros+quote-devel}"
SRC_URI[aarch64_rust-cursive-macros+quote-devel.sha256sum] = "9e031b96a1b1e5c0fdb2d91883982afbe28fc0b6e017e7bc02effdc2d3624624"

URI_aarch64_rust-cursive-macros+syn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros+syn-devel-0.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursive-macros+syn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros+syn-devel}"
SRC_URI[aarch64_rust-cursive-macros+syn-devel.sha256sum] = "cc5b0effe9a74ba602865bb35776ddc161cb68e7465bf31939d4a7ecf69f699b"

URI_aarch64_rust-cursive-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros-devel-0.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-cursive-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros-devel}"
SRC_URI[aarch64_rust-cursive-macros-devel.sha256sum] = "eab2796659a20f4e02eb7270f63fe5ae27b329f49082f6a27b67e5bed05b412d"

RDEPENDS:rust-cursive-macros+builder-devel = " \
 cargo \
 rust-cursive-macros+find-crate-devel \
 rust-cursive-macros+quote-devel \
 rust-cursive-macros+syn-devel \
 rust-cursive-macros-devel \
 "
RDEPENDS:rust-cursive-macros+default-devel = " \
 cargo \
 rust-cursive-macros-devel \
 "
RDEPENDS:rust-cursive-macros+find-crate-devel = " \
 cargo \
 rust-cursive-macros-devel \
 rust-find-crate+default-devel \
 "
RDEPENDS:rust-cursive-macros+quote-devel = " \
 cargo \
 rust-cursive-macros-devel \
 rust-quote+default-devel \
 "
RDEPENDS:rust-cursive-macros+syn-devel = " \
 cargo \
 rust-cursive-macros-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
RDEPENDS:rust-cursive-macros-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 "
