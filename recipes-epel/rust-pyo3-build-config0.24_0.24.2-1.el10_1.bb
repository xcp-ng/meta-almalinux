# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config0.24"
PV = "0.24.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-build-config0.24+abi3-devel \
 rust-pyo3-build-config0.24+abi3-py310-devel \
 rust-pyo3-build-config0.24+abi3-py311-devel \
 rust-pyo3-build-config0.24+abi3-py312-devel \
 rust-pyo3-build-config0.24+abi3-py313-devel \
 rust-pyo3-build-config0.24+abi3-py37-devel \
 rust-pyo3-build-config0.24+abi3-py38-devel \
 rust-pyo3-build-config0.24+abi3-py39-devel \
 rust-pyo3-build-config0.24+default-devel \
 rust-pyo3-build-config0.24+extension-module-devel \
 rust-pyo3-build-config0.24+resolve-config-devel \
 rust-pyo3-build-config0.24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config0.24-0.24.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8730ed2ceee89b404b10fbf73f2769ab9e78f68e49a87facca445dcbd9cbb72e"

URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+abi3-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+abi3-devel.sha256sum] = "164a50f402a3dd31dcb5aa9ac47686a0eb934bee6ea82306835d8d8eef152cd7"

URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+abi3-py310-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+abi3-py310-devel.sha256sum] = "7fa9355f1abbeb5632d06d24aba6ba73f7f97567e322876d4efb0f6dbad537fc"

URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+abi3-py311-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+abi3-py311-devel.sha256sum] = "a1a3398ed9ac4d0c897c4b4946c0ffdaa3162dd4e91468fe26828c7b4fa5376a"

URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+abi3-py312-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+abi3-py312-devel.sha256sum] = "100fa57362e41177aba7ccad863354fa8ebcfa454e732922214084fc62467aba"

URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+abi3-py313-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+abi3-py313-devel.sha256sum] = "39263c82e3b6e6ec15ef4d2391536ce6d120cbd764955ae766de0fe3d22a3ab9"

URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+abi3-py37-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+abi3-py37-devel.sha256sum] = "37029bee1691a4dc336ab17545a6b8051b3894e1c81b0bc82ae288613d2689be"

URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+abi3-py38-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+abi3-py38-devel.sha256sum] = "9aba361a981e348fa9162105b60d7abd030c4f69a6f973d155ede85fcd87114f"

URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+abi3-py39-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+abi3-py39-devel.sha256sum] = "48c5a6eb0741f7e69846d61ecd627414af9c01902d86849aa59248e94639014d"

URI_x86_64_v2_rust-pyo3-build-config0.24+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+default-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+default-devel.sha256sum] = "e265255c7ff6fb6c3ae8dcafdf5cab08dfc132359e77053037e751c464c30fd7"

URI_x86_64_v2_rust-pyo3-build-config0.24+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+extension-module-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+extension-module-devel.sha256sum] = "026a1ee7f538449bdf8a86b3658ce526fb0daf6958e555a4d7cf30e4e304bb71"

URI_x86_64_v2_rust-pyo3-build-config0.24+resolve-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24+resolve-config-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24+resolve-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24+resolve-config-devel.sha256sum] = "59badfc39330d853468f801166651a3efa81729a8eddb79c5e40f8486d1d5ab1"

URI_x86_64_v2_rust-pyo3-build-config0.24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.24-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.24-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.24-devel.sha256sum] = "735a5cb4271615e057de9af4e7bf499c7840c14787c5befacebceaa98657511c"

URI_aarch64_rust-pyo3-build-config0.24+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+abi3-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+abi3-devel.sha256sum] = "c15e6a38d87a8b7e5457feaf2d87f69dea0d73a0c2b636adbd469276ec53355f"

URI_aarch64_rust-pyo3-build-config0.24+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+abi3-py310-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+abi3-py310-devel.sha256sum] = "591481a0d64ed5f3f45d8a0c109097392fff89002b40d332d5d1e2062d2bc388"

URI_aarch64_rust-pyo3-build-config0.24+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+abi3-py311-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+abi3-py311-devel.sha256sum] = "7217f0aa6b1f8e21bca9081e8200b76b94b1820c36e9feb785cbacc8ac154ffb"

URI_aarch64_rust-pyo3-build-config0.24+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+abi3-py312-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+abi3-py312-devel.sha256sum] = "57bf1c644f6be2f797f9ef39a510b126da7231c1f59e1e800c5b4a329385ee03"

URI_aarch64_rust-pyo3-build-config0.24+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+abi3-py313-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+abi3-py313-devel.sha256sum] = "6b297db7f102e73ba543728558d8808e606002482b536e96047a7cf4f7284b40"

URI_aarch64_rust-pyo3-build-config0.24+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+abi3-py37-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+abi3-py37-devel.sha256sum] = "fd472a72b851b4678b30473132125001749947758989ae2c235b724d05e0e558"

URI_aarch64_rust-pyo3-build-config0.24+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+abi3-py38-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+abi3-py38-devel.sha256sum] = "d3f2cc434f38272c7de63b776d44f3151e157e831bf9959a0652541a376749a8"

URI_aarch64_rust-pyo3-build-config0.24+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+abi3-py39-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+abi3-py39-devel.sha256sum] = "f0e121c1cc33a1ff632d28de8e141ffb4e249162834abdc979b6ec16d9b798d1"

URI_aarch64_rust-pyo3-build-config0.24+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+default-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+default-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+default-devel.sha256sum] = "dc13622f70d7fa0d3efadf57f7b973789840cd1df7118f63ad357183589087c2"

URI_aarch64_rust-pyo3-build-config0.24+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+extension-module-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+extension-module-devel.sha256sum] = "9c61595a3a01375074ecfbdba93c2abb115fe292579520e1ec7c7198444ff0af"

URI_aarch64_rust-pyo3-build-config0.24+resolve-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24+resolve-config-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24+resolve-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24+resolve-config-devel.sha256sum] = "aaf95bba61c510473cf2d15d1fbe9ec2cb77e57df21bb5e523b8b8b173b12edf"

URI_aarch64_rust-pyo3-build-config0.24-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.24-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config0.24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.24-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.24-devel.sha256sum] = "cbd5f37717d8cd6e05cf6ed37a721a789bc49e4007dedc9799530974767798bf"

RDEPENDS:rust-pyo3-build-config0.24+abi3-devel = " \
 cargo \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24+abi3-py310-devel = " \
 cargo \
 rust-pyo3-build-config0.24+abi3-py311-devel \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24+abi3-py311-devel = " \
 cargo \
 rust-pyo3-build-config0.24+abi3-py312-devel \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24+abi3-py312-devel = " \
 cargo \
 rust-pyo3-build-config0.24+abi3-py313-devel \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24+abi3-py313-devel = " \
 cargo \
 rust-pyo3-build-config0.24+abi3-devel \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24+abi3-py37-devel = " \
 cargo \
 rust-pyo3-build-config0.24+abi3-py38-devel \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24+abi3-py38-devel = " \
 cargo \
 rust-pyo3-build-config0.24+abi3-py39-devel \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24+abi3-py39-devel = " \
 cargo \
 rust-pyo3-build-config0.24+abi3-py310-devel \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24+default-devel = " \
 cargo \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config0.24-devel \
 "
RDEPENDS:rust-pyo3-build-config0.24-devel = " \
 cargo \
 python3 \
 rust \
 rust-once_cell+default-devel \
 rust-target-lexicon+default-devel \
 "
