# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "airrac"
PV = "1.00.12"
PR = "1.el10_2"
PACKAGES = " \
 airrac \
 airrac-devel \
 airrac-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/airrac-1.00.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75a9e794e43370bf41f90458900bb54e191eab2683eb9e77e98a96e968811bbb"

URI_x86_64_v2_airrac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/airrac-1.00.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_airrac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_airrac}"
SRC_URI[x86_64_v2_airrac.sha256sum] = "9d832e1acd9721f001146dc27a523f7724185f701ebabaaec32923c026f9f882"

URI_x86_64_v2_airrac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/airrac-devel-1.00.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_airrac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_airrac-devel}"
SRC_URI[x86_64_v2_airrac-devel.sha256sum] = "f8f1de7729cc656e612b7eb51f8edca226960217dc318ca92db29670d8b55e6c"

URI_x86_64_v2_airrac-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/airrac-doc-1.00.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_airrac-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_airrac-doc}"
SRC_URI[x86_64_v2_airrac-doc.sha256sum] = "d6cd5eff3e13ec87b1c6a840d13f1f8242a11018f64c52f0e72d785780d9c3b2"

URI_aarch64_airrac = "${EPEL_MIRROR}/aarch64/Packages/a/airrac-1.00.12-1.el10_2.aarch64.rpm;name=aarch64_airrac;unpack=0"
SRC_URI:append = " ${URI_aarch64_airrac}"
SRC_URI[aarch64_airrac.sha256sum] = "e25c775f8622df7564e8a784b50061581edbe7ad522ae16124ef4d0a9d26a3e5"

URI_aarch64_airrac-devel = "${EPEL_MIRROR}/aarch64/Packages/a/airrac-devel-1.00.12-1.el10_2.aarch64.rpm;name=aarch64_airrac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_airrac-devel}"
SRC_URI[aarch64_airrac-devel.sha256sum] = "87dca512de8b788b517d1485f5d35825be4ba47128376bf8ca6c4c8b82ff5366"

URI_aarch64_airrac-doc = "${EPEL_MIRROR}/aarch64/Packages/a/airrac-doc-1.00.12-1.el10_2.noarch.rpm;name=aarch64_airrac-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_airrac-doc}"
SRC_URI[aarch64_airrac-doc.sha256sum] = "8a133745008d6c5fe6de82e71919d204a994b73b2b42b567939438e1b8275cb8"

RDEPENDS:airrac = " \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 stdair \
 "
RDEPENDS:airrac-devel = " \
 airrac \
 bash \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:airrac-doc = " \
 "
