# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-myst-parser"
PV = "4.0.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-myst-parser \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-myst-parser-4.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a03a5a479ac97bffcaf3a99ce5a86e6b51e9c5ff869a74e8b057f9054a199fc"

URI_x86_64_v2_python3-myst-parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-myst-parser-4.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-myst-parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-myst-parser}"
SRC_URI[x86_64_v2_python3-myst-parser.sha256sum] = "5659e41d7c75dc0d499dbd85baa405586deda345f2df425ddf3964b7f1a940b3"

URI_aarch64_python3-myst-parser = "${EPEL_MIRROR}/aarch64/Packages/p/python3-myst-parser-4.0.0-2.el10_0.noarch.rpm;name=aarch64_python3-myst-parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-myst-parser}"
SRC_URI[aarch64_python3-myst-parser.sha256sum] = "a08da566dd410174198cd89979246192460c87ada886a9b5b16df42b208d70e3"

RDEPENDS:python3-myst-parser = " \
 python3 \
 python3-docutils \
 python3-jinja2 \
 python3-markdown-it-py \
 python3-mdit-py-plugins \
 python3-pyyaml \
 python3-sphinx \
 "
