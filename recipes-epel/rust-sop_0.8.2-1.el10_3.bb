# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sop"
PV = "0.8.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-sop+anyhow-devel \
 rust-sop+chrono-devel \
 rust-sop+clap-devel \
 rust-sop+clap_complete-devel \
 rust-sop+clap_mangen-devel \
 rust-sop+cli-devel \
 rust-sop+cliv-devel \
 rust-sop+default-devel \
 rust-sop+libc-devel \
 rust-sop-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sop-0.8.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4e609ce6f04939e77fd5abeeac60caf69f5a20f8920aacca9546bd7a36901e2"

URI_x86_64_v2_rust-sop+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sop+anyhow-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sop+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sop+anyhow-devel}"
SRC_URI[x86_64_v2_rust-sop+anyhow-devel.sha256sum] = "743db2c305765bf93c937321f5d87d0a33e9eec15b4d8502b2a1ba2a71c74bdc"

URI_x86_64_v2_rust-sop+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sop+chrono-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sop+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sop+chrono-devel}"
SRC_URI[x86_64_v2_rust-sop+chrono-devel.sha256sum] = "6fc9c4f3646749119caa97c47d5ed4b1151c5caff94a4c26f27eb5ea59ecdae3"

URI_x86_64_v2_rust-sop+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sop+clap-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sop+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sop+clap-devel}"
SRC_URI[x86_64_v2_rust-sop+clap-devel.sha256sum] = "289ef59a977a6d93e255c1505cc3108d19a9839f275971965bc1b9ea87ff3ff1"

URI_x86_64_v2_rust-sop+clap_complete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sop+clap_complete-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sop+clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sop+clap_complete-devel}"
SRC_URI[x86_64_v2_rust-sop+clap_complete-devel.sha256sum] = "609ff3ca8d3ce0ded278551140f57769dc6aeac3a167cc891e2226b528910343"

URI_x86_64_v2_rust-sop+clap_mangen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sop+clap_mangen-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sop+clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sop+clap_mangen-devel}"
SRC_URI[x86_64_v2_rust-sop+clap_mangen-devel.sha256sum] = "136135bc57eea39b1ad726908fd432928fd1730f350f1333b0a68ae91fa4e5b7"

URI_x86_64_v2_rust-sop+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sop+cli-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sop+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sop+cli-devel}"
SRC_URI[x86_64_v2_rust-sop+cli-devel.sha256sum] = "8d0918d433c5e8909590e6939bd45ddffc12286c5aece1440a3f946c7e1c52df"

URI_x86_64_v2_rust-sop+cliv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sop+cliv-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sop+cliv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sop+cliv-devel}"
SRC_URI[x86_64_v2_rust-sop+cliv-devel.sha256sum] = "305fc53374cce31feb55294ed6a55a80a93dd35d0775e66e96357ad3251a65d1"

URI_x86_64_v2_rust-sop+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sop+default-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sop+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sop+default-devel}"
SRC_URI[x86_64_v2_rust-sop+default-devel.sha256sum] = "5cabf35a5f83740767435744b520f9fdd938f1fafe61f522509205efa7d09a3c"

URI_x86_64_v2_rust-sop+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sop+libc-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sop+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sop+libc-devel}"
SRC_URI[x86_64_v2_rust-sop+libc-devel.sha256sum] = "f60cc1abcf9872d9d56a78a6cffebd4b8c5a802eb04a851e4d01357a6f26fcac"

URI_x86_64_v2_rust-sop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sop-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sop-devel}"
SRC_URI[x86_64_v2_rust-sop-devel.sha256sum] = "c9b4412b152709563612738f4a43c7360fae2c0f9c7ce1eb712d36c030a7115c"

URI_aarch64_rust-sop+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sop+anyhow-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sop+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sop+anyhow-devel}"
SRC_URI[aarch64_rust-sop+anyhow-devel.sha256sum] = "a8c23f5b231cc91f8f4baa481d68976726b1f85d8bff7e6c69535307bd48cc4a"

URI_aarch64_rust-sop+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sop+chrono-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sop+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sop+chrono-devel}"
SRC_URI[aarch64_rust-sop+chrono-devel.sha256sum] = "e6fef56f20a8b173bb7ac757bb36c3bb00f4fe4aa02ad265220ff3b5c3d958b6"

URI_aarch64_rust-sop+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sop+clap-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sop+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sop+clap-devel}"
SRC_URI[aarch64_rust-sop+clap-devel.sha256sum] = "43b19d0837216bcde52131947f886cebec5d0b4aa8bee841394f350c90c60561"

URI_aarch64_rust-sop+clap_complete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sop+clap_complete-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sop+clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sop+clap_complete-devel}"
SRC_URI[aarch64_rust-sop+clap_complete-devel.sha256sum] = "139159f5bf9ea09b6d8d95885ecd5bebee97ad8af47cd252929782459a915a7a"

URI_aarch64_rust-sop+clap_mangen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sop+clap_mangen-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sop+clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sop+clap_mangen-devel}"
SRC_URI[aarch64_rust-sop+clap_mangen-devel.sha256sum] = "63f8166d6a02c268306cacc551c6c5211352065efde8ea83fb559613015b1197"

URI_aarch64_rust-sop+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sop+cli-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sop+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sop+cli-devel}"
SRC_URI[aarch64_rust-sop+cli-devel.sha256sum] = "caa461620c4142be779a406c0c595018afb14729ee2ecea101c72997b73b67d5"

URI_aarch64_rust-sop+cliv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sop+cliv-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sop+cliv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sop+cliv-devel}"
SRC_URI[aarch64_rust-sop+cliv-devel.sha256sum] = "9e8018000dfab25f1d29ea638d30d9df699ee5a280e74f7b8ce3786eaee1d7eb"

URI_aarch64_rust-sop+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sop+default-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sop+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sop+default-devel}"
SRC_URI[aarch64_rust-sop+default-devel.sha256sum] = "206956effccd7c3cc79e271e0d7c0735b7909bce7330e4560b4c2668cc5346fb"

URI_aarch64_rust-sop+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sop+libc-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sop+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sop+libc-devel}"
SRC_URI[aarch64_rust-sop+libc-devel.sha256sum] = "5c8b42b1f142eb5a0b4d080799b5603fd3481bbd8294ea206e118a021e5f28de"

URI_aarch64_rust-sop-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sop-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sop-devel}"
SRC_URI[aarch64_rust-sop-devel.sha256sum] = "2cedf529bd6b5a1979551388b64303be78b2e8f610eb77777301bb3478e10e13"

RDEPENDS:rust-sop+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-sop-devel \
 "
RDEPENDS:rust-sop+chrono-devel = " \
 cargo \
 rust-chrono+default-devel \
 rust-sop-devel \
 "
RDEPENDS:rust-sop+clap-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+usage-devel \
 rust-clap+wrap_help-devel \
 rust-clap-devel \
 rust-sop-devel \
 "
RDEPENDS:rust-sop+clap_complete-devel = " \
 cargo \
 rust-clap_complete-devel \
 rust-sop-devel \
 "
RDEPENDS:rust-sop+clap_mangen-devel = " \
 cargo \
 rust-clap_mangen+default-devel \
 rust-sop-devel \
 "
RDEPENDS:rust-sop+cli-devel = " \
 cargo \
 rust-sop+anyhow-devel \
 rust-sop+chrono-devel \
 rust-sop+clap-devel \
 rust-sop+clap_complete-devel \
 rust-sop+clap_mangen-devel \
 rust-sop+libc-devel \
 rust-sop-devel \
 "
RDEPENDS:rust-sop+cliv-devel = " \
 cargo \
 rust-sop+anyhow-devel \
 rust-sop+chrono-devel \
 rust-sop+clap-devel \
 rust-sop+clap_complete-devel \
 rust-sop+clap_mangen-devel \
 rust-sop+libc-devel \
 rust-sop-devel \
 "
RDEPENDS:rust-sop+default-devel = " \
 cargo \
 rust-sop-devel \
 "
RDEPENDS:rust-sop+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-sop-devel \
 "
RDEPENDS:rust-sop-devel = " \
 cargo \
 rust-memsec-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror1+default-devel \
 "
