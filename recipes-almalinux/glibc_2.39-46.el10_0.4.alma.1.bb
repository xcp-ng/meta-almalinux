# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glibc"
PV = "2.39"
PR = "46.el10_0.4.alma.1"
PACKAGES = " \
 glibc \
 glibc-all-langpacks \
 glibc-benchtests \
 glibc-common \
 glibc-devel \
 glibc-doc \
 glibc-gconv-extra \
 glibc-langpack-aa \
 glibc-langpack-af \
 glibc-langpack-agr \
 glibc-langpack-ak \
 glibc-langpack-am \
 glibc-langpack-an \
 glibc-langpack-anp \
 glibc-langpack-ar \
 glibc-langpack-as \
 glibc-langpack-ast \
 glibc-langpack-ayc \
 glibc-langpack-az \
 glibc-langpack-be \
 glibc-langpack-bem \
 glibc-langpack-ber \
 glibc-langpack-bg \
 glibc-langpack-bhb \
 glibc-langpack-bho \
 glibc-langpack-bi \
 glibc-langpack-bn \
 glibc-langpack-bo \
 glibc-langpack-br \
 glibc-langpack-brx \
 glibc-langpack-bs \
 glibc-langpack-byn \
 glibc-langpack-ca \
 glibc-langpack-ce \
 glibc-langpack-chr \
 glibc-langpack-ckb \
 glibc-langpack-cmn \
 glibc-langpack-crh \
 glibc-langpack-cs \
 glibc-langpack-csb \
 glibc-langpack-cv \
 glibc-langpack-cy \
 glibc-langpack-da \
 glibc-langpack-de \
 glibc-langpack-doi \
 glibc-langpack-dsb \
 glibc-langpack-dv \
 glibc-langpack-dz \
 glibc-langpack-el \
 glibc-langpack-en \
 glibc-langpack-eo \
 glibc-langpack-es \
 glibc-langpack-et \
 glibc-langpack-eu \
 glibc-langpack-fa \
 glibc-langpack-ff \
 glibc-langpack-fi \
 glibc-langpack-fil \
 glibc-langpack-fo \
 glibc-langpack-fr \
 glibc-langpack-fur \
 glibc-langpack-fy \
 glibc-langpack-ga \
 glibc-langpack-gbm \
 glibc-langpack-gd \
 glibc-langpack-gez \
 glibc-langpack-gl \
 glibc-langpack-gu \
 glibc-langpack-gv \
 glibc-langpack-ha \
 glibc-langpack-hak \
 glibc-langpack-he \
 glibc-langpack-hi \
 glibc-langpack-hif \
 glibc-langpack-hne \
 glibc-langpack-hr \
 glibc-langpack-hsb \
 glibc-langpack-ht \
 glibc-langpack-hu \
 glibc-langpack-hy \
 glibc-langpack-ia \
 glibc-langpack-id \
 glibc-langpack-ig \
 glibc-langpack-ik \
 glibc-langpack-is \
 glibc-langpack-it \
 glibc-langpack-iu \
 glibc-langpack-ja \
 glibc-langpack-ka \
 glibc-langpack-kab \
 glibc-langpack-kk \
 glibc-langpack-kl \
 glibc-langpack-km \
 glibc-langpack-kn \
 glibc-langpack-ko \
 glibc-langpack-kok \
 glibc-langpack-ks \
 glibc-langpack-ku \
 glibc-langpack-kv \
 glibc-langpack-kw \
 glibc-langpack-ky \
 glibc-langpack-lb \
 glibc-langpack-lg \
 glibc-langpack-li \
 glibc-langpack-lij \
 glibc-langpack-ln \
 glibc-langpack-lo \
 glibc-langpack-lt \
 glibc-langpack-lv \
 glibc-langpack-lzh \
 glibc-langpack-mag \
 glibc-langpack-mai \
 glibc-langpack-mfe \
 glibc-langpack-mg \
 glibc-langpack-mhr \
 glibc-langpack-mi \
 glibc-langpack-miq \
 glibc-langpack-mjw \
 glibc-langpack-mk \
 glibc-langpack-ml \
 glibc-langpack-mn \
 glibc-langpack-mni \
 glibc-langpack-mnw \
 glibc-langpack-mr \
 glibc-langpack-ms \
 glibc-langpack-mt \
 glibc-langpack-my \
 glibc-langpack-nan \
 glibc-langpack-nb \
 glibc-langpack-nds \
 glibc-langpack-ne \
 glibc-langpack-nhn \
 glibc-langpack-niu \
 glibc-langpack-nl \
 glibc-langpack-nn \
 glibc-langpack-nr \
 glibc-langpack-nso \
 glibc-langpack-oc \
 glibc-langpack-om \
 glibc-langpack-or \
 glibc-langpack-os \
 glibc-langpack-pa \
 glibc-langpack-pap \
 glibc-langpack-pl \
 glibc-langpack-ps \
 glibc-langpack-pt \
 glibc-langpack-quz \
 glibc-langpack-raj \
 glibc-langpack-rif \
 glibc-langpack-ro \
 glibc-langpack-ru \
 glibc-langpack-rw \
 glibc-langpack-sa \
 glibc-langpack-sah \
 glibc-langpack-sat \
 glibc-langpack-sc \
 glibc-langpack-sd \
 glibc-langpack-se \
 glibc-langpack-sgs \
 glibc-langpack-shn \
 glibc-langpack-shs \
 glibc-langpack-si \
 glibc-langpack-sid \
 glibc-langpack-sk \
 glibc-langpack-sl \
 glibc-langpack-sm \
 glibc-langpack-so \
 glibc-langpack-sq \
 glibc-langpack-sr \
 glibc-langpack-ss \
 glibc-langpack-ssy \
 glibc-langpack-st \
 glibc-langpack-su \
 glibc-langpack-sv \
 glibc-langpack-sw \
 glibc-langpack-syr \
 glibc-langpack-szl \
 glibc-langpack-ta \
 glibc-langpack-tcy \
 glibc-langpack-te \
 glibc-langpack-tg \
 glibc-langpack-th \
 glibc-langpack-the \
 glibc-langpack-ti \
 glibc-langpack-tig \
 glibc-langpack-tk \
 glibc-langpack-tl \
 glibc-langpack-tn \
 glibc-langpack-to \
 glibc-langpack-tok \
 glibc-langpack-tpi \
 glibc-langpack-tr \
 glibc-langpack-ts \
 glibc-langpack-tt \
 glibc-langpack-ug \
 glibc-langpack-uk \
 glibc-langpack-unm \
 glibc-langpack-ur \
 glibc-langpack-uz \
 glibc-langpack-ve \
 glibc-langpack-vi \
 glibc-langpack-wa \
 glibc-langpack-wae \
 glibc-langpack-wal \
 glibc-langpack-wo \
 glibc-langpack-xh \
 glibc-langpack-yi \
 glibc-langpack-yo \
 glibc-langpack-yue \
 glibc-langpack-yuw \
 glibc-langpack-zgh \
 glibc-langpack-zh \
 glibc-langpack-zu \
 glibc-locale-source \
 glibc-minimal-langpack \
 glibc-nss-devel \
 glibc-static \
 glibc-utils \
 libnsl \
 nss_db \
 nss_hesiod \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glibc-2.39-46.el10_0.4.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54c199d7db6a48bf11adc17baf6346e2f2ca9a90f1bc168d4a3a2266e8f1c1a8"

URI_x86_64_v2_glibc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc}"
SRC_URI[x86_64_v2_glibc.sha256sum] = "2fb9267bf5864c9da0e3e7c5d0b361fe3534e0bc90fb172ca85090966cac96f6"

URI_x86_64_v2_glibc-all-langpacks = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-all-langpacks-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-all-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-all-langpacks}"
SRC_URI[x86_64_v2_glibc-all-langpacks.sha256sum] = "7e3da6bf4b7361a0274867b30e34cddd114b5c30b42f2657f95715f7f6b3f794"
RPROVIDES:glibc-all-langpacks:x86_64_v2 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-benchtests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-benchtests-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-benchtests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-benchtests}"
SRC_URI[x86_64_v2_glibc-benchtests.sha256sum] = "61aec7c297435b2a5234295089c3e7bd2853c0879c8b7a5dbdd720208a49c727"

URI_x86_64_v2_glibc-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-common-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-common}"
SRC_URI[x86_64_v2_glibc-common.sha256sum] = "938b9f59bedc4bc4f18f7755ad8187991682706f83516656d0dabd2b0168fbc0"

URI_x86_64_v2_glibc-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-devel-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-devel}"
SRC_URI[x86_64_v2_glibc-devel.sha256sum] = "c31fe58a113534655bf8e17ed4aba3e9b3c1045e11f05f039e5f7d034ce66a0c"

URI_x86_64_v2_glibc-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-doc-2.39-46.el10_0.4.alma.1.noarch.rpm;name=x86_64_v2_glibc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-doc}"
SRC_URI[x86_64_v2_glibc-doc.sha256sum] = "d425eba84ead05dbb4a8da01c44663ed00c93a16e93fcb9e6c07fb5047b499d1"

URI_x86_64_v2_glibc-gconv-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-gconv-extra-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-gconv-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-gconv-extra}"
SRC_URI[x86_64_v2_glibc-gconv-extra.sha256sum] = "d903c85e015cb0c95ee23a8e2453a8d04077fb15cd7b43be9ac2034ad15ef8e9"

URI_x86_64_v2_glibc-langpack-aa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-aa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-aa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-aa}"
SRC_URI[x86_64_v2_glibc-langpack-aa.sha256sum] = "b90ffe3c4518663ab5a93b195dbbf9c29168647d02d3db4c93ffd288cb09119b"
RPROVIDES:glibc-langpack-aa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-af = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-af-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-af;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-af}"
SRC_URI[x86_64_v2_glibc-langpack-af.sha256sum] = "6c05b973e24c148e7dc1926b04bbca5ba87f14856ba403e876707e52ffc7fee1"
RPROVIDES:glibc-langpack-af:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-agr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-agr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-agr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-agr}"
SRC_URI[x86_64_v2_glibc-langpack-agr.sha256sum] = "169c8071fe28591df3a115ff0873af398451a1ab24867fdab0d83cb9d78202e4"
RPROVIDES:glibc-langpack-agr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ak = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ak-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ak}"
SRC_URI[x86_64_v2_glibc-langpack-ak.sha256sum] = "8e09cda8ecd7205e529e4e629febfb20abde41a49a373aade1f98554c4fe61d1"
RPROVIDES:glibc-langpack-ak:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-am = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-am-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-am;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-am}"
SRC_URI[x86_64_v2_glibc-langpack-am.sha256sum] = "ae11ef8aa2ac9d2c753a49723b90f2a08ee5af112d9cd4c6427aa80c4e1bf9d2"
RPROVIDES:glibc-langpack-am:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-an = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-an-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-an;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-an}"
SRC_URI[x86_64_v2_glibc-langpack-an.sha256sum] = "550a4a09b6a93cbe2a378ac59200d27eb14eea3f7684ad02476d4d159449f77e"
RPROVIDES:glibc-langpack-an:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-anp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-anp-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-anp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-anp}"
SRC_URI[x86_64_v2_glibc-langpack-anp.sha256sum] = "242e3888abd8ec8ca0f2572fa58383e3f8a75891a6f76bb3c1e9795ad560e0a4"
RPROVIDES:glibc-langpack-anp:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ar = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ar-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ar}"
SRC_URI[x86_64_v2_glibc-langpack-ar.sha256sum] = "d7f1aa7d31cc41aee815958738ceb9f514446020335be4f9c3244488cb19c9af"
RPROVIDES:glibc-langpack-ar:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-as = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-as-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-as;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-as}"
SRC_URI[x86_64_v2_glibc-langpack-as.sha256sum] = "7e1dc629cf09ee55750ff474514642b8710e4106f4ab2fc0b63fca8d06ed86a4"
RPROVIDES:glibc-langpack-as:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ast = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ast-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ast}"
SRC_URI[x86_64_v2_glibc-langpack-ast.sha256sum] = "0e7aff31d5a3a5b016b1d6ced3f034b89d8ce7f62c376eecb76a55ce2ea183e2"
RPROVIDES:glibc-langpack-ast:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ayc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ayc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ayc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ayc}"
SRC_URI[x86_64_v2_glibc-langpack-ayc.sha256sum] = "aa967fafded7a6ec6b8c97cb882ed5f4282abd9922f9c106a0dc1187c188593a"
RPROVIDES:glibc-langpack-ayc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-az = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-az-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-az;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-az}"
SRC_URI[x86_64_v2_glibc-langpack-az.sha256sum] = "8048d1b6c87a7609905a7dde8a078a0eb65bea0c9303d2cc0effbff9f2e65ac4"
RPROVIDES:glibc-langpack-az:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-be = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-be-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-be;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-be}"
SRC_URI[x86_64_v2_glibc-langpack-be.sha256sum] = "c9eb054d9efacef928a06d350f77698ef2833477cc57d7737ee64a91c15ff8d1"
RPROVIDES:glibc-langpack-be:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-bem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bem-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bem}"
SRC_URI[x86_64_v2_glibc-langpack-bem.sha256sum] = "cdd74260b1e42d87cd9a24175031b4220e5b29099a88c736dbd631d396083382"
RPROVIDES:glibc-langpack-bem:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ber = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ber-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ber}"
SRC_URI[x86_64_v2_glibc-langpack-ber.sha256sum] = "9fcafe0b06a38a0b12585d69a5c18fa7202e740405a78e8ad3a0d12c651b8d50"
RPROVIDES:glibc-langpack-ber:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-bg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bg}"
SRC_URI[x86_64_v2_glibc-langpack-bg.sha256sum] = "43749160305b5bba0672f2ecd312574e2d5e090fd156e0cfad61025219fcbcf6"
RPROVIDES:glibc-langpack-bg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-bhb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bhb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bhb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bhb}"
SRC_URI[x86_64_v2_glibc-langpack-bhb.sha256sum] = "dc86213cd874abc892cc01d4073f3c5fb645755555c0440f81a427a34f1324db"
RPROVIDES:glibc-langpack-bhb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-bho = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bho-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bho;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bho}"
SRC_URI[x86_64_v2_glibc-langpack-bho.sha256sum] = "a60e2c09313f83e6cfa558b89871b8eb9e9634625a6d8ae81cf1f68eb9882204"
RPROVIDES:glibc-langpack-bho:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-bi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bi}"
SRC_URI[x86_64_v2_glibc-langpack-bi.sha256sum] = "2cb306d2ce27980335ead6142c33d7b90c71473a6c91ecf7a5e546b33b54fdaf"
RPROVIDES:glibc-langpack-bi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-bn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bn}"
SRC_URI[x86_64_v2_glibc-langpack-bn.sha256sum] = "0a97a198403e047d89e7b04850be8439e3c78231da5557e5fd5ba533c58564a6"
RPROVIDES:glibc-langpack-bn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-bo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bo}"
SRC_URI[x86_64_v2_glibc-langpack-bo.sha256sum] = "ffca41f724e643debc05a2f552354bdee322c8c206373a400aeb9f9c6d43ffe0"
RPROVIDES:glibc-langpack-bo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-br = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-br-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-br;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-br}"
SRC_URI[x86_64_v2_glibc-langpack-br.sha256sum] = "8ae4c5fed411d4c0384481d5a5a8e480b4caedf86615abd428bc97b54ebbb243"
RPROVIDES:glibc-langpack-br:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-brx = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-brx-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-brx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-brx}"
SRC_URI[x86_64_v2_glibc-langpack-brx.sha256sum] = "1d130438ac6750bd7cae51f2d7ddf5d1478d312c521e56d1074256c066d71305"
RPROVIDES:glibc-langpack-brx:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-bs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bs}"
SRC_URI[x86_64_v2_glibc-langpack-bs.sha256sum] = "371a64d4395857ca079b0a6b7774f27ef9642d9520e028cc68983a4e8867d406"
RPROVIDES:glibc-langpack-bs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-byn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-byn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-byn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-byn}"
SRC_URI[x86_64_v2_glibc-langpack-byn.sha256sum] = "3bfb4a878221d46d7429dc0da05d6b6a78f6ed45d82673edfda7072fc028d2b0"
RPROVIDES:glibc-langpack-byn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ca = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ca-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ca}"
SRC_URI[x86_64_v2_glibc-langpack-ca.sha256sum] = "b4b010eee1e8cd618e04272b880071c97609a792010123dd01c80cf9d0545c83"
RPROVIDES:glibc-langpack-ca:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ce = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ce-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ce}"
SRC_URI[x86_64_v2_glibc-langpack-ce.sha256sum] = "cd5e7a09566c1a38b35817cdb06657aeb5399567c3e8199bc92a3fd0f943d71a"
RPROVIDES:glibc-langpack-ce:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-chr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-chr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-chr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-chr}"
SRC_URI[x86_64_v2_glibc-langpack-chr.sha256sum] = "0ac4460a97d08bad2ca29fb6d4251ba9f7ed88b07e9f7d472d6586727326b69d"
RPROVIDES:glibc-langpack-chr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ckb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ckb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ckb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ckb}"
SRC_URI[x86_64_v2_glibc-langpack-ckb.sha256sum] = "85922e563bf0a1fd7cf626e22f7a644af8ced568002b14e212b5e13bb5e728a3"
RPROVIDES:glibc-langpack-ckb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-cmn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cmn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cmn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cmn}"
SRC_URI[x86_64_v2_glibc-langpack-cmn.sha256sum] = "88f5d16eb0764df25b2524ec21514fed0764446afaae867e86d16ce48d9174dd"
RPROVIDES:glibc-langpack-cmn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-crh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-crh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-crh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-crh}"
SRC_URI[x86_64_v2_glibc-langpack-crh.sha256sum] = "a0b36057019d8f9bc91dd7dd9e6d8726c7cd97b0e0119799b066ca0f44bbcc0c"
RPROVIDES:glibc-langpack-crh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-cs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cs}"
SRC_URI[x86_64_v2_glibc-langpack-cs.sha256sum] = "a17cf9f283d9901afb5da8c9a21757b59e205341c7192ca31ff5815ae4cc1d7e"
RPROVIDES:glibc-langpack-cs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-csb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-csb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-csb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-csb}"
SRC_URI[x86_64_v2_glibc-langpack-csb.sha256sum] = "685dcb113ecf32ab7fd43aefa4b34e28c1a1cdfa9324a5d34a34d9049aecd0cb"
RPROVIDES:glibc-langpack-csb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-cv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cv}"
SRC_URI[x86_64_v2_glibc-langpack-cv.sha256sum] = "6c8a1c0ae3443d23011f1fad4e1859fb5d75c338cc392b3a30c8d51c956b5a10"
RPROVIDES:glibc-langpack-cv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-cy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cy}"
SRC_URI[x86_64_v2_glibc-langpack-cy.sha256sum] = "e3db96886760e087633abda64a16972c2a23c56fc2d0f7520433bf4b353fd92a"
RPROVIDES:glibc-langpack-cy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-da = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-da-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-da;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-da}"
SRC_URI[x86_64_v2_glibc-langpack-da.sha256sum] = "7fc6e0349797353d9864ed3c19ea16c75c8441c3aba678aeb0a777a4a131fdfb"
RPROVIDES:glibc-langpack-da:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-de = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-de-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-de;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-de}"
SRC_URI[x86_64_v2_glibc-langpack-de.sha256sum] = "a8f8ec4cb9b068d46a82ea6fa03f136429ba88b0f8abbaff8b5c6f62a1cc7096"
RPROVIDES:glibc-langpack-de:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-doi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-doi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-doi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-doi}"
SRC_URI[x86_64_v2_glibc-langpack-doi.sha256sum] = "8896a06fdaa6006c8780b34c37a188896d28b223c1fa0e7e159f5fd2dad64960"
RPROVIDES:glibc-langpack-doi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-dsb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dsb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dsb}"
SRC_URI[x86_64_v2_glibc-langpack-dsb.sha256sum] = "e93ba162cba771a01185e2643f28c77b30e3f99cf96a1aa3c32c7c4f94a1cc0a"
RPROVIDES:glibc-langpack-dsb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-dv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dv}"
SRC_URI[x86_64_v2_glibc-langpack-dv.sha256sum] = "268260ab846639cd250ba5c7982cc93b885fe3dc74b79a26ec38d87d00f4cffe"
RPROVIDES:glibc-langpack-dv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-dz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dz-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dz}"
SRC_URI[x86_64_v2_glibc-langpack-dz.sha256sum] = "03c62bd8ad18f0b8d673dfc753b85f63772c1d9f50e893041413709f7c51da8b"
RPROVIDES:glibc-langpack-dz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-el = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-el-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-el;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-el}"
SRC_URI[x86_64_v2_glibc-langpack-el.sha256sum] = "c79dc9fe8c2ee97611d0f4b3a6db0777f9c1ed57a569808f4cd326ab11911c3a"
RPROVIDES:glibc-langpack-el:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-en = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-en-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-en;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-en}"
SRC_URI[x86_64_v2_glibc-langpack-en.sha256sum] = "f41bf15e11e68133f2cc76ffe62da1d81c1e2fd433198605edc91893aff354d2"
RPROVIDES:glibc-langpack-en:x86_64_v2 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-eo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-eo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-eo}"
SRC_URI[x86_64_v2_glibc-langpack-eo.sha256sum] = "298eace09ffa348fa69daba8d4fc284cab2db909e58bb9c3c9896dfae0d76c94"
RPROVIDES:glibc-langpack-eo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-es = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-es-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-es;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-es}"
SRC_URI[x86_64_v2_glibc-langpack-es.sha256sum] = "4df3358be6d9c3a2bf69f6ece110a88306fc7bffc5c6087f5576c78733ef2c67"
RPROVIDES:glibc-langpack-es:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-et = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-et-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-et;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-et}"
SRC_URI[x86_64_v2_glibc-langpack-et.sha256sum] = "963d0445716d55f2868c6be87a5f597bece947d3061e99aaf221573f3616f539"
RPROVIDES:glibc-langpack-et:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-eu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-eu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-eu}"
SRC_URI[x86_64_v2_glibc-langpack-eu.sha256sum] = "fb72e9c404cfb9de1c97ad7f8c560c587ebe52770a7a261c53741fc06f162d8f"
RPROVIDES:glibc-langpack-eu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-fa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fa}"
SRC_URI[x86_64_v2_glibc-langpack-fa.sha256sum] = "bee3f0b07fa1176030cc28b334663ea7c4a835faf93f436e36c75759429afbf2"
RPROVIDES:glibc-langpack-fa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ff = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ff-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ff}"
SRC_URI[x86_64_v2_glibc-langpack-ff.sha256sum] = "0172df1747e6ac9e1b2da81ce01af390e212ecec77d61390f406b6909ea95e50"
RPROVIDES:glibc-langpack-ff:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-fi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fi}"
SRC_URI[x86_64_v2_glibc-langpack-fi.sha256sum] = "01ce54ce644a12fc77d9f19709d87c0b0ad60f06c644b42f624ff1d503271ade"
RPROVIDES:glibc-langpack-fi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-fil = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fil-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fil}"
SRC_URI[x86_64_v2_glibc-langpack-fil.sha256sum] = "a9b9828183dfb9c89d2344f3c32449bdb1e5eabe3dd28da42c38d52577127c21"
RPROVIDES:glibc-langpack-fil:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-fo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fo}"
SRC_URI[x86_64_v2_glibc-langpack-fo.sha256sum] = "fa228f65cf05e566a3deb3c403b7953aaacf4698fb55089a733ded353457c3e4"
RPROVIDES:glibc-langpack-fo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-fr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fr}"
SRC_URI[x86_64_v2_glibc-langpack-fr.sha256sum] = "029ca5ee6053595a40a85b01a3c16fe0041712d5c1d04372c868dba650b2d4cb"
RPROVIDES:glibc-langpack-fr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-fur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fur-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fur}"
SRC_URI[x86_64_v2_glibc-langpack-fur.sha256sum] = "286056932188db44d04632d13ada4a156f16e88ec1ff30044445f44735c79c6b"
RPROVIDES:glibc-langpack-fur:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-fy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fy}"
SRC_URI[x86_64_v2_glibc-langpack-fy.sha256sum] = "91de192661c436f8af71dbfcca7b339f83d06cc5d54d85202dffe657053ac7c2"
RPROVIDES:glibc-langpack-fy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ga = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ga-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ga;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ga}"
SRC_URI[x86_64_v2_glibc-langpack-ga.sha256sum] = "b4e1923de05d6853b9020c6db0e831108a4007b5420fce4a62622362281ec911"
RPROVIDES:glibc-langpack-ga:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-gbm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gbm-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gbm}"
SRC_URI[x86_64_v2_glibc-langpack-gbm.sha256sum] = "026c1a60ba113548d16db3c0480960b068d8b6f1c7eb6cf857be341984d705fb"
RPROVIDES:glibc-langpack-gbm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-gd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gd-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gd}"
SRC_URI[x86_64_v2_glibc-langpack-gd.sha256sum] = "4ce1e4781cb968f6805fe74c2b567d1f99bb36447d4508dbb3a2acf5f5bdab0c"
RPROVIDES:glibc-langpack-gd:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-gez = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gez-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gez;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gez}"
SRC_URI[x86_64_v2_glibc-langpack-gez.sha256sum] = "5eeeb33a74b52b1e3486a8ea42fc0a6d9777b9f83fe8d0ba63033232138e38cf"
RPROVIDES:glibc-langpack-gez:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-gl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gl}"
SRC_URI[x86_64_v2_glibc-langpack-gl.sha256sum] = "fa4a957d6ab3b543af82b97ce7378f62d9b24c07e99918ef1e7eb23562ddf75a"
RPROVIDES:glibc-langpack-gl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-gu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gu}"
SRC_URI[x86_64_v2_glibc-langpack-gu.sha256sum] = "b4206cb470bcaf00807452b6a2e59e41eb5883563f7ed30a9a4a99b09157d886"
RPROVIDES:glibc-langpack-gu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-gv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gv}"
SRC_URI[x86_64_v2_glibc-langpack-gv.sha256sum] = "c70ba498268f6b3c88325ababeb897d876cb61a701f7d579fc794c65726f1dee"
RPROVIDES:glibc-langpack-gv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ha = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ha-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ha;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ha}"
SRC_URI[x86_64_v2_glibc-langpack-ha.sha256sum] = "ccd41beeffb6b8cb630149d2e41cb604b7067a592f6fd73105251249ebbce5ac"
RPROVIDES:glibc-langpack-ha:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-hak = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hak-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hak}"
SRC_URI[x86_64_v2_glibc-langpack-hak.sha256sum] = "486ecdf2e89a9fd96f946cf35a7a2fbb51319261c3373c4abf174f1f7b8ab34e"
RPROVIDES:glibc-langpack-hak:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-he = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-he-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-he;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-he}"
SRC_URI[x86_64_v2_glibc-langpack-he.sha256sum] = "7a7902c00d0c8f9d4d594aade1c4f32d3a1b8bc427bc6196150e8ac68abc56b2"
RPROVIDES:glibc-langpack-he:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-hi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hi}"
SRC_URI[x86_64_v2_glibc-langpack-hi.sha256sum] = "2adf32e29b9e1add30e3ad58c063316062233b141f2df8f9a6c050c1624a2564"
RPROVIDES:glibc-langpack-hi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-hif = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hif-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hif}"
SRC_URI[x86_64_v2_glibc-langpack-hif.sha256sum] = "a0de4cfd628740d4013a07c6b4239872a6065b2f1ab368db3b4ba4593267a55d"
RPROVIDES:glibc-langpack-hif:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-hne = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hne-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hne;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hne}"
SRC_URI[x86_64_v2_glibc-langpack-hne.sha256sum] = "c908bb75a90ecc57afb981b53650021b9f09fe3bc9842f2690246ae025a53445"
RPROVIDES:glibc-langpack-hne:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-hr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hr}"
SRC_URI[x86_64_v2_glibc-langpack-hr.sha256sum] = "1f5d3121757b92a779c5de418fcd2db72f5144b54ad72b75c4755a580de49c1f"
RPROVIDES:glibc-langpack-hr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-hsb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hsb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hsb}"
SRC_URI[x86_64_v2_glibc-langpack-hsb.sha256sum] = "55e55e20b457d2d54c8e58ead2e76a10cdc70314c0781eef9fbdcfb83da84f60"
RPROVIDES:glibc-langpack-hsb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ht = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ht-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ht;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ht}"
SRC_URI[x86_64_v2_glibc-langpack-ht.sha256sum] = "05855cbb502a63c8ee760892034f360943da7e40785e03f215f9c84a81ff09a8"
RPROVIDES:glibc-langpack-ht:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-hu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hu}"
SRC_URI[x86_64_v2_glibc-langpack-hu.sha256sum] = "9d44db988beab1096d751dffe965494d381cd758ec11dc31d23e05b48aa6ba0d"
RPROVIDES:glibc-langpack-hu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-hy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hy}"
SRC_URI[x86_64_v2_glibc-langpack-hy.sha256sum] = "3655e1090264e99ba4a2efff91037e31f91d3feb65d0e9cb0c18208a943af926"
RPROVIDES:glibc-langpack-hy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ia = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ia-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ia}"
SRC_URI[x86_64_v2_glibc-langpack-ia.sha256sum] = "046213cff2337171958375d6e41ad1954e43e90c59465322110913de64a8b1ea"
RPROVIDES:glibc-langpack-ia:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-id = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-id-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-id;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-id}"
SRC_URI[x86_64_v2_glibc-langpack-id.sha256sum] = "f709658f63f60c151f560a193d7362917a0eff9afc73255748661b6eda42a329"
RPROVIDES:glibc-langpack-id:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ig-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ig}"
SRC_URI[x86_64_v2_glibc-langpack-ig.sha256sum] = "e78f9edc7af725fe2d99412a7a8964ca2703a0bd00baec177160a786fa56da94"
RPROVIDES:glibc-langpack-ig:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ik = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ik-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ik;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ik}"
SRC_URI[x86_64_v2_glibc-langpack-ik.sha256sum] = "ffd7c98f8969ea141256f8a4be4b65c767e67d12b18e69347060efbcb16b2b04"
RPROVIDES:glibc-langpack-ik:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-is = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-is-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-is;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-is}"
SRC_URI[x86_64_v2_glibc-langpack-is.sha256sum] = "aeabc0a806ced30786a1e9bfc4038d2485e3d33591bbcbf7d05c381bc5f4f60a"
RPROVIDES:glibc-langpack-is:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-it = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-it-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-it;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-it}"
SRC_URI[x86_64_v2_glibc-langpack-it.sha256sum] = "991eb687bf62d4c4b95ca93d74101b23a4500d88a07b609007767fd8e1a732fa"
RPROVIDES:glibc-langpack-it:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-iu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-iu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-iu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-iu}"
SRC_URI[x86_64_v2_glibc-langpack-iu.sha256sum] = "124cafe5db099e56e56f5ca380f34c1900c4ae74bb0c4e387c5cb7af36a1897b"
RPROVIDES:glibc-langpack-iu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ja = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ja-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ja}"
SRC_URI[x86_64_v2_glibc-langpack-ja.sha256sum] = "4dc63485ae4bec5856ee33544cd0d527e725c9ce4d15015fad93e3cf26e9c312"
RPROVIDES:glibc-langpack-ja:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ka = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ka-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ka}"
SRC_URI[x86_64_v2_glibc-langpack-ka.sha256sum] = "503439b9cb9faa9768d6ece77e8268e0d1c70be7aa1e46eb45392e03d4e55f55"
RPROVIDES:glibc-langpack-ka:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-kab = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kab-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kab}"
SRC_URI[x86_64_v2_glibc-langpack-kab.sha256sum] = "f2b7f996d6c54ee737b371b997b16fec27952f6d920ca82cd12d7104476271a7"
RPROVIDES:glibc-langpack-kab:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-kk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kk}"
SRC_URI[x86_64_v2_glibc-langpack-kk.sha256sum] = "89ef9d1952b72977ed20295e28b43699a86930623f03acc614f91d46e7e5282f"
RPROVIDES:glibc-langpack-kk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-kl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kl}"
SRC_URI[x86_64_v2_glibc-langpack-kl.sha256sum] = "c5e0f3d98e3218abd7776919f1acfd80058c4fd634e567908494ba48bf713a06"
RPROVIDES:glibc-langpack-kl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-km = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-km-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-km;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-km}"
SRC_URI[x86_64_v2_glibc-langpack-km.sha256sum] = "5e87021d2df87e7687ba2998268123b4562ed5669883cb8c1ddc1febe0daa812"
RPROVIDES:glibc-langpack-km:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-kn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kn}"
SRC_URI[x86_64_v2_glibc-langpack-kn.sha256sum] = "8e3b696b18ebe0e6fbdfa4dee267f8bdf8634d72252ecf0cbaa0cd993e464306"
RPROVIDES:glibc-langpack-kn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ko = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ko-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ko}"
SRC_URI[x86_64_v2_glibc-langpack-ko.sha256sum] = "2f6eee26d074c8f8b282e60490d4d71cb3653be7ff9874918c55c9854894bce7"
RPROVIDES:glibc-langpack-ko:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-kok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kok-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kok}"
SRC_URI[x86_64_v2_glibc-langpack-kok.sha256sum] = "3d5590a8b9794c873f249f308649b284e835f6887c3085aec99fdd5fb9e419f3"
RPROVIDES:glibc-langpack-kok:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ks = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ks-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ks}"
SRC_URI[x86_64_v2_glibc-langpack-ks.sha256sum] = "68f7c259175811966c56d123d8bd31b545b114a1c9aa0b69df355e8a19400848"
RPROVIDES:glibc-langpack-ks:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ku = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ku-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ku;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ku}"
SRC_URI[x86_64_v2_glibc-langpack-ku.sha256sum] = "51f72ac255291a878b18374f8e0eb4334f9985f8a662ff0cfbd97a35483a68b4"
RPROVIDES:glibc-langpack-ku:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-kv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kv}"
SRC_URI[x86_64_v2_glibc-langpack-kv.sha256sum] = "cdb701400cd65a34dadf2fded7db26095cbf319be713e9877853fc9777df5fdd"
RPROVIDES:glibc-langpack-kv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-kw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kw}"
SRC_URI[x86_64_v2_glibc-langpack-kw.sha256sum] = "37aaacf7e69dc48724fb9abbcbf2dc694e835dedfb2bea5027403a3ff9c2c172"
RPROVIDES:glibc-langpack-kw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ky = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ky-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ky;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ky}"
SRC_URI[x86_64_v2_glibc-langpack-ky.sha256sum] = "e51858d8a573163f8e03f07b88e11f8c15ae88de684fbf62c724a0fbf05c16fc"
RPROVIDES:glibc-langpack-ky:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-lb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lb}"
SRC_URI[x86_64_v2_glibc-langpack-lb.sha256sum] = "08c770f7d129120e4dbfa7e3fd725c7a5023895f67c3fadba7741fff85acca34"
RPROVIDES:glibc-langpack-lb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-lg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lg}"
SRC_URI[x86_64_v2_glibc-langpack-lg.sha256sum] = "c1554ee3e63101a8b2b23ee47000b8600db81414b7e38db11ff0ac3e7a5ee6a6"
RPROVIDES:glibc-langpack-lg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-li = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-li-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-li;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-li}"
SRC_URI[x86_64_v2_glibc-langpack-li.sha256sum] = "120e849660572d5f589bf0739b80ea1f5ab9ab0ae029e2c2a5ba868527a9ca7f"
RPROVIDES:glibc-langpack-li:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-lij = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lij-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lij;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lij}"
SRC_URI[x86_64_v2_glibc-langpack-lij.sha256sum] = "17e60dfc31c9833bd1b50369c748096185a1f725897ad6ae6531a73cf7a9ebe2"
RPROVIDES:glibc-langpack-lij:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ln = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ln-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ln;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ln}"
SRC_URI[x86_64_v2_glibc-langpack-ln.sha256sum] = "cb3beb858fbbbf98ff900baaf629fbbc32246594c0ce6009d381ce0879bc4eaf"
RPROVIDES:glibc-langpack-ln:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-lo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lo}"
SRC_URI[x86_64_v2_glibc-langpack-lo.sha256sum] = "22163bd4b5cdd4fc8cc6ae53c5a534aeff55f9ebbfbc92994db8075b67e5d0bf"
RPROVIDES:glibc-langpack-lo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-lt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lt}"
SRC_URI[x86_64_v2_glibc-langpack-lt.sha256sum] = "4ec8ed6d62e933f64f4e0587f3d9a26835fb664d15418db7602e29c565a57157"
RPROVIDES:glibc-langpack-lt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-lv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lv}"
SRC_URI[x86_64_v2_glibc-langpack-lv.sha256sum] = "be013d4d296a085a6d1efd6aefd9b3b3d578faba34ffe4dac57657ed8c99b744"
RPROVIDES:glibc-langpack-lv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-lzh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lzh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lzh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lzh}"
SRC_URI[x86_64_v2_glibc-langpack-lzh.sha256sum] = "123fbdfa8c4e41743cabd2c1faf2c07f8a173959d68a4520e0879e261f378b19"
RPROVIDES:glibc-langpack-lzh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mag = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mag-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mag}"
SRC_URI[x86_64_v2_glibc-langpack-mag.sha256sum] = "d9464ce8cf3100380088a0704944c38b1318d0f3be39d5b89e853e8ee31a2dc8"
RPROVIDES:glibc-langpack-mag:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mai = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mai-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mai}"
SRC_URI[x86_64_v2_glibc-langpack-mai.sha256sum] = "0d6e7364c2332c6f0d351f46a506e69865927b8225c525ddad511d40d245a155"
RPROVIDES:glibc-langpack-mai:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mfe = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mfe-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mfe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mfe}"
SRC_URI[x86_64_v2_glibc-langpack-mfe.sha256sum] = "fe82d7cf8ec2969b2c5b7e3ba4d0315e111492f7909b9d36a38df2a48f76ea86"
RPROVIDES:glibc-langpack-mfe:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mg}"
SRC_URI[x86_64_v2_glibc-langpack-mg.sha256sum] = "9c7fc21957e63e1fc223dca1aa8332a15b9bb4e8b8901d7c55a81d3cffec653e"
RPROVIDES:glibc-langpack-mg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mhr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mhr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mhr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mhr}"
SRC_URI[x86_64_v2_glibc-langpack-mhr.sha256sum] = "b373a94bba5bd986b260ae47ffc08e34722472c21c47612ba6f9cd6d03086591"
RPROVIDES:glibc-langpack-mhr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mi}"
SRC_URI[x86_64_v2_glibc-langpack-mi.sha256sum] = "61501102bf02097166690ea0d4ef4dcef9196a1fa480851f94d2fd6397d3ce69"
RPROVIDES:glibc-langpack-mi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-miq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-miq-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-miq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-miq}"
SRC_URI[x86_64_v2_glibc-langpack-miq.sha256sum] = "e18604725f003211b79ee2e11f5bd4df617e651a0241397e92f0eff593058b75"
RPROVIDES:glibc-langpack-miq:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mjw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mjw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mjw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mjw}"
SRC_URI[x86_64_v2_glibc-langpack-mjw.sha256sum] = "2e51bf3c3434273143f2e46c84c4faf08fc698a4469e3faa0645ea39cf0b087c"
RPROVIDES:glibc-langpack-mjw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mk}"
SRC_URI[x86_64_v2_glibc-langpack-mk.sha256sum] = "197dfc4b644e6c8becf26f0151f80a703248656b509675d3ad62c2b16e36f0ad"
RPROVIDES:glibc-langpack-mk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ml = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ml-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ml}"
SRC_URI[x86_64_v2_glibc-langpack-ml.sha256sum] = "ecf0ba8092b248d33f09e1c1414f3daf76f37e5e89163bde51a054c4930b4489"
RPROVIDES:glibc-langpack-ml:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mn}"
SRC_URI[x86_64_v2_glibc-langpack-mn.sha256sum] = "7c394811ec50e738f23ed038de96e89aefa2bb17c6972e688798026057b38df1"
RPROVIDES:glibc-langpack-mn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mni = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mni-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mni;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mni}"
SRC_URI[x86_64_v2_glibc-langpack-mni.sha256sum] = "a2dd3e83ccd0704d3b3bd00a4747a0b642604022b195dff2d84d37832074704c"
RPROVIDES:glibc-langpack-mni:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mnw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mnw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mnw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mnw}"
SRC_URI[x86_64_v2_glibc-langpack-mnw.sha256sum] = "1f597a358687bb2e30b0b53854423efb767079eb8a921c5e6b19a849f1767dd2"
RPROVIDES:glibc-langpack-mnw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mr}"
SRC_URI[x86_64_v2_glibc-langpack-mr.sha256sum] = "c5de8f1966db1d247631a2e1d5617f91569b2d18e37c70573b0246176ad5d39f"
RPROVIDES:glibc-langpack-mr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ms = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ms-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ms}"
SRC_URI[x86_64_v2_glibc-langpack-ms.sha256sum] = "26006fa35dbb731251ab4f6f1cf2ffd19c16974580865635e34125843537d802"
RPROVIDES:glibc-langpack-ms:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-mt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mt}"
SRC_URI[x86_64_v2_glibc-langpack-mt.sha256sum] = "6201b1e23525e9fcae8e116071e9464b45c61efdb18506d8c7e3aada4347ea17"
RPROVIDES:glibc-langpack-mt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-my = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-my-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-my;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-my}"
SRC_URI[x86_64_v2_glibc-langpack-my.sha256sum] = "29f63941a167eaf1e9d0f41c38ca2ae7b9109d7d0281f72703b2fb2a91efeb41"
RPROVIDES:glibc-langpack-my:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-nan = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nan-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nan}"
SRC_URI[x86_64_v2_glibc-langpack-nan.sha256sum] = "39bd6933f499cc6cce646cce8c9e427c0366a9ab717c992d1e89e0f5f85c1d4d"
RPROVIDES:glibc-langpack-nan:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-nb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nb-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nb}"
SRC_URI[x86_64_v2_glibc-langpack-nb.sha256sum] = "e2056134a20df4410f807821e776b8f6beefd348940deb695d3379e8ec568de0"
RPROVIDES:glibc-langpack-nb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-nds = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nds-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nds}"
SRC_URI[x86_64_v2_glibc-langpack-nds.sha256sum] = "6b3737b1162c08a76a518aa6824d28fdd278d77d284c0b3e937b9c7d5edbe221"
RPROVIDES:glibc-langpack-nds:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ne = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ne-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ne;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ne}"
SRC_URI[x86_64_v2_glibc-langpack-ne.sha256sum] = "4c2a067f3ed85d5b7f40b4c0b0db04910e363af25096eaca7bea2553597a46ef"
RPROVIDES:glibc-langpack-ne:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-nhn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nhn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nhn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nhn}"
SRC_URI[x86_64_v2_glibc-langpack-nhn.sha256sum] = "33a95bffd37243d1cf90feb5cee2bf6677890faa377555abd5120048f34a54a0"
RPROVIDES:glibc-langpack-nhn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-niu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-niu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-niu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-niu}"
SRC_URI[x86_64_v2_glibc-langpack-niu.sha256sum] = "6898c48b2ae8dadd9b1c494bf3f10fb64c1cea23aae0a857951ca714e18e7452"
RPROVIDES:glibc-langpack-niu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-nl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nl}"
SRC_URI[x86_64_v2_glibc-langpack-nl.sha256sum] = "7630333de24063cfd87cc6114e85646966bd0410e59c8f70cf32e6977f6d1541"
RPROVIDES:glibc-langpack-nl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-nn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nn}"
SRC_URI[x86_64_v2_glibc-langpack-nn.sha256sum] = "bbe629476ea2bcd83cc5dd95c3ced611ebd0a929d507903e6507480b0d9c4605"
RPROVIDES:glibc-langpack-nn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-nr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nr}"
SRC_URI[x86_64_v2_glibc-langpack-nr.sha256sum] = "1cc417a9afb1744baa3d0096b1c2269e1bebc6ff2874f84e0c72d193574e3a49"
RPROVIDES:glibc-langpack-nr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-nso = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nso-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nso}"
SRC_URI[x86_64_v2_glibc-langpack-nso.sha256sum] = "1d6f85d00553940a8015d5e61d64f2e09b4c38d316d8f28250c0d236ce3494b6"
RPROVIDES:glibc-langpack-nso:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-oc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-oc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-oc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-oc}"
SRC_URI[x86_64_v2_glibc-langpack-oc.sha256sum] = "45a9d789c780a2d067dd5c888c57ddd37cf1c54ad61f02895ed5671897f712c4"
RPROVIDES:glibc-langpack-oc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-om = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-om-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-om;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-om}"
SRC_URI[x86_64_v2_glibc-langpack-om.sha256sum] = "18f9ce9960943a92d001fd170f13189155b86b5d1f55564773240cb7d0271a5c"
RPROVIDES:glibc-langpack-om:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-or = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-or-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-or;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-or}"
SRC_URI[x86_64_v2_glibc-langpack-or.sha256sum] = "fa7a82c832caef7e0969696d6f608100229945778dfc18ab1d3b7fbd3c13ea59"
RPROVIDES:glibc-langpack-or:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-os = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-os-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-os;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-os}"
SRC_URI[x86_64_v2_glibc-langpack-os.sha256sum] = "df51300c6a10ff855adebe844cc2eaf68e30a57c60bfdd495638bea53a696600"
RPROVIDES:glibc-langpack-os:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-pa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pa}"
SRC_URI[x86_64_v2_glibc-langpack-pa.sha256sum] = "209323f9303f46ba12d36785b7b7202494529aa41670d6e868ceac5dd44ed805"
RPROVIDES:glibc-langpack-pa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-pap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pap-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pap}"
SRC_URI[x86_64_v2_glibc-langpack-pap.sha256sum] = "caeb23e7ee15c23dce183a44c407f77cd46482bf977594fab3de254f3ca522c8"
RPROVIDES:glibc-langpack-pap:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-pl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pl}"
SRC_URI[x86_64_v2_glibc-langpack-pl.sha256sum] = "1b8cb2dea821864ae73d579705327b612f1c51148c41f957a594430521e41a17"
RPROVIDES:glibc-langpack-pl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ps = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ps-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ps}"
SRC_URI[x86_64_v2_glibc-langpack-ps.sha256sum] = "ddf1c1554e2d2c5ecfba0236db791c95ac46ab18bef5a69b2fe4601c77836a79"
RPROVIDES:glibc-langpack-ps:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-pt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pt}"
SRC_URI[x86_64_v2_glibc-langpack-pt.sha256sum] = "5c4e32066a76bf123830bf8ea77e30835d600dfd305ed14c29ccaa993476cf20"
RPROVIDES:glibc-langpack-pt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-quz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-quz-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-quz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-quz}"
SRC_URI[x86_64_v2_glibc-langpack-quz.sha256sum] = "0d1aaed20f444a9cba2e491efc3b50e507784fad24f473b1327a2be0bce21141"
RPROVIDES:glibc-langpack-quz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-raj = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-raj-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-raj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-raj}"
SRC_URI[x86_64_v2_glibc-langpack-raj.sha256sum] = "80d19a83cf0380a5d0d9f74e5d2956309ffe743e1b13600521bc645989ecdf15"
RPROVIDES:glibc-langpack-raj:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-rif = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rif-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-rif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-rif}"
SRC_URI[x86_64_v2_glibc-langpack-rif.sha256sum] = "db4442c17b8fdcb92e5b237d886d915262e30e729719d170abce37aef4d038f3"
RPROVIDES:glibc-langpack-rif:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ro = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ro-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ro}"
SRC_URI[x86_64_v2_glibc-langpack-ro.sha256sum] = "589e100395fcf9987b35b691ce74c4eddf40ee8f3fba416590a9378b95e722d2"
RPROVIDES:glibc-langpack-ro:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ru = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ru-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ru;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ru}"
SRC_URI[x86_64_v2_glibc-langpack-ru.sha256sum] = "63cad8eddfb3c79af3360906083387daf811469f3763924972faf2c1d91814f1"
RPROVIDES:glibc-langpack-ru:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-rw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-rw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-rw}"
SRC_URI[x86_64_v2_glibc-langpack-rw.sha256sum] = "87bdd23fc5ecbc689b621b9485fb338bd87e8d79f2b57819f6bb15b8b8314788"
RPROVIDES:glibc-langpack-rw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sa}"
SRC_URI[x86_64_v2_glibc-langpack-sa.sha256sum] = "05ee16d0722bbcec776ad03e5ba2d36a48c1ee7069133a7411307e58258fa46e"
RPROVIDES:glibc-langpack-sa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sah = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sah-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sah;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sah}"
SRC_URI[x86_64_v2_glibc-langpack-sah.sha256sum] = "bae06924ffb309eb0f0b30ee9367be685c9329c1b0491080518c6fdb7eda7285"
RPROVIDES:glibc-langpack-sah:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sat-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sat}"
SRC_URI[x86_64_v2_glibc-langpack-sat.sha256sum] = "a06caf609deb8f1434c8ff4e484f2e409bb1bd24669154070131fd3f29885994"
RPROVIDES:glibc-langpack-sat:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sc-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sc}"
SRC_URI[x86_64_v2_glibc-langpack-sc.sha256sum] = "6c559a9224fbea2df6dea71512bf90bb27ae32b997be1b5106a70d62aab8f1e2"
RPROVIDES:glibc-langpack-sc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sd-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sd}"
SRC_URI[x86_64_v2_glibc-langpack-sd.sha256sum] = "b4b9d3a41561caea3aef6cfae551da20bc73c18f535ca9fadd8b13ba0f53ebc4"
RPROVIDES:glibc-langpack-sd:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-se = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-se-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-se;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-se}"
SRC_URI[x86_64_v2_glibc-langpack-se.sha256sum] = "d9a30284bfbabdcf1226fa9eef475db052ed5ad49f6e3ed6fbd60ca9c152e0d6"
RPROVIDES:glibc-langpack-se:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sgs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sgs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sgs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sgs}"
SRC_URI[x86_64_v2_glibc-langpack-sgs.sha256sum] = "dee205394149429f6a6e22fe72549d2c1aa1e8db5ab21dff7d42b9151e97dfff"
RPROVIDES:glibc-langpack-sgs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-shn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-shn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-shn}"
SRC_URI[x86_64_v2_glibc-langpack-shn.sha256sum] = "2eb4c6394aa2b3de2f0a64ac2b25e4e5d78634f646405f7aacfd4db77995dc5e"
RPROVIDES:glibc-langpack-shn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-shs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shs-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-shs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-shs}"
SRC_URI[x86_64_v2_glibc-langpack-shs.sha256sum] = "e37b89f77141954dc329d27f1b79b00d4f5b7871e221625ee5359d2b07e7e4c4"
RPROVIDES:glibc-langpack-shs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-si = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-si-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-si;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-si}"
SRC_URI[x86_64_v2_glibc-langpack-si.sha256sum] = "7167c96f55fd5976eda55ec6cec9c8b89073b1fa06549d4ab5cf0b99df9b2cd0"
RPROVIDES:glibc-langpack-si:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sid-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sid}"
SRC_URI[x86_64_v2_glibc-langpack-sid.sha256sum] = "a1ed5eaff69bc12f9dafe9d0d068c3d5cac0d0f9d7c8c1447c16ee0d848e5024"
RPROVIDES:glibc-langpack-sid:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sk}"
SRC_URI[x86_64_v2_glibc-langpack-sk.sha256sum] = "8db4c241eec6e2ac4476d50591dc9e5cb60e15ebd971996419ff785a89aa627d"
RPROVIDES:glibc-langpack-sk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sl}"
SRC_URI[x86_64_v2_glibc-langpack-sl.sha256sum] = "fa4a009fd840f5a28827a49925d6acf9fa1b0d35532f40580dc6f10ab8828ab9"
RPROVIDES:glibc-langpack-sl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sm-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sm}"
SRC_URI[x86_64_v2_glibc-langpack-sm.sha256sum] = "cc5b6fe5b0c36419b2efffebf478d690ce8bf2ace874b1227da0a7eee129ae32"
RPROVIDES:glibc-langpack-sm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-so = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-so-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-so;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-so}"
SRC_URI[x86_64_v2_glibc-langpack-so.sha256sum] = "5bb05fb3fe1afd0e44ff1f66528cc222b64a13e42ad3abb3a029ea3ac9fe72a1"
RPROVIDES:glibc-langpack-so:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sq-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sq}"
SRC_URI[x86_64_v2_glibc-langpack-sq.sha256sum] = "ebb041e7f5122995a0561cd6404049fa5f6931031587603904c97864107a51da"
RPROVIDES:glibc-langpack-sq:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sr}"
SRC_URI[x86_64_v2_glibc-langpack-sr.sha256sum] = "707f5cf97cab8952dbe3e820049a1b5258e25497861872785ebce298aa7fca56"
RPROVIDES:glibc-langpack-sr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ss-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ss}"
SRC_URI[x86_64_v2_glibc-langpack-ss.sha256sum] = "b335e22f0517b7242bc5f1b80ca0380fd160db50ac7390e3fa472c72b66c537a"
RPROVIDES:glibc-langpack-ss:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ssy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ssy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ssy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ssy}"
SRC_URI[x86_64_v2_glibc-langpack-ssy.sha256sum] = "3e4017299b3f6e661b5ec2188391db2e3a0fd373a04178bbfdf2c11ec0365951"
RPROVIDES:glibc-langpack-ssy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-st = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-st-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-st;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-st}"
SRC_URI[x86_64_v2_glibc-langpack-st.sha256sum] = "3335bd036651f8cf335a497ad9ceefac898addd44e7b95dfcbf923e8a9e8ecc8"
RPROVIDES:glibc-langpack-st:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-su = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-su-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-su;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-su}"
SRC_URI[x86_64_v2_glibc-langpack-su.sha256sum] = "6dd7a9f3ee37e345b1d8a736e03a5bde381849f7681799bc3f4e2a46dcd9acee"
RPROVIDES:glibc-langpack-su:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sv-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sv}"
SRC_URI[x86_64_v2_glibc-langpack-sv.sha256sum] = "4a1063420aae8b2f5ab8a0022d53e9ff104be8c505ef61c9677ebc3bb0787817"
RPROVIDES:glibc-langpack-sv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-sw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sw}"
SRC_URI[x86_64_v2_glibc-langpack-sw.sha256sum] = "d9889f2aaceaf269c31ba53871eafa0f5a6604d3e2f23a5bdcff9e5d94a7fb17"
RPROVIDES:glibc-langpack-sw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-syr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-syr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-syr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-syr}"
SRC_URI[x86_64_v2_glibc-langpack-syr.sha256sum] = "62ed6ac7b9fcda62d01317755b8a231524f9bcad485bc13b700db0953ac67f08"
RPROVIDES:glibc-langpack-syr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-szl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-szl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-szl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-szl}"
SRC_URI[x86_64_v2_glibc-langpack-szl.sha256sum] = "8ad2333526c777bf813a6b4875bca22e0358ca498bab7a4f7494d2126dc4d966"
RPROVIDES:glibc-langpack-szl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ta = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ta-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ta}"
SRC_URI[x86_64_v2_glibc-langpack-ta.sha256sum] = "f48090daa7e7c6eb3fe0621c99473ea75ac5e833f68330d39c07e1ef8a742edd"
RPROVIDES:glibc-langpack-ta:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-tcy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tcy-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tcy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tcy}"
SRC_URI[x86_64_v2_glibc-langpack-tcy.sha256sum] = "9e291289a3780468d86c425737fb341ab1ad5a036ab0c05ee51cddac55dc4834"
RPROVIDES:glibc-langpack-tcy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-te = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-te-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-te;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-te}"
SRC_URI[x86_64_v2_glibc-langpack-te.sha256sum] = "138a2a2461d9a43e242c374220f8aa6a32f9cb0d812fb5a9f26d710cba498760"
RPROVIDES:glibc-langpack-te:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-tg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tg-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tg}"
SRC_URI[x86_64_v2_glibc-langpack-tg.sha256sum] = "903e88d961072677bd21158de52c676c0c0690aa70cad32f304c3c43637fb953"
RPROVIDES:glibc-langpack-tg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-th = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-th-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-th}"
SRC_URI[x86_64_v2_glibc-langpack-th.sha256sum] = "0b85f2cce1fd5ecb1a9ac596973e2a4abf7552dc10fba007571c1cf86874f0ef"
RPROVIDES:glibc-langpack-th:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-the = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-the-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-the;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-the}"
SRC_URI[x86_64_v2_glibc-langpack-the.sha256sum] = "d17c1481b789128472bcc2f41892a4d78c359ac421a071af29b040ca36f19288"
RPROVIDES:glibc-langpack-the:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ti = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ti-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ti;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ti}"
SRC_URI[x86_64_v2_glibc-langpack-ti.sha256sum] = "89f96310c5fca941524e6cd09df7970d2b38d6807531b6c54836ac001a978151"
RPROVIDES:glibc-langpack-ti:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-tig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tig-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tig}"
SRC_URI[x86_64_v2_glibc-langpack-tig.sha256sum] = "ee18c9788e91ece7091d941978834d3502ca49683f0ccefd4fd254668e7db951"
RPROVIDES:glibc-langpack-tig:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-tk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tk}"
SRC_URI[x86_64_v2_glibc-langpack-tk.sha256sum] = "7dffa1baddf503d2238506462d69f5e51c104be6d6095ab65cb43ad24d99e1bc"
RPROVIDES:glibc-langpack-tk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-tl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tl}"
SRC_URI[x86_64_v2_glibc-langpack-tl.sha256sum] = "e9d7a48ba2e791913df08c0693e64f6713c99c12007edcefc3201f084b4be15d"
RPROVIDES:glibc-langpack-tl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-tn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tn-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tn}"
SRC_URI[x86_64_v2_glibc-langpack-tn.sha256sum] = "2ed33848eff6b48cc02f66a5e448f6474f51c11fc5f28841307c6fa66b070489"
RPROVIDES:glibc-langpack-tn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-to = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-to-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-to;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-to}"
SRC_URI[x86_64_v2_glibc-langpack-to.sha256sum] = "54ce17ab3649d8ee2cbb10c62d60a7b952bbb5b744424950c2b7f2e3a2172c0e"
RPROVIDES:glibc-langpack-to:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-tok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tok-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tok}"
SRC_URI[x86_64_v2_glibc-langpack-tok.sha256sum] = "1d2a81efafd8dae4816f5e1945ac99b7651f97b66b16ea0e17e507e69f9664b6"
RPROVIDES:glibc-langpack-tok:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-tpi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tpi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tpi}"
SRC_URI[x86_64_v2_glibc-langpack-tpi.sha256sum] = "43d85b4c75df83dc43a947ebd54a82cdf47fe23cd2e3f7a46b95e1519751ad91"
RPROVIDES:glibc-langpack-tpi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-tr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tr-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tr}"
SRC_URI[x86_64_v2_glibc-langpack-tr.sha256sum] = "c126068ee43cf3619c872a27f7b4ebb5bee27e20f22a64b5f60c2c339fcc5fa6"
RPROVIDES:glibc-langpack-tr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ts-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ts}"
SRC_URI[x86_64_v2_glibc-langpack-ts.sha256sum] = "06c0408e18315ac7fcadd72518c2c0a5f0c92d2ed17ba88a8e60021754a514f7"
RPROVIDES:glibc-langpack-ts:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-tt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tt-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tt}"
SRC_URI[x86_64_v2_glibc-langpack-tt.sha256sum] = "249271de2fb38b9f95b869577f556dc698708ca78ad88b5535774fd1d57a5224"
RPROVIDES:glibc-langpack-tt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ug = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ug-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ug}"
SRC_URI[x86_64_v2_glibc-langpack-ug.sha256sum] = "d235c10d332470121d89edd66494070d8ddf591ca3903201754c8d8e1e26e47a"
RPROVIDES:glibc-langpack-ug:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-uk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uk-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-uk}"
SRC_URI[x86_64_v2_glibc-langpack-uk.sha256sum] = "22dfaf91752bc1d30123f1a4e88b2e8f65d9b79350e20b84ed539061812cf8dd"
RPROVIDES:glibc-langpack-uk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-unm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-unm-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-unm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-unm}"
SRC_URI[x86_64_v2_glibc-langpack-unm.sha256sum] = "102a663f7166b07ba3bfad1144885f56742d98bdc0fbf1bef2421ece8f5d00eb"
RPROVIDES:glibc-langpack-unm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ur-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ur}"
SRC_URI[x86_64_v2_glibc-langpack-ur.sha256sum] = "9ad3fbb1f30cfc81c5993219499456c8c6d35719869c6ab3ee864c7a543b34cd"
RPROVIDES:glibc-langpack-ur:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-uz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uz-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-uz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-uz}"
SRC_URI[x86_64_v2_glibc-langpack-uz.sha256sum] = "d040eee4aa8d736b1ca23824c792dd8b5762162c0654c609b32af2015684cf39"
RPROVIDES:glibc-langpack-uz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-ve = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ve-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ve}"
SRC_URI[x86_64_v2_glibc-langpack-ve.sha256sum] = "972e266237cefda8ada2009eb30faffd9c43def9210bddc3ef1cefcd8353c901"
RPROVIDES:glibc-langpack-ve:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-vi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-vi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-vi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-vi}"
SRC_URI[x86_64_v2_glibc-langpack-vi.sha256sum] = "3ad4115e125e40902e007ca771cdb5d10ccd821e27cfc08831ea293bedfcb344"
RPROVIDES:glibc-langpack-vi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-wa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wa-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wa}"
SRC_URI[x86_64_v2_glibc-langpack-wa.sha256sum] = "7eac5e7dbfc71d04104dbe9e4604eaa8b54424d74e7adb47446e8a8123885605"
RPROVIDES:glibc-langpack-wa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-wae = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wae-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wae;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wae}"
SRC_URI[x86_64_v2_glibc-langpack-wae.sha256sum] = "b42cc3f4c77db6f3194876d0f8c35427510cd6aed0437b7aa0366b1191f585a2"
RPROVIDES:glibc-langpack-wae:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-wal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wal-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wal}"
SRC_URI[x86_64_v2_glibc-langpack-wal.sha256sum] = "3188dadc7c043575a93414e7e0c69b0c143d238a07632a8a10db45e5cac03e8d"
RPROVIDES:glibc-langpack-wal:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-wo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wo}"
SRC_URI[x86_64_v2_glibc-langpack-wo.sha256sum] = "c8952bdb065ec3a2718d23cc0cdbb6da751af2cc5c8b621c43b576feb0d40406"
RPROVIDES:glibc-langpack-wo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-xh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-xh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-xh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-xh}"
SRC_URI[x86_64_v2_glibc-langpack-xh.sha256sum] = "e8b23bf01c7e2a4f3c6ca3790851806631931381c89d2c3fd4e8922ddcf3deea"
RPROVIDES:glibc-langpack-xh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-yi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yi-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yi}"
SRC_URI[x86_64_v2_glibc-langpack-yi.sha256sum] = "f483284d676dac90b68447357bf2c372bf512d356d3c9801daf9f03eb9237205"
RPROVIDES:glibc-langpack-yi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-yo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yo-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yo}"
SRC_URI[x86_64_v2_glibc-langpack-yo.sha256sum] = "838b19155ee5ce5de8eebcc66c58209be34ac92544b2b3867efbaefa0aba51b4"
RPROVIDES:glibc-langpack-yo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-yue = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yue-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yue}"
SRC_URI[x86_64_v2_glibc-langpack-yue.sha256sum] = "e9d32cfc5237e0c7e981ad6056ad827b4e96e57ee06c07fb4e8a48842a25fa8e"
RPROVIDES:glibc-langpack-yue:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-yuw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yuw-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yuw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yuw}"
SRC_URI[x86_64_v2_glibc-langpack-yuw.sha256sum] = "726ad8dc06edbbfbc6806205a30b539b47b31319fe884cd476834bee151ee20d"
RPROVIDES:glibc-langpack-yuw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-zgh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zgh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zgh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zgh}"
SRC_URI[x86_64_v2_glibc-langpack-zgh.sha256sum] = "85408a21feff2b94ee9e6e18e91a6508a1832a395f34bc891ea5148af4882bf4"
RPROVIDES:glibc-langpack-zgh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-zh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zh-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zh}"
SRC_URI[x86_64_v2_glibc-langpack-zh.sha256sum] = "6a56cd57f8d676db91ec40033fe5cdd07c0f433f6b0f8ae7419a7eb762fedad2"
RPROVIDES:glibc-langpack-zh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-langpack-zu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zu-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zu}"
SRC_URI[x86_64_v2_glibc-langpack-zu.sha256sum] = "ec512dda875304939070bf64e22b56219f17973ba444a03616c0e1c93194b67d"
RPROVIDES:glibc-langpack-zu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-locale-source = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-locale-source-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-locale-source;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-locale-source}"
SRC_URI[x86_64_v2_glibc-locale-source.sha256sum] = "8290806821c9c95005305ccf0df641af27f4bf45c6849980b9f6f6df758b5b04"

URI_x86_64_v2_glibc-minimal-langpack = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-minimal-langpack-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-minimal-langpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-minimal-langpack}"
SRC_URI[x86_64_v2_glibc-minimal-langpack.sha256sum] = "03a104e2792d877edd06efd040f5aed1c628231512cc02ea28b1c82250503644"
RPROVIDES:glibc-minimal-langpack:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_x86_64_v2_glibc-nss-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-nss-devel-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-nss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-nss-devel}"
SRC_URI[x86_64_v2_glibc-nss-devel.sha256sum] = "d284ea832fb96f3c0cd516f1bfa00fb4923d879f0cf19f9bb27f1f880d8447e4"

URI_x86_64_v2_glibc-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-static-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-static}"
SRC_URI[x86_64_v2_glibc-static.sha256sum] = "2a034916b7f071cbdbd75dfba04338acfbf9eb2554ec39b7eafdb0b2540d01a6"

URI_x86_64_v2_glibc-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-utils-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-utils}"
SRC_URI[x86_64_v2_glibc-utils.sha256sum] = "7111e5c5f8ade3714d14730817ad86fba6e67c60cf661e93e5eac25c6b6343e1"

URI_x86_64_v2_libnsl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnsl-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_libnsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnsl}"
SRC_URI[x86_64_v2_libnsl.sha256sum] = "5e5c6edb7b71d06c1e2641b4853abebb1b6f8835fc0b46741dcab023a42fd9d9"

URI_x86_64_v2_nss_db = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nss_db-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_nss_db;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss_db}"
SRC_URI[x86_64_v2_nss_db.sha256sum] = "8d70e5ffbd4ff7589d095bfd679c205f72395bc45a6e1ac3db7d8996cf554cf0"

URI_x86_64_v2_nss_hesiod = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nss_hesiod-2.39-46.el10_0.4.alma.1.x86_64_v2.rpm;name=x86_64_v2_nss_hesiod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss_hesiod}"
SRC_URI[x86_64_v2_nss_hesiod.sha256sum] = "6fa2cea253dc6ced149dcfbf715bdfe6855cf742a6cde808014f1473f24b75cb"

URI_aarch64_glibc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc}"
SRC_URI[aarch64_glibc.sha256sum] = "1a21a59318562bacf6433310fb0a57b9ab85d3b213cc70d35426e4846c9403ff"

URI_aarch64_glibc-all-langpacks = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-all-langpacks-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-all-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-all-langpacks}"
SRC_URI[aarch64_glibc-all-langpacks.sha256sum] = "17464139f0ae8073f836361ed910e03cae5c1423a55c5d5f0d1e138ac3a82ee4"
RPROVIDES:glibc-all-langpacks:aarch64 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-benchtests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-benchtests-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-benchtests;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-benchtests}"
SRC_URI[aarch64_glibc-benchtests.sha256sum] = "e74f61f458e29f5f9b9c18dacd2c95f0e081794e0187e12a2f7fad1fbd429384"

URI_aarch64_glibc-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-common-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-common}"
SRC_URI[aarch64_glibc-common.sha256sum] = "ae72d47fbe5486d1e276d54ac48b4f57522cef78b20ca06496ccad52119d8154"

URI_aarch64_glibc-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-devel-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-devel}"
SRC_URI[aarch64_glibc-devel.sha256sum] = "0d159fcfb62aa2a631a8264b64ece0cd3796ac6aa35b5c41681798f558f9c2b5"

URI_aarch64_glibc-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-doc-2.39-46.el10_0.4.alma.1.noarch.rpm;name=aarch64_glibc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-doc}"
SRC_URI[aarch64_glibc-doc.sha256sum] = "d425eba84ead05dbb4a8da01c44663ed00c93a16e93fcb9e6c07fb5047b499d1"

URI_aarch64_glibc-gconv-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-gconv-extra-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-gconv-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-gconv-extra}"
SRC_URI[aarch64_glibc-gconv-extra.sha256sum] = "ba278b5afa3940fda3b68f4f6831684725645540d6acdf171197f0dcf6681044"

URI_aarch64_glibc-langpack-aa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-aa-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-aa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-aa}"
SRC_URI[aarch64_glibc-langpack-aa.sha256sum] = "18e1863f2247760eced0214dd45e1b9e9b62851ab465be0fdaee5cc7b5789fb8"
RPROVIDES:glibc-langpack-aa:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-af = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-af-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-af;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-af}"
SRC_URI[aarch64_glibc-langpack-af.sha256sum] = "c119a65ac16dc75c01d4395d7f20d153c4dd5c93ed3ee8e1834a1b9ca51aec56"
RPROVIDES:glibc-langpack-af:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-agr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-agr-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-agr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-agr}"
SRC_URI[aarch64_glibc-langpack-agr.sha256sum] = "1ad20619ce12f56ca47b9c1f0ca40a4936a0341c5d5348a33302159abd7d74a5"
RPROVIDES:glibc-langpack-agr:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ak = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ak-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ak;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ak}"
SRC_URI[aarch64_glibc-langpack-ak.sha256sum] = "5e1d926a52a36cf12b72a28bc3ef964869442567ad8a91f9cd6475c295c48a08"
RPROVIDES:glibc-langpack-ak:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-am = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-am-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-am;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-am}"
SRC_URI[aarch64_glibc-langpack-am.sha256sum] = "ab0e669486408c9f19666b6e6f670269211d8ee2bf625cf12addf6980f3263db"
RPROVIDES:glibc-langpack-am:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-an = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-an-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-an;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-an}"
SRC_URI[aarch64_glibc-langpack-an.sha256sum] = "493c4f61e401cb1e757e177176650f44d1a6cb52dfe9c75fbd0b26e823a79aba"
RPROVIDES:glibc-langpack-an:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-anp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-anp-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-anp;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-anp}"
SRC_URI[aarch64_glibc-langpack-anp.sha256sum] = "c7a7025a4f5b25360d160e8700c862e109d1da7050b81dd498da96c3960a9f73"
RPROVIDES:glibc-langpack-anp:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ar = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ar-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ar;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ar}"
SRC_URI[aarch64_glibc-langpack-ar.sha256sum] = "6b84087865729962951f2860e5a2dcef43ca47de15ea62d12c4c5fa7d96b4214"
RPROVIDES:glibc-langpack-ar:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-as = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-as-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-as;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-as}"
SRC_URI[aarch64_glibc-langpack-as.sha256sum] = "902350d9a1da53d62e80a185073fb32691927b60bc333efd64b8bc8175984d8f"
RPROVIDES:glibc-langpack-as:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ast = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ast-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ast;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ast}"
SRC_URI[aarch64_glibc-langpack-ast.sha256sum] = "3922714ac077c07b90a0aa8b4a39623cb0ec56d179fa4a1cc85bedd08bfaa274"
RPROVIDES:glibc-langpack-ast:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ayc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ayc-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ayc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ayc}"
SRC_URI[aarch64_glibc-langpack-ayc.sha256sum] = "d8ffb366f64e339ff7417dc0e486b3513d7b6b198dcc8413662dfee6d6dd29b2"
RPROVIDES:glibc-langpack-ayc:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-az = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-az-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-az;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-az}"
SRC_URI[aarch64_glibc-langpack-az.sha256sum] = "533ccf50827dd854969e415f5f1c95fa877a7d29a94161c38beea24c8930b33e"
RPROVIDES:glibc-langpack-az:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-be = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-be-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-be;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-be}"
SRC_URI[aarch64_glibc-langpack-be.sha256sum] = "b4ac0eb54361426b69c8642a440297d0200f8b0ad97cf8cfd247fd8f55109b0b"
RPROVIDES:glibc-langpack-be:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-bem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bem-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bem;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bem}"
SRC_URI[aarch64_glibc-langpack-bem.sha256sum] = "b6d9f77d2b21e5c4bfb82ceb1ab81587886e1c3225dad9d432d22c20d81d1fdf"
RPROVIDES:glibc-langpack-bem:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ber = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ber-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ber;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ber}"
SRC_URI[aarch64_glibc-langpack-ber.sha256sum] = "fae17c2a85d3f448807396a6f38f008e80c7813357af71d4ad1132c856c5146b"
RPROVIDES:glibc-langpack-ber:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-bg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bg-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bg}"
SRC_URI[aarch64_glibc-langpack-bg.sha256sum] = "febbae181bf22f61a58a869f7577f43d1cc966d75363ec2de918f896b4d7546d"
RPROVIDES:glibc-langpack-bg:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-bhb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bhb-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bhb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bhb}"
SRC_URI[aarch64_glibc-langpack-bhb.sha256sum] = "6ceab1a7d0ef59da0a7c597e5f38deed914b31daf5a2ae476c72d440e8a01e95"
RPROVIDES:glibc-langpack-bhb:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-bho = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bho-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bho;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bho}"
SRC_URI[aarch64_glibc-langpack-bho.sha256sum] = "4edd46d8e9b93950dd3b108660e65805d89b6dabd940eed381d1f214fc6d1d8d"
RPROVIDES:glibc-langpack-bho:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-bi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bi-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bi}"
SRC_URI[aarch64_glibc-langpack-bi.sha256sum] = "e2ac6ea4a47528f3cf73c79d2ece31f435e14c81360547e3aff3caace1543bfb"
RPROVIDES:glibc-langpack-bi:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-bn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bn-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bn}"
SRC_URI[aarch64_glibc-langpack-bn.sha256sum] = "cbe877cd136b1f5b66549483a63493692d72862700098f62f51746800b2dd5ad"
RPROVIDES:glibc-langpack-bn:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-bo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bo-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bo}"
SRC_URI[aarch64_glibc-langpack-bo.sha256sum] = "7a936099197fb8f068c5af4521e55e284ee9bd16256ceb7279c187828194bfd1"
RPROVIDES:glibc-langpack-bo:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-br = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-br-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-br;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-br}"
SRC_URI[aarch64_glibc-langpack-br.sha256sum] = "de665853a8d4d80214affd43a030b9e01593856667e106de28d713a66da9d2d2"
RPROVIDES:glibc-langpack-br:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-brx = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-brx-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-brx;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-brx}"
SRC_URI[aarch64_glibc-langpack-brx.sha256sum] = "b47588eab7287d3f4ceac291f9f12310cb3ab7b079aa10817bd1ef6c9d6c8a66"
RPROVIDES:glibc-langpack-brx:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-bs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bs-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bs}"
SRC_URI[aarch64_glibc-langpack-bs.sha256sum] = "cf37cc47ef3825efb6e537524e71044aab3363332ac35144a0dffbec63e3a651"
RPROVIDES:glibc-langpack-bs:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-byn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-byn-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-byn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-byn}"
SRC_URI[aarch64_glibc-langpack-byn.sha256sum] = "3ad612ddeefa841e530470c09ffca01072c3268f4eab09286640ce576505d186"
RPROVIDES:glibc-langpack-byn:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ca = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ca-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ca;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ca}"
SRC_URI[aarch64_glibc-langpack-ca.sha256sum] = "0066b2efad25848008455c3deb17ec8c13cf199e607447b67d368f8d2608da50"
RPROVIDES:glibc-langpack-ca:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ce = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ce-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ce;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ce}"
SRC_URI[aarch64_glibc-langpack-ce.sha256sum] = "891dad4aa04ece4e7365896367b6c2a6d2e11d57b74977275aff1ec033a02b4d"
RPROVIDES:glibc-langpack-ce:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-chr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-chr-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-chr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-chr}"
SRC_URI[aarch64_glibc-langpack-chr.sha256sum] = "8d83fb93a68010272289265dc9ccac93b48cef1a988f1120e3d1c40e28fc6673"
RPROVIDES:glibc-langpack-chr:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ckb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ckb-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ckb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ckb}"
SRC_URI[aarch64_glibc-langpack-ckb.sha256sum] = "ab16443b74b092f2055200564757fdaecb8748020d8337aa21d9cc339b4f2a2f"
RPROVIDES:glibc-langpack-ckb:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-cmn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cmn-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cmn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cmn}"
SRC_URI[aarch64_glibc-langpack-cmn.sha256sum] = "d93c84f3db9fe45b1136b703ceedae87854f8fd9b79bdbebcd3a359e11cb69bf"
RPROVIDES:glibc-langpack-cmn:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-crh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-crh-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-crh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-crh}"
SRC_URI[aarch64_glibc-langpack-crh.sha256sum] = "6632491f2b2696c825ba69aa3b948571299b563d40b0198ef57bd51e17125916"
RPROVIDES:glibc-langpack-crh:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-cs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cs-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cs}"
SRC_URI[aarch64_glibc-langpack-cs.sha256sum] = "fb5a8d9a499b54f694621084b75bedf3a3eb1983d3ab42067d4833bdd5d3b31f"
RPROVIDES:glibc-langpack-cs:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-csb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-csb-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-csb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-csb}"
SRC_URI[aarch64_glibc-langpack-csb.sha256sum] = "95dbf22c30bbfa0b4d0ecd1db3d9b9530160d06975ac731e1de98f9d7b179a11"
RPROVIDES:glibc-langpack-csb:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-cv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cv-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cv}"
SRC_URI[aarch64_glibc-langpack-cv.sha256sum] = "a745922d63859162cc25c42a2c680fcaf23ea512e6b58986cfba9665affc3478"
RPROVIDES:glibc-langpack-cv:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-cy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cy-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cy}"
SRC_URI[aarch64_glibc-langpack-cy.sha256sum] = "badb1c332aac382b98f42fdfe09a979a80adb675b71878ea0dfabc1b7417fb07"
RPROVIDES:glibc-langpack-cy:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-da = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-da-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-da;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-da}"
SRC_URI[aarch64_glibc-langpack-da.sha256sum] = "608cc00b521a82a6d13c5cd3e8ae4cb8ef4078225639cc8e656cee52d69e0bb2"
RPROVIDES:glibc-langpack-da:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-de = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-de-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-de;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-de}"
SRC_URI[aarch64_glibc-langpack-de.sha256sum] = "6a79a00766aca819c6720cfd1a2f00d5c52bdb5f30678106ce481ccb403ef949"
RPROVIDES:glibc-langpack-de:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-doi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-doi-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-doi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-doi}"
SRC_URI[aarch64_glibc-langpack-doi.sha256sum] = "0edde3d6b9c19a8ed47c26f3dbf0b7c117b57f880c6a5f0c922346b7700bec8e"
RPROVIDES:glibc-langpack-doi:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-dsb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dsb-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dsb}"
SRC_URI[aarch64_glibc-langpack-dsb.sha256sum] = "a12ed3f8bf3e67c3f7fb37ffe5f6d9573d37dcc35ae989558ff50d0283d199f7"
RPROVIDES:glibc-langpack-dsb:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-dv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dv-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dv}"
SRC_URI[aarch64_glibc-langpack-dv.sha256sum] = "c669288370053e9f10d66fa3cce09f24eb9de55e8b2ccd9f72b87b10030399ca"
RPROVIDES:glibc-langpack-dv:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-dz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dz-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dz}"
SRC_URI[aarch64_glibc-langpack-dz.sha256sum] = "0ca680a5c64add0cb0304a9bb00960f42f918f7869ea1586f9b204106056b14b"
RPROVIDES:glibc-langpack-dz:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-el = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-el-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-el;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-el}"
SRC_URI[aarch64_glibc-langpack-el.sha256sum] = "d40542698d84e5a9214e3a32d6f1364d6cb19a06763da87bedd3713d434ccbbf"
RPROVIDES:glibc-langpack-el:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-en = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-en-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-en;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-en}"
SRC_URI[aarch64_glibc-langpack-en.sha256sum] = "1e28834942175510e7a227cdbfc5039be545ce2de1bd17e6e91e363784b78021"
RPROVIDES:glibc-langpack-en:aarch64 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-eo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-eo-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-eo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-eo}"
SRC_URI[aarch64_glibc-langpack-eo.sha256sum] = "eb194d3f62c2549727be1aba7dcab745c6963a7abd04cd11a2fb4a6115e09025"
RPROVIDES:glibc-langpack-eo:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-es = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-es-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-es;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-es}"
SRC_URI[aarch64_glibc-langpack-es.sha256sum] = "877bc897c0cfcabc919bd3bbd28e8a5ee889b013e544d0f5eb18edc0d54bdc90"
RPROVIDES:glibc-langpack-es:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-et = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-et-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-et;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-et}"
SRC_URI[aarch64_glibc-langpack-et.sha256sum] = "a733bd7b980b2250b59660d644bbe4141f9711de8161fd8d0475b34ca05349f9"
RPROVIDES:glibc-langpack-et:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-eu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-eu-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-eu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-eu}"
SRC_URI[aarch64_glibc-langpack-eu.sha256sum] = "e0ec1d05eba6cb19badf2cf3af5a91127f07da5798cd099336bd222e3b7ab242"
RPROVIDES:glibc-langpack-eu:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-fa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fa-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fa}"
SRC_URI[aarch64_glibc-langpack-fa.sha256sum] = "5f0f36cd7012ce35c9f8ceeab958de3deb87c419a70fe4ea396df9c185bfa491"
RPROVIDES:glibc-langpack-fa:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ff = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ff-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ff;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ff}"
SRC_URI[aarch64_glibc-langpack-ff.sha256sum] = "4e02e899054b0f36763aacb8607bb5e3c8ede326017f24e0e1ea277445081754"
RPROVIDES:glibc-langpack-ff:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-fi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fi-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fi}"
SRC_URI[aarch64_glibc-langpack-fi.sha256sum] = "b343ae9ec5db7a765da069c53e91c40e495bbf882cf426951a372acae077183f"
RPROVIDES:glibc-langpack-fi:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-fil = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fil-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fil;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fil}"
SRC_URI[aarch64_glibc-langpack-fil.sha256sum] = "0dba53d5e170ecb670f1cff2b8c2831150fb2956a6e1dd08d196316b41ec962b"
RPROVIDES:glibc-langpack-fil:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-fo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fo-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fo}"
SRC_URI[aarch64_glibc-langpack-fo.sha256sum] = "54a6dc34d578b57874c338639878c7c7d2af2aebc1891c67166b1ea2d61438dd"
RPROVIDES:glibc-langpack-fo:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-fr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fr-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fr}"
SRC_URI[aarch64_glibc-langpack-fr.sha256sum] = "f8ae32cbe249ffb514203895911c16c56f38d5c480ea5202238c162ead127fce"
RPROVIDES:glibc-langpack-fr:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-fur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fur-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fur;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fur}"
SRC_URI[aarch64_glibc-langpack-fur.sha256sum] = "8c0ea68fff2a6b2daa698280a928ad0b19d4c681e99b74a612403ea4e6173fd2"
RPROVIDES:glibc-langpack-fur:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-fy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fy-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fy}"
SRC_URI[aarch64_glibc-langpack-fy.sha256sum] = "67bd870687aae56e26eef5aa9e83dfc10d4520a206259ebcdd63340e934a5081"
RPROVIDES:glibc-langpack-fy:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ga = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ga-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ga;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ga}"
SRC_URI[aarch64_glibc-langpack-ga.sha256sum] = "9eb43b14a4f81645c29fd8cc7e0d9fea9344f3ea206cb94446ec7c7ee2a4473b"
RPROVIDES:glibc-langpack-ga:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-gbm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gbm-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gbm}"
SRC_URI[aarch64_glibc-langpack-gbm.sha256sum] = "bcd01c649b48ce3c8e2280775031f954bb26a70a355fbdaae99c9beea96a0cf5"
RPROVIDES:glibc-langpack-gbm:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-gd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gd-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gd}"
SRC_URI[aarch64_glibc-langpack-gd.sha256sum] = "a99ab2f14f58e7360055fe9d9d81edf2aa6474c146e0ba6872864175d7a16a50"
RPROVIDES:glibc-langpack-gd:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-gez = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gez-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gez;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gez}"
SRC_URI[aarch64_glibc-langpack-gez.sha256sum] = "8edab739dc3043de20520dcff6bd5b4c3d3a158efecd1f438c9ca23a62362daa"
RPROVIDES:glibc-langpack-gez:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-gl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gl-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gl}"
SRC_URI[aarch64_glibc-langpack-gl.sha256sum] = "1cd13bf2649491c600a9f1a42e5a10b3ca244e12b2d799ad3cec44eb3b3ae3e8"
RPROVIDES:glibc-langpack-gl:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-gu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gu-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gu}"
SRC_URI[aarch64_glibc-langpack-gu.sha256sum] = "13bf6352e21f82476bf28d240064dacad00e1464cf0e1acfc8c26d6788271a57"
RPROVIDES:glibc-langpack-gu:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-gv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gv-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gv}"
SRC_URI[aarch64_glibc-langpack-gv.sha256sum] = "9f9fb4be9bbb9e596c1e6a9f604971a5836f9729d71ea1888a58e8a4708301a9"
RPROVIDES:glibc-langpack-gv:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ha = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ha-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ha;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ha}"
SRC_URI[aarch64_glibc-langpack-ha.sha256sum] = "9f609cf3f26b97b22a17c6ce0982bb323d38e8fd71aea86a6bfef49c14ecad3d"
RPROVIDES:glibc-langpack-ha:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-hak = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hak-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hak;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hak}"
SRC_URI[aarch64_glibc-langpack-hak.sha256sum] = "6d09b833297cd295b4bdd8a15d07e5589b51a290f482b8fb0603e925cc26f557"
RPROVIDES:glibc-langpack-hak:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-he = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-he-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-he;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-he}"
SRC_URI[aarch64_glibc-langpack-he.sha256sum] = "5289703d9429a6e1bedca60a389042688a85392631c9b9d09366c9d0d2b71355"
RPROVIDES:glibc-langpack-he:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-hi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hi-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hi}"
SRC_URI[aarch64_glibc-langpack-hi.sha256sum] = "4befb20bcf47a131ab63acfe861e3346d1c89a607038b7f93d520194d403d43d"
RPROVIDES:glibc-langpack-hi:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-hif = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hif-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hif;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hif}"
SRC_URI[aarch64_glibc-langpack-hif.sha256sum] = "1e5f50dce25fa5d1c183172fa5c85b628641c9978943b0218b05abf14ff39f97"
RPROVIDES:glibc-langpack-hif:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-hne = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hne-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hne;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hne}"
SRC_URI[aarch64_glibc-langpack-hne.sha256sum] = "bd3f0c8ccd0dfaf72bbb1adf933875e4be2519253df7df546748df02b8d4181d"
RPROVIDES:glibc-langpack-hne:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-hr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hr-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hr}"
SRC_URI[aarch64_glibc-langpack-hr.sha256sum] = "d432b5744af98bcfcebc505fad9875d863adcc0e8ff762e1d7420547234fc3d1"
RPROVIDES:glibc-langpack-hr:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-hsb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hsb-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hsb}"
SRC_URI[aarch64_glibc-langpack-hsb.sha256sum] = "cdd41d4e6195d147a0c531be83dd01ef2087d28939a83533679da8cfa11a247a"
RPROVIDES:glibc-langpack-hsb:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ht = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ht-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ht;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ht}"
SRC_URI[aarch64_glibc-langpack-ht.sha256sum] = "f30aab2b972a68612d95a6fc0903c4c23fccac99107f6aa15ad67c2087241dd6"
RPROVIDES:glibc-langpack-ht:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-hu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hu-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hu}"
SRC_URI[aarch64_glibc-langpack-hu.sha256sum] = "82d769296f37dc1907ff04c6483c22fce1403d1df649584f36f997cb247b693c"
RPROVIDES:glibc-langpack-hu:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-hy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hy-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hy}"
SRC_URI[aarch64_glibc-langpack-hy.sha256sum] = "b7be20e938e441259e56b0927cbcf3928520a98b29c59a4f92c12db568a28ce7"
RPROVIDES:glibc-langpack-hy:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ia = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ia-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ia;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ia}"
SRC_URI[aarch64_glibc-langpack-ia.sha256sum] = "6a0addce298ab05217f66fccb91872139962224dfa54f808d9b43b041c9a7a08"
RPROVIDES:glibc-langpack-ia:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-id = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-id-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-id;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-id}"
SRC_URI[aarch64_glibc-langpack-id.sha256sum] = "f8f01a579b7f90542567b7e08c6fc0f0b7bf12df4ef484a9f37d403dd67f960a"
RPROVIDES:glibc-langpack-id:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ig-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ig;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ig}"
SRC_URI[aarch64_glibc-langpack-ig.sha256sum] = "c4b2d9180245bf14085ec7c9fe10e2922cc7ea279efade1b30b67590050f32be"
RPROVIDES:glibc-langpack-ig:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ik = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ik-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ik;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ik}"
SRC_URI[aarch64_glibc-langpack-ik.sha256sum] = "0c06c06bb02649370c73e713066979284d8c9828b99b0895ffbd3d14418545f1"
RPROVIDES:glibc-langpack-ik:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-is = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-is-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-is;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-is}"
SRC_URI[aarch64_glibc-langpack-is.sha256sum] = "5352f76f9d5710640c3a445f3dfd1824f87b99207b38391a6081fb9e2dfd94aa"
RPROVIDES:glibc-langpack-is:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-it = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-it-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-it;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-it}"
SRC_URI[aarch64_glibc-langpack-it.sha256sum] = "88b28d51ff8626295bf0b1114bd6def15414f0e6c0b2538d856d614aff6c133d"
RPROVIDES:glibc-langpack-it:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-iu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-iu-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-iu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-iu}"
SRC_URI[aarch64_glibc-langpack-iu.sha256sum] = "605ba876bc1c1e0101dfedbc29a22caf862c4a0c453c3be830c06f6f3c164cf4"
RPROVIDES:glibc-langpack-iu:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ja = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ja-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ja;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ja}"
SRC_URI[aarch64_glibc-langpack-ja.sha256sum] = "1f1e6117678d97688c53707f87b251dfe0fa3f79bbdd67027d8814af0051a67e"
RPROVIDES:glibc-langpack-ja:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ka = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ka-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ka;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ka}"
SRC_URI[aarch64_glibc-langpack-ka.sha256sum] = "e250187dc5fd3d1294846f3d801b23777947762666f6c697be91a0e3457c862b"
RPROVIDES:glibc-langpack-ka:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-kab = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kab-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kab;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kab}"
SRC_URI[aarch64_glibc-langpack-kab.sha256sum] = "c6d592378f373f97e6acc0e2d986eb43609e9bab7bd24ebeb5bdd8514b5be3fd"
RPROVIDES:glibc-langpack-kab:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-kk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kk-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kk}"
SRC_URI[aarch64_glibc-langpack-kk.sha256sum] = "a4e8aacc8e1bfddf6347c0215fe704e2558dc82e8a8398e0536d7b5fc2d2c404"
RPROVIDES:glibc-langpack-kk:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-kl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kl-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kl}"
SRC_URI[aarch64_glibc-langpack-kl.sha256sum] = "4ed936a03a01e7dca62415f38a3d6aaba0741bc13e04f29b26df943322d6d98c"
RPROVIDES:glibc-langpack-kl:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-km = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-km-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-km;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-km}"
SRC_URI[aarch64_glibc-langpack-km.sha256sum] = "cbf162d427a5b35e2f92d7eee481d57f487569bd330a8b9f60d5ee560f5fa95d"
RPROVIDES:glibc-langpack-km:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-kn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kn-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kn}"
SRC_URI[aarch64_glibc-langpack-kn.sha256sum] = "ca5aa6cbaa9004ca88395d58baf33f1391c0fb3a060778e449af013470f0efc2"
RPROVIDES:glibc-langpack-kn:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ko = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ko-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ko;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ko}"
SRC_URI[aarch64_glibc-langpack-ko.sha256sum] = "36d5c0e26a33e5a149a8c4ee83cfd7b12a5e708fff59bec84a110bb7725793d7"
RPROVIDES:glibc-langpack-ko:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-kok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kok-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kok;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kok}"
SRC_URI[aarch64_glibc-langpack-kok.sha256sum] = "64085572d9d61317681748242134a0272011342d46a207e129dc708182994603"
RPROVIDES:glibc-langpack-kok:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ks = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ks-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ks;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ks}"
SRC_URI[aarch64_glibc-langpack-ks.sha256sum] = "a9e21644f7657b9b145b8c8130c093744bf8966b8f7d1b74d6d9950789644bc1"
RPROVIDES:glibc-langpack-ks:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ku = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ku-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ku;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ku}"
SRC_URI[aarch64_glibc-langpack-ku.sha256sum] = "5b0378fe4ab419b84416bd6a1e7987ddedc9b20bbe75c3170e83f67ad8bab025"
RPROVIDES:glibc-langpack-ku:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-kv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kv-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kv}"
SRC_URI[aarch64_glibc-langpack-kv.sha256sum] = "d66f9a41be2ffad8cec01473b90fb93707c3903d5f89a83e5fb09c7cdc201c4f"
RPROVIDES:glibc-langpack-kv:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-kw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kw-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kw}"
SRC_URI[aarch64_glibc-langpack-kw.sha256sum] = "516a6219f16fb656eca1d562cf2ce1dc203266d3f583827141256b8b0cc004b5"
RPROVIDES:glibc-langpack-kw:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ky = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ky-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ky;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ky}"
SRC_URI[aarch64_glibc-langpack-ky.sha256sum] = "d15907040eaaea4130cb99fe34a73cb73f1f393e1be218bc14d2634fae969107"
RPROVIDES:glibc-langpack-ky:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-lb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lb-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lb}"
SRC_URI[aarch64_glibc-langpack-lb.sha256sum] = "d7936d2f495153787576662d3572b0f1b8ce0f97019b584388c51368ad21e6df"
RPROVIDES:glibc-langpack-lb:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-lg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lg-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lg}"
SRC_URI[aarch64_glibc-langpack-lg.sha256sum] = "e1a88130ba897c8083b2af4b040463e94925a77acbb40add5ac3d96e48c4a4d1"
RPROVIDES:glibc-langpack-lg:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-li = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-li-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-li;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-li}"
SRC_URI[aarch64_glibc-langpack-li.sha256sum] = "522168ae7fcd88b25513a6ea8e9188408af72f1508183180505d83b09eeb8a39"
RPROVIDES:glibc-langpack-li:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-lij = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lij-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lij;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lij}"
SRC_URI[aarch64_glibc-langpack-lij.sha256sum] = "7c4e797af60f3b88c264e06c3bdd13e4d0f924f03f5e6e2d5f4fd2129fcd8263"
RPROVIDES:glibc-langpack-lij:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ln = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ln-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ln;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ln}"
SRC_URI[aarch64_glibc-langpack-ln.sha256sum] = "f4b57456649bfd255c82e88d47c8a2621a74aa82b7c14b47d543378e7a347311"
RPROVIDES:glibc-langpack-ln:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-lo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lo-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lo}"
SRC_URI[aarch64_glibc-langpack-lo.sha256sum] = "648a8e05eae884001658b6067496053cab6c978f94644b3b3779030568f28eb7"
RPROVIDES:glibc-langpack-lo:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-lt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lt-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lt}"
SRC_URI[aarch64_glibc-langpack-lt.sha256sum] = "416413a21f612c0ccf8a2c17fe122b82d961463e78071a2414924bf59f68864a"
RPROVIDES:glibc-langpack-lt:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-lv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lv-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lv}"
SRC_URI[aarch64_glibc-langpack-lv.sha256sum] = "cc5348cacc35465197b8fbfe874b550685a6a3a5911c7ffff849079234e32714"
RPROVIDES:glibc-langpack-lv:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-lzh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lzh-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lzh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lzh}"
SRC_URI[aarch64_glibc-langpack-lzh.sha256sum] = "505c69419393f352ae1ba3724d9d7e617f9e2046681524cce5ef134278252c2f"
RPROVIDES:glibc-langpack-lzh:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mag = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mag-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mag;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mag}"
SRC_URI[aarch64_glibc-langpack-mag.sha256sum] = "aa19beaeabb8ddb60433bd22966f103f363abef8985a42fc5d1273a8d922266e"
RPROVIDES:glibc-langpack-mag:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mai = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mai-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mai;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mai}"
SRC_URI[aarch64_glibc-langpack-mai.sha256sum] = "3dd0b5a14b7451eba7f873e70ad3b79fc1873c49f34f96bdb600d28372dfe540"
RPROVIDES:glibc-langpack-mai:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mfe = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mfe-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mfe;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mfe}"
SRC_URI[aarch64_glibc-langpack-mfe.sha256sum] = "0959b47b0392c5254123f00e889ecfac4d624cd4ba7517ae82bcd75eb2c1a186"
RPROVIDES:glibc-langpack-mfe:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mg-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mg}"
SRC_URI[aarch64_glibc-langpack-mg.sha256sum] = "08c0ec4fe7b90fc6a0ab8599a346efd1c40fa4cc54d5be8e431cf53c3b8e5b28"
RPROVIDES:glibc-langpack-mg:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mhr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mhr-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mhr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mhr}"
SRC_URI[aarch64_glibc-langpack-mhr.sha256sum] = "cc52fab85d7744c459727c43624235b205a0189f57e755e8e1576ebaa6545785"
RPROVIDES:glibc-langpack-mhr:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mi-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mi}"
SRC_URI[aarch64_glibc-langpack-mi.sha256sum] = "6bea4accfaa97b1fd449124dce9e4e121e829334144740911d2b073f88b4904e"
RPROVIDES:glibc-langpack-mi:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-miq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-miq-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-miq;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-miq}"
SRC_URI[aarch64_glibc-langpack-miq.sha256sum] = "aaf4188433445d7c75393ec799dd6aa71025a7db57379c1b0c5ffb3757aff7c3"
RPROVIDES:glibc-langpack-miq:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mjw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mjw-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mjw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mjw}"
SRC_URI[aarch64_glibc-langpack-mjw.sha256sum] = "8a6c623c177d082777b1e9ca8c1ed359ac0c3139a6c39be5e1ff9ff2b62b8482"
RPROVIDES:glibc-langpack-mjw:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mk-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mk}"
SRC_URI[aarch64_glibc-langpack-mk.sha256sum] = "4f60402ef996701810117993591090d06edfabb605b1ead962341e3451bcd5e3"
RPROVIDES:glibc-langpack-mk:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ml = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ml-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ml;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ml}"
SRC_URI[aarch64_glibc-langpack-ml.sha256sum] = "b60d3b63da0b44e3f54fc4c1610ea9ea3e8785935f1a74ad13af183e568965d1"
RPROVIDES:glibc-langpack-ml:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mn-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mn}"
SRC_URI[aarch64_glibc-langpack-mn.sha256sum] = "77adaee684f0c546d4fd329e4bfb9301bcadd8f6963907f94f2f11158ab71d01"
RPROVIDES:glibc-langpack-mn:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mni = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mni-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mni;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mni}"
SRC_URI[aarch64_glibc-langpack-mni.sha256sum] = "878b85842b0be3321d9ec852a79308ca9e4f318f6935e193ff76cdf80e1d36ed"
RPROVIDES:glibc-langpack-mni:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mnw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mnw-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mnw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mnw}"
SRC_URI[aarch64_glibc-langpack-mnw.sha256sum] = "36342e083e2f94e14d8ce79bae44767711d38f5349121270853ff16fb52377c9"
RPROVIDES:glibc-langpack-mnw:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mr-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mr}"
SRC_URI[aarch64_glibc-langpack-mr.sha256sum] = "fdc834e78a75bd1a8fbf7956da6380328f26ca813ab68b06d5589d8f98998af4"
RPROVIDES:glibc-langpack-mr:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ms = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ms-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ms;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ms}"
SRC_URI[aarch64_glibc-langpack-ms.sha256sum] = "238167a8e603056c56fab00744704fcbfc501d872ba116c39af4adc1c0b1e800"
RPROVIDES:glibc-langpack-ms:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-mt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mt-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mt}"
SRC_URI[aarch64_glibc-langpack-mt.sha256sum] = "1dbbaf2cee67a0250e827a12235a48ddaccca3033e9f8357fdb1225e09081266"
RPROVIDES:glibc-langpack-mt:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-my = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-my-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-my;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-my}"
SRC_URI[aarch64_glibc-langpack-my.sha256sum] = "4e57623165c66fcef4d255394b59dd2411d130611cfa2c44f670270ebf79faa4"
RPROVIDES:glibc-langpack-my:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-nan = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nan-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nan;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nan}"
SRC_URI[aarch64_glibc-langpack-nan.sha256sum] = "7f9ac383e39e485cf9048da4872cffaeade7288d3cd47d226dc1bea99e7cc6af"
RPROVIDES:glibc-langpack-nan:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-nb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nb-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nb}"
SRC_URI[aarch64_glibc-langpack-nb.sha256sum] = "fe0c4319c4032eb81ec0703c23a181de7362d3af42f9a252df2533de2367956b"
RPROVIDES:glibc-langpack-nb:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-nds = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nds-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nds;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nds}"
SRC_URI[aarch64_glibc-langpack-nds.sha256sum] = "0a6460364c05ca8f65b7b80828a47cd710087568be91b418f84d32f33182a1c8"
RPROVIDES:glibc-langpack-nds:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ne = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ne-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ne;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ne}"
SRC_URI[aarch64_glibc-langpack-ne.sha256sum] = "6b6c4e3cab7aebb18cc1e989258049a7967cc297dd579f3347e446db29216270"
RPROVIDES:glibc-langpack-ne:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-nhn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nhn-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nhn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nhn}"
SRC_URI[aarch64_glibc-langpack-nhn.sha256sum] = "f1888504aa952724fbc4f26aea3e387bbc674c083656e2ec33a4890c2f107425"
RPROVIDES:glibc-langpack-nhn:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-niu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-niu-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-niu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-niu}"
SRC_URI[aarch64_glibc-langpack-niu.sha256sum] = "feb8bcb2ce770f898a333306cdcbc12baef17aac1c475880eca7c3bf1e37e0ed"
RPROVIDES:glibc-langpack-niu:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-nl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nl-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nl}"
SRC_URI[aarch64_glibc-langpack-nl.sha256sum] = "3b7a940b223c3d0c42a206f6b0f6fb0eaf398fab996acbfaa0f85679696d3263"
RPROVIDES:glibc-langpack-nl:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-nn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nn-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nn}"
SRC_URI[aarch64_glibc-langpack-nn.sha256sum] = "ed6eaa2794a6aceb583eff771b80b7e1291d905092e51e7d6d269cabef647495"
RPROVIDES:glibc-langpack-nn:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-nr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nr-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nr}"
SRC_URI[aarch64_glibc-langpack-nr.sha256sum] = "8d518a19a1a4d2a3f771184ee4a2e14476b4632fe400e1ca3d915306bcd8c073"
RPROVIDES:glibc-langpack-nr:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-nso = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nso-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nso;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nso}"
SRC_URI[aarch64_glibc-langpack-nso.sha256sum] = "437d1ef55433fa50bdc95f6b283081585b0bcaea4999e304d5dc79ae9245f6ff"
RPROVIDES:glibc-langpack-nso:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-oc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-oc-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-oc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-oc}"
SRC_URI[aarch64_glibc-langpack-oc.sha256sum] = "3b5fecc1b1fd204476dc18ace18f1bebe4e7d64da442615b124126a526a6310f"
RPROVIDES:glibc-langpack-oc:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-om = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-om-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-om;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-om}"
SRC_URI[aarch64_glibc-langpack-om.sha256sum] = "aaba6ff0a5e759efd1a8d5d1a1a1be08719452fbf49de34626ab78c1586f3f6f"
RPROVIDES:glibc-langpack-om:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-or = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-or-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-or;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-or}"
SRC_URI[aarch64_glibc-langpack-or.sha256sum] = "fbcd6d608672fb484be4ff6bd6a58d39aa8a035124ef52b71681cfaead7ca8cf"
RPROVIDES:glibc-langpack-or:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-os = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-os-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-os;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-os}"
SRC_URI[aarch64_glibc-langpack-os.sha256sum] = "4e30a0fd64377c2eef4508dfa6924e2bb94115805d4d12b833ae77771278fdba"
RPROVIDES:glibc-langpack-os:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-pa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pa-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pa}"
SRC_URI[aarch64_glibc-langpack-pa.sha256sum] = "db0b3edcc5395ec8b7960ed568277d008e098bb93ee78e394bc932719727b7ef"
RPROVIDES:glibc-langpack-pa:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-pap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pap-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pap;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pap}"
SRC_URI[aarch64_glibc-langpack-pap.sha256sum] = "81a990ade2efaad3379bc0ea1feff4c29eef0f0ee03ce21c9c5a8d91a110f433"
RPROVIDES:glibc-langpack-pap:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-pl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pl-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pl}"
SRC_URI[aarch64_glibc-langpack-pl.sha256sum] = "119e3ab73756419d6a8ed6771b8cee1206de7502105774c9d4ea03de1301f8a3"
RPROVIDES:glibc-langpack-pl:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ps = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ps-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ps;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ps}"
SRC_URI[aarch64_glibc-langpack-ps.sha256sum] = "af1a787287ef6ba5f80ad78b5451769365075aac0f16271473400eadb6ee58a0"
RPROVIDES:glibc-langpack-ps:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-pt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pt-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pt}"
SRC_URI[aarch64_glibc-langpack-pt.sha256sum] = "1277b45df57a5c49c0c47041817260f10651544ba036b61d0096c4d3e718f335"
RPROVIDES:glibc-langpack-pt:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-quz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-quz-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-quz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-quz}"
SRC_URI[aarch64_glibc-langpack-quz.sha256sum] = "ec2b48736d7651eb0a98585f4a583566de8e8f053f84289c31a65f52fd18e699"
RPROVIDES:glibc-langpack-quz:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-raj = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-raj-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-raj;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-raj}"
SRC_URI[aarch64_glibc-langpack-raj.sha256sum] = "7b766b38e252bc20042a02e655f0ef68108bf2fb951f9a92cda85584725c1606"
RPROVIDES:glibc-langpack-raj:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-rif = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-rif-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-rif;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-rif}"
SRC_URI[aarch64_glibc-langpack-rif.sha256sum] = "5d96e828f5cb2ca275a17e31b35dc0989555f0efe638ed42ba0cbcad4f6fb156"
RPROVIDES:glibc-langpack-rif:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ro = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ro-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ro;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ro}"
SRC_URI[aarch64_glibc-langpack-ro.sha256sum] = "8c02c5c8527d12f6390ae4bf753251eb92fad16fb96a8cb03febc03baaaf6713"
RPROVIDES:glibc-langpack-ro:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ru = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ru-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ru;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ru}"
SRC_URI[aarch64_glibc-langpack-ru.sha256sum] = "554ef63bc3c132421e371f2fce8649037d0933646f2da4270645f24e79d67aa5"
RPROVIDES:glibc-langpack-ru:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-rw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-rw-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-rw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-rw}"
SRC_URI[aarch64_glibc-langpack-rw.sha256sum] = "eeb59d530fa685300e6873c78810db4e47a64eee4bb5da0e66dfbf70c7aeea69"
RPROVIDES:glibc-langpack-rw:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sa-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sa}"
SRC_URI[aarch64_glibc-langpack-sa.sha256sum] = "f0b98e0a9566e4a1edcea9289f81c50bee21e8eacd7cd233cf3bb57a9dcf742a"
RPROVIDES:glibc-langpack-sa:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sah = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sah-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sah;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sah}"
SRC_URI[aarch64_glibc-langpack-sah.sha256sum] = "95aa52e51d1a39485f702723b57ba924f0bbe86ff903ca662dd72a410dac2d03"
RPROVIDES:glibc-langpack-sah:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sat-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sat;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sat}"
SRC_URI[aarch64_glibc-langpack-sat.sha256sum] = "cd2b12e0451e00040bb9850577c0b683ddee466008cbf70b81fd548ca7f41297"
RPROVIDES:glibc-langpack-sat:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sc-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sc}"
SRC_URI[aarch64_glibc-langpack-sc.sha256sum] = "138ea5f3505f3ce95d6d1f0a9fd961857dddfdd5fa75eebcdcb102bcb7c01dc1"
RPROVIDES:glibc-langpack-sc:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sd-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sd;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sd}"
SRC_URI[aarch64_glibc-langpack-sd.sha256sum] = "4e0d9eaf9ae84fdfe9c4fdd10ae78a71ed23a917fd7155a59d0fe849663bda5b"
RPROVIDES:glibc-langpack-sd:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-se = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-se-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-se;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-se}"
SRC_URI[aarch64_glibc-langpack-se.sha256sum] = "f7666ecf23b253ce2fb9923acb0f8853127028c921540a1bf56e1bcf92769404"
RPROVIDES:glibc-langpack-se:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sgs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sgs-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sgs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sgs}"
SRC_URI[aarch64_glibc-langpack-sgs.sha256sum] = "260950e9d481a033e0634e9980950b03e6f9ddd54a25590f7e11bcef813ae2d2"
RPROVIDES:glibc-langpack-sgs:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-shn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-shn-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-shn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-shn}"
SRC_URI[aarch64_glibc-langpack-shn.sha256sum] = "b0a0f2fa679181c3de7dd840cbdf4418abc710d0b8ecb97dd9696db2855615b0"
RPROVIDES:glibc-langpack-shn:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-shs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-shs-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-shs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-shs}"
SRC_URI[aarch64_glibc-langpack-shs.sha256sum] = "53345941887fa3de4dd4ac85e211786b7a8341e056e7f4c5921f9d7900403919"
RPROVIDES:glibc-langpack-shs:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-si = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-si-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-si;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-si}"
SRC_URI[aarch64_glibc-langpack-si.sha256sum] = "33b2b704acf241d653c1add7ab3693d07fcc357334e2f8fb29e51d669bd31bf2"
RPROVIDES:glibc-langpack-si:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sid-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sid;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sid}"
SRC_URI[aarch64_glibc-langpack-sid.sha256sum] = "ead090ba3b2945f1110d3c0b8a640752bb4e03d4edc9100e6c961f6de28874f9"
RPROVIDES:glibc-langpack-sid:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sk-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sk}"
SRC_URI[aarch64_glibc-langpack-sk.sha256sum] = "140cb6dfeffbb3beef692df8b2719da2c76b6d0e0a2b56a4a05f24ed2524f85f"
RPROVIDES:glibc-langpack-sk:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sl-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sl}"
SRC_URI[aarch64_glibc-langpack-sl.sha256sum] = "028e8c5da0317c8411b35ec891141be2f3e87e9edec01be21bb05f65210c4b10"
RPROVIDES:glibc-langpack-sl:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sm-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sm}"
SRC_URI[aarch64_glibc-langpack-sm.sha256sum] = "e8380861136dcebfd79935dfed39af80a7664d2f01f2e8d36be89ac23922eeef"
RPROVIDES:glibc-langpack-sm:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-so = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-so-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-so;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-so}"
SRC_URI[aarch64_glibc-langpack-so.sha256sum] = "7253cb2241c9d59c3fb978954ce329c2943c39eab78bdfea0b3ebe1141776e95"
RPROVIDES:glibc-langpack-so:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sq-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sq;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sq}"
SRC_URI[aarch64_glibc-langpack-sq.sha256sum] = "616df91162a93c581f8d7f54f19b22dd551da53cd04f085b4afa1d73f31f4ac1"
RPROVIDES:glibc-langpack-sq:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sr-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sr}"
SRC_URI[aarch64_glibc-langpack-sr.sha256sum] = "58295a6019c5e5765d36b7528d01cdda4d30bbd5207734e5fe457866dc61cf56"
RPROVIDES:glibc-langpack-sr:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ss-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ss;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ss}"
SRC_URI[aarch64_glibc-langpack-ss.sha256sum] = "9cc3660c1011394de432fea740a44b4bcb2adfc55707d7f68ec85fbdd8773172"
RPROVIDES:glibc-langpack-ss:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ssy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ssy-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ssy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ssy}"
SRC_URI[aarch64_glibc-langpack-ssy.sha256sum] = "9998e774b2f0a3954080d1009f059b9ccaf30d7ae8417a1ea3bb6cf1703b90bf"
RPROVIDES:glibc-langpack-ssy:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-st = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-st-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-st;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-st}"
SRC_URI[aarch64_glibc-langpack-st.sha256sum] = "5276dc7ca892b5bb6360286657ab8e535e0986745eef91efd2206c518b5b15db"
RPROVIDES:glibc-langpack-st:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-su = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-su-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-su;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-su}"
SRC_URI[aarch64_glibc-langpack-su.sha256sum] = "31a1d32204eb392db5bcc591537f951c3598819b99391f42d569ac8876cc22ba"
RPROVIDES:glibc-langpack-su:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sv-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sv}"
SRC_URI[aarch64_glibc-langpack-sv.sha256sum] = "7f304ace673f6412f410ae12d8b27df6e4c0af7d4253f72204aabec51bb9d5e6"
RPROVIDES:glibc-langpack-sv:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-sw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sw-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sw}"
SRC_URI[aarch64_glibc-langpack-sw.sha256sum] = "d130b04fbd89393137cc19dcefeab13b2ee3d940767174e8770f13a57df2a23c"
RPROVIDES:glibc-langpack-sw:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-syr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-syr-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-syr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-syr}"
SRC_URI[aarch64_glibc-langpack-syr.sha256sum] = "b57dbebcdd105f8609b7410cb44f09d4504a22ada5fc67f823b79533e6fcc2b8"
RPROVIDES:glibc-langpack-syr:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-szl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-szl-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-szl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-szl}"
SRC_URI[aarch64_glibc-langpack-szl.sha256sum] = "75c20f05da8f88d6aef77cbefed95ed00d3346b8524a45be00e0eeef712b2365"
RPROVIDES:glibc-langpack-szl:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ta = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ta-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ta;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ta}"
SRC_URI[aarch64_glibc-langpack-ta.sha256sum] = "94f4b6cb99e36ba863bb4eae7f62f5f21cfffdfac589a82aed80f79b1bdeb281"
RPROVIDES:glibc-langpack-ta:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-tcy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tcy-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tcy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tcy}"
SRC_URI[aarch64_glibc-langpack-tcy.sha256sum] = "e4fe6c50952fd704b6e1c9062dc191283f261806fcb81ba93ef3ef1c5c6d3c63"
RPROVIDES:glibc-langpack-tcy:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-te = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-te-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-te;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-te}"
SRC_URI[aarch64_glibc-langpack-te.sha256sum] = "f5dcd285c139b00ef7562f005c8401d7e4dbf92f7c2597cf878346d912c25227"
RPROVIDES:glibc-langpack-te:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-tg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tg-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tg}"
SRC_URI[aarch64_glibc-langpack-tg.sha256sum] = "7e137dce63a310a2244951c75ea4d3ae705a46bb0521b8a10099a0dad33cbc4d"
RPROVIDES:glibc-langpack-tg:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-th = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-th-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-th}"
SRC_URI[aarch64_glibc-langpack-th.sha256sum] = "3e67ae9b725501038139f490932ce84fe7a9aefc869a42c5e6bdd9fa43e1b63e"
RPROVIDES:glibc-langpack-th:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-the = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-the-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-the;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-the}"
SRC_URI[aarch64_glibc-langpack-the.sha256sum] = "bc588871b815cb2a2f8f9c2a02e95dc9258714dc46a04fca62be96121cf8db0e"
RPROVIDES:glibc-langpack-the:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ti = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ti-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ti;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ti}"
SRC_URI[aarch64_glibc-langpack-ti.sha256sum] = "03cee9c5a3efda1e8151896de22315334eb6c4a9095763ed1dd6d888390c8dfd"
RPROVIDES:glibc-langpack-ti:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-tig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tig-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tig;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tig}"
SRC_URI[aarch64_glibc-langpack-tig.sha256sum] = "314fa141f517aff6c799deb0c1d1f9e20b85725635529011f9ea05b78ad93ceb"
RPROVIDES:glibc-langpack-tig:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-tk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tk-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tk}"
SRC_URI[aarch64_glibc-langpack-tk.sha256sum] = "fafa093236a310b8c43a681e3d309411314c6343b887e92c853c2fc3af4d1b07"
RPROVIDES:glibc-langpack-tk:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-tl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tl-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tl}"
SRC_URI[aarch64_glibc-langpack-tl.sha256sum] = "65a44b1b0b5b1b2565a774eec8f0e287676709c05a9b387f6bdfde658a739144"
RPROVIDES:glibc-langpack-tl:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-tn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tn-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tn}"
SRC_URI[aarch64_glibc-langpack-tn.sha256sum] = "623eca3c7033e192a797dd3c2b299f22217f9ed0cf6e156102093ccbe6db94c8"
RPROVIDES:glibc-langpack-tn:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-to = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-to-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-to;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-to}"
SRC_URI[aarch64_glibc-langpack-to.sha256sum] = "10e823dc43d8f2abfe8d4018ff5f79bcfbebb728036ada06555674195099fb9c"
RPROVIDES:glibc-langpack-to:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-tok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tok-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tok;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tok}"
SRC_URI[aarch64_glibc-langpack-tok.sha256sum] = "f9be529f58927006a1e4238692765824d58a68798894def88faaf39fdef796b7"
RPROVIDES:glibc-langpack-tok:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-tpi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tpi-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tpi}"
SRC_URI[aarch64_glibc-langpack-tpi.sha256sum] = "94685c481355d872f50830be60652c5848353756faa60eb6010ea5ddef8f8a43"
RPROVIDES:glibc-langpack-tpi:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-tr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tr-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tr}"
SRC_URI[aarch64_glibc-langpack-tr.sha256sum] = "8550d339be25593eb0b7e73f85651cdf900018037c7cf1b96db6d217ff8d77e9"
RPROVIDES:glibc-langpack-tr:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ts-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ts;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ts}"
SRC_URI[aarch64_glibc-langpack-ts.sha256sum] = "f5cfdb64860d28ef0c2983007c9196f6949bcee7931d3d37e8b3f06c64fc5028"
RPROVIDES:glibc-langpack-ts:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-tt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tt-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tt}"
SRC_URI[aarch64_glibc-langpack-tt.sha256sum] = "3bde264e29930d2ec02581c9b492840f19718e6dfedbce933ddc79f41b8e480e"
RPROVIDES:glibc-langpack-tt:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ug-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ug;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ug}"
SRC_URI[aarch64_glibc-langpack-ug.sha256sum] = "e081823e8c28becbad4c5331eb6eab046f1f3a316fbb9daed02ee68f4c4d97ee"
RPROVIDES:glibc-langpack-ug:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-uk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-uk-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-uk}"
SRC_URI[aarch64_glibc-langpack-uk.sha256sum] = "9bd21da4c0fee78a445b0238c1a52f4893fcddf20de32d3689b28e9c05efb479"
RPROVIDES:glibc-langpack-uk:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-unm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-unm-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-unm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-unm}"
SRC_URI[aarch64_glibc-langpack-unm.sha256sum] = "cee209bbc914d1f5870186590b34882af852c0e80ec1d1d6620a36c62a380ba9"
RPROVIDES:glibc-langpack-unm:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ur-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ur;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ur}"
SRC_URI[aarch64_glibc-langpack-ur.sha256sum] = "e644a0ca199aa07764c11a76b18adfda7124f01789bc57a88f4da24af987074c"
RPROVIDES:glibc-langpack-ur:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-uz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-uz-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-uz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-uz}"
SRC_URI[aarch64_glibc-langpack-uz.sha256sum] = "945e5a52662feabdd046c0447a478f1dde032b9501966b8b04eb723a47db1ab4"
RPROVIDES:glibc-langpack-uz:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-ve = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ve-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ve;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ve}"
SRC_URI[aarch64_glibc-langpack-ve.sha256sum] = "13d3cdcfb15112d7a99cfc8e31dfb18f0a862da3688ecc0073401ac78b0222d1"
RPROVIDES:glibc-langpack-ve:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-vi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-vi-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-vi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-vi}"
SRC_URI[aarch64_glibc-langpack-vi.sha256sum] = "580ffa91ce978df54aa58c6f55f775950d8afb57566c27a720514b9941d9c707"
RPROVIDES:glibc-langpack-vi:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-wa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wa-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wa}"
SRC_URI[aarch64_glibc-langpack-wa.sha256sum] = "9fe2c80bdbe87e62736ff13f9ce4826d30cd838f452c1a92eb5ba7c35dda2994"
RPROVIDES:glibc-langpack-wa:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-wae = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wae-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wae;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wae}"
SRC_URI[aarch64_glibc-langpack-wae.sha256sum] = "c8d495ecf6d8ecf48f8c02f3a6a00fc507aad4cc9b70e4ce266f3c0da43f2f34"
RPROVIDES:glibc-langpack-wae:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-wal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wal-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wal;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wal}"
SRC_URI[aarch64_glibc-langpack-wal.sha256sum] = "8f3a672d87d9607232376fae7eef7030e2b891a269d94b97f11b33c6b306a9a3"
RPROVIDES:glibc-langpack-wal:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-wo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wo-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wo}"
SRC_URI[aarch64_glibc-langpack-wo.sha256sum] = "65a351a09b9bea067ec646767aa8867a8f02f3cd925f1c2d2ff7f6acb583ebe2"
RPROVIDES:glibc-langpack-wo:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-xh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-xh-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-xh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-xh}"
SRC_URI[aarch64_glibc-langpack-xh.sha256sum] = "454640894fbf4d7bc8a6a8c3124ed956454efa507cdc0e1e52facea2eff711fc"
RPROVIDES:glibc-langpack-xh:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-yi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yi-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yi}"
SRC_URI[aarch64_glibc-langpack-yi.sha256sum] = "64648a11851112b4d3eac69ba0755b1fcfc16579539a77f8912e42468e0e9b0e"
RPROVIDES:glibc-langpack-yi:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-yo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yo-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yo}"
SRC_URI[aarch64_glibc-langpack-yo.sha256sum] = "7733d23f54bfc62e7664b29970d83999de55bdcfa0cbc5ea408efcb6be25d2f5"
RPROVIDES:glibc-langpack-yo:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-yue = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yue-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yue;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yue}"
SRC_URI[aarch64_glibc-langpack-yue.sha256sum] = "2ea553b106ee25c3ab74201b00914b30b75630b882c9fb99798e331b4a309443"
RPROVIDES:glibc-langpack-yue:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-yuw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yuw-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yuw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yuw}"
SRC_URI[aarch64_glibc-langpack-yuw.sha256sum] = "0bee527a39f855b8a12f26d307ed2d7b9bf557a509cf489f1773558327dd724b"
RPROVIDES:glibc-langpack-yuw:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-zgh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zgh-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zgh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zgh}"
SRC_URI[aarch64_glibc-langpack-zgh.sha256sum] = "3f2d5637c1b68018fd90824d325ef33b46f92400f0abd461b720959c1aeb2981"
RPROVIDES:glibc-langpack-zgh:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-zh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zh-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zh}"
SRC_URI[aarch64_glibc-langpack-zh.sha256sum] = "ac772b02bc9edd81d7d93adb3980e75e84ee30b9a255dcf634514d21d8655a5b"
RPROVIDES:glibc-langpack-zh:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-langpack-zu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zu-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zu}"
SRC_URI[aarch64_glibc-langpack-zu.sha256sum] = "309a2e38e38c89b5f5393a69bc62ac4bf3c552b01fa3adde00f076d9100c5dc9"
RPROVIDES:glibc-langpack-zu:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-locale-source = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-locale-source-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-locale-source;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-locale-source}"
SRC_URI[aarch64_glibc-locale-source.sha256sum] = "690ff0de21f7ed6c808455051c799287146ea800ce376bea249223997999435e"

URI_aarch64_glibc-minimal-langpack = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-minimal-langpack-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-minimal-langpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-minimal-langpack}"
SRC_URI[aarch64_glibc-minimal-langpack.sha256sum] = "42ed70244a128d3590ea166d8e1267947e1f66fb0a0f515c7cf1bdf7ae12c115"
RPROVIDES:glibc-minimal-langpack:aarch64 = "virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

URI_aarch64_glibc-nss-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-nss-devel-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-nss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-nss-devel}"
SRC_URI[aarch64_glibc-nss-devel.sha256sum] = "043e55f101c01b0d1d03b8ea87b837099736fee532b04009e4df7a8a2d08a937"

URI_aarch64_glibc-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-static-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-static}"
SRC_URI[aarch64_glibc-static.sha256sum] = "89633b34c56676e1f18d2d52bca93897386d46e5ebbd732d7ebc39143eac9104"

URI_aarch64_glibc-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-utils-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_glibc-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-utils}"
SRC_URI[aarch64_glibc-utils.sha256sum] = "300475e21f5bc60f0bc15d94497acb01deca1d4c0490dcadd6bfb7206125ddb5"

URI_aarch64_libnsl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnsl-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_libnsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnsl}"
SRC_URI[aarch64_libnsl.sha256sum] = "5a6cb8fb573de1a64b66b52ceff850786fdea41e16e3e5b2eb08ae947a029f2d"

URI_aarch64_nss_db = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nss_db-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_nss_db;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss_db}"
SRC_URI[aarch64_nss_db.sha256sum] = "5cec9fde4f3bbec20b52788f3828f7828d502516be5860bcd63cbe316bd02835"

URI_aarch64_nss_hesiod = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nss_hesiod-2.39-46.el10_0.4.alma.1.aarch64.rpm;name=aarch64_nss_hesiod;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss_hesiod}"
SRC_URI[aarch64_nss_hesiod.sha256sum] = "6931ec29993c7d34f6659b22f24283bc148b5348dbc319ed568ac17c96f434be"

RDEPENDS:glibc = " \
 basesystem \
 glibc-common \
 glibc-gconv-extra \
 libgcc \
 virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1 \
 "
RDEPENDS:glibc-all-langpacks = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-benchtests = " \
 bash \
 glibc \
 python3 \
 "
RDEPENDS:glibc-common = " \
 bash \
 glibc \
 "
RDEPENDS:glibc-devel = " \
 glibc \
 kernel-headers \
 libxcrypt-devel \
 "
RDEPENDS:glibc-doc = " \
 glibc \
 "
RDEPENDS:glibc-gconv-extra = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-aa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-af = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-agr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ak = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-am = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-an = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-anp = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ar = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-as = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ast = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ayc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-az = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-be = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bem = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ber = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bhb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bho = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-br = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-brx = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-byn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ca = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ce = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-chr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ckb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cmn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-crh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-csb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-da = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-de = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-doi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dsb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-el = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-en = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-eo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-es = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-et = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-eu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ff = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fil = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fur = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ga = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gbm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gd = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gez = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ha = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hak = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-he = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hif = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hne = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hsb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ht = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ia = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-id = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ig = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ik = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-is = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-it = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-iu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ja = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ka = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kab = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-km = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ko = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kok = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ks = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ku = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ky = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-li = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lij = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ln = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lzh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mag = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mai = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mfe = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mhr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-miq = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mjw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ml = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mni = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mnw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ms = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-my = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nan = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nds = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ne = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nhn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-niu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nso = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-oc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-om = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-or = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-os = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pap = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ps = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-quz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-raj = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-rif = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ro = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ru = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-rw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sah = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sat = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sd = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-se = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sgs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-shn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-shs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-si = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sid = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-so = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sq = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ss = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ssy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-st = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-su = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-syr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-szl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ta = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tcy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-te = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-th = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-the = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ti = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tig = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-to = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tok = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tpi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ts = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ug = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-uk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-unm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ur = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-uz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ve = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-vi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wae = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wal = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-xh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yue = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yuw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zgh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-locale-source = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-minimal-langpack = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-nss-devel = " \
 glibc \
 nss_db \
 nss_hesiod \
 "
RDEPENDS:glibc-static = " \
 glibc-devel \
 libxcrypt-static \
 "
RDEPENDS:glibc-utils = " \
 bash \
 gd \
 glibc \
 libpng \
 perl-interpreter \
 zlib-ng-compat \
 "
RDEPENDS:libnsl = " \
 glibc \
 "
RDEPENDS:nss_db = " \
 glibc \
 libselinux \
 "
RDEPENDS:nss_hesiod = " \
 glibc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/glibc-langpack-en_or_glibc-all-langpacks rpm/virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"

PROVIDES:append:aarch64 = " rpm/virtual/glibc-langpack-en_or_glibc-all-langpacks rpm/virtual/glibc-langpack_eq_2.39-46.el10_0.4.alma.1"
