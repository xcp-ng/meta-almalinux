# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-escargot"
PV = "0.5.15"
PR = "1.el10_1"
PACKAGES = " \
 rust-escargot+cargo_unstable-devel \
 rust-escargot+default-devel \
 rust-escargot+print-devel \
 rust-escargot+strict_unstable-devel \
 rust-escargot+test_unstable-devel \
 rust-escargot-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-escargot-0.5.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1caf4ab5064357b2ff5242960696f4577cace0a2c2c2d123e14d4d99cc4d9546"

URI_x86_64_v2_rust-escargot+cargo_unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot+cargo_unstable-devel-0.5.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot+cargo_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot+cargo_unstable-devel}"
SRC_URI[x86_64_v2_rust-escargot+cargo_unstable-devel.sha256sum] = "3ecc76a80a84145a30057e3cab3327a676570015a1e88598922c1b7b1382608c"

URI_x86_64_v2_rust-escargot+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot+default-devel-0.5.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot+default-devel}"
SRC_URI[x86_64_v2_rust-escargot+default-devel.sha256sum] = "164d8c8bcf9cf9a21ea491c29bd65ef09fa85677c8f91f7881d2abe00f942df0"

URI_x86_64_v2_rust-escargot+print-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot+print-devel-0.5.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot+print-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot+print-devel}"
SRC_URI[x86_64_v2_rust-escargot+print-devel.sha256sum] = "f0c326aaaa4ca9bff98f15e22a6c66ca71e07fd8fff673302c1f0cca10f7d8d8"

URI_x86_64_v2_rust-escargot+strict_unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot+strict_unstable-devel-0.5.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot+strict_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot+strict_unstable-devel}"
SRC_URI[x86_64_v2_rust-escargot+strict_unstable-devel.sha256sum] = "7e53e13735be0b2d3578f9534454b09a234f91d005c5dc2d0d387204cd65209f"

URI_x86_64_v2_rust-escargot+test_unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot+test_unstable-devel-0.5.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot+test_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot+test_unstable-devel}"
SRC_URI[x86_64_v2_rust-escargot+test_unstable-devel.sha256sum] = "ba2846ee33f6e94c38e3a2257224fee3ed5f0b2c88c0447cd79fb5b5ce04a1db"

URI_x86_64_v2_rust-escargot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-escargot-devel-0.5.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-escargot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-escargot-devel}"
SRC_URI[x86_64_v2_rust-escargot-devel.sha256sum] = "6e306c978dd937c67bab48d8cf9f9ce7d05c39a8a1214f89f0040d19173d8a6c"

URI_aarch64_rust-escargot+cargo_unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot+cargo_unstable-devel-0.5.15-1.el10_1.noarch.rpm;name=aarch64_rust-escargot+cargo_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot+cargo_unstable-devel}"
SRC_URI[aarch64_rust-escargot+cargo_unstable-devel.sha256sum] = "c36532950722ee054347ac72a6dc84785b7b60b207c7a09049bbd8041dcf18ce"

URI_aarch64_rust-escargot+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot+default-devel-0.5.15-1.el10_1.noarch.rpm;name=aarch64_rust-escargot+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot+default-devel}"
SRC_URI[aarch64_rust-escargot+default-devel.sha256sum] = "ac5c3eb64469b53d1df47c9310ebb201eb9dc822746fa5b8490aa56bc99fcddf"

URI_aarch64_rust-escargot+print-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot+print-devel-0.5.15-1.el10_1.noarch.rpm;name=aarch64_rust-escargot+print-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot+print-devel}"
SRC_URI[aarch64_rust-escargot+print-devel.sha256sum] = "dcdf5f83e14fac9c63a9ed66bbdf1d11f97046ab09b3248ade488b786ecbdcbc"

URI_aarch64_rust-escargot+strict_unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot+strict_unstable-devel-0.5.15-1.el10_1.noarch.rpm;name=aarch64_rust-escargot+strict_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot+strict_unstable-devel}"
SRC_URI[aarch64_rust-escargot+strict_unstable-devel.sha256sum] = "e632012c3df10fad43b05c3ab2d8d770e88373fe115ffbf207f749822639b332"

URI_aarch64_rust-escargot+test_unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot+test_unstable-devel-0.5.15-1.el10_1.noarch.rpm;name=aarch64_rust-escargot+test_unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot+test_unstable-devel}"
SRC_URI[aarch64_rust-escargot+test_unstable-devel.sha256sum] = "f0d8a8120f80020a710000651f446009c1f271ee62851131ea2b0c0dcb7743e6"

URI_aarch64_rust-escargot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-escargot-devel-0.5.15-1.el10_1.noarch.rpm;name=aarch64_rust-escargot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-escargot-devel}"
SRC_URI[aarch64_rust-escargot-devel.sha256sum] = "9a12f07fd03c3d3e3a6f6294fbd7d76f2be9d5f2b3187423153efd14d202edcf"

RDEPENDS:rust-escargot+cargo_unstable-devel = " \
 cargo \
 rust-escargot-devel \
 "
RDEPENDS:rust-escargot+default-devel = " \
 cargo \
 rust-escargot-devel \
 "
RDEPENDS:rust-escargot+print-devel = " \
 cargo \
 rust-escargot-devel \
 "
RDEPENDS:rust-escargot+strict_unstable-devel = " \
 cargo \
 rust-escargot-devel \
 "
RDEPENDS:rust-escargot+test_unstable-devel = " \
 cargo \
 rust-escargot-devel \
 "
RDEPENDS:rust-escargot-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
