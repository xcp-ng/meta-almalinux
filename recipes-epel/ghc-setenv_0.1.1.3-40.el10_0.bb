# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-setenv"
PV = "0.1.1.3"
PR = "40.el10_0"
PACKAGES = " \
 ghc-setenv \
 ghc-setenv-devel \
 ghc-setenv-doc \
 ghc-setenv-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-setenv-0.1.1.3-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad1f5370f93e4d69a0643861200e9c899fe334db5dba766f769fea7c5f96952a"

URI_x86_64_v2_ghc-setenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-setenv-0.1.1.3-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-setenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-setenv}"
SRC_URI[x86_64_v2_ghc-setenv.sha256sum] = "d63f99162bf8bce25daa1b013ac68400725e6fc52ac537d352dfc0b3adc41266"

URI_x86_64_v2_ghc-setenv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-setenv-devel-0.1.1.3-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-setenv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-setenv-devel}"
SRC_URI[x86_64_v2_ghc-setenv-devel.sha256sum] = "a4553f7deb7fb339197fc687a231e2689c673119051d298448c7495747b9610d"

URI_x86_64_v2_ghc-setenv-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-setenv-doc-0.1.1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-setenv-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-setenv-doc}"
SRC_URI[x86_64_v2_ghc-setenv-doc.sha256sum] = "1f251b6c76dd62338d7e0272ba60736569af82d06ec318948dfff61cd2ba2e8a"

URI_x86_64_v2_ghc-setenv-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-setenv-prof-0.1.1.3-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-setenv-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-setenv-prof}"
SRC_URI[x86_64_v2_ghc-setenv-prof.sha256sum] = "f3106dece5a16e7c8a042639a94f217cee4a04d07cc480e0ea78e9a2903a5ca9"

URI_aarch64_ghc-setenv = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-setenv-0.1.1.3-40.el10_0.aarch64.rpm;name=aarch64_ghc-setenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-setenv}"
SRC_URI[aarch64_ghc-setenv.sha256sum] = "5e3350a4a73f978bc352f847d8c4e9a49fb238d3f91a074ac824213e38909324"

URI_aarch64_ghc-setenv-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-setenv-devel-0.1.1.3-40.el10_0.aarch64.rpm;name=aarch64_ghc-setenv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-setenv-devel}"
SRC_URI[aarch64_ghc-setenv-devel.sha256sum] = "202def5d29e6b89eeeeb6dbf9e38b2f1d4de8cfe370a5f3e55689b59f51740f8"

URI_aarch64_ghc-setenv-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-setenv-doc-0.1.1.3-40.el10_0.noarch.rpm;name=aarch64_ghc-setenv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-setenv-doc}"
SRC_URI[aarch64_ghc-setenv-doc.sha256sum] = "5573c4e029a91695a26f11bf7c6734ebbcf0842bba72713a8bbcf2c4d7a50f9e"

URI_aarch64_ghc-setenv-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-setenv-prof-0.1.1.3-40.el10_0.aarch64.rpm;name=aarch64_ghc-setenv-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-setenv-prof}"
SRC_URI[aarch64_ghc-setenv-prof.sha256sum] = "16033b20f7905ac7920bf503f05f7d6f3ec1e2fbdfa8ac56c13cc288d34d8a6d"

RDEPENDS:ghc-setenv = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-setenv-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-setenv \
 ghc-unix-devel \
 "
RDEPENDS:ghc-setenv-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-setenv-prof = " \
 ghc-base-prof \
 ghc-setenv-devel \
 ghc-unix-prof \
 "
