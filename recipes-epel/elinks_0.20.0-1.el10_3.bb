# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elinks"
PV = "0.20.0"
PR = "1.el10_3"
PACKAGES = " \
 elinks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/elinks-0.20.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f66810851e3941f7d9339c29678c0fdfb63574ea98c8ad65853d087909e8ac7f"

URI_x86_64_v2_elinks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/elinks-0.20.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_elinks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elinks}"
SRC_URI[x86_64_v2_elinks.sha256sum] = "00e0eef622d294eab0d80872d1c7047b270853dd36953f40132c58384953996b"
RPROVIDES:elinks:x86_64_v2 = "virtual/text-www-browser"

URI_aarch64_elinks = "${EPEL_MIRROR}/aarch64/Packages/e/elinks-0.20.0-1.el10_3.aarch64.rpm;name=aarch64_elinks;unpack=0"
SRC_URI:append = " ${URI_aarch64_elinks}"
SRC_URI[aarch64_elinks.sha256sum] = "64619247c5e3c651710ed976fdd3a983b86190ccc3fb90d2414b4fd3a6bffd21"
RPROVIDES:elinks:aarch64 = "virtual/text-www-browser"

RDEPENDS:elinks = " \
 alternatives \
 bash \
 bzip2-libs \
 expat \
 glibc \
 krb5-libs \
 libgcc \
 libidn2 \
 libstdc++ \
 lua-libs \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/text-www-browser"

PROVIDES:append:aarch64 = " rpm/virtual/text-www-browser"
