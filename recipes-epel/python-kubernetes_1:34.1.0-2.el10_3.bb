# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-kubernetes"
PE = "1"
PV = "34.1.0"
PR = "2.el10_3"
PACKAGES = " \
 python3-kubernetes \
 python3-kubernetes-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-kubernetes-34.1.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44adbe1a1f806dfd633d9ae50a10d2e552597e67828a19f08345413ef110afe7"

URI_x86_64_v2_python3-kubernetes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kubernetes-34.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kubernetes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kubernetes}"
SRC_URI[x86_64_v2_python3-kubernetes.sha256sum] = "5c333be526c9d9f3947be026ea0c0d9d03ef28f4b90edefe4836f5ea5e308908"

URI_x86_64_v2_python3-kubernetes-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kubernetes-tests-34.1.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kubernetes-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kubernetes-tests}"
SRC_URI[x86_64_v2_python3-kubernetes-tests.sha256sum] = "2d98c697c599c4a4d7cad2bcaa3d36504108bddbfa9a7079d34ff11c28113966"

URI_aarch64_python3-kubernetes = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kubernetes-34.1.0-2.el10_3.noarch.rpm;name=aarch64_python3-kubernetes;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kubernetes}"
SRC_URI[aarch64_python3-kubernetes.sha256sum] = "c4bc56aa6839109a831955e50d354af1c3f37085e93bd9f070a16c8d7d800fa6"

URI_aarch64_python3-kubernetes-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kubernetes-tests-34.1.0-2.el10_3.noarch.rpm;name=aarch64_python3-kubernetes-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kubernetes-tests}"
SRC_URI[aarch64_python3-kubernetes-tests.sha256sum] = "48e4fd0788dbf64b1f773862b74d3b9ff4ca35f7251430e82c7a308fe4498021"

RDEPENDS:python3-kubernetes = " \
 python3 \
 python3-certifi \
 python3-dateutil \
 python3-durationpy \
 python3-google-auth \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-urllib3 \
 python3-websocket-client \
 "
RDEPENDS:python3-kubernetes-tests = " \
 python3 \
 python3-kubernetes \
 "
