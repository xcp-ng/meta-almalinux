# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mutter"
PV = "47.5"
PR = "13.el10"
PACKAGES = " \
 mutter \
 mutter-common \
 mutter-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mutter-47.5-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c39e1ee6dfe974c1accc046f3492ede1f705a6be1a7d27bf5bb2c45b661c3087"

URI_x86_64_v2_mutter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mutter-47.5-13.el10.x86_64_v2.rpm;name=x86_64_v2_mutter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mutter}"
SRC_URI[x86_64_v2_mutter.sha256sum] = "663b13be7236e4638a0ddb236591e3f454357f0c87d44625a365e2c5917d1fed"
RPROVIDES:mutter:x86_64_v2 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_x86_64_v2_mutter-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mutter-common-47.5-13.el10.noarch.rpm;name=x86_64_v2_mutter-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mutter-common}"
SRC_URI[x86_64_v2_mutter-common.sha256sum] = "2b75ccaef11c5e7053c7d8394adc9d30a10b4fc6030c53bf2247cfe1698a86e5"

URI_x86_64_v2_mutter-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mutter-devel-47.5-13.el10.x86_64_v2.rpm;name=x86_64_v2_mutter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mutter-devel}"
SRC_URI[x86_64_v2_mutter-devel.sha256sum] = "89341081694502209fd73120bdb42420fc40139fa928e4b3888fca7127ce8984"

URI_aarch64_mutter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mutter-47.5-13.el10.aarch64.rpm;name=aarch64_mutter;unpack=0"
SRC_URI:append = " ${URI_aarch64_mutter}"
SRC_URI[aarch64_mutter.sha256sum] = "9fdf4f013f0bd5d6ead5a065c6980463cf62593f2af42a3f9bc6456ba3c8b03a"
RPROVIDES:mutter:aarch64 = "virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_mutter-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mutter-common-47.5-13.el10.noarch.rpm;name=aarch64_mutter-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mutter-common}"
SRC_URI[aarch64_mutter-common.sha256sum] = "2b75ccaef11c5e7053c7d8394adc9d30a10b4fc6030c53bf2247cfe1698a86e5"

URI_aarch64_mutter-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mutter-devel-47.5-13.el10.aarch64.rpm;name=aarch64_mutter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mutter-devel}"
SRC_URI[aarch64_mutter-devel.sha256sum] = "dbe74c65e5927c5d3c020596c0809d3f532102f44d6724bf250561741cf3f232"

RDEPENDS:mutter = " \
 atk \
 cairo \
 colord-libs \
 dbus \
 fribidi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-control-center-filesystem \
 gnome-desktop4 \
 gnome-settings-daemon \
 graphene \
 gsettings-desktop-schemas \
 gtk4 \
 harfbuzz \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libXau \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libXtst \
 libcanberra \
 libdisplay-info \
 libdrm \
 libeis \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libgudev \
 libinput \
 libwacom \
 libwayland-server \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 libxkbfile \
 mesa-libgbm \
 mutter-common \
 pango \
 pipewire \
 pipewire-libs \
 pixman \
 python3 \
 python3-argcomplete \
 startup-notification \
 systemd-libs \
 "
RDEPENDS:mutter-common = " \
 "
RDEPENDS:mutter-devel = " \
 atk-devel \
 cairo \
 cairo-devel \
 glib2 \
 glib2-devel \
 glibc \
 graphene-devel \
 gsettings-desktop-schemas-devel \
 harfbuzz-devel \
 libX11-devel \
 libXext \
 libXfixes-devel \
 libXi-devel \
 libgcc \
 libglvnd-devel \
 libglvnd-gles \
 libwayland-client \
 libxcb \
 mesa-libEGL-devel \
 mutter \
 mutter-devel \
 pango-devel \
 pixman-devel \
 pkgconf-pkg-config \
 wayland-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

PROVIDES:append:aarch64 = " rpm/virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"
