# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-nix"
PV = "0.3.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-nix+default-devel \
 rust-tree-sitter-nix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-nix-0.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12cde75d083de4fe70b7958bd7cd4d8133ec7b72764d63725662d0fb50f72f4f"

URI_x86_64_v2_rust-tree-sitter-nix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-nix+default-devel-0.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-nix+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-nix+default-devel.sha256sum] = "3d53af95ff355353a86ea5d5a8d2b90f489a1f932b806873a3b6ce5f8787afc2"

URI_x86_64_v2_rust-tree-sitter-nix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-nix-devel-0.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-nix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-nix-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-nix-devel.sha256sum] = "58bfb71fea447541a750261cb88f856a40e3caab9810f80cebef50738e1cde85"

URI_aarch64_rust-tree-sitter-nix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-nix+default-devel-0.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-nix+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-nix+default-devel.sha256sum] = "e4de7dbba0aec906175630ff5af4b912d099e3c88d1c66d97e0fae8b44c85c53"

URI_aarch64_rust-tree-sitter-nix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-nix-devel-0.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-nix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-nix-devel}"
SRC_URI[aarch64_rust-tree-sitter-nix-devel.sha256sum] = "dd6b4b2549cc9eb03030eb22236c5fe850d9bc7fe15ad08e83b6fcc330c09920"

RDEPENDS:rust-tree-sitter-nix+default-devel = " \
 cargo \
 rust-tree-sitter-nix-devel \
 "
RDEPENDS:rust-tree-sitter-nix-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
