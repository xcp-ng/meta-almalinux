# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libptytty"
PV = "2.0"
PR = "13.el10_2"
PACKAGES = " \
 libptytty \
 libptytty-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libptytty-2.0-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8ccb9eb67c72a25b95569d666e0e1d0c131888ff2b6655dac5599f5ed987612"

URI_x86_64_v2_libptytty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libptytty-2.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libptytty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libptytty}"
SRC_URI[x86_64_v2_libptytty.sha256sum] = "700cc6131656ba1f5df6ea97c1de709394ad9a49a9ab11fda880662c92f12d88"

URI_x86_64_v2_libptytty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libptytty-devel-2.0-13.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libptytty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libptytty-devel}"
SRC_URI[x86_64_v2_libptytty-devel.sha256sum] = "60b4a0b2563dce71005682d4396bf02abe8dbef66667410bc6ed16f1cdb20fc1"

URI_aarch64_libptytty = "${EPEL_MIRROR}/aarch64/Packages/l/libptytty-2.0-13.el10_2.aarch64.rpm;name=aarch64_libptytty;unpack=0"
SRC_URI:append = " ${URI_aarch64_libptytty}"
SRC_URI[aarch64_libptytty.sha256sum] = "737cedb9cf72edd0a473e7eb3dfe869b8931cdc85402f9092034691549175b07"

URI_aarch64_libptytty-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libptytty-devel-2.0-13.el10_2.aarch64.rpm;name=aarch64_libptytty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libptytty-devel}"
SRC_URI[aarch64_libptytty-devel.sha256sum] = "122165fb09727ff3a1a49bd4a8466702eebc6668fd1dd1b8ae72ebb8ab1b3de9"

RDEPENDS:libptytty = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libptytty-devel = " \
 libptytty \
 pkgconf-pkg-config \
 "
