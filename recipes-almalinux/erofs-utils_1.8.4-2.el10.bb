# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "erofs-utils"
PV = "1.8.4"
PR = "2.el10"
PACKAGES = " \
 erofs-fuse \
 erofs-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/erofs-utils-1.8.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "387130416b5d98261beb22bf4e90f313fa7af27dc10e1b98c506e6c82412f1e2"

URI_x86_64_v2_erofs-fuse = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/erofs-fuse-1.8.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_erofs-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_erofs-fuse}"
SRC_URI[x86_64_v2_erofs-fuse.sha256sum] = "0f6ab08daf2d5aab9ab151319f95d56fa83a0957bc9bf877c3b17eb267b3c16d"

URI_x86_64_v2_erofs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/erofs-utils-1.8.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_erofs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_erofs-utils}"
SRC_URI[x86_64_v2_erofs-utils.sha256sum] = "8359fafed278822af7c806fb186e342c27331dbf4c896e34ae8cc764c96e552b"

URI_aarch64_erofs-fuse = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/erofs-fuse-1.8.4-2.el10.aarch64.rpm;name=aarch64_erofs-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_erofs-fuse}"
SRC_URI[aarch64_erofs-fuse.sha256sum] = "99767ca23d937154ddbf17521be049054f0d4e1fc35ac8c334088c2d5191f168"

URI_aarch64_erofs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/erofs-utils-1.8.4-2.el10.aarch64.rpm;name=aarch64_erofs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_erofs-utils}"
SRC_URI[aarch64_erofs-utils.sha256sum] = "c5bbf2b1cd5c5a027691c94e8d2f6d790270c5ae616417d760ffdb30f9561c77"

RDEPENDS:erofs-fuse = " \
 fuse3 \
 fuse3-libs \
 glibc \
 libselinux \
 libzstd \
 lz4-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:erofs-utils = " \
 glibc \
 libselinux \
 libuuid \
 libzstd \
 lz4-libs \
 xz-libs \
 zlib-ng-compat \
 "
