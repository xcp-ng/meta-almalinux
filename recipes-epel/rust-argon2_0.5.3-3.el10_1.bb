# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argon2"
PV = "0.5.3"
PR = "3.el10_1"
PACKAGES = " \
 rust-argon2+alloc-devel \
 rust-argon2+default-devel \
 rust-argon2+password-hash-devel \
 rust-argon2+rand-devel \
 rust-argon2+simple-devel \
 rust-argon2+std-devel \
 rust-argon2+zeroize-devel \
 rust-argon2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argon2-0.5.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5351304dbd22077549de3a8edfe82d8b76d5bb162ed5f0070a6bf22ef38b306f"

URI_x86_64_v2_rust-argon2+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+alloc-devel-0.5.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+alloc-devel}"
SRC_URI[x86_64_v2_rust-argon2+alloc-devel.sha256sum] = "988a36ae07e1c9f6e55a31a1495eff40b5a8036bb076ddaf09b537efb3ae2200"

URI_x86_64_v2_rust-argon2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+default-devel-0.5.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+default-devel}"
SRC_URI[x86_64_v2_rust-argon2+default-devel.sha256sum] = "b8332571dc2d982d0c19a3351b9247f634491670222208fa70f4740dffd0e25f"

URI_x86_64_v2_rust-argon2+password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+password-hash-devel-0.5.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+password-hash-devel}"
SRC_URI[x86_64_v2_rust-argon2+password-hash-devel.sha256sum] = "cb24e40424d0661206064b93fe83cd0f1b250fd05bff2d8b39e64649e3392870"

URI_x86_64_v2_rust-argon2+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+rand-devel-0.5.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+rand-devel}"
SRC_URI[x86_64_v2_rust-argon2+rand-devel.sha256sum] = "5f40fc9d318b135b789d41f21fe63077695e75313297bdc68c1ff560d08f281d"

URI_x86_64_v2_rust-argon2+simple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+simple-devel-0.5.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+simple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+simple-devel}"
SRC_URI[x86_64_v2_rust-argon2+simple-devel.sha256sum] = "964c04e70509d4ad01311fbcf162d61871895ba992f677186d92bf8fca5c6c02"

URI_x86_64_v2_rust-argon2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+std-devel-0.5.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+std-devel}"
SRC_URI[x86_64_v2_rust-argon2+std-devel.sha256sum] = "bb588bb8f54dd3b77c194a144e2c6bf52f9dd4440d9811e1a02efbd24701e2bb"

URI_x86_64_v2_rust-argon2+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+zeroize-devel-0.5.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+zeroize-devel}"
SRC_URI[x86_64_v2_rust-argon2+zeroize-devel.sha256sum] = "d2587040ce30417d6802a691d074e653c623e3cdbe39bb924596c4a1a54a652c"

URI_x86_64_v2_rust-argon2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2-devel-0.5.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2-devel}"
SRC_URI[x86_64_v2_rust-argon2-devel.sha256sum] = "8160273bcc0705c6ebd9671de493d518ac5d6051d73da4cac6c7219787591a0a"

URI_aarch64_rust-argon2+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+alloc-devel-0.5.3-3.el10_1.noarch.rpm;name=aarch64_rust-argon2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+alloc-devel}"
SRC_URI[aarch64_rust-argon2+alloc-devel.sha256sum] = "fda61a142f45071c45f1de570746fa6993792abe283ba383a2d98e00c1929a99"

URI_aarch64_rust-argon2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+default-devel-0.5.3-3.el10_1.noarch.rpm;name=aarch64_rust-argon2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+default-devel}"
SRC_URI[aarch64_rust-argon2+default-devel.sha256sum] = "1631117f34537d892068ab91ab54fdffe995688e16043ac8b43154844c6d349b"

URI_aarch64_rust-argon2+password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+password-hash-devel-0.5.3-3.el10_1.noarch.rpm;name=aarch64_rust-argon2+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+password-hash-devel}"
SRC_URI[aarch64_rust-argon2+password-hash-devel.sha256sum] = "4dc4e84717bd52e86d7c560ebc5215c6b145a4dc070fa9591e2032ad40144c6e"

URI_aarch64_rust-argon2+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+rand-devel-0.5.3-3.el10_1.noarch.rpm;name=aarch64_rust-argon2+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+rand-devel}"
SRC_URI[aarch64_rust-argon2+rand-devel.sha256sum] = "ccab240c00bac681c6c66a11622a3f31d2c5ed9f16ee440d66bd6b17e822d4b7"

URI_aarch64_rust-argon2+simple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+simple-devel-0.5.3-3.el10_1.noarch.rpm;name=aarch64_rust-argon2+simple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+simple-devel}"
SRC_URI[aarch64_rust-argon2+simple-devel.sha256sum] = "549a1df89186bd41445221e64c5bb7d7dd2fe8daf74ee3b9e0828757ce4f339a"

URI_aarch64_rust-argon2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+std-devel-0.5.3-3.el10_1.noarch.rpm;name=aarch64_rust-argon2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+std-devel}"
SRC_URI[aarch64_rust-argon2+std-devel.sha256sum] = "76aa7fba5091b32bd697af5e00c4dd3d99ba698c5c59acd933fa03ff179d46d5"

URI_aarch64_rust-argon2+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+zeroize-devel-0.5.3-3.el10_1.noarch.rpm;name=aarch64_rust-argon2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+zeroize-devel}"
SRC_URI[aarch64_rust-argon2+zeroize-devel.sha256sum] = "b327c278d5d8f191e705bf46d45a403469ded1a24f8c30f5ba930d27aa6e672c"

URI_aarch64_rust-argon2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2-devel-0.5.3-3.el10_1.noarch.rpm;name=aarch64_rust-argon2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2-devel}"
SRC_URI[aarch64_rust-argon2-devel.sha256sum] = "4e26556283a7c765274a39fc634f02f9d37bcb47a12ffa05cae43a3d99160ab8"

RDEPENDS:rust-argon2+alloc-devel = " \
 cargo \
 rust-argon2-devel \
 rust-password-hash+alloc-devel \
 rust-password-hash+default-devel \
 "
RDEPENDS:rust-argon2+default-devel = " \
 cargo \
 rust-argon2+alloc-devel \
 rust-argon2+password-hash-devel \
 rust-argon2+rand-devel \
 rust-argon2-devel \
 "
RDEPENDS:rust-argon2+password-hash-devel = " \
 cargo \
 rust-argon2-devel \
 rust-password-hash+default-devel \
 "
RDEPENDS:rust-argon2+rand-devel = " \
 cargo \
 rust-argon2-devel \
 rust-password-hash+default-devel \
 rust-password-hash+rand_core-devel \
 "
RDEPENDS:rust-argon2+simple-devel = " \
 cargo \
 rust-argon2+password-hash-devel \
 rust-argon2-devel \
 "
RDEPENDS:rust-argon2+std-devel = " \
 cargo \
 rust-argon2+alloc-devel \
 rust-argon2-devel \
 rust-password-hash+default-devel \
 rust-password-hash+std-devel \
 "
RDEPENDS:rust-argon2+zeroize-devel = " \
 cargo \
 rust-argon2-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-argon2-devel = " \
 cargo \
 rust \
 rust-base64ct+default-devel \
 rust-blake2-devel \
 rust-cpufeatures+default-devel \
 "
