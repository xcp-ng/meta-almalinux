# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-sys"
PV = "1.1.29"
PR = "1.el10_3"
PACKAGES = " \
 rust-libz-sys+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys+stock-zlib-devel \
 rust-libz-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libz-sys-1.1.29-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "58b1f177fcd6600f6f6eb7596a3e6efe66c7eec6da643a82556561420404c590"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+default-devel-1.1.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-sys+default-devel.sha256sum] = "6c445346ebaab0df3b456953b2ea8f77c3a1a22d418c3ee33835d5f08e88978d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+libc-devel-1.1.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+libc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-sys+libc-devel.sha256sum] = "1411a8b5bad4ba56ec121462efc3fdfd18c6393c773a1232ccfa112fc0a1cdb4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+stock-zlib-devel-1.1.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+stock-zlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-sys+stock-zlib-devel.sha256sum] = "311476944735e7dc1a893056f67df0da32e8a42dd0bea46c6705fcd59802df0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys-devel-1.1.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-sys-devel.sha256sum] = "5167ec0662bd8efc1a4bc58090563f6173fa8ae9bd8ed99625ab28f0d6e56fe6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+default-devel-1.1.29-1.el10_3.noarch.rpm;name=aarch64_rust-libz-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-libz-sys+default-devel.sha256sum] = "2edb046ee6097b0193c29c05b818aca628da772cf82f1fc3a6b53a3f36d2a103"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+libc-devel-1.1.29-1.el10_3.noarch.rpm;name=aarch64_rust-libz-sys+libc-devel;unpack=0"
SRC_URI[aarch64_rust-libz-sys+libc-devel.sha256sum] = "12aebb76ca2de4ca21cfe1f9ed8efc8181ef5241db7b1f64bf50c21ff7691bb0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+stock-zlib-devel-1.1.29-1.el10_3.noarch.rpm;name=aarch64_rust-libz-sys+stock-zlib-devel;unpack=0"
SRC_URI[aarch64_rust-libz-sys+stock-zlib-devel.sha256sum] = "6a044cbca4da7f8c193e87b19d62fef3b06d1cae6c1eee938208ca0f91ea54dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys-devel-1.1.29-1.el10_3.noarch.rpm;name=aarch64_rust-libz-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libz-sys-devel.sha256sum] = "2d2ce8aff4f791b3cac6c0bab83000499be358229611dfdf964b466ec6302e6f"

RDEPENDS:rust-libz-sys+default-devel = " \
 cargo \
 rust-libz-sys+libc-devel \
 rust-libz-sys+stock-zlib-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys+stock-zlib-devel = " \
 cargo \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 zlib-ng-compat-devel \
 "
