# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pbr"
PV = "5.11.1"
PR = "10.el10_0~bootstrap"
PACKAGES = " \
 python3-pbr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pbr-5.11.1-10.el10_0~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "521190556e0a188530f93164e34214c2ee8a17873aa2e6c80564a309565cd63b"

URI_x86_64_v2_python3-pbr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pbr-5.11.1-10.el10_0~bootstrap.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pbr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pbr}"
SRC_URI[x86_64_v2_python3-pbr.sha256sum] = "83824bee0d27d61a85647abf342b84030d2ed0d26259dd974c78203b61a3db93"

URI_aarch64_python3-pbr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pbr-5.11.1-10.el10_0~bootstrap.noarch.rpm;name=aarch64_python3-pbr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pbr}"
SRC_URI[aarch64_python3-pbr.sha256sum] = "b79a7f28c39abd5a761deda054d1346398e30fecc0cb51687af40f055444cadf"

RDEPENDS:python3-pbr = " \
 git-core \
 python3 \
 python3-setuptools \
 "
