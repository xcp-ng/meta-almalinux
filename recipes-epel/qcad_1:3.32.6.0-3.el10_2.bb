# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qcad"
PE = "1"
PV = "3.32.6.0"
PR = "3.el10_2"
PACKAGES = " \
 qcad \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qcad-3.32.6.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80a2f2de11aa4f60db2a928ab6fa36fc1cdfdfcb0a19d7c599c021511715dd53"

URI_x86_64_v2_qcad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcad-3.32.6.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcad}"
SRC_URI[x86_64_v2_qcad.sha256sum] = "207405542ae67c93393d320385271760a728d0e7131def7bd6d74deb76f762c7"

URI_aarch64_qcad = "${EPEL_MIRROR}/aarch64/Packages/q/qcad-3.32.6.0-3.el10_2.aarch64.rpm;name=aarch64_qcad;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcad}"
SRC_URI[aarch64_qcad.sha256sum] = "edb6385b0c1422686c9cedbff8d6e143ede5a24376a31582c1761559a03f1822"

RDEPENDS:qcad = " \
 bash \
 dejavu-sans-fonts \
 dejavu-sans-mono-fonts \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtscript \
 qt5-qtsvg \
 qt5-qtxmlpatterns \
 vl-gothic-fonts \
 "
