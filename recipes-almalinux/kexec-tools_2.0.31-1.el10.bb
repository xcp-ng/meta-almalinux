# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kexec-tools"
PV = "2.0.31"
PR = "1.el10"
PACKAGES = " \
 kexec-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kexec-tools-2.0.31-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "28d7d0006b7804250f8cd03a4cd4b622e541bee8470371b7e37ae13c45c33da5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kexec-tools-2.0.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_kexec-tools;unpack=0"
SRC_URI[x86_64_v2_kexec-tools.sha256sum] = "3bc34165c76f849583686ab5ab60ac0bf67ef71afc1c76650b19bccb438caaa4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kexec-tools-2.0.31-1.el10.aarch64.rpm;name=aarch64_kexec-tools;unpack=0"
SRC_URI[aarch64_kexec-tools.sha256sum] = "2a80015b05791ef4ae9ed738c255589c0af4394a1f1f2f1ab6974e87f35257c1"

RDEPENDS:kexec-tools = " \
 glibc \
 xz-libs \
 zlib-ng-compat \
 "
