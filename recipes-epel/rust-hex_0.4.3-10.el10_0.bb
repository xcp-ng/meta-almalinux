# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hex"
PV = "0.4.3"
PR = "10.el10_0"
PACKAGES = " \
 rust-hex+alloc-devel \
 rust-hex+default-devel \
 rust-hex+serde-devel \
 rust-hex+std-devel \
 rust-hex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hex-0.4.3-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f136a953788b5c09d098a6f12ffa2ce6db8189d5e0460c9e146d0384d497f4d2"

URI_x86_64_v2_rust-hex+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex+alloc-devel-0.4.3-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex+alloc-devel}"
SRC_URI[x86_64_v2_rust-hex+alloc-devel.sha256sum] = "338353f799d3690490e05008132f8a0dca743353fa17a58ed3763f7670f25a98"

URI_x86_64_v2_rust-hex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex+default-devel-0.4.3-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex+default-devel}"
SRC_URI[x86_64_v2_rust-hex+default-devel.sha256sum] = "d3b3eca9fb09925800da0d6d16d5023578101fa8b5b00c3c5fb6dacbce362474"

URI_x86_64_v2_rust-hex+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex+serde-devel-0.4.3-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex+serde-devel}"
SRC_URI[x86_64_v2_rust-hex+serde-devel.sha256sum] = "995c8ca6b54f6afb5321bd81a4dd227371f3be75e82b8cda1168927920b92f92"

URI_x86_64_v2_rust-hex+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex+std-devel-0.4.3-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex+std-devel}"
SRC_URI[x86_64_v2_rust-hex+std-devel.sha256sum] = "f1557eb2997829aaa085973eb0314bafdb21e58c15508ea8ee590246a162815a"

URI_x86_64_v2_rust-hex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-devel-0.4.3-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex-devel}"
SRC_URI[x86_64_v2_rust-hex-devel.sha256sum] = "5ce5dc51dfeaee5fcdfdb25a46c19178e6dba3518ee2ed538cbff39ae1fa8a84"

URI_aarch64_rust-hex+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex+alloc-devel-0.4.3-10.el10_0.noarch.rpm;name=aarch64_rust-hex+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex+alloc-devel}"
SRC_URI[aarch64_rust-hex+alloc-devel.sha256sum] = "0d13e8199769d3ea04b2bd6708232f8c630693eeb5f98c1f8663679fe9767c81"

URI_aarch64_rust-hex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex+default-devel-0.4.3-10.el10_0.noarch.rpm;name=aarch64_rust-hex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex+default-devel}"
SRC_URI[aarch64_rust-hex+default-devel.sha256sum] = "a1c94c37333fe190621d4c75d6761ccc102113a42c49703a323c17e55814e6a4"

URI_aarch64_rust-hex+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex+serde-devel-0.4.3-10.el10_0.noarch.rpm;name=aarch64_rust-hex+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex+serde-devel}"
SRC_URI[aarch64_rust-hex+serde-devel.sha256sum] = "7b9627e1d5e898b8d111304ab1a7ad66f8bf4a712dcdc16e1d0f2324ce6a7b71"

URI_aarch64_rust-hex+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex+std-devel-0.4.3-10.el10_0.noarch.rpm;name=aarch64_rust-hex+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex+std-devel}"
SRC_URI[aarch64_rust-hex+std-devel.sha256sum] = "c9f54a7b20951a8f8936025383118ea6165a108b662d9827e73d3aa7ce0db4f6"

URI_aarch64_rust-hex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-devel-0.4.3-10.el10_0.noarch.rpm;name=aarch64_rust-hex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex-devel}"
SRC_URI[aarch64_rust-hex-devel.sha256sum] = "316e238c71e4e33ddef2f24a48d29f9da004e77900c404458346d673bef5ac0e"

RDEPENDS:rust-hex+alloc-devel = " \
 cargo \
 rust-hex-devel \
 "
RDEPENDS:rust-hex+default-devel = " \
 cargo \
 rust-hex+std-devel \
 rust-hex-devel \
 "
RDEPENDS:rust-hex+serde-devel = " \
 cargo \
 rust-hex-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hex+std-devel = " \
 cargo \
 rust-hex+alloc-devel \
 rust-hex-devel \
 "
RDEPENDS:rust-hex-devel = " \
 cargo \
 "
