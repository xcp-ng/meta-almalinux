# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6ct"
PV = "0.11"
PR = "10.20250907git23a985f.el10_2"
PACKAGES = " \
 qt6ct \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qt6ct-0.11-10.20250907git23a985f.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "74214a350719ac7393619ceb9ac07a53c73c91045363b14063fc1e8413b43f97"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt6ct-0.11-10.20250907git23a985f.el10_2.aarch64.rpm;name=aarch64_qt6ct;unpack=0"
SRC_URI[aarch64_qt6ct.sha256sum] = "fa5859fff4516ee281a1f567220b915f98a7f585c0edd8e7c15b78047d06ce69"

RDEPENDS:qt6ct = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
