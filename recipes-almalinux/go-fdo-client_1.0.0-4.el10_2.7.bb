# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-fdo-client"
PV = "1.0.0"
PR = "4.el10_2.7"
PACKAGES = " \
 go-fdo-client \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/go-fdo-client-1.0.0-4.el10_2.7.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a1a98daf1dfe21b41ae67a1154c6a6de60d54ef8ac3e0ef58701d71fe6ed6dd4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-client-1.0.0-4.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_go-fdo-client;unpack=0"
SRC_URI[x86_64_v2_go-fdo-client.sha256sum] = "a0565631152a699ee8bac4e7c962dca6e655fbcb0abea6fdc41c00c43564b54f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-client-1.0.0-4.el10_2.7.aarch64.rpm;name=aarch64_go-fdo-client;unpack=0"
SRC_URI[aarch64_go-fdo-client.sha256sum] = "4924dd4a84e7431cd830f6e65c70bad37dff009a69cdb4cca86909f4ee969a7c"

RDEPENDS:go-fdo-client = " \
 glibc \
 "
