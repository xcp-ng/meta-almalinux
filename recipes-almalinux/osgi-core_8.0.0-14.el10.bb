# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osgi-core"
PV = "8.0.0"
PR = "14.el10"
PACKAGES = " \
 osgi-core \
 osgi-core-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/osgi-core-8.0.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b298fb7e4b017d14dd7105de5a444e6358fec1f9e01a50a2037c5ef2615d9c2"

URI_x86_64_v2_osgi-core = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/osgi-core-8.0.0-14.el10.noarch.rpm;name=x86_64_v2_osgi-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osgi-core}"
SRC_URI[x86_64_v2_osgi-core.sha256sum] = "31c055febf689e0dc81bc418ac634147b3b18a03cbff3fc81cd9fd4a500e14f5"

URI_x86_64_v2_osgi-core-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/osgi-core-javadoc-8.0.0-14.el10.noarch.rpm;name=x86_64_v2_osgi-core-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osgi-core-javadoc}"
SRC_URI[x86_64_v2_osgi-core-javadoc.sha256sum] = "8ab0904f05aa0247ab7af2d11b12fd6478dd4aea82f71bde000f0d23090c380c"

URI_aarch64_osgi-core = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/osgi-core-8.0.0-14.el10.noarch.rpm;name=aarch64_osgi-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_osgi-core}"
SRC_URI[aarch64_osgi-core.sha256sum] = "31c055febf689e0dc81bc418ac634147b3b18a03cbff3fc81cd9fd4a500e14f5"

URI_aarch64_osgi-core-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/osgi-core-javadoc-8.0.0-14.el10.noarch.rpm;name=aarch64_osgi-core-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_osgi-core-javadoc}"
SRC_URI[aarch64_osgi-core-javadoc.sha256sum] = "8ab0904f05aa0247ab7af2d11b12fd6478dd4aea82f71bde000f0d23090c380c"

RDEPENDS:osgi-core = " \
 javapackages-filesystem \
 "
RDEPENDS:osgi-core-javadoc = " \
 javapackages-filesystem \
 "
