# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koko"
PV = "24.12.0"
PR = "1.el10_0"
PACKAGES = " \
 koko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koko-24.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78eeea6cf34ba96a00f7ca3db38c6dfe9c6aa2f59c2cb089b84fa65208eaa1a4"

URI_x86_64_v2_koko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koko-24.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_koko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koko}"
SRC_URI[x86_64_v2_koko.sha256sum] = "214f09bb72d3b7f04a5cdaa60e40901730b7cedb393a119a375e1eab0bfd5f7c"

URI_aarch64_koko = "${EPEL_MIRROR}/aarch64/Packages/k/koko-24.12.0-1.el10_0.aarch64.rpm;name=aarch64_koko;unpack=0"
SRC_URI:append = " ${URI_aarch64_koko}"
SRC_URI[aarch64_koko.sha256sum] = "e3fd621131c576d62d1711b15b1ef9f84bc281df7f205bb23e3340bc225cd363"

RDEPENDS:koko = " \
 exiv2-libs \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 kquickimageeditor-qt6 \
 libgcc \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtsvg \
 "
