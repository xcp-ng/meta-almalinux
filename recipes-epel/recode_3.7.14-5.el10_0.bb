# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "recode"
PV = "3.7.14"
PR = "5.el10_0"
PACKAGES = " \
 recode \
 recode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/recode-3.7.14-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a77ac11bc522a7dee1856115162424cce3c09b03b34e4bae7246e569b902ae18"

URI_x86_64_v2_recode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recode-3.7.14-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recode}"
SRC_URI[x86_64_v2_recode.sha256sum] = "e0f432bb66cffe5e554996267d4811dde4c213bcc7ad70a476fae392837e0ea3"

URI_x86_64_v2_recode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recode-devel-3.7.14-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_recode-devel}"
SRC_URI[x86_64_v2_recode-devel.sha256sum] = "7a59edef250237af67d24f8fa00486d423f6da33280b45e255d106878818af94"

URI_aarch64_recode = "${EPEL_MIRROR}/aarch64/Packages/r/recode-3.7.14-5.el10_0.aarch64.rpm;name=aarch64_recode;unpack=0"
SRC_URI:append = " ${URI_aarch64_recode}"
SRC_URI[aarch64_recode.sha256sum] = "7285cd3e52f7a524a97163d28ea978032851a92921f8b435a180a18ceed9251f"

URI_aarch64_recode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/recode-devel-3.7.14-5.el10_0.aarch64.rpm;name=aarch64_recode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_recode-devel}"
SRC_URI[aarch64_recode-devel.sha256sum] = "3fadb477f3671d471b9b8d51154523af3433806ca3eb2685051196c89d20a9d8"

RDEPENDS:recode = " \
 glibc \
 "
RDEPENDS:recode-devel = " \
 recode \
 "
