# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsemanage"
PV = "3.8.1"
PR = "1.el10_0"
PACKAGES = " \
 libsemanage \
 libsemanage-devel \
 python3-libsemanage \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsemanage-3.8.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f299103a1bba856f7e2f1a822e93ed21d025823c2f713f09092c714cef506ba"

URI_x86_64_v2_libsemanage = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsemanage-3.8.1-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libsemanage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsemanage}"
SRC_URI[x86_64_v2_libsemanage.sha256sum] = "8b9fb454011da505938817fc5d54c1a96abaf7e4668774e0ecb88e2fc4f0b879"

URI_x86_64_v2_libsemanage-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsemanage-devel-3.8.1-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libsemanage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsemanage-devel}"
SRC_URI[x86_64_v2_libsemanage-devel.sha256sum] = "a7821ee5ed4ef6c3dd7359763e0f32f796fd2f09cae785069551415fb0831ef5"

URI_x86_64_v2_python3-libsemanage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libsemanage-3.8.1-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-libsemanage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libsemanage}"
SRC_URI[x86_64_v2_python3-libsemanage.sha256sum] = "701e4bc5cb3ca01a991d2ea65b70d17076c7f22e954139ae1c559b38d57499c5"

URI_aarch64_libsemanage = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsemanage-3.8.1-1.el10_0.aarch64.rpm;name=aarch64_libsemanage;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsemanage}"
SRC_URI[aarch64_libsemanage.sha256sum] = "b272a36ada58c3218ba9fb171f4028b88b44a9760d488d5e64d9b80215b8ada1"

URI_aarch64_libsemanage-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsemanage-devel-3.8.1-1.el10_0.aarch64.rpm;name=aarch64_libsemanage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsemanage-devel}"
SRC_URI[aarch64_libsemanage-devel.sha256sum] = "caef17ce3dec40f4d51b546581ff0d59e50a02f485fbac96a2ee85f640f658f5"

URI_aarch64_python3-libsemanage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libsemanage-3.8.1-1.el10_0.aarch64.rpm;name=aarch64_python3-libsemanage;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libsemanage}"
SRC_URI[aarch64_python3-libsemanage.sha256sum] = "0d434654be93a4bddda6f982512f35f2a1dbe357f2d44a31085bb6d5e5d3ef74"

RDEPENDS:libsemanage = " \
 audit-libs \
 bzip2-libs \
 glibc \
 libselinux \
 libsepol \
 "
RDEPENDS:libsemanage-devel = " \
 libselinux-devel \
 libsemanage \
 libsepol-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libsemanage = " \
 glibc \
 libsemanage \
 python3 \
 python3-libselinux \
 "
