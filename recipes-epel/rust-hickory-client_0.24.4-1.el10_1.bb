# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-client"
PV = "0.24.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-hickory-client+backtrace-devel \
 rust-hickory-client+default-devel \
 rust-hickory-client+dns-over-native-tls-devel \
 rust-hickory-client+dns-over-openssl-devel \
 rust-hickory-client+dns-over-tls-devel \
 rust-hickory-client+dnssec-devel \
 rust-hickory-client+dnssec-openssl-devel \
 rust-hickory-client+mdns-devel \
 rust-hickory-client+serde-config-devel \
 rust-hickory-client+serde-devel \
 rust-hickory-client-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-client-0.24.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c66bad197cb4ade416cdb1fb1f261be2709631e679aceea25b0069b3ec8b361b"

URI_x86_64_v2_rust-hickory-client+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+backtrace-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+backtrace-devel.sha256sum] = "d763d4d88a6e00a89fb04f48142a8af5573f71e1fbaeff7e9c8333028999b175"

URI_x86_64_v2_rust-hickory-client+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+default-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+default-devel.sha256sum] = "758e6d439c9955b721554124b15f3c517cafb596d8287518604c11adecb22fe4"

URI_x86_64_v2_rust-hickory-client+dns-over-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+dns-over-native-tls-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+dns-over-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+dns-over-native-tls-devel.sha256sum] = "99b1f7ac7f5a0167d73b23d1d2b6c147d0d37148abadd82523025941752c3585"

URI_x86_64_v2_rust-hickory-client+dns-over-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+dns-over-openssl-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+dns-over-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+dns-over-openssl-devel.sha256sum] = "c739b7d09bd26a004cd8e4588c7d9d1014eec1fe1e4d5bf116db03589af6e68e"

URI_x86_64_v2_rust-hickory-client+dns-over-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+dns-over-tls-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+dns-over-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+dns-over-tls-devel.sha256sum] = "d8b54129ecf0844f8cb13051614264d5e5450e94cc61dd783507ff1657b850a8"

URI_x86_64_v2_rust-hickory-client+dnssec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+dnssec-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+dnssec-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+dnssec-devel.sha256sum] = "e72bdb6104305729e75a6c33b7ce4537dc983db6f67f8aeb8808396f0f83a906"

URI_x86_64_v2_rust-hickory-client+dnssec-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+dnssec-openssl-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+dnssec-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+dnssec-openssl-devel.sha256sum] = "600ae3ac5a529f307c9419181e0f211c775a6e0848a7b79bb93503ff1b66af10"

URI_x86_64_v2_rust-hickory-client+mdns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+mdns-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+mdns-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+mdns-devel.sha256sum] = "3c9a3858330de1e46926405926c6c86fde06191201e73df67bf7a1a05c4593b8"

URI_x86_64_v2_rust-hickory-client+serde-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+serde-config-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+serde-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+serde-config-devel.sha256sum] = "da07c2118e0aa9cf4c2e4469c01928f036c1cffe0616a681ec4ea600477fb238"

URI_x86_64_v2_rust-hickory-client+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+serde-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+serde-devel.sha256sum] = "0f5032357cac6519f78b2a503a32578d1ef66240c9719e342d2d3c4d7f8fb4df"

URI_x86_64_v2_rust-hickory-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client-devel}"
SRC_URI[x86_64_v2_rust-hickory-client-devel.sha256sum] = "505ea8014507ca46e64329e0c5333f6479512e429e2822b17d25681e5a3fdc2b"

URI_aarch64_rust-hickory-client+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+backtrace-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-client+backtrace-devel.sha256sum] = "91462abef56364a9a617e454f3f3ff26cef35397cf0ba1882969481c11e0f202"

URI_aarch64_rust-hickory-client+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+default-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+default-devel}"
SRC_URI[aarch64_rust-hickory-client+default-devel.sha256sum] = "98cabac26844fbd75d709d5df12a216f7c5fea56dde8edbfdc386964926d378d"

URI_aarch64_rust-hickory-client+dns-over-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+dns-over-native-tls-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+dns-over-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-client+dns-over-native-tls-devel.sha256sum] = "5f2084de840d9c08d28098088b29fd9540b865ca09a4af384008448d0303880b"

URI_aarch64_rust-hickory-client+dns-over-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+dns-over-openssl-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+dns-over-openssl-devel}"
SRC_URI[aarch64_rust-hickory-client+dns-over-openssl-devel.sha256sum] = "565c56d14163128aff5448bb67e73af012841f4d33460db36f3b2fc1635289a5"

URI_aarch64_rust-hickory-client+dns-over-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+dns-over-tls-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+dns-over-tls-devel}"
SRC_URI[aarch64_rust-hickory-client+dns-over-tls-devel.sha256sum] = "8358d04f22d170b53d2f856f8783a3e9986bce08aece27f94f5e889184ee6553"

URI_aarch64_rust-hickory-client+dnssec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+dnssec-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+dnssec-devel}"
SRC_URI[aarch64_rust-hickory-client+dnssec-devel.sha256sum] = "b9448fd4e6d5a0ef7eddf15eeec3e1e3ab82174e8fcb33b4bb5d67575240c606"

URI_aarch64_rust-hickory-client+dnssec-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+dnssec-openssl-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+dnssec-openssl-devel}"
SRC_URI[aarch64_rust-hickory-client+dnssec-openssl-devel.sha256sum] = "1289ee3f624456c075553508becfdcd50cc62061290f480dde3d30b57ae29fcf"

URI_aarch64_rust-hickory-client+mdns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+mdns-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+mdns-devel}"
SRC_URI[aarch64_rust-hickory-client+mdns-devel.sha256sum] = "d84516ec3e942cd4c0d07c3db01ec124bfe97db880dc8bf1d4444333f0f36747"

URI_aarch64_rust-hickory-client+serde-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+serde-config-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+serde-config-devel}"
SRC_URI[aarch64_rust-hickory-client+serde-config-devel.sha256sum] = "e0466094e5ea7a6004fb13236639d3df35bb8538033d66781d4736c7d7f48a4c"

URI_aarch64_rust-hickory-client+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+serde-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+serde-devel}"
SRC_URI[aarch64_rust-hickory-client+serde-devel.sha256sum] = "70e7738add276a2c4441d2c83eeff0d9800191b71bf2db413632063dd7911700"

URI_aarch64_rust-hickory-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client-devel}"
SRC_URI[aarch64_rust-hickory-client-devel.sha256sum] = "fed6b6ff95de5a789e58ff27e19bc7b4d4f6ddac5a3875edde537f9e69caad0d"

RDEPENDS:rust-hickory-client+backtrace-devel = " \
 cargo \
 rust-hickory-client-devel \
 rust-hickory-proto0.24+backtrace-devel \
 "
RDEPENDS:rust-hickory-client+default-devel = " \
 cargo \
 rust-hickory-client-devel \
 "
RDEPENDS:rust-hickory-client+dns-over-native-tls-devel = " \
 cargo \
 rust-hickory-client+dns-over-tls-devel \
 rust-hickory-client-devel \
 rust-hickory-proto0.24+dns-over-native-tls-devel \
 "
RDEPENDS:rust-hickory-client+dns-over-openssl-devel = " \
 cargo \
 rust-hickory-client+dns-over-tls-devel \
 rust-hickory-client+dnssec-openssl-devel \
 rust-hickory-client-devel \
 "
RDEPENDS:rust-hickory-client+dns-over-tls-devel = " \
 cargo \
 rust-hickory-client-devel \
 "
RDEPENDS:rust-hickory-client+dnssec-devel = " \
 cargo \
 rust-hickory-client-devel \
 rust-hickory-proto0.24+dnssec-devel \
 "
RDEPENDS:rust-hickory-client+dnssec-openssl-devel = " \
 cargo \
 rust-hickory-client+dnssec-devel \
 rust-hickory-client-devel \
 rust-hickory-proto0.24+dnssec-openssl-devel \
 "
RDEPENDS:rust-hickory-client+mdns-devel = " \
 cargo \
 rust-hickory-client-devel \
 rust-hickory-proto0.24+mdns-devel \
 "
RDEPENDS:rust-hickory-client+serde-config-devel = " \
 cargo \
 rust-hickory-client+serde-devel \
 rust-hickory-client-devel \
 rust-hickory-proto0.24+serde-config-devel \
 "
RDEPENDS:rust-hickory-client+serde-devel = " \
 cargo \
 rust-hickory-client-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-hickory-client-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-data-encoding+default-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-proto0.24+text-parsing-devel \
 rust-hickory-proto0.24+tokio-runtime-devel \
 rust-hickory-proto0.24-devel \
 rust-once_cell+default-devel \
 rust-radix_trie+default-devel \
 rust-rand0.8+default-devel \
 rust-thiserror1+default-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tracing+default-devel \
 "
