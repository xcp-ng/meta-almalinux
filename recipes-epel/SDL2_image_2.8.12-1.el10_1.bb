# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SDL2_image"
PV = "2.8.12"
PR = "1.el10_1"
PACKAGES = " \
 SDL2_image \
 SDL2_image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SDL2_image-2.8.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58669ab2ae6f58cfd43b163cdb1d689855cd096ba454285eea85c34a3222b581"

URI_x86_64_v2_SDL2_image = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_image-2.8.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_image;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_image}"
SRC_URI[x86_64_v2_SDL2_image.sha256sum] = "5bde7f6828605179f050ef6043f89e063b6a4ea5a8eeb6304f5f38a006d338d3"

URI_x86_64_v2_SDL2_image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_image-devel-2.8.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_image-devel}"
SRC_URI[x86_64_v2_SDL2_image-devel.sha256sum] = "4e2d380379ac8cda745efc36adbce9b8895378734d3576554885669c19b403ab"

URI_aarch64_SDL2_image = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_image-2.8.12-1.el10_1.aarch64.rpm;name=aarch64_SDL2_image;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_image}"
SRC_URI[aarch64_SDL2_image.sha256sum] = "6875347dac8b28324d3f84c0a21fafa554c057e055f86df192bb1d6e4969e933"

URI_aarch64_SDL2_image-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_image-devel-2.8.12-1.el10_1.aarch64.rpm;name=aarch64_SDL2_image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_image-devel}"
SRC_URI[aarch64_SDL2_image-devel.sha256sum] = "3ebf50f996978cce45139ad95dce8469903fd5eab899dcc55a3230a1a5449ce5"

RDEPENDS:SDL2_image = " \
 glibc \
 libavif \
 libjxl \
 libtiff \
 libwebp \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:SDL2_image-devel = " \
 SDL2-devel \
 SDL2_image \
 libavif-devel \
 libjxl-devel \
 libtiff-devel \
 libwebp-devel \
 pkgconf-pkg-config \
 "
