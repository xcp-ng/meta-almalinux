# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kimageformats"
PV = "6.28.1"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kimageformats \
 kf6-kimageformats-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kimageformats-6.28.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac3eb790371b9873a9a0b68618df1ede1091924cbaf492d4267bec9e2e6d5d4c"

URI_x86_64_v2_kf6-kimageformats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kimageformats-6.28.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kimageformats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kimageformats}"
SRC_URI[x86_64_v2_kf6-kimageformats.sha256sum] = "0047ca9879035b48f5a3aa26b37974a4f87b1169d3603f7f4f932548335ca758"

URI_x86_64_v2_kf6-kimageformats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kimageformats-devel-6.28.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kimageformats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kimageformats-devel}"
SRC_URI[x86_64_v2_kf6-kimageformats-devel.sha256sum] = "a916a0967b0a4d5b9d7ebfecc1f681f28c80a66850f67b594c46d654f1c0cbd8"

URI_aarch64_kf6-kimageformats = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kimageformats-6.28.1-1.el10_3.aarch64.rpm;name=aarch64_kf6-kimageformats;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kimageformats}"
SRC_URI[aarch64_kf6-kimageformats.sha256sum] = "ec55db313e2d3c3c58af29341dec599fbd33b9b07c0e4ff3dd77409d41d25080"

URI_aarch64_kf6-kimageformats-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kimageformats-devel-6.28.1-1.el10_3.aarch64.rpm;name=aarch64_kf6-kimageformats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kimageformats-devel}"
SRC_URI[aarch64_kf6-kimageformats-devel.sha256sum] = "6dbe1f6473c335aa7a4b503b28a8b7cd69a64d0590961097e8201fe1a826bb11"

RDEPENDS:kf6-kimageformats = " \
 LibRaw \
 glibc \
 imath \
 kf6-filesystem \
 kf6-karchive \
 libavif \
 libgcc \
 libheif \
 libjxl \
 libstdc++ \
 openexr-libs \
 openjpeg2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kimageformats-devel = " \
 cmake-filesystem \
 kf6-kimageformats \
 "
