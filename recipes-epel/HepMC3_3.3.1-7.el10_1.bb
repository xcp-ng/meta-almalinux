# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "HepMC3"
PV = "3.3.1"
PR = "7.el10_1"
PACKAGES = " \
 HepMC3 \
 HepMC3-devel \
 HepMC3-doc \
 HepMC3-interfaces-devel \
 HepMC3-protobufIO \
 HepMC3-protobufIO-devel \
 HepMC3-rootIO \
 HepMC3-rootIO-devel \
 HepMC3-search \
 HepMC3-search-devel \
 python3-HepMC3 \
 python3-HepMC3-protobufIO \
 python3-HepMC3-rootIO \
 python3-HepMC3-search \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/HepMC3-3.3.1-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d3742b814931e3100136f112267eeb666fd92d2fd55a6f74cec87f97d69b843"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - HepMC3-rootIO: libCore.so.6.36()(64bit)
# - HepMC3-rootIO: libRIO.so.6.36()(64bit)
# - HepMC3-rootIO: libTree.so.6.36()(64bit)
# - python3-HepMC3-rootIO: libCore.so.6.36()(64bit)

URI_x86_64_v2_HepMC3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3}"
SRC_URI[x86_64_v2_HepMC3.sha256sum] = "4f60aa99b8605ebb6e5d7603f48cedc4e97d9cadf25016cd6aa5016831bfe673"

URI_x86_64_v2_HepMC3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-devel-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-devel}"
SRC_URI[x86_64_v2_HepMC3-devel.sha256sum] = "9055b00cf08cbb55cb66d554cee15c6df562e436aeffc120c58ee67168bc1b22"

URI_x86_64_v2_HepMC3-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-doc-3.3.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-doc}"
SRC_URI[x86_64_v2_HepMC3-doc.sha256sum] = "b56f8ee8a2e39647c4fee6721bd3a8e814b0a4da0a345133c9c25c21df13bf87"

URI_x86_64_v2_HepMC3-interfaces-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-interfaces-devel-3.3.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC3-interfaces-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-interfaces-devel}"
SRC_URI[x86_64_v2_HepMC3-interfaces-devel.sha256sum] = "dac4911ac317334b6a9eabe3369ca376d5f05216cb343dcbc35ae3fba7946ecd"

URI_x86_64_v2_HepMC3-protobufIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-protobufIO-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-protobufIO}"
SRC_URI[x86_64_v2_HepMC3-protobufIO.sha256sum] = "27fc95b6ff464fe557fefa28e7943b6ecb929adab7b463fcb2f951e3295ca15a"

URI_x86_64_v2_HepMC3-protobufIO-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-protobufIO-devel-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-protobufIO-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-protobufIO-devel}"
SRC_URI[x86_64_v2_HepMC3-protobufIO-devel.sha256sum] = "3c38ea62a0cf9ce443f16cf307bdb03ca93deb94cdaebb187ddfa548f632a7de"

URI_x86_64_v2_HepMC3-rootIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-rootIO-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-rootIO}"
SRC_URI[x86_64_v2_HepMC3-rootIO.sha256sum] = "4db08271c8ecbbcc25e7de92ffd7c7eae9d92a4abc9e1c40aade970feaaac50f"

URI_x86_64_v2_HepMC3-rootIO-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-rootIO-devel-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-rootIO-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-rootIO-devel}"
SRC_URI[x86_64_v2_HepMC3-rootIO-devel.sha256sum] = "5cb10af4c6f57dfd0b4755bc27264ac06ddeea401c773a04f11ccd11384144f7"

URI_x86_64_v2_HepMC3-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-search-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-search}"
SRC_URI[x86_64_v2_HepMC3-search.sha256sum] = "77cfaaac7952f05ffb8ff10fe6284d5b20a42cac62bbafdb58630d8add2de74d"

URI_x86_64_v2_HepMC3-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC3-search-devel-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC3-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC3-search-devel}"
SRC_URI[x86_64_v2_HepMC3-search-devel.sha256sum] = "bdff6ced2c8fae4ea6c8efe7ac566e09d93f6562db2e27feccf86ff852505b54"

URI_x86_64_v2_python3-HepMC3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3}"
SRC_URI[x86_64_v2_python3-HepMC3.sha256sum] = "37ef3632fc76cbdf6405ecde7020b14471d2b3c2bfa54d2e1c38df585937c845"

URI_x86_64_v2_python3-HepMC3-protobufIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-protobufIO-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-protobufIO}"
SRC_URI[x86_64_v2_python3-HepMC3-protobufIO.sha256sum] = "9fb734b77f29e9f6715c6476fce46a9e63948d8b671cfbacb35cb8c4a13cc6dd"

URI_x86_64_v2_python3-HepMC3-rootIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-rootIO-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-rootIO}"
SRC_URI[x86_64_v2_python3-HepMC3-rootIO.sha256sum] = "97815278e678b737edd9a69e3af629d1d641f213b2ffcd1782954c610ea6e454"

URI_x86_64_v2_python3-HepMC3-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-HepMC3-search-3.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-HepMC3-search}"
SRC_URI[x86_64_v2_python3-HepMC3-search.sha256sum] = "e46cabc38b6f967fa6e9af9f0e6007d439b90ed2d39f69f0265d5341320e8fbc"

URI_aarch64_HepMC3 = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_HepMC3;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3}"
SRC_URI[aarch64_HepMC3.sha256sum] = "5151e644c455019dae7d272ef5028d667518420550ebdc8e08a2a1e03c9f37d8"

URI_aarch64_HepMC3-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-devel-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_HepMC3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-devel}"
SRC_URI[aarch64_HepMC3-devel.sha256sum] = "e07e44983ce312a64ae84df7e8809db0a5dae8fb0559a704c6e61a7bf742dee1"

URI_aarch64_HepMC3-doc = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-doc-3.3.1-7.el10_1.noarch.rpm;name=aarch64_HepMC3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-doc}"
SRC_URI[aarch64_HepMC3-doc.sha256sum] = "36234c80af551e7037133da66006d0b6eb06b3026267aa9506354c701be5eddb"

URI_aarch64_HepMC3-interfaces-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-interfaces-devel-3.3.1-7.el10_1.noarch.rpm;name=aarch64_HepMC3-interfaces-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-interfaces-devel}"
SRC_URI[aarch64_HepMC3-interfaces-devel.sha256sum] = "ee5ec43d525a4f5d333d5992162a322b9da7a00140cd57c0a68659d570dd8698"

URI_aarch64_HepMC3-protobufIO = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-protobufIO-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-protobufIO}"
SRC_URI[aarch64_HepMC3-protobufIO.sha256sum] = "be98ea7424874d57824c0b37c594fd752bb5953a7d16cfa365f14818317abe68"

URI_aarch64_HepMC3-protobufIO-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-protobufIO-devel-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_HepMC3-protobufIO-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-protobufIO-devel}"
SRC_URI[aarch64_HepMC3-protobufIO-devel.sha256sum] = "e5c2b5589d106ed1f00bae1e0d5c623b691bd8d532d80d2d9bf0977f2c85ebd8"

URI_aarch64_HepMC3-rootIO = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-rootIO-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-rootIO}"
SRC_URI[aarch64_HepMC3-rootIO.sha256sum] = "fd8a116d7c662ed1cae84fae17dd8e38df82641dd37b392416ad407a12936c39"

URI_aarch64_HepMC3-rootIO-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-rootIO-devel-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_HepMC3-rootIO-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-rootIO-devel}"
SRC_URI[aarch64_HepMC3-rootIO-devel.sha256sum] = "6e27adf80dd3afed75e006cef0cdbe1e85bceac905e2b05663c1832c751fdc2c"

URI_aarch64_HepMC3-search = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-search-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-search}"
SRC_URI[aarch64_HepMC3-search.sha256sum] = "278f73a6d52ed19ad7d6a25a1f17830a1b99db49aedc08eb7c31206ddc5c1f8c"

URI_aarch64_HepMC3-search-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC3-search-devel-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_HepMC3-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC3-search-devel}"
SRC_URI[aarch64_HepMC3-search-devel.sha256sum] = "330cb68a302dff7e1803aa441587289f23d88590fb1e620dca2cae5d647ee0a7"

URI_aarch64_python3-HepMC3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_python3-HepMC3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3}"
SRC_URI[aarch64_python3-HepMC3.sha256sum] = "cefa1d9448178f9f1e3dc27b9cb66689aac96134ee92252c9ebbe568ab253f43"

URI_aarch64_python3-HepMC3-protobufIO = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-protobufIO-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_python3-HepMC3-protobufIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-protobufIO}"
SRC_URI[aarch64_python3-HepMC3-protobufIO.sha256sum] = "f733245390e3905b1c87bdd398408387ee985e05bdbf229c23317e220c3bca65"

URI_aarch64_python3-HepMC3-rootIO = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-rootIO-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_python3-HepMC3-rootIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-rootIO}"
SRC_URI[aarch64_python3-HepMC3-rootIO.sha256sum] = "1eb094cdba465500ab5f5261a48433df40c0eb0fa59128b07a463a0ba0a577fc"

URI_aarch64_python3-HepMC3-search = "${EPEL_MIRROR}/aarch64/Packages/p/python3-HepMC3-search-3.3.1-7.el10_1.aarch64.rpm;name=aarch64_python3-HepMC3-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-HepMC3-search}"
SRC_URI[aarch64_python3-HepMC3-search.sha256sum] = "cb8b8c971e7077de0a4ae01292de53cdbed20e715eaa0778ee5a8820663c0316"

RDEPENDS:HepMC3 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC3-devel = " \
 HepMC3 \
 bash \
 "
RDEPENDS:HepMC3-doc = " \
 "
RDEPENDS:HepMC3-interfaces-devel = " \
 HepMC3-devel \
 "
RDEPENDS:HepMC3-protobufIO = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 "
RDEPENDS:HepMC3-protobufIO-devel = " \
 HepMC3-devel \
 HepMC3-protobufIO \
 "
RDEPENDS:HepMC3-rootIO:x86_64_v2 = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
"
RDEPENDS:HepMC3-rootIO:aarch64 = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-tree \
"
RDEPENDS:HepMC3-rootIO-devel = " \
 HepMC3-devel \
 HepMC3-rootIO \
 "
RDEPENDS:HepMC3-search = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC3-search-devel = " \
 HepMC3-devel \
 HepMC3-search \
 "
RDEPENDS:python3-HepMC3 = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:python3-HepMC3-protobufIO = " \
 HepMC3 \
 HepMC3-protobufIO \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 python3 \
 python3-HepMC3 \
 "
RDEPENDS:python3-HepMC3-rootIO:x86_64_v2 = " \
 HepMC3 \
 HepMC3-rootIO \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-HepMC3 \
"
RDEPENDS:python3-HepMC3-rootIO:aarch64 = " \
 HepMC3 \
 HepMC3-rootIO \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-HepMC3 \
 root-core \
"
RDEPENDS:python3-HepMC3-search = " \
 HepMC3 \
 HepMC3-search \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-HepMC3 \
 "
