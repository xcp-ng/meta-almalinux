# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "license-validate"
PV = "31"
PR = "1.el10_3"
PACKAGES = " \
 license-validate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/license-validate-31-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce1c51e8978c2823e262f202ecd1a8574a7f6aa1e0aaf9e6378cac2c9140e719"

URI_x86_64_v2_license-validate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/license-validate-31-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_license-validate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_license-validate}"
SRC_URI[x86_64_v2_license-validate.sha256sum] = "09d640020020c86a1f03822b5ab93f977c0fa0ffed0b1d8c2e0109a80ef3da6b"

URI_aarch64_license-validate = "${EPEL_MIRROR}/aarch64/Packages/l/license-validate-31-1.el10_3.noarch.rpm;name=aarch64_license-validate;unpack=0"
SRC_URI:append = " ${URI_aarch64_license-validate}"
SRC_URI[aarch64_license-validate.sha256sum] = "c3a4f98efa999adb73cf3baa510da23721fb8c9daee4b4b0b1ebc46d547281ee"

RDEPENDS:license-validate = " \
 fedora-license-data \
 python3 \
 python3-lark \
 python3-specfile \
 "
