# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-omp"
PV = "7.1.1"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 rocm-omp \
 rocm-omp-devel \
 rocm-omp-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-omp-7.1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "602777fa44112976789bcb0ece681b5c0346a9715f770d3c336d650836064cac"

URI_x86_64_v2_rocm-omp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-omp-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-omp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-omp}"
SRC_URI[x86_64_v2_rocm-omp.sha256sum] = "90c2ca6df0cd54db56a0c980d9f57d814e75854b91e438c614e4e5abb9346aeb"

URI_x86_64_v2_rocm-omp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-omp-devel-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-omp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-omp-devel}"
SRC_URI[x86_64_v2_rocm-omp-devel.sha256sum] = "b47ec849010193fea45305c9f2b561840bcc9a9d6355f49c925a6c898facccb3"
RPROVIDES:rocm-omp-devel:x86_64_v2 = "virtual/libomp.so_VERSION__64bit_ virtual/libomp.so___64bit_"

URI_x86_64_v2_rocm-omp-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-omp-static-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-omp-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-omp-static}"
SRC_URI[x86_64_v2_rocm-omp-static.sha256sum] = "d5d0b21a249045f9f80fdad8350a97714a284dcfc5096fa04dd3b4e722eb2582"

RDEPENDS:rocm-omp = " \
 rocm-llvm-filesystem \
 "
RDEPENDS:rocm-omp-devel = " \
 glibc \
 rocm-omp \
 "
RDEPENDS:rocm-omp-static = " \
 rocm-omp-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libomp.so_VERSION__64bit_ rpm/virtual/libomp.so___64bit_"
