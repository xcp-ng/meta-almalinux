# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openstacksdk"
PV = "4.10.0"
PR = "2.el10_3"
PACKAGES = " \
 python3-openstacksdk \
 python3-openstacksdk-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openstacksdk-4.10.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "722f290de299f01434d66d53c52372373d89941fd079900fabb2b45ea5b6f697"

URI_x86_64_v2_python3-openstacksdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstacksdk-4.10.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openstacksdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstacksdk}"
SRC_URI[x86_64_v2_python3-openstacksdk.sha256sum] = "cadb81de12fd1496d717c9e133b0940ff158e5718fbf694223ab63e735f80d11"

URI_x86_64_v2_python3-openstacksdk-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstacksdk-tests-4.10.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openstacksdk-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstacksdk-tests}"
SRC_URI[x86_64_v2_python3-openstacksdk-tests.sha256sum] = "a940a5b4b76be5b8a00a2bf3f4e87696681298993a95d073260cbb9d5521f4b3"

URI_aarch64_python3-openstacksdk = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstacksdk-4.10.0-2.el10_3.noarch.rpm;name=aarch64_python3-openstacksdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstacksdk}"
SRC_URI[aarch64_python3-openstacksdk.sha256sum] = "0648b41b0a7e1150111355a3751040670b687c957d51b67ed54765ba5d3d77e8"

URI_aarch64_python3-openstacksdk-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstacksdk-tests-4.10.0-2.el10_3.noarch.rpm;name=aarch64_python3-openstacksdk-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstacksdk-tests}"
SRC_URI[aarch64_python3-openstacksdk-tests.sha256sum] = "4b05d17761eac6808d1debc37ff3fdb7496df73a0a2b962960542a7dd36ffb79"

RDEPENDS:python3-openstacksdk = " \
 python3 \
 python3-cryptography \
 python3-decorator \
 python3-dogpile-cache \
 python3-iso8601 \
 python3-jmespath \
 python3-jsonpatch \
 python3-keystoneauth1 \
 python3-os-service-types \
 python3-pbr \
 python3-platformdirs \
 python3-psutil \
 python3-pyyaml \
 python3-requestsexceptions \
 python3-typing-extensions \
 "
RDEPENDS:python3-openstacksdk-tests = " \
 bash \
 python3 \
 python3-openstacksdk \
 "
