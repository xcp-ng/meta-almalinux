# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-filesystem \
 qt6-rpm-macros \
 qt6-srpm-macros \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "39723329874da257a13a4b89306950d669b5ca4314a3b6c3bc24799279baa660"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-filesystem-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-filesystem;unpack=0"
SRC_URI[x86_64_v2_qt6-filesystem.sha256sum] = "20cc1ef2622b48eb83a27889ef68f13e3551268b88c20acd24cc6a1365c0995d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-rpm-macros-6.10.1-1.el10.noarch.rpm;name=x86_64_v2_qt6-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_qt6-rpm-macros.sha256sum] = "e46bc5d0286518a66d1aba5f9492e763f0313223980d749ea09062436111c77d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-srpm-macros-6.10.1-1.el10.noarch.rpm;name=x86_64_v2_qt6-srpm-macros;unpack=0"
SRC_URI[x86_64_v2_qt6-srpm-macros.sha256sum] = "894de6c329420bfac338492dbd3c77c6100f22775702f395c4d212f082abd6dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-filesystem-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-filesystem;unpack=0"
SRC_URI[aarch64_qt6-filesystem.sha256sum] = "3b4a50d83c59bfd1edb615bd0232c72579557f8fd8978f04dbb7c70150e74983"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-rpm-macros-6.10.1-1.el10.noarch.rpm;name=aarch64_qt6-rpm-macros;unpack=0"
SRC_URI[aarch64_qt6-rpm-macros.sha256sum] = "e46bc5d0286518a66d1aba5f9492e763f0313223980d749ea09062436111c77d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-srpm-macros-6.10.1-1.el10.noarch.rpm;name=aarch64_qt6-srpm-macros;unpack=0"
SRC_URI[aarch64_qt6-srpm-macros.sha256sum] = "894de6c329420bfac338492dbd3c77c6100f22775702f395c4d212f082abd6dd"

RDEPENDS:qt6-filesystem = " \
 "
RDEPENDS:qt6-rpm-macros = " \
 bash \
 chrpath \
 cmake \
 gcc-c++ \
 "
RDEPENDS:qt6-srpm-macros = " \
 "
