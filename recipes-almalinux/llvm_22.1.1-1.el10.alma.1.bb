# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm"
PV = "22.1.1"
PR = "1.el10.alma.1"
PACKAGES = " \
 clang \
 clang-analyzer \
 clang-devel \
 clang-libs \
 clang-resource-filesystem \
 clang-tools-extra \
 compiler-rt \
 git-clang-format \
 libomp \
 libomp-devel \
 lld \
 lld-devel \
 lld-libs \
 lldb \
 lldb-devel \
 llvm \
 llvm-devel \
 llvm-doc \
 llvm-filesystem \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 llvm-toolset \
 python3-clang \
 python3-lit \
 python3-lldb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/llvm-22.1.1-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee577add623057850ea472dc00970c9ccfcc1f8b531afa61ea94e757bff2c9c5"

URI_x86_64_v2_clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang}"
SRC_URI[x86_64_v2_clang.sha256sum] = "867f43cbdbc9228c7ac5fd5c5ca76836fcb143d7ce4da1c5390e185912dba16e"

URI_x86_64_v2_clang-analyzer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-analyzer-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-analyzer}"
SRC_URI[x86_64_v2_clang-analyzer.sha256sum] = "1e8d6246d7a8305faa4670045c89151a4b9be98418e49ec3039ee9006ae9d500"

URI_x86_64_v2_clang-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-devel-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-devel}"
SRC_URI[x86_64_v2_clang-devel.sha256sum] = "fc66564f0ef48765ffddc8463230f260c30ae625c1bf690e07fd2b588b587cc4"

URI_x86_64_v2_clang-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-libs-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-libs}"
SRC_URI[x86_64_v2_clang-libs.sha256sum] = "aeecc8f120b70f7a8c172f27b264b6a662dd8d8a4d486a39964b9f1233cad143"

URI_x86_64_v2_clang-resource-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-resource-filesystem-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-resource-filesystem}"
SRC_URI[x86_64_v2_clang-resource-filesystem.sha256sum] = "d22a46718121896edb155974d616c156549207c7dc030b42eac36da35904e3d9"

URI_x86_64_v2_clang-tools-extra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-tools-extra-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang-tools-extra}"
SRC_URI[x86_64_v2_clang-tools-extra.sha256sum] = "a555378466d806068113d28185325d3c3b52a9a8dfeb95839a564f313ec0bdac"

URI_x86_64_v2_compiler-rt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/compiler-rt-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_compiler-rt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compiler-rt}"
SRC_URI[x86_64_v2_compiler-rt.sha256sum] = "a8790a865cae035dd130d5d0983668d4ade228d93cf582a08111702fbabd666b"

URI_x86_64_v2_git-clang-format = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-clang-format-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_git-clang-format;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-clang-format}"
SRC_URI[x86_64_v2_git-clang-format.sha256sum] = "230b5fa9fa882e3d842561d88744bf23cc9875dda4a9d9b703332a75af42e5c7"

URI_x86_64_v2_libomp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libomp-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp}"
SRC_URI[x86_64_v2_libomp.sha256sum] = "b5af31edc92d97f5eba3904d34104e120cde1d88d2cc7c6f34a66c284505d861"
RPROVIDES:libomp:x86_64_v2 = "virtual/libomp.so_VERSION__64bit_ virtual/libomp.so___64bit_"

URI_x86_64_v2_libomp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libomp-devel-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp-devel}"
SRC_URI[x86_64_v2_libomp-devel.sha256sum] = "a6c60ec90a00db5c8feefca3b4dc7990adf9c4fc176642d8ad50caea9a7af1ac"

URI_x86_64_v2_lld = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld}"
SRC_URI[x86_64_v2_lld.sha256sum] = "0954446529d52f4db0876999cdf1131435017dbe55ec4627ef9a5a6418d5cae5"

URI_x86_64_v2_lld-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-devel-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld-devel}"
SRC_URI[x86_64_v2_lld-devel.sha256sum] = "261c31b88fa122af7812d14e88c4cf0c84251794ecf0860edb21dedbe41b32ab"

URI_x86_64_v2_lld-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-libs-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld-libs}"
SRC_URI[x86_64_v2_lld-libs.sha256sum] = "dcd0eadb59f8aa02b475755c69beed1ddbd80accd04dddfca320f1808990d092"

URI_x86_64_v2_lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldb-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb}"
SRC_URI[x86_64_v2_lldb.sha256sum] = "9a6c62b3db180cbe05f04415a3406e9443fde727eadce8eb355441c95142a417"

URI_x86_64_v2_lldb-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldb-devel-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lldb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb-devel}"
SRC_URI[x86_64_v2_lldb-devel.sha256sum] = "fabd65077a1ba449aa7bcd9a88ca2248d32f3f463131cfbabba43d6f88ce9ec1"

URI_x86_64_v2_llvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm}"
SRC_URI[x86_64_v2_llvm.sha256sum] = "7cfe9153858ffd302423cad674f37caf197a3f0e301b1c89ac092a46ccf0b099"

URI_x86_64_v2_llvm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-devel-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-devel}"
SRC_URI[x86_64_v2_llvm-devel.sha256sum] = "d2ff4f8cd51560929f94b5d0666fdafe9fc88f54b470c90030dc1dac52a44b9e"

URI_x86_64_v2_llvm-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-doc-22.1.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_llvm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-doc}"
SRC_URI[x86_64_v2_llvm-doc.sha256sum] = "31009e4c51ec17d0a2ce7c666b28a2497aa5890d598d67946a744bb743b319d5"

URI_x86_64_v2_llvm-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-filesystem-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-filesystem}"
SRC_URI[x86_64_v2_llvm-filesystem.sha256sum] = "735f9e8cfb1c8898e7bcbdea35631480db5bcd3092bb7cf5b2206df7d8b6779a"

URI_x86_64_v2_llvm-googletest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-googletest-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-googletest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-googletest}"
SRC_URI[x86_64_v2_llvm-googletest.sha256sum] = "b2f649a712a285db44d76635b1d1856eac305fe409087303cc64526f67a88616"

URI_x86_64_v2_llvm-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-libs-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-libs}"
SRC_URI[x86_64_v2_llvm-libs.sha256sum] = "b71b3e20faab3a317c737f856570a38c616fe75cc3ebefc9c443d57a92883062"

URI_x86_64_v2_llvm-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-static-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-static}"
SRC_URI[x86_64_v2_llvm-static.sha256sum] = "f912c59867ecd43eb8f65a6177f6e3729c601760b8ff429d6ce3468f4851a0ac"

URI_x86_64_v2_llvm-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-test-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-test}"
SRC_URI[x86_64_v2_llvm-test.sha256sum] = "a599be1b75cb2e1017c20fdfe467b71eda4d1f5cd9556c14df9911544ee89756"

URI_x86_64_v2_llvm-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-toolset-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm-toolset}"
SRC_URI[x86_64_v2_llvm-toolset.sha256sum] = "769d844788d64af2f79706de9cac33d0afda5c10ba7fe85accb60a8c6bedad84"

URI_x86_64_v2_python3-clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-clang-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-clang}"
SRC_URI[x86_64_v2_python3-clang.sha256sum] = "f2f27fefab2aefebccccfdfa2d305c4e5fe46447e9e954185392e003094c21f6"

URI_x86_64_v2_python3-lit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lit-22.1.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-lit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lit}"
SRC_URI[x86_64_v2_python3-lit.sha256sum] = "a3079f45cf0a91a45dead5ac1763c9a3c5ff363e3029afff26e66cd777649a77"

URI_x86_64_v2_python3-lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lldb-22.1.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lldb}"
SRC_URI[x86_64_v2_python3-lldb.sha256sum] = "05a332492790054e849a4bac4350ffb7af9cdc6757cf50991e1cf032420c9ffa"

URI_aarch64_clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang}"
SRC_URI[aarch64_clang.sha256sum] = "8c08c36eee8632bc154c93b889ad7f07e53d354d29cb1f7763d9a187e7e42f4e"

URI_aarch64_clang-analyzer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-analyzer-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-analyzer}"
SRC_URI[aarch64_clang-analyzer.sha256sum] = "740f3dfc351dad79cce869a0740ed2d546526d7f3b38bc3322a30e4b1c1f6712"

URI_aarch64_clang-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-devel-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-devel}"
SRC_URI[aarch64_clang-devel.sha256sum] = "63e06b5bfc288674dc48483728774e7c0f65a268a9b5445bd5ac9005e8f5662a"

URI_aarch64_clang-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-libs-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-libs}"
SRC_URI[aarch64_clang-libs.sha256sum] = "615ab1781aa4ffdfa12c7589f629c69ac7b51f49a589eaa4cf8ce6f1a115e0b6"
RPROVIDES:clang-libs:aarch64 = "virtual/libclang-cpp.so.21.1_LLVM_21.1__64bit_ virtual/libclang-cpp.so.21.1___64bit_ virtual/libclang.so.21.1_LLVM_13__64bit_ virtual/libclang.so.21.1_LLVM_16__64bit_ virtual/libclang.so.21.1_LLVM_17__64bit_ virtual/libclang.so.21.1_LLVM_21__64bit_ virtual/libclang.so.21.1___64bit_"

URI_aarch64_clang-resource-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-resource-filesystem-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-resource-filesystem}"
SRC_URI[aarch64_clang-resource-filesystem.sha256sum] = "eb5924611a33188868b6ce44888aff1ecf562a4f6cf6f52aac6d42bb22805fd2"

URI_aarch64_clang-tools-extra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-tools-extra-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang-tools-extra}"
SRC_URI[aarch64_clang-tools-extra.sha256sum] = "a37ac193aa45848a0490295edddc07a36536d9bb3036f7c8df5e87ece9019a19"

URI_aarch64_compiler-rt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/compiler-rt-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_compiler-rt;unpack=0"
SRC_URI:append = " ${URI_aarch64_compiler-rt}"
SRC_URI[aarch64_compiler-rt.sha256sum] = "5293c17683aba35a667fe5f059d35ee92b5cfefbf1dae37b4d59ce81163736de"

URI_aarch64_git-clang-format = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-clang-format-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_git-clang-format;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-clang-format}"
SRC_URI[aarch64_git-clang-format.sha256sum] = "416f7f045832994c0ba99b647631473e81e5f35bce4327c6b9a95a5701579201"

URI_aarch64_libomp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libomp-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_libomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp}"
SRC_URI[aarch64_libomp.sha256sum] = "5e411435a0f5fff0ff3d31f717d098810e906ca1ec6a81a6f9fc2633e4ed1ebf"

URI_aarch64_libomp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libomp-devel-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_libomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp-devel}"
SRC_URI[aarch64_libomp-devel.sha256sum] = "fc54edcb64ab4de8f6bb790251f40825c8f42bef27720a8527c22023ccf738f6"

URI_aarch64_lld = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_lld;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld}"
SRC_URI[aarch64_lld.sha256sum] = "313ac43c0b3434f41002a781691cb2d95de289731174734a34f3cd3e5aefdf4b"

URI_aarch64_lld-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-devel-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_lld-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld-devel}"
SRC_URI[aarch64_lld-devel.sha256sum] = "486a8e174427ad7905f7eaaefdc4754882861ae04ccd6a56303fb343e66a389d"

URI_aarch64_lld-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-libs-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_lld-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld-libs}"
SRC_URI[aarch64_lld-libs.sha256sum] = "e065e9038f3fc98bd7b3dd3f4a24c62eb219f4abeeb014a9eab1c58e5938c06c"

URI_aarch64_lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldb-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb}"
SRC_URI[aarch64_lldb.sha256sum] = "94ee675e774ad9d9f7c81c9457f5d3d2086e81db0b28e86c7b466fbfea24e2a7"

URI_aarch64_lldb-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldb-devel-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_lldb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb-devel}"
SRC_URI[aarch64_lldb-devel.sha256sum] = "d4e7075b29c957c4c32ff2db22e7f719bbeb912788e3b1e3a387d9212502d8d7"

URI_aarch64_llvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm}"
SRC_URI[aarch64_llvm.sha256sum] = "cbd581899f767d7d963206d1e7f12ae595d277092bd617d2a03bc6aad76a1cca"

URI_aarch64_llvm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-devel-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-devel}"
SRC_URI[aarch64_llvm-devel.sha256sum] = "29ea29f9540eaf43e90aae0e83eb879d1928c790c324b5501007f04215357cfd"

URI_aarch64_llvm-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-doc-22.1.1-1.el10.alma.1.noarch.rpm;name=aarch64_llvm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-doc}"
SRC_URI[aarch64_llvm-doc.sha256sum] = "31009e4c51ec17d0a2ce7c666b28a2497aa5890d598d67946a744bb743b319d5"

URI_aarch64_llvm-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-filesystem-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-filesystem}"
SRC_URI[aarch64_llvm-filesystem.sha256sum] = "758269a5a657efea5baae2baa7560a8af94c0486583f7f01cf5ecd29736c4336"

URI_aarch64_llvm-googletest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-googletest-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-googletest;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-googletest}"
SRC_URI[aarch64_llvm-googletest.sha256sum] = "b5795c0ad28cccc40ba4d355dc053b380080a7564dc1ab6e09948ac8c45419f8"

URI_aarch64_llvm-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-libs-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-libs}"
SRC_URI[aarch64_llvm-libs.sha256sum] = "3a27a76e5977e4f78ab01c0d1343922e480ca528310ad294cdedbdc6b5390e2f"
RPROVIDES:llvm-libs:aarch64 = "virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ virtual/libLLVM.so.21.1___64bit_"

URI_aarch64_llvm-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-static-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-static}"
SRC_URI[aarch64_llvm-static.sha256sum] = "c6df2195d4f6ce2d183264e3bb768f30538ab61a481f05bc88ab54c2a6216d2c"

URI_aarch64_llvm-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-test-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-test}"
SRC_URI[aarch64_llvm-test.sha256sum] = "55e73c5ac2975dc5bf191f70280194f878a57f6a86dfb36ac1b8edb53642164a"

URI_aarch64_llvm-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-toolset-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm-toolset}"
SRC_URI[aarch64_llvm-toolset.sha256sum] = "43664ee4e5729d907b9a7dfbe644ff6202335a74834ce79de2f0b58cb8f6d379"

URI_aarch64_python3-clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-clang-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-clang}"
SRC_URI[aarch64_python3-clang.sha256sum] = "fb43f38f9c835d45dc6ddb3bf82e8a51aeac77dc7cbb084e6fe49f94a745d4f5"

URI_aarch64_python3-lit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lit-22.1.1-1.el10.alma.1.noarch.rpm;name=aarch64_python3-lit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lit}"
SRC_URI[aarch64_python3-lit.sha256sum] = "a3079f45cf0a91a45dead5ac1763c9a3c5ff363e3029afff26e66cd777649a77"

URI_aarch64_python3-lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lldb-22.1.1-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lldb}"
SRC_URI[aarch64_python3-lldb.sha256sum] = "0b066b6ee76a76238e062e33a326cc15173fa411a40214c825e359f9e1137b1e"

RDEPENDS:clang = " \
 clang-libs \
 gcc-c++ \
 glibc \
 libstdc++ \
 libstdc++-devel \
 llvm-libs \
 "
RDEPENDS:clang-analyzer = " \
 clang \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Hash-Util \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3 \
 "
RDEPENDS:clang-devel = " \
 clang \
 clang-libs \
 clang-tools-extra \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 llvm-devel \
 "
RDEPENDS:clang-libs:x86_64_v2 = " \
 clang-resource-filesystem \
 gcc-toolset-15-gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
"
RDEPENDS:clang-libs:aarch64 = " \
 clang-resource-filesystem \
 gcc-toolset-15-gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
"
RDEPENDS:clang-resource-filesystem = " \
 "
RDEPENDS:clang-tools-extra = " \
 clang-libs \
 emacs-filesystem \
 glibc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 python3 \
 "
RDEPENDS:compiler-rt = " \
 clang-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:git-clang-format = " \
 clang-tools-extra \
 git \
 python3 \
 "
RDEPENDS:libomp = " \
 elfutils-libelf \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:libomp-devel = " \
 clang-resource-filesystem \
 libomp \
 "
RDEPENDS:lld = " \
 alternatives \
 bash \
 glibc \
 libstdc++ \
 lld-libs \
 llvm-libs \
 "
RDEPENDS:lld-devel = " \
 cmake-filesystem \
 lld \
 lld-libs \
 "
RDEPENDS:lld-libs = " \
 glibc \
 libstdc++ \
 libzstd \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb:x86_64_v2 = " \
 clang-libs \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 ncurses-libs \
 python3-libs \
 python3-lldb \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:lldb:aarch64 = " \
 clang-libs \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 ncurses-libs \
 python3-libs \
 python3-lldb \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
 virtual/libclang-cpp.so.21.1_LLVM_21.1__64bit_ \
 virtual/libclang-cpp.so.21.1___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:lldb-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 lldb \
 llvm-libs \
 "
RDEPENDS:llvm = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:llvm-devel = " \
 alternatives \
 bash \
 cmake-filesystem \
 glibc \
 libedit-devel \
 libstdc++ \
 libzstd-devel \
 llvm \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 "
RDEPENDS:llvm-doc = " \
 llvm \
 "
RDEPENDS:llvm-filesystem = " \
 "
RDEPENDS:llvm-googletest = " \
 llvm-filesystem \
 "
RDEPENDS:llvm-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 libxml2 \
 libzstd \
 llvm-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:llvm-static = " \
 llvm-filesystem \
 "
RDEPENDS:llvm-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm \
 llvm-libs \
 "
RDEPENDS:llvm-toolset = " \
 clang \
 lld \
 llvm \
 "
RDEPENDS:python3-clang = " \
 clang-devel \
 python3 \
 "
RDEPENDS:python3-lit = " \
 python3 \
 "
RDEPENDS:python3-lldb = " \
 lldb \
 python3 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libomp.so_VERSION__64bit_ rpm/virtual/libomp.so___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ rpm/virtual/libLLVM.so.21.1___64bit_ rpm/virtual/libclang-cpp.so.21.1_LLVM_21.1__64bit_ rpm/virtual/libclang-cpp.so.21.1___64bit_ rpm/virtual/libclang.so.21.1_LLVM_13__64bit_ rpm/virtual/libclang.so.21.1_LLVM_16__64bit_ rpm/virtual/libclang.so.21.1_LLVM_17__64bit_ rpm/virtual/libclang.so.21.1_LLVM_21__64bit_ rpm/virtual/libclang.so.21.1___64bit_"
