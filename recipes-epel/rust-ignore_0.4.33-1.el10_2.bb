# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ignore"
PV = "0.4.33"
PR = "1.el10_2"
PACKAGES = " \
 rust-ignore+default-devel \
 rust-ignore+simd-accel-devel \
 rust-ignore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ignore-0.4.33-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4dcec93d36197b36cf3c619c0ebb3f6e9bf165a8a75377495535547e73afb89"

URI_x86_64_v2_rust-ignore+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore+default-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore+default-devel}"
SRC_URI[x86_64_v2_rust-ignore+default-devel.sha256sum] = "91bb55654ec682899129b1e03cddfbe206955dcb8474ff94e846e8690f433107"

URI_x86_64_v2_rust-ignore+simd-accel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore+simd-accel-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore+simd-accel-devel}"
SRC_URI[x86_64_v2_rust-ignore+simd-accel-devel.sha256sum] = "7df34a03e0809b61a06b9d077010d82067dea868716cd0941bd1a45b901ad72d"

URI_x86_64_v2_rust-ignore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore-devel}"
SRC_URI[x86_64_v2_rust-ignore-devel.sha256sum] = "da16efe4989ec19b40b6b1288e84a30f62bbefa555e5a2ef23b56481707a38b6"

URI_aarch64_rust-ignore+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore+default-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore+default-devel}"
SRC_URI[aarch64_rust-ignore+default-devel.sha256sum] = "77b1dcf7ef2df37a6ffbeb1429710b600ab6e56e4065fa45e0d2c1d361cf7ac5"

URI_aarch64_rust-ignore+simd-accel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore+simd-accel-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-ignore+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore+simd-accel-devel}"
SRC_URI[aarch64_rust-ignore+simd-accel-devel.sha256sum] = "3831eec988f662a67cc3c8762045046e4e73aa0d0004370adfa7df212c09e7e4"

URI_aarch64_rust-ignore-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore-devel}"
SRC_URI[aarch64_rust-ignore-devel.sha256sum] = "b5445fbb38559463b303e74fb3135b8c6e277b59b3b537fa17d75a5c8ffbc68f"

RDEPENDS:rust-ignore+default-devel = " \
 cargo \
 rust-ignore-devel \
 "
RDEPENDS:rust-ignore+simd-accel-devel = " \
 cargo \
 rust-ignore-devel \
 "
RDEPENDS:rust-ignore-devel = " \
 cargo \
 rust \
 rust-crossbeam-deque+default-devel \
 rust-globset+default-devel \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-same-file+default-devel \
 rust-walkdir+default-devel \
 "
