# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.14"
PV = "9.14.1"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 ghc9.14 \
 ghc9.14-Cabal \
 ghc9.14-Cabal-devel \
 ghc9.14-Cabal-doc \
 ghc9.14-Cabal-syntax \
 ghc9.14-Cabal-syntax-devel \
 ghc9.14-Cabal-syntax-doc \
 ghc9.14-array \
 ghc9.14-array-devel \
 ghc9.14-array-doc \
 ghc9.14-base \
 ghc9.14-base-devel \
 ghc9.14-base-doc \
 ghc9.14-binary \
 ghc9.14-binary-devel \
 ghc9.14-binary-doc \
 ghc9.14-bytestring \
 ghc9.14-bytestring-devel \
 ghc9.14-bytestring-doc \
 ghc9.14-compiler \
 ghc9.14-compiler-default \
 ghc9.14-containers \
 ghc9.14-containers-devel \
 ghc9.14-containers-doc \
 ghc9.14-deepseq \
 ghc9.14-deepseq-devel \
 ghc9.14-deepseq-doc \
 ghc9.14-devel \
 ghc9.14-directory \
 ghc9.14-directory-devel \
 ghc9.14-directory-doc \
 ghc9.14-doc \
 ghc9.14-doc-index \
 ghc9.14-exceptions \
 ghc9.14-exceptions-devel \
 ghc9.14-exceptions-doc \
 ghc9.14-file-io \
 ghc9.14-file-io-devel \
 ghc9.14-file-io-doc \
 ghc9.14-filepath \
 ghc9.14-filepath-devel \
 ghc9.14-filepath-doc \
 ghc9.14-filesystem \
 ghc9.14-ghc \
 ghc9.14-ghc-bignum \
 ghc9.14-ghc-bignum-devel \
 ghc9.14-ghc-bignum-doc \
 ghc9.14-ghc-boot \
 ghc9.14-ghc-boot-devel \
 ghc9.14-ghc-boot-doc \
 ghc9.14-ghc-boot-th \
 ghc9.14-ghc-boot-th-devel \
 ghc9.14-ghc-boot-th-doc \
 ghc9.14-ghc-compact \
 ghc9.14-ghc-compact-devel \
 ghc9.14-ghc-compact-doc \
 ghc9.14-ghc-devel \
 ghc9.14-ghc-doc \
 ghc9.14-ghc-experimental \
 ghc9.14-ghc-experimental-devel \
 ghc9.14-ghc-experimental-doc \
 ghc9.14-ghc-heap \
 ghc9.14-ghc-heap-devel \
 ghc9.14-ghc-heap-doc \
 ghc9.14-ghc-platform \
 ghc9.14-ghc-platform-devel \
 ghc9.14-ghc-platform-doc \
 ghc9.14-ghc-toolchain \
 ghc9.14-ghc-toolchain-devel \
 ghc9.14-ghc-toolchain-doc \
 ghc9.14-ghci \
 ghc9.14-ghci-devel \
 ghc9.14-ghci-doc \
 ghc9.14-haddock-api \
 ghc9.14-haddock-api-devel \
 ghc9.14-haddock-api-doc \
 ghc9.14-haddock-library \
 ghc9.14-haddock-library-devel \
 ghc9.14-haddock-library-doc \
 ghc9.14-hadrian \
 ghc9.14-haskeline \
 ghc9.14-haskeline-devel \
 ghc9.14-haskeline-doc \
 ghc9.14-hpc \
 ghc9.14-hpc-devel \
 ghc9.14-hpc-doc \
 ghc9.14-manual \
 ghc9.14-mtl \
 ghc9.14-mtl-devel \
 ghc9.14-mtl-doc \
 ghc9.14-os-string \
 ghc9.14-os-string-devel \
 ghc9.14-os-string-doc \
 ghc9.14-parsec \
 ghc9.14-parsec-devel \
 ghc9.14-parsec-doc \
 ghc9.14-pretty \
 ghc9.14-pretty-devel \
 ghc9.14-pretty-doc \
 ghc9.14-process \
 ghc9.14-process-devel \
 ghc9.14-process-doc \
 ghc9.14-semaphore-compat \
 ghc9.14-semaphore-compat-devel \
 ghc9.14-semaphore-compat-doc \
 ghc9.14-stm \
 ghc9.14-stm-devel \
 ghc9.14-stm-doc \
 ghc9.14-template-haskell \
 ghc9.14-template-haskell-devel \
 ghc9.14-template-haskell-doc \
 ghc9.14-template-haskell-lift \
 ghc9.14-template-haskell-lift-devel \
 ghc9.14-template-haskell-lift-doc \
 ghc9.14-template-haskell-quasiquoter \
 ghc9.14-template-haskell-quasiquoter-devel \
 ghc9.14-template-haskell-quasiquoter-doc \
 ghc9.14-terminfo \
 ghc9.14-terminfo-devel \
 ghc9.14-terminfo-doc \
 ghc9.14-text \
 ghc9.14-text-devel \
 ghc9.14-text-doc \
 ghc9.14-time \
 ghc9.14-time-devel \
 ghc9.14-time-doc \
 ghc9.14-transformers \
 ghc9.14-transformers-devel \
 ghc9.14-transformers-doc \
 ghc9.14-unix \
 ghc9.14-unix-devel \
 ghc9.14-unix-doc \
 ghc9.14-xhtml \
 ghc9.14-xhtml-devel \
 ghc9.14-xhtml-doc \
"
PACKAGES:aarch64 = " \
 ghc9.14 \
 ghc9.14-Cabal \
 ghc9.14-Cabal-devel \
 ghc9.14-Cabal-doc \
 ghc9.14-Cabal-prof \
 ghc9.14-Cabal-syntax \
 ghc9.14-Cabal-syntax-devel \
 ghc9.14-Cabal-syntax-doc \
 ghc9.14-Cabal-syntax-prof \
 ghc9.14-array \
 ghc9.14-array-devel \
 ghc9.14-array-doc \
 ghc9.14-array-prof \
 ghc9.14-base \
 ghc9.14-base-devel \
 ghc9.14-base-doc \
 ghc9.14-base-prof \
 ghc9.14-binary \
 ghc9.14-binary-devel \
 ghc9.14-binary-doc \
 ghc9.14-binary-prof \
 ghc9.14-bytestring \
 ghc9.14-bytestring-devel \
 ghc9.14-bytestring-doc \
 ghc9.14-bytestring-prof \
 ghc9.14-compiler \
 ghc9.14-compiler-default \
 ghc9.14-containers \
 ghc9.14-containers-devel \
 ghc9.14-containers-doc \
 ghc9.14-containers-prof \
 ghc9.14-deepseq \
 ghc9.14-deepseq-devel \
 ghc9.14-deepseq-doc \
 ghc9.14-deepseq-prof \
 ghc9.14-devel \
 ghc9.14-directory \
 ghc9.14-directory-devel \
 ghc9.14-directory-doc \
 ghc9.14-directory-prof \
 ghc9.14-doc \
 ghc9.14-doc-index \
 ghc9.14-exceptions \
 ghc9.14-exceptions-devel \
 ghc9.14-exceptions-doc \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io \
 ghc9.14-file-io-devel \
 ghc9.14-file-io-doc \
 ghc9.14-file-io-prof \
 ghc9.14-filepath \
 ghc9.14-filepath-devel \
 ghc9.14-filepath-doc \
 ghc9.14-filepath-prof \
 ghc9.14-filesystem \
 ghc9.14-ghc \
 ghc9.14-ghc-bignum \
 ghc9.14-ghc-bignum-devel \
 ghc9.14-ghc-bignum-doc \
 ghc9.14-ghc-bignum-prof \
 ghc9.14-ghc-boot \
 ghc9.14-ghc-boot-devel \
 ghc9.14-ghc-boot-doc \
 ghc9.14-ghc-boot-prof \
 ghc9.14-ghc-boot-th \
 ghc9.14-ghc-boot-th-devel \
 ghc9.14-ghc-boot-th-doc \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-ghc-compact \
 ghc9.14-ghc-compact-devel \
 ghc9.14-ghc-compact-doc \
 ghc9.14-ghc-compact-prof \
 ghc9.14-ghc-devel \
 ghc9.14-ghc-doc \
 ghc9.14-ghc-experimental \
 ghc9.14-ghc-experimental-devel \
 ghc9.14-ghc-experimental-doc \
 ghc9.14-ghc-experimental-prof \
 ghc9.14-ghc-heap \
 ghc9.14-ghc-heap-devel \
 ghc9.14-ghc-heap-doc \
 ghc9.14-ghc-heap-prof \
 ghc9.14-ghc-platform \
 ghc9.14-ghc-platform-devel \
 ghc9.14-ghc-platform-doc \
 ghc9.14-ghc-platform-prof \
 ghc9.14-ghc-prof \
 ghc9.14-ghc-toolchain \
 ghc9.14-ghc-toolchain-devel \
 ghc9.14-ghc-toolchain-doc \
 ghc9.14-ghc-toolchain-prof \
 ghc9.14-ghci \
 ghc9.14-ghci-devel \
 ghc9.14-ghci-doc \
 ghc9.14-ghci-prof \
 ghc9.14-haddock-api \
 ghc9.14-haddock-api-devel \
 ghc9.14-haddock-api-doc \
 ghc9.14-haddock-api-prof \
 ghc9.14-haddock-library \
 ghc9.14-haddock-library-devel \
 ghc9.14-haddock-library-doc \
 ghc9.14-haddock-library-prof \
 ghc9.14-hadrian \
 ghc9.14-haskeline \
 ghc9.14-haskeline-devel \
 ghc9.14-haskeline-doc \
 ghc9.14-haskeline-prof \
 ghc9.14-hpc \
 ghc9.14-hpc-devel \
 ghc9.14-hpc-doc \
 ghc9.14-hpc-prof \
 ghc9.14-manual \
 ghc9.14-mtl \
 ghc9.14-mtl-devel \
 ghc9.14-mtl-doc \
 ghc9.14-mtl-prof \
 ghc9.14-os-string \
 ghc9.14-os-string-devel \
 ghc9.14-os-string-doc \
 ghc9.14-os-string-prof \
 ghc9.14-parsec \
 ghc9.14-parsec-devel \
 ghc9.14-parsec-doc \
 ghc9.14-parsec-prof \
 ghc9.14-pretty \
 ghc9.14-pretty-devel \
 ghc9.14-pretty-doc \
 ghc9.14-pretty-prof \
 ghc9.14-process \
 ghc9.14-process-devel \
 ghc9.14-process-doc \
 ghc9.14-process-prof \
 ghc9.14-prof \
 ghc9.14-semaphore-compat \
 ghc9.14-semaphore-compat-devel \
 ghc9.14-semaphore-compat-doc \
 ghc9.14-semaphore-compat-prof \
 ghc9.14-stm \
 ghc9.14-stm-devel \
 ghc9.14-stm-doc \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell \
 ghc9.14-template-haskell-devel \
 ghc9.14-template-haskell-doc \
 ghc9.14-template-haskell-lift \
 ghc9.14-template-haskell-lift-devel \
 ghc9.14-template-haskell-lift-doc \
 ghc9.14-template-haskell-lift-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-template-haskell-quasiquoter \
 ghc9.14-template-haskell-quasiquoter-devel \
 ghc9.14-template-haskell-quasiquoter-doc \
 ghc9.14-template-haskell-quasiquoter-prof \
 ghc9.14-terminfo \
 ghc9.14-terminfo-devel \
 ghc9.14-terminfo-doc \
 ghc9.14-terminfo-prof \
 ghc9.14-text \
 ghc9.14-text-devel \
 ghc9.14-text-doc \
 ghc9.14-text-prof \
 ghc9.14-time \
 ghc9.14-time-devel \
 ghc9.14-time-doc \
 ghc9.14-time-prof \
 ghc9.14-transformers \
 ghc9.14-transformers-devel \
 ghc9.14-transformers-doc \
 ghc9.14-transformers-prof \
 ghc9.14-unix \
 ghc9.14-unix-devel \
 ghc9.14-unix-doc \
 ghc9.14-unix-prof \
 ghc9.14-xhtml \
 ghc9.14-xhtml-devel \
 ghc9.14-xhtml-doc \
 ghc9.14-xhtml-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.14-9.14.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71b2235f2a96f9fe57b209593c866d9cb1de407a1e30bb4ab381eb1d9e261390"

URI_x86_64_v2_ghc9.14 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14}"
SRC_URI[x86_64_v2_ghc9.14.sha256sum] = "32e5b6e832a22a060df9fea8c4c19dbc3eba4354afc69947feacc907b0065705"

URI_x86_64_v2_ghc9.14-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-Cabal-3.16.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-Cabal}"
SRC_URI[x86_64_v2_ghc9.14-Cabal.sha256sum] = "e6da77d07754780b92405456f88c0ee4e5d2a458a878732fc8712a59828e1e9a"

URI_x86_64_v2_ghc9.14-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-Cabal-devel-3.16.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.14-Cabal-devel.sha256sum] = "4ad5230a788eb2b11a0cd947860194490d3fdf71524bf6ebcd77d240937e790f"

URI_x86_64_v2_ghc9.14-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-Cabal-doc-3.16.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.14-Cabal-doc.sha256sum] = "b180d5ada638bb20d004259b04acda13e346ab462ee5aabd8896e204392eb92f"

URI_x86_64_v2_ghc9.14-Cabal-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-Cabal-syntax-3.16.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-Cabal-syntax}"
SRC_URI[x86_64_v2_ghc9.14-Cabal-syntax.sha256sum] = "35ea701c4a4cddc8e2e467f0910ed4c5c3a98e468518556bb51033c4d5c9e3a1"

URI_x86_64_v2_ghc9.14-Cabal-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-Cabal-syntax-devel-3.16.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-Cabal-syntax-devel}"
SRC_URI[x86_64_v2_ghc9.14-Cabal-syntax-devel.sha256sum] = "45fbec0648f7bcaf287f0788bf9b98c6f6f7b6786f8d5e0a58782a72be5cb6e8"

URI_x86_64_v2_ghc9.14-Cabal-syntax-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-Cabal-syntax-doc-3.16.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-Cabal-syntax-doc}"
SRC_URI[x86_64_v2_ghc9.14-Cabal-syntax-doc.sha256sum] = "9c37138761a739d36cdbf7b846e3056f696e602dec394ab2cab1c85bbd5ba568"

URI_x86_64_v2_ghc9.14-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-array-0.5.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-array}"
SRC_URI[x86_64_v2_ghc9.14-array.sha256sum] = "c0d230001067a0f2bd46e8abd0221967feeb3567c2754e7c74d62e30abb13780"

URI_x86_64_v2_ghc9.14-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-array-devel-0.5.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-array-devel}"
SRC_URI[x86_64_v2_ghc9.14-array-devel.sha256sum] = "df47ee2684355a5f1138a1e04dfeafebe57d9fb0536966ab6dd9e99452f19bde"

URI_x86_64_v2_ghc9.14-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-array-doc-0.5.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-array-doc}"
SRC_URI[x86_64_v2_ghc9.14-array-doc.sha256sum] = "bb35f7be0662f66e9c75be30a6a56862f23a0243c71a1d2c7fa15181faa3f804"

URI_x86_64_v2_ghc9.14-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-base-4.22.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-base}"
SRC_URI[x86_64_v2_ghc9.14-base.sha256sum] = "2d32a14550e2d3b58a7eaefd1d2faeac0c605b85245e81d74091e1acc6b7dc41"

URI_x86_64_v2_ghc9.14-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-base-devel-4.22.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-base-devel}"
SRC_URI[x86_64_v2_ghc9.14-base-devel.sha256sum] = "44f32d10f67fd60412624404431a4448df8aaa685cecc4081de7a92da7cd1345"

URI_x86_64_v2_ghc9.14-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-base-doc-4.22.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-base-doc}"
SRC_URI[x86_64_v2_ghc9.14-base-doc.sha256sum] = "8854fa88c6824b086e58cf2b8bd2cf749d78590565f0f082a4a8701d06116e8a"

URI_x86_64_v2_ghc9.14-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-binary-0.8.9.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-binary}"
SRC_URI[x86_64_v2_ghc9.14-binary.sha256sum] = "23b9cfb5d3b5945ebe161229b057cc03044e0f806bd36847f430cc39f0396b3a"

URI_x86_64_v2_ghc9.14-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-binary-devel-0.8.9.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-binary-devel}"
SRC_URI[x86_64_v2_ghc9.14-binary-devel.sha256sum] = "7828912ac8add1b1088d5b39d069b5e4cba16bd134dc3edd8826a11ed3ce8ea0"

URI_x86_64_v2_ghc9.14-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-binary-doc-0.8.9.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-binary-doc}"
SRC_URI[x86_64_v2_ghc9.14-binary-doc.sha256sum] = "d161b24b1d32a2d2536673a28c016795ad2797e2a4d0769d8365ed7e95d33720"

URI_x86_64_v2_ghc9.14-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-bytestring-0.12.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-bytestring}"
SRC_URI[x86_64_v2_ghc9.14-bytestring.sha256sum] = "0997dd933651a27efcec876084bbaceef6b06b50737d4b1790f91c3db3708f1e"

URI_x86_64_v2_ghc9.14-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-bytestring-devel-0.12.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.14-bytestring-devel.sha256sum] = "1681f0db32d4a4cde3311534397e96a89d24eff396fcf2db4962a44d0d6969e8"

URI_x86_64_v2_ghc9.14-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-bytestring-doc-0.12.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.14-bytestring-doc.sha256sum] = "6638bc342e62d2e748a3cb30b54de7383031eaf02afac2bbc93d974242117105"

URI_x86_64_v2_ghc9.14-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-compiler-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-compiler}"
SRC_URI[x86_64_v2_ghc9.14-compiler.sha256sum] = "68158ee238a94e33c38dd8db1a63a90d890cf964e78978913719c0eeb1b896a9"

URI_x86_64_v2_ghc9.14-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-compiler-default-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-compiler-default}"
SRC_URI[x86_64_v2_ghc9.14-compiler-default.sha256sum] = "38955310626813da632a2d845af1be7d1bd74027d972d2861e9f9adb224612f4"

URI_x86_64_v2_ghc9.14-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-containers-0.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-containers}"
SRC_URI[x86_64_v2_ghc9.14-containers.sha256sum] = "da5bdde8c2850551e07a7d4fad595754f353e71087275f06ea953b786b800589"

URI_x86_64_v2_ghc9.14-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-containers-devel-0.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-containers-devel}"
SRC_URI[x86_64_v2_ghc9.14-containers-devel.sha256sum] = "4fd5221518e3201872880225d29d1ae43473e355a889ad0180367c8f2c1b897e"

URI_x86_64_v2_ghc9.14-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-containers-doc-0.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-containers-doc}"
SRC_URI[x86_64_v2_ghc9.14-containers-doc.sha256sum] = "4aacc3d2bf07e2a6c47d23f4bc1910d5351f6367f076a22fd3edff1f6fe9f7ee"

URI_x86_64_v2_ghc9.14-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-deepseq-1.5.1.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-deepseq}"
SRC_URI[x86_64_v2_ghc9.14-deepseq.sha256sum] = "72657da2d74a70ce272fe56689d5a2e151f4d8683fdbd42ffa37360f57f5c8a0"

URI_x86_64_v2_ghc9.14-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-deepseq-devel-1.5.1.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.14-deepseq-devel.sha256sum] = "bd22c5225085889a29591f34ae9709e9b0b622896531e220cd00a9b52f05c774"

URI_x86_64_v2_ghc9.14-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-deepseq-doc-1.5.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.14-deepseq-doc.sha256sum] = "7a3c3379ba754bc4bbfae57737c3d52f31cbd1b949d0e955b5c450c8e69b4e85"

URI_x86_64_v2_ghc9.14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-devel-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-devel}"
SRC_URI[x86_64_v2_ghc9.14-devel.sha256sum] = "2af42253e5843625de835fbaeb0e4326cecc7a3486496784fc63af50acd12b96"

URI_x86_64_v2_ghc9.14-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-directory-1.3.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-directory}"
SRC_URI[x86_64_v2_ghc9.14-directory.sha256sum] = "4d89569862ee42627a8c6659c35f4c84e8bbfbb3ef1432da9fcd961ba4316b33"

URI_x86_64_v2_ghc9.14-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-directory-devel-1.3.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-directory-devel}"
SRC_URI[x86_64_v2_ghc9.14-directory-devel.sha256sum] = "d887a865538c20896ceabc7c56ec3b3e8596395a6c7e49af85bc25d2c2989d45"

URI_x86_64_v2_ghc9.14-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-directory-doc-1.3.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-directory-doc}"
SRC_URI[x86_64_v2_ghc9.14-directory-doc.sha256sum] = "5a8c24366be74ebf6f41c4111894289b8bd5e57dd25a98cee2cd7c26faa0cd4a"

URI_x86_64_v2_ghc9.14-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-doc-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-doc}"
SRC_URI[x86_64_v2_ghc9.14-doc.sha256sum] = "a3abc1fe9a60295beb450fff9c56509559eccb6c3380ea071377eecc94a51f7d"

URI_x86_64_v2_ghc9.14-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-doc-index-9.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-doc-index}"
SRC_URI[x86_64_v2_ghc9.14-doc-index.sha256sum] = "b29f5d70e7d0d109d9efac4c8115357844c2bb802129884d0bf9a61f72634837"

URI_x86_64_v2_ghc9.14-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-exceptions-0.10.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-exceptions}"
SRC_URI[x86_64_v2_ghc9.14-exceptions.sha256sum] = "31ee91e7684dbb4d8458d1fa379708f9ee524a2e270e76aa97fbb4f7f2fdfcb7"

URI_x86_64_v2_ghc9.14-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-exceptions-devel-0.10.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.14-exceptions-devel.sha256sum] = "bbdc76f631cb025de9e66869e82ad1918c66533674b4c280e62730cba81cff76"

URI_x86_64_v2_ghc9.14-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-exceptions-doc-0.10.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.14-exceptions-doc.sha256sum] = "c5fefea3c3f9a95e2c5c2d001aa9d339488699dbb01caf96a20a39a842eeffca"

URI_x86_64_v2_ghc9.14-file-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-file-io-0.1.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-file-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-file-io}"
SRC_URI[x86_64_v2_ghc9.14-file-io.sha256sum] = "59364593b8b46d699017e1b38adb14d708bdac7307a87af126106e4ec3be329f"

URI_x86_64_v2_ghc9.14-file-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-file-io-devel-0.1.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-file-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-file-io-devel}"
SRC_URI[x86_64_v2_ghc9.14-file-io-devel.sha256sum] = "8a0bfe5630ddafcff42fe3b6186ef4ebff0b2ff698fcf67f819029335771f1f5"

URI_x86_64_v2_ghc9.14-file-io-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-file-io-doc-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-file-io-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-file-io-doc}"
SRC_URI[x86_64_v2_ghc9.14-file-io-doc.sha256sum] = "b5ca44e080c374ac547a8e99c65f635569375fe273f4ffdfc674f08396fc5fbf"

URI_x86_64_v2_ghc9.14-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-filepath-1.5.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-filepath}"
SRC_URI[x86_64_v2_ghc9.14-filepath.sha256sum] = "89922739790a22af33e17c41a10fcc4af3b18fcac7a663f54a18c8f7e7282a1d"

URI_x86_64_v2_ghc9.14-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-filepath-devel-1.5.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.14-filepath-devel.sha256sum] = "417c3517f3e279f8d6d7ea9bfe16cc26a365b17f1c5569b860357f541f31d7dd"

URI_x86_64_v2_ghc9.14-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-filepath-doc-1.5.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.14-filepath-doc.sha256sum] = "9a86a711abaae13a41006ec69e62c62662c0760a6bb3576d556df2a6bfb27860"

URI_x86_64_v2_ghc9.14-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-filesystem-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-filesystem}"
SRC_URI[x86_64_v2_ghc9.14-filesystem.sha256sum] = "ce04c45d51fd3858931e7c41ed219b9472cc84bcad3b669f85c155440a47164e"

URI_x86_64_v2_ghc9.14-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc}"
SRC_URI[x86_64_v2_ghc9.14-ghc.sha256sum] = "2943474a56f58f69cd9cca89b4a7697ab7a967b73dc3de4fd8e47176feab307f"

URI_x86_64_v2_ghc9.14-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-bignum-1.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.14-ghc-bignum.sha256sum] = "e2275659d3fce2a05f3116363039e8e3c3587a0be54bd1da4c53ce38992464c5"

URI_x86_64_v2_ghc9.14-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-bignum-devel-1.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.14-ghc-bignum-devel.sha256sum] = "9e178803f37c1bc4267649a8fd532a6c5cb69c5f8eae2886eba16a80692248ec"

URI_x86_64_v2_ghc9.14-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-bignum-doc-1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.14-ghc-bignum-doc.sha256sum] = "ce0357853ee919a8e7ad1cb5c04f7e7433a128a3ad2f52647133ef24d19e8d83"

URI_x86_64_v2_ghc9.14-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-boot-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.14-ghc-boot.sha256sum] = "6e574225054ba9be184e1bb84f9a3555a1a41ca3d038afaaa48dec9d8f21dd1d"

URI_x86_64_v2_ghc9.14-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-boot-devel-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.14-ghc-boot-devel.sha256sum] = "cf1dcde25b7bfe305483fbbf03ed9ab6387afd417d99ef71ff0102abf3bd6598"

URI_x86_64_v2_ghc9.14-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-boot-doc-9.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.14-ghc-boot-doc.sha256sum] = "9c9e47d7c994e06f1ffdfe3b5ab9c15ea18a2bbfe327d236033c391d7a8e2746"

URI_x86_64_v2_ghc9.14-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-boot-th-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.14-ghc-boot-th.sha256sum] = "0fb4b08c8117628f661e5a8193a596acd2a3d6bca5082f5421faa715f5484559"

URI_x86_64_v2_ghc9.14-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-boot-th-devel-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.14-ghc-boot-th-devel.sha256sum] = "6db0b50631cbf85e2a4fb6373487b28d0391e530c0e36e3111e2183f2183f562"

URI_x86_64_v2_ghc9.14-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-boot-th-doc-9.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.14-ghc-boot-th-doc.sha256sum] = "1f84c28ba84859b88137c002073b55c7ff63c44327bf596e467ccbefdb48d046"

URI_x86_64_v2_ghc9.14-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-compact-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.14-ghc-compact.sha256sum] = "13d01d99d67f2a06a2eea61083d5fbb708cf9240eb5b9165ad993386ddd763f2"

URI_x86_64_v2_ghc9.14-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-compact-devel-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.14-ghc-compact-devel.sha256sum] = "18a5f4fbf0289f987b8f52c09ea8215aa7d44163bc870ba3b3897d1ec8e80f39"

URI_x86_64_v2_ghc9.14-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-compact-doc-0.1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.14-ghc-compact-doc.sha256sum] = "ab0f469ab85609927a58653d3a937bb2e011973b5d15b574c9e510fa99d41eb6"

URI_x86_64_v2_ghc9.14-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-devel-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.14-ghc-devel.sha256sum] = "2f950555d646a3cda0ddb1e29cd466d5a3c041e40632d4d6810e4e8ffec56545"

URI_x86_64_v2_ghc9.14-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-doc-9.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.14-ghc-doc.sha256sum] = "2461062928580964e4d9cdf48f763a4d1daba318b9a29d98bda650f924edef8a"

URI_x86_64_v2_ghc9.14-ghc-experimental = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-experimental-9.1401.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-experimental}"
SRC_URI[x86_64_v2_ghc9.14-ghc-experimental.sha256sum] = "1a0899c8b9bea85b43ca8dc89108cdef4e672005acd4d3a15ef69f6fba6fa91f"

URI_x86_64_v2_ghc9.14-ghc-experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-experimental-devel-9.1401.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-experimental-devel}"
SRC_URI[x86_64_v2_ghc9.14-ghc-experimental-devel.sha256sum] = "53a170377fb6be0be62f9acd6ca277d7e2dd9576b37092c40c48fa48539230bd"

URI_x86_64_v2_ghc9.14-ghc-experimental-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-experimental-doc-9.1401.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-experimental-doc}"
SRC_URI[x86_64_v2_ghc9.14-ghc-experimental-doc.sha256sum] = "7356cd080c41c3f16383d34ba1a37c9d1d19351528aecab6d49c6db20ae78801"

URI_x86_64_v2_ghc9.14-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-heap-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.14-ghc-heap.sha256sum] = "9983a4f04298e68879c4162c388b28a5c5cc8f183c8a21364e6db04bf9bd9880"

URI_x86_64_v2_ghc9.14-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-heap-devel-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.14-ghc-heap-devel.sha256sum] = "5ad0d41db0f55c38d3f7e6d494891091d7b80d2b2cca9ee96c8a241a2d6f206f"

URI_x86_64_v2_ghc9.14-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-heap-doc-9.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.14-ghc-heap-doc.sha256sum] = "a5c556ccc1383dec2644d29ae8b294c2ef0b3b84ec005f7d6db5bfa4d99c447e"

URI_x86_64_v2_ghc9.14-ghc-platform = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-platform-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-platform}"
SRC_URI[x86_64_v2_ghc9.14-ghc-platform.sha256sum] = "8fb4031319df8c4b3b934509e37dd4b4ebe58c3cfca6dbec0344e0dc79f1fe27"

URI_x86_64_v2_ghc9.14-ghc-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-platform-devel-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-platform-devel}"
SRC_URI[x86_64_v2_ghc9.14-ghc-platform-devel.sha256sum] = "c95760d8726ae953ac340973fa6c58f70074780161d66d8ded98213f8ef489e0"

URI_x86_64_v2_ghc9.14-ghc-platform-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-platform-doc-0.1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-platform-doc}"
SRC_URI[x86_64_v2_ghc9.14-ghc-platform-doc.sha256sum] = "3fdd8f36b754a18b66ea0b859486c2a31735574ac7d541f57501459ea52a5b6b"

URI_x86_64_v2_ghc9.14-ghc-toolchain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-toolchain-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-toolchain}"
SRC_URI[x86_64_v2_ghc9.14-ghc-toolchain.sha256sum] = "c208fb78a06cf4394a42e2d5fa4932a01e01c585beed5cb56b7c50fca877fab4"

URI_x86_64_v2_ghc9.14-ghc-toolchain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-toolchain-devel-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-toolchain-devel}"
SRC_URI[x86_64_v2_ghc9.14-ghc-toolchain-devel.sha256sum] = "74f45d076c2b4522bce55a529c22ca7f6accb2869ac5d8617b1edf9fb20c6af8"

URI_x86_64_v2_ghc9.14-ghc-toolchain-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghc-toolchain-doc-0.1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghc-toolchain-doc}"
SRC_URI[x86_64_v2_ghc9.14-ghc-toolchain-doc.sha256sum] = "ef46b0f0d7baee5d7f4934e37e5e6ad6bba93a54cb7b80908fab4f0190a50f66"

URI_x86_64_v2_ghc9.14-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghci-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghci}"
SRC_URI[x86_64_v2_ghc9.14-ghci.sha256sum] = "c4e9945a134b94f400c5059a2be904fb02cdad78d06b7416fe47c03a7d8ac18c"

URI_x86_64_v2_ghc9.14-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghci-devel-9.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.14-ghci-devel.sha256sum] = "933857da0b3a3c67f70653c954c4116d8398f5ac8483702156d9d3ef3d7ea9e6"

URI_x86_64_v2_ghc9.14-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-ghci-doc-9.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.14-ghci-doc.sha256sum] = "6246679ff508c15123b8881664ae19bda6ccce683cb8c4ac6ba4131094a66131"

URI_x86_64_v2_ghc9.14-haddock-api = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-haddock-api-2.33.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-haddock-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-haddock-api}"
SRC_URI[x86_64_v2_ghc9.14-haddock-api.sha256sum] = "2a0ea1e4c7e617da386e659574ec686363e79e2bf32f0c3e3de18f807946fb3d"

URI_x86_64_v2_ghc9.14-haddock-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-haddock-api-devel-2.33.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-haddock-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-haddock-api-devel}"
SRC_URI[x86_64_v2_ghc9.14-haddock-api-devel.sha256sum] = "06d7f9a1e004d27e02be9e2a3785d23c3f36a804926f3887f206b4e3ec52f907"

URI_x86_64_v2_ghc9.14-haddock-api-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-haddock-api-doc-2.33.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-haddock-api-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-haddock-api-doc}"
SRC_URI[x86_64_v2_ghc9.14-haddock-api-doc.sha256sum] = "2751a50dc6b40e8484a4ccdd5dbe33131f05124efc935224b0627b87a4daca91"

URI_x86_64_v2_ghc9.14-haddock-library = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-haddock-library-1.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-haddock-library;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-haddock-library}"
SRC_URI[x86_64_v2_ghc9.14-haddock-library.sha256sum] = "3183145867c4048c2a1a3c4d2725a6fbfa5b30721785a296f5f5fcce5c77d28a"

URI_x86_64_v2_ghc9.14-haddock-library-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-haddock-library-devel-1.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-haddock-library-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-haddock-library-devel}"
SRC_URI[x86_64_v2_ghc9.14-haddock-library-devel.sha256sum] = "ef0ac1d54b32db1e5e370dbc205261155d6a7d911e5a6893b543df2c463a85a2"

URI_x86_64_v2_ghc9.14-haddock-library-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-haddock-library-doc-1.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-haddock-library-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-haddock-library-doc}"
SRC_URI[x86_64_v2_ghc9.14-haddock-library-doc.sha256sum] = "22174c8ec1d4d3c97cd0777a421b06a346b2dd96a99becb00309b6deadf4f5fa"

URI_x86_64_v2_ghc9.14-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-hadrian-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-hadrian}"
SRC_URI[x86_64_v2_ghc9.14-hadrian.sha256sum] = "7456b4f7a58c348d5b52a64ba9f7400db6e83182d1483799b3939fa4e672cb56"

URI_x86_64_v2_ghc9.14-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-haskeline-0.8.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-haskeline}"
SRC_URI[x86_64_v2_ghc9.14-haskeline.sha256sum] = "0387352f12de8b51c8c2cf29f07d6270bd70f3da7e52ad049d6c0c7239176a17"

URI_x86_64_v2_ghc9.14-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-haskeline-devel-0.8.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.14-haskeline-devel.sha256sum] = "c76ce36f8ed329c0a62e7bc4efe469925a540a22553c67653a1460f04e0fd5bc"

URI_x86_64_v2_ghc9.14-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-haskeline-doc-0.8.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.14-haskeline-doc.sha256sum] = "f45cad46688dd1a13e443dfc3351a4f808f3788362c70ac1b7634cf699f1ac07"

URI_x86_64_v2_ghc9.14-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-hpc-0.7.0.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-hpc}"
SRC_URI[x86_64_v2_ghc9.14-hpc.sha256sum] = "660f93906aaeb0402af317fa624aa9d92aefdc05775d744e7a9ac2d44498e33c"

URI_x86_64_v2_ghc9.14-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-hpc-devel-0.7.0.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.14-hpc-devel.sha256sum] = "f350cf41fe46744a80d75240f5adce0349a06f26423bcd6fcc5335d64a520b8f"

URI_x86_64_v2_ghc9.14-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-hpc-doc-0.7.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.14-hpc-doc.sha256sum] = "3b601cee5d5f9d4b0d14663f7cdefc85351a71de0b9856a20efb327cb76fb92c"

URI_x86_64_v2_ghc9.14-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-manual-9.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-manual}"
SRC_URI[x86_64_v2_ghc9.14-manual.sha256sum] = "dcd87fa14844ac439daf006123e66402f3e36bc8489e840faeefda9e2d2a0976"

URI_x86_64_v2_ghc9.14-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-mtl-2.3.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-mtl}"
SRC_URI[x86_64_v2_ghc9.14-mtl.sha256sum] = "ac7b325df1252a95482d9bafe006b8ad3711efbb67a9605b3e6b107c6bef0e0f"

URI_x86_64_v2_ghc9.14-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-mtl-devel-2.3.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.14-mtl-devel.sha256sum] = "a1c2c50ed0247ab40d5556507a412ad393a3e5f5ea3fe06b4500be66f6ac9dfe"

URI_x86_64_v2_ghc9.14-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-mtl-doc-2.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.14-mtl-doc.sha256sum] = "f11b13e58a5d3c9a588a869b80aa5e7ec9435e0dc5975cb5a2921560e8a88cee"

URI_x86_64_v2_ghc9.14-os-string = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-os-string-2.0.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-os-string;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-os-string}"
SRC_URI[x86_64_v2_ghc9.14-os-string.sha256sum] = "af0a18be9613996d4a40605a7829d14021af9cc4d0db68eb9f884170b40e0043"

URI_x86_64_v2_ghc9.14-os-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-os-string-devel-2.0.8-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-os-string-devel}"
SRC_URI[x86_64_v2_ghc9.14-os-string-devel.sha256sum] = "dd3099006ab1e011617105f7328fb357ed3aa11fcd896eb4b4763c1d834bcd79"

URI_x86_64_v2_ghc9.14-os-string-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-os-string-doc-2.0.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-os-string-doc}"
SRC_URI[x86_64_v2_ghc9.14-os-string-doc.sha256sum] = "1d7975f81af73d6f13efda88e8e47319d97a55809dd9003bed733059314780d2"

URI_x86_64_v2_ghc9.14-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-parsec-3.1.18.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-parsec}"
SRC_URI[x86_64_v2_ghc9.14-parsec.sha256sum] = "a9f51ae4d7fcdd8a316952d87a7589ec3c1622946899a998ab34d0ab57d92e32"

URI_x86_64_v2_ghc9.14-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-parsec-devel-3.1.18.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.14-parsec-devel.sha256sum] = "65dea08263c5b458bd0adef527b35f8c12b43a106c73d0086021a4b129ab52cc"

URI_x86_64_v2_ghc9.14-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-parsec-doc-3.1.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.14-parsec-doc.sha256sum] = "5713b3c519869709a923f69440524bd954c627c3f1c25c691486fec0c2f4884d"

URI_x86_64_v2_ghc9.14-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-pretty-1.1.3.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-pretty}"
SRC_URI[x86_64_v2_ghc9.14-pretty.sha256sum] = "2aeecb362884c49eab00bd89c8b03809f6b6c8fa81200d136b7effa185818a40"

URI_x86_64_v2_ghc9.14-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-pretty-devel-1.1.3.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.14-pretty-devel.sha256sum] = "206a76393a3e929890a469e63b60cb438e3de3f1fb0af2bf7edc927c071d82c8"

URI_x86_64_v2_ghc9.14-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-pretty-doc-1.1.3.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.14-pretty-doc.sha256sum] = "6dcbd4c36e6c3d07c19229751ce4e8ea4e178fd66fc58f41a23ba9e84d9222c6"

URI_x86_64_v2_ghc9.14-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-process-1.6.26.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-process}"
SRC_URI[x86_64_v2_ghc9.14-process.sha256sum] = "a9bc50f71b9a0a9be1febeb6e5f0b260146e42b94c8b780a39d273c63ae3cbba"

URI_x86_64_v2_ghc9.14-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-process-devel-1.6.26.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-process-devel}"
SRC_URI[x86_64_v2_ghc9.14-process-devel.sha256sum] = "12b402785188d680b407d81b3cebc4d4da59e4a3e38ce3de9116cf3fa0d78699"

URI_x86_64_v2_ghc9.14-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-process-doc-1.6.26.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-process-doc}"
SRC_URI[x86_64_v2_ghc9.14-process-doc.sha256sum] = "c351f94a52d1e3e95bcf5b614bc18a77d75d8b8be9a0521a702b248ef128690e"

URI_x86_64_v2_ghc9.14-semaphore-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-semaphore-compat-1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-semaphore-compat}"
SRC_URI[x86_64_v2_ghc9.14-semaphore-compat.sha256sum] = "d0076ee737ebdad625b47a960b9364c1a573a58642745ebd32020918a109043e"

URI_x86_64_v2_ghc9.14-semaphore-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-semaphore-compat-devel-1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-semaphore-compat-devel}"
SRC_URI[x86_64_v2_ghc9.14-semaphore-compat-devel.sha256sum] = "4e56b0a0d2b66ca36696ad157f7b50acf018eca74eee9acec28aba97a8b0ca5b"

URI_x86_64_v2_ghc9.14-semaphore-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-semaphore-compat-doc-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-semaphore-compat-doc}"
SRC_URI[x86_64_v2_ghc9.14-semaphore-compat-doc.sha256sum] = "d6a943b62b7a13a62c8f5fbf02a189e32ccf145a2cca4b04dce47db24e7619e1"

URI_x86_64_v2_ghc9.14-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-stm-2.5.3.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-stm}"
SRC_URI[x86_64_v2_ghc9.14-stm.sha256sum] = "d7a66a21f5890c842e5fb4f129331c05fb06773efee44ad52b8396071404d2f2"

URI_x86_64_v2_ghc9.14-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-stm-devel-2.5.3.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-stm-devel}"
SRC_URI[x86_64_v2_ghc9.14-stm-devel.sha256sum] = "bfc5193a6913a01d37258825fa8950e7ae6b20439826387ba89bf5ace76eb15b"

URI_x86_64_v2_ghc9.14-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-stm-doc-2.5.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-stm-doc}"
SRC_URI[x86_64_v2_ghc9.14-stm-doc.sha256sum] = "2e49bf981a0b9a21509eb37e6662dd05b1930a735dd62b81ef5f123d63ccd8f4"

URI_x86_64_v2_ghc9.14-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-template-haskell-2.24.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-template-haskell}"
SRC_URI[x86_64_v2_ghc9.14-template-haskell.sha256sum] = "76dffc9e49b74163a2ad44f11e6f7fbc477db78c41f0824b7476ce1ecddd47ff"

URI_x86_64_v2_ghc9.14-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-template-haskell-devel-2.24.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.14-template-haskell-devel.sha256sum] = "11f470f828ebd0194122b9824ef093d77eb11344243930811215f17774ccddaa"

URI_x86_64_v2_ghc9.14-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-template-haskell-doc-2.24.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.14-template-haskell-doc.sha256sum] = "1ea11749a3ec992c6a93ad176659bb430c008cbc565d171b436f3f89f7ac222f"

URI_x86_64_v2_ghc9.14-template-haskell-lift = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-template-haskell-lift-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-template-haskell-lift;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-template-haskell-lift}"
SRC_URI[x86_64_v2_ghc9.14-template-haskell-lift.sha256sum] = "36115f8b6e20ff36fdce3e697a507b5a70d3a5e45f3c95063b7e4049467c6cff"

URI_x86_64_v2_ghc9.14-template-haskell-lift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-template-haskell-lift-devel-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-template-haskell-lift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-template-haskell-lift-devel}"
SRC_URI[x86_64_v2_ghc9.14-template-haskell-lift-devel.sha256sum] = "78ce27038a188fd13882ec7f18730d3c23843f9246fc75e970153c09340db85f"

URI_x86_64_v2_ghc9.14-template-haskell-lift-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-template-haskell-lift-doc-0.1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-template-haskell-lift-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-template-haskell-lift-doc}"
SRC_URI[x86_64_v2_ghc9.14-template-haskell-lift-doc.sha256sum] = "cfa7069a0bcc4a19b7b83ff495e88cb13986b9f80c7a63d20574785e2be45a29"

URI_x86_64_v2_ghc9.14-template-haskell-quasiquoter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-template-haskell-quasiquoter-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-template-haskell-quasiquoter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-template-haskell-quasiquoter}"
SRC_URI[x86_64_v2_ghc9.14-template-haskell-quasiquoter.sha256sum] = "3c1396bf3f2e47001ad84d722b5743ccfcc234232b2bebed227dfade38da73c8"

URI_x86_64_v2_ghc9.14-template-haskell-quasiquoter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-template-haskell-quasiquoter-devel-0.1.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-template-haskell-quasiquoter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-template-haskell-quasiquoter-devel}"
SRC_URI[x86_64_v2_ghc9.14-template-haskell-quasiquoter-devel.sha256sum] = "aaeff812d57f05eda0114fada4421a061075261cfd3512b75a717ec8b66f14cf"

URI_x86_64_v2_ghc9.14-template-haskell-quasiquoter-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-template-haskell-quasiquoter-doc-0.1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-template-haskell-quasiquoter-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-template-haskell-quasiquoter-doc}"
SRC_URI[x86_64_v2_ghc9.14-template-haskell-quasiquoter-doc.sha256sum] = "f4cd096ff6408ce0e7d28ce8fd0a903fa89bf6ff108c70710a3d4dd3f7ea0202"

URI_x86_64_v2_ghc9.14-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-terminfo-0.4.1.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-terminfo}"
SRC_URI[x86_64_v2_ghc9.14-terminfo.sha256sum] = "c5ae043a9e0effaee370e16140f6f4f194aa5d1f15d1e6bf0222474a3ce27404"

URI_x86_64_v2_ghc9.14-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-terminfo-devel-0.4.1.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.14-terminfo-devel.sha256sum] = "8554088027ac6220a15426d1349d07ac231d7dbac585bda00686257e0a0331d9"

URI_x86_64_v2_ghc9.14-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-terminfo-doc-0.4.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.14-terminfo-doc.sha256sum] = "f26cf6f9802862a89963e392c4669ed86a3b02964531e12fabc391d2c5ec6551"

URI_x86_64_v2_ghc9.14-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-text-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-text}"
SRC_URI[x86_64_v2_ghc9.14-text.sha256sum] = "605e7c9fa8c9f357138c410fe1d1ea1ab2701ed6ffeff66d6efabae590cc9177"

URI_x86_64_v2_ghc9.14-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-text-devel-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-text-devel}"
SRC_URI[x86_64_v2_ghc9.14-text-devel.sha256sum] = "80141ca889d3b357f66ea5918a919e595347ab4cae5d0855ace940c02a3314c2"

URI_x86_64_v2_ghc9.14-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-text-doc-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-text-doc}"
SRC_URI[x86_64_v2_ghc9.14-text-doc.sha256sum] = "c826e2966e906a41d10f2cc22700025188a0df8d142054253ddfc19c5ace8f78"

URI_x86_64_v2_ghc9.14-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-time-1.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-time}"
SRC_URI[x86_64_v2_ghc9.14-time.sha256sum] = "d4224923574275b3e86d01162cbc5bc542526fbb29a5c4720aeb0c8ad5a49907"

URI_x86_64_v2_ghc9.14-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-time-devel-1.15-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-time-devel}"
SRC_URI[x86_64_v2_ghc9.14-time-devel.sha256sum] = "aea709d4bcadc33f7588c417cc1c0676b015dcacb5e2a93e3eacecd932d6fd0f"

URI_x86_64_v2_ghc9.14-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-time-doc-1.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-time-doc}"
SRC_URI[x86_64_v2_ghc9.14-time-doc.sha256sum] = "886195478faad6b4e9f15dbdc4d34cdec23ca327168fa5f45b3d7559a5fa22af"

URI_x86_64_v2_ghc9.14-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-transformers-0.6.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-transformers}"
SRC_URI[x86_64_v2_ghc9.14-transformers.sha256sum] = "38cd31150ddb669d33c9a73b9e9f316f67fcb39bd29786b53174e1565c2c34b2"

URI_x86_64_v2_ghc9.14-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-transformers-devel-0.6.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.14-transformers-devel.sha256sum] = "71ca79344b4cc2d0ae868899fdf0380b2b0d15aa479a851c6a79725436fb2607"

URI_x86_64_v2_ghc9.14-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-transformers-doc-0.6.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.14-transformers-doc.sha256sum] = "093cc913221e291d27d463d49bbab9a1423e2322428f9096123865df6d53d5c8"

URI_x86_64_v2_ghc9.14-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-unix-2.8.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-unix}"
SRC_URI[x86_64_v2_ghc9.14-unix.sha256sum] = "28a4aa88a316bfab937920e33dc7979a104cfb5f4f0008cee5c49b0040cee7a2"

URI_x86_64_v2_ghc9.14-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-unix-devel-2.8.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-unix-devel}"
SRC_URI[x86_64_v2_ghc9.14-unix-devel.sha256sum] = "25d0e68f0ac5a38b3b6a28b0caf63f1fe166bce126c3d4ac4f73fa916f5ad442"

URI_x86_64_v2_ghc9.14-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-unix-doc-2.8.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-unix-doc}"
SRC_URI[x86_64_v2_ghc9.14-unix-doc.sha256sum] = "0d8cf53fffa5dce9969f17fbd314716ad058252e9137e5d4366b2f4f18ae466d"

URI_x86_64_v2_ghc9.14-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-xhtml-3000.2.2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-xhtml}"
SRC_URI[x86_64_v2_ghc9.14-xhtml.sha256sum] = "a4ea4d84013dd91dfb85feee528624676bcadcddfcbd784962aafe06d6b30d65"

URI_x86_64_v2_ghc9.14-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-xhtml-devel-3000.2.2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.14-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.14-xhtml-devel.sha256sum] = "088975e523d3c07aa422981fa31dce2dab04f80608fb4915babbf13fb96bd58a"

URI_x86_64_v2_ghc9.14-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.14-xhtml-doc-3000.2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.14-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.14-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.14-xhtml-doc.sha256sum] = "e61d49a23ee1426109cb54942c6218cccd9d3715b85f1cb05492b3df552f4bbe"

URI_aarch64_ghc9.14 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14}"
SRC_URI[aarch64_ghc9.14.sha256sum] = "065f2a234f7ae0f9a3890c844b00a37996461bd56b30aad0143736102ec660f1"

URI_aarch64_ghc9.14-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-Cabal-3.16.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-Cabal}"
SRC_URI[aarch64_ghc9.14-Cabal.sha256sum] = "c4e1119e1ce44c29da99276f6c0df1b936bcc711dd2d5148f943f8f9fb38b430"

URI_aarch64_ghc9.14-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-Cabal-devel-3.16.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-Cabal-devel}"
SRC_URI[aarch64_ghc9.14-Cabal-devel.sha256sum] = "1bc2dfcab0629c711be2f64779e2a73fb023bf868343302864c93fed23013849"

URI_aarch64_ghc9.14-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-Cabal-doc-3.16.0.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-Cabal-doc}"
SRC_URI[aarch64_ghc9.14-Cabal-doc.sha256sum] = "e63c96f8ef7161ec99b5a41a2bab1c074a903177d04b44c801339fe88bd34029"

URI_aarch64_ghc9.14-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-Cabal-prof-3.16.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-Cabal-prof}"
SRC_URI[aarch64_ghc9.14-Cabal-prof.sha256sum] = "352df070dfe90c7e2008dff19f0518741b194070791ab98d9662b579d3bce7c5"

URI_aarch64_ghc9.14-Cabal-syntax = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-Cabal-syntax-3.16.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-Cabal-syntax}"
SRC_URI[aarch64_ghc9.14-Cabal-syntax.sha256sum] = "1c68ebe69904f879571c01c594ff42ca3bf70a0e39997bd934c5d5d7dc6290ef"

URI_aarch64_ghc9.14-Cabal-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-Cabal-syntax-devel-3.16.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-Cabal-syntax-devel}"
SRC_URI[aarch64_ghc9.14-Cabal-syntax-devel.sha256sum] = "cedef069e292fbfc1d53934e74f61abb680a94bd831722eb762980bd8bf3e46a"

URI_aarch64_ghc9.14-Cabal-syntax-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-Cabal-syntax-doc-3.16.0.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-Cabal-syntax-doc}"
SRC_URI[aarch64_ghc9.14-Cabal-syntax-doc.sha256sum] = "38ffc7aac6d840b21b2f2c25a09553b3f3668cb7f86a1e36bc1f48dedc106403"

URI_aarch64_ghc9.14-Cabal-syntax-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-Cabal-syntax-prof-3.16.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-Cabal-syntax-prof}"
SRC_URI[aarch64_ghc9.14-Cabal-syntax-prof.sha256sum] = "e93282026247dc229eb28419d5ca371519b40d7db2a08d4ac146a4ce7d7a2861"

URI_aarch64_ghc9.14-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-array-0.5.8.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-array}"
SRC_URI[aarch64_ghc9.14-array.sha256sum] = "e164ca9bd958f6fcdea05dc60045c1067f84316ee861a281bb00ea5df6e10fbe"

URI_aarch64_ghc9.14-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-array-devel-0.5.8.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-array-devel}"
SRC_URI[aarch64_ghc9.14-array-devel.sha256sum] = "dfe9a9796a7feb036b7698dd6e2e76ff06e22db5f34f02d9ce3114c914ebe373"

URI_aarch64_ghc9.14-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-array-doc-0.5.8.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-array-doc}"
SRC_URI[aarch64_ghc9.14-array-doc.sha256sum] = "e0334d755b5fdcce76c476376507cda0efaab060b504817a2fcc9b03796d93db"

URI_aarch64_ghc9.14-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-array-prof-0.5.8.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-array-prof}"
SRC_URI[aarch64_ghc9.14-array-prof.sha256sum] = "438bf30f2e8db7e6a0151d6e0f5f19503cc25aa2b0798d1d92c98809bbb946ea"

URI_aarch64_ghc9.14-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-base-4.22.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-base}"
SRC_URI[aarch64_ghc9.14-base.sha256sum] = "6584723841fb8e4fa9d9fcb6bab4d3720c4fbe1a8a8176ef1c828cbe51f7611a"

URI_aarch64_ghc9.14-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-base-devel-4.22.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-base-devel}"
SRC_URI[aarch64_ghc9.14-base-devel.sha256sum] = "f519658d5573906a652971d099157fc85ba62e7fb6e8b9c6e53e98dc3f53c596"

URI_aarch64_ghc9.14-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-base-doc-4.22.0.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-base-doc}"
SRC_URI[aarch64_ghc9.14-base-doc.sha256sum] = "cf01bba970adb0620ee6695c5150bc77fbbfd5c91f1e09083e926d2e7f752e42"

URI_aarch64_ghc9.14-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-base-prof-4.22.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-base-prof}"
SRC_URI[aarch64_ghc9.14-base-prof.sha256sum] = "d45ee80e98f327053ff9cd3ee98f1b7bcce7542a8763f22f8b5d7cc5373b200d"

URI_aarch64_ghc9.14-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-binary-0.8.9.3-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-binary}"
SRC_URI[aarch64_ghc9.14-binary.sha256sum] = "94f9a9d26d92477a0c3d4671153e1d6b0c2cb5fb13fc8b08bc8c227bcb97e182"

URI_aarch64_ghc9.14-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-binary-devel-0.8.9.3-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-binary-devel}"
SRC_URI[aarch64_ghc9.14-binary-devel.sha256sum] = "d98fe19a2475cd0b8567b645a0f59b352e5539fd812161d848235cfdd5e7782f"

URI_aarch64_ghc9.14-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-binary-doc-0.8.9.3-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-binary-doc}"
SRC_URI[aarch64_ghc9.14-binary-doc.sha256sum] = "5264b9a08d74708d4461543376fbbf0ac071e9f8c203c24fc4e1383a9e6e8c8e"

URI_aarch64_ghc9.14-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-binary-prof-0.8.9.3-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-binary-prof}"
SRC_URI[aarch64_ghc9.14-binary-prof.sha256sum] = "d9a849463d5d2b5187ae08d6b33e02ab60ee06db1cc427889a2c3a1e36d9cbb2"

URI_aarch64_ghc9.14-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-bytestring-0.12.2.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-bytestring}"
SRC_URI[aarch64_ghc9.14-bytestring.sha256sum] = "8e98287479ec6c0a94ea8f673872e5fab3f8419c2e13d10a9ea79af2c6dc2c8f"

URI_aarch64_ghc9.14-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-bytestring-devel-0.12.2.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-bytestring-devel}"
SRC_URI[aarch64_ghc9.14-bytestring-devel.sha256sum] = "439c600c5a11aef1b9b4208f95db6f4936ef34c67fdcee8603eb6a2e0df1c5ef"

URI_aarch64_ghc9.14-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-bytestring-doc-0.12.2.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-bytestring-doc}"
SRC_URI[aarch64_ghc9.14-bytestring-doc.sha256sum] = "57e14ff0b8b16b1b964478ed354b7513bcdff52b41b6f85ce39b3404b4a9e3e5"

URI_aarch64_ghc9.14-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-bytestring-prof-0.12.2.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-bytestring-prof}"
SRC_URI[aarch64_ghc9.14-bytestring-prof.sha256sum] = "e2239ef21f40af450eec5b163282b0bc2e0dd303f799e8ca19e659f7fb8acd1c"

URI_aarch64_ghc9.14-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-compiler-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-compiler}"
SRC_URI[aarch64_ghc9.14-compiler.sha256sum] = "4f5fa75e2532e01bff22560ab89174e49e301c1de191a22b46f9dda77ddd86c7"

URI_aarch64_ghc9.14-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-compiler-default-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-compiler-default}"
SRC_URI[aarch64_ghc9.14-compiler-default.sha256sum] = "57f14fffa13158dfa5a5768798af54fae9eb1ceaa137aadb508e6be67b82decc"

URI_aarch64_ghc9.14-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-containers-0.8-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-containers}"
SRC_URI[aarch64_ghc9.14-containers.sha256sum] = "d746c66baee4ca776671c2c365cb7eb616c06d115489c546fc735e2151b82200"

URI_aarch64_ghc9.14-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-containers-devel-0.8-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-containers-devel}"
SRC_URI[aarch64_ghc9.14-containers-devel.sha256sum] = "33dfb491860a6d51a11a29671a79cc57d84577d210919668279937c9ab624535"

URI_aarch64_ghc9.14-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-containers-doc-0.8-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-containers-doc}"
SRC_URI[aarch64_ghc9.14-containers-doc.sha256sum] = "593a23810505c50651a7c6af2d1ba071a016142bbdfb89ab51c52c2d3c4905b3"

URI_aarch64_ghc9.14-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-containers-prof-0.8-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-containers-prof}"
SRC_URI[aarch64_ghc9.14-containers-prof.sha256sum] = "3d15e81a10d242c8af6451bf915fd37d6032ee15653e837a424081e289b429de"

URI_aarch64_ghc9.14-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-deepseq-1.5.1.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-deepseq}"
SRC_URI[aarch64_ghc9.14-deepseq.sha256sum] = "0e30d971077d826a1913431c2f2305a482a0a4efbdc0d42611cc2f97d57f9d12"

URI_aarch64_ghc9.14-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-deepseq-devel-1.5.1.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-deepseq-devel}"
SRC_URI[aarch64_ghc9.14-deepseq-devel.sha256sum] = "571a81fccdc7b6ad2f7c73ef136920357e8cc8ead9e27706952b816d3a73db55"

URI_aarch64_ghc9.14-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-deepseq-doc-1.5.1.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-deepseq-doc}"
SRC_URI[aarch64_ghc9.14-deepseq-doc.sha256sum] = "f8cba1ba745a3dfe709a6fb9b8758287452d6b3c2cead36fc19e19df201c19f0"

URI_aarch64_ghc9.14-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-deepseq-prof-1.5.1.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-deepseq-prof}"
SRC_URI[aarch64_ghc9.14-deepseq-prof.sha256sum] = "a82a2434f7998f923b7df0d4e7945b954ac7f26485ec3b857f47749b92a0d9e9"

URI_aarch64_ghc9.14-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-devel-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-devel}"
SRC_URI[aarch64_ghc9.14-devel.sha256sum] = "2b761a0bab6af0a483d62d4223f0cb3b7df6daab7f845fbf347034de57f59d31"

URI_aarch64_ghc9.14-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-directory-1.3.10.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-directory}"
SRC_URI[aarch64_ghc9.14-directory.sha256sum] = "876e7f4cff07582b9093318c34315cc71dc08584f49bb689f4be1e4940be2604"

URI_aarch64_ghc9.14-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-directory-devel-1.3.10.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-directory-devel}"
SRC_URI[aarch64_ghc9.14-directory-devel.sha256sum] = "3881cec7796f64117ee5ba902a8ace309e5446c09d42669814fc5c5948b0de6a"

URI_aarch64_ghc9.14-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-directory-doc-1.3.10.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-directory-doc}"
SRC_URI[aarch64_ghc9.14-directory-doc.sha256sum] = "8413393d9c9881e4c1da747e25b82389c7074e1f6037bb90005a7f2b0d45110d"

URI_aarch64_ghc9.14-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-directory-prof-1.3.10.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-directory-prof}"
SRC_URI[aarch64_ghc9.14-directory-prof.sha256sum] = "87122386a9c5dca1531a5c0ccb0a319fa678f546a4238459b83f5f63dfcc2298"

URI_aarch64_ghc9.14-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-doc-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-doc}"
SRC_URI[aarch64_ghc9.14-doc.sha256sum] = "e4d5f4d6b820be2af045595fd213525f84b37a1d94ce37703ed2d3dc009d5258"

URI_aarch64_ghc9.14-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-doc-index-9.14.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-doc-index}"
SRC_URI[aarch64_ghc9.14-doc-index.sha256sum] = "0d308e08140938535f4f74c638f29c1c4f6e7ecee6307967b2419089e417691c"

URI_aarch64_ghc9.14-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-exceptions-0.10.11-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-exceptions}"
SRC_URI[aarch64_ghc9.14-exceptions.sha256sum] = "71f6ff052e4b3b6c3326c1ef5c52eda1de2890c7332b714bddab4c5dcd6c3a2b"

URI_aarch64_ghc9.14-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-exceptions-devel-0.10.11-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-exceptions-devel}"
SRC_URI[aarch64_ghc9.14-exceptions-devel.sha256sum] = "4d433c50d6ed766b8b356bc248124a8889f3f0dad3f3a6a9a05d192a259e99e9"

URI_aarch64_ghc9.14-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-exceptions-doc-0.10.11-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-exceptions-doc}"
SRC_URI[aarch64_ghc9.14-exceptions-doc.sha256sum] = "ee75c8f7b4ceb01c2f4c0359a23a47404d4c81000ca697a9bb8660f7759ffe27"

URI_aarch64_ghc9.14-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-exceptions-prof-0.10.11-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-exceptions-prof}"
SRC_URI[aarch64_ghc9.14-exceptions-prof.sha256sum] = "92f10ee6b79988cde5f705f19de9c89c12c4b40ca7f6f7bc9ee49b35aa7a5144"

URI_aarch64_ghc9.14-file-io = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-file-io-0.1.5-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-file-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-file-io}"
SRC_URI[aarch64_ghc9.14-file-io.sha256sum] = "f07c17bb49e41d80fdf67f9ac21717cfa931fd8c8673dfc0615f356d90577705"

URI_aarch64_ghc9.14-file-io-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-file-io-devel-0.1.5-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-file-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-file-io-devel}"
SRC_URI[aarch64_ghc9.14-file-io-devel.sha256sum] = "9a0051032e16ba5f7102adbd098b0dc298972f5a331ef2bafe6fb9f1431ed25c"

URI_aarch64_ghc9.14-file-io-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-file-io-doc-0.1.5-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-file-io-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-file-io-doc}"
SRC_URI[aarch64_ghc9.14-file-io-doc.sha256sum] = "8091d61091fce89a47fcf2d10feae70bf193f1cd9865ce6baea22da1a7654962"

URI_aarch64_ghc9.14-file-io-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-file-io-prof-0.1.5-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-file-io-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-file-io-prof}"
SRC_URI[aarch64_ghc9.14-file-io-prof.sha256sum] = "f3643982068353554d7a2c19014fcde39b36f0f961170501b604f573fb671479"

URI_aarch64_ghc9.14-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-filepath-1.5.4.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-filepath}"
SRC_URI[aarch64_ghc9.14-filepath.sha256sum] = "32d31f50be536fef34ebf65cb8b4fc4bbfb15ccf91993d0a95a5efa117518f69"

URI_aarch64_ghc9.14-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-filepath-devel-1.5.4.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-filepath-devel}"
SRC_URI[aarch64_ghc9.14-filepath-devel.sha256sum] = "2dbb1554485450ec2e1bf7e9bc80b873fcb1c5fc04190ada3f42f57fd3d505ef"

URI_aarch64_ghc9.14-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-filepath-doc-1.5.4.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-filepath-doc}"
SRC_URI[aarch64_ghc9.14-filepath-doc.sha256sum] = "0fd3ffb5b32a38df4dc44f1fb6f513509b40c45117782df8097eb3fe13c86525"

URI_aarch64_ghc9.14-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-filepath-prof-1.5.4.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-filepath-prof}"
SRC_URI[aarch64_ghc9.14-filepath-prof.sha256sum] = "c4dd29e9453a1d08307f16075719d35d613a578f717668d4b2f31f2c29f5eaac"

URI_aarch64_ghc9.14-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-filesystem-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-filesystem}"
SRC_URI[aarch64_ghc9.14-filesystem.sha256sum] = "bb59a00ceae9b407e8c6a970074b36be8738fa5937e20d3e5e9ebd89f7c4bfcc"

URI_aarch64_ghc9.14-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc}"
SRC_URI[aarch64_ghc9.14-ghc.sha256sum] = "501d6b49d56ed2ab88e61bb697f0e1f64f99a661850f29d908dc0229cc763300"

URI_aarch64_ghc9.14-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-bignum-1.4-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-bignum}"
SRC_URI[aarch64_ghc9.14-ghc-bignum.sha256sum] = "54a53452552c314f38b52dc215440111e593daaea5d417b0d98d72ca66275565"

URI_aarch64_ghc9.14-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-bignum-devel-1.4-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.14-ghc-bignum-devel.sha256sum] = "bf720be86ae5c8fc6dc439877c4214c2af6a08ba76ee9d70bb11251b4034317b"

URI_aarch64_ghc9.14-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-bignum-doc-1.4-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.14-ghc-bignum-doc.sha256sum] = "6a07bc6c10c62774c6920bc8b25f7f2197facd7cb09d88de67ac58d9d0606b68"

URI_aarch64_ghc9.14-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-bignum-prof-1.4-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.14-ghc-bignum-prof.sha256sum] = "f7e6459d86071b2993d5150f994a515f4a3df22e63ee4272990d785c74e4d84c"

URI_aarch64_ghc9.14-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-boot-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-boot}"
SRC_URI[aarch64_ghc9.14-ghc-boot.sha256sum] = "efb801fef60fc20b9dd4658c58802e4a2c809e8ff648523094b57d3b5d430102"

URI_aarch64_ghc9.14-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-boot-devel-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.14-ghc-boot-devel.sha256sum] = "d03fe201254da9ec4c655f50bba3cf6895c441764677ca5bda38bc9d13839ee8"

URI_aarch64_ghc9.14-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-boot-doc-9.14.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.14-ghc-boot-doc.sha256sum] = "e26324a3b5b39423cb256572c79a897c39269d36022f8b09be45aae15e43cede"

URI_aarch64_ghc9.14-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-boot-prof-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.14-ghc-boot-prof.sha256sum] = "f925b4203e71cba421bc9268b82bc731bfe1db2e6d20c2475365aae6d573582d"

URI_aarch64_ghc9.14-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-boot-th-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-boot-th}"
SRC_URI[aarch64_ghc9.14-ghc-boot-th.sha256sum] = "d36673a005a90d7a7141d1bb4b7a65ac0b502c04d1cb62883e63fbc8c014b775"

URI_aarch64_ghc9.14-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-boot-th-devel-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.14-ghc-boot-th-devel.sha256sum] = "823c421cd31d5c049700b9b639914462dcc13a533851c8e1f66441dad4b644cb"

URI_aarch64_ghc9.14-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-boot-th-doc-9.14.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.14-ghc-boot-th-doc.sha256sum] = "83725bf1c1434dc9e4b0924a2bdc20623df34f0ef465be1afa403b7f16a8c8c8"

URI_aarch64_ghc9.14-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-boot-th-prof-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.14-ghc-boot-th-prof.sha256sum] = "2c6cfb4885e8c217079a3bf7d46d73b053fe9d4dedb3da17708537ec50ad4f9e"

URI_aarch64_ghc9.14-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-compact-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-compact}"
SRC_URI[aarch64_ghc9.14-ghc-compact.sha256sum] = "51e04f929bb5f47c8faf337205ccc31fbcd56303d1ab0ca94ea00db52ed9a8ec"

URI_aarch64_ghc9.14-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-compact-devel-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.14-ghc-compact-devel.sha256sum] = "cac43a213aee3b4075e3bc56606c9ad1e6c942f6e5db1ea2b8a38d4ad6d6cba2"

URI_aarch64_ghc9.14-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-compact-doc-0.1.0.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.14-ghc-compact-doc.sha256sum] = "cc13ef72a5335cb3bfd5043b20a7ff35105a411c367b3607fc154e353e306935"

URI_aarch64_ghc9.14-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-compact-prof-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.14-ghc-compact-prof.sha256sum] = "0cf435cdbd918c20599de7a362c7bd5222031871295a19f97aecd9479938f7d1"

URI_aarch64_ghc9.14-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-devel-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-devel}"
SRC_URI[aarch64_ghc9.14-ghc-devel.sha256sum] = "2820660f4e136fca5ff960bc07df79b711ab942a3ce353e56dcbbd6357fc0846"

URI_aarch64_ghc9.14-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-doc-9.14.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-doc}"
SRC_URI[aarch64_ghc9.14-ghc-doc.sha256sum] = "9a328fe68a4908151aa049527ba0e8ae9e61ad86f5e01fc433ff989f31398569"

URI_aarch64_ghc9.14-ghc-experimental = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-experimental-9.1401.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-experimental}"
SRC_URI[aarch64_ghc9.14-ghc-experimental.sha256sum] = "85e0ee37b6c03871152470faf7cab42fef0ec62d595ec265a24c08893d9c90f9"

URI_aarch64_ghc9.14-ghc-experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-experimental-devel-9.1401.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-experimental-devel}"
SRC_URI[aarch64_ghc9.14-ghc-experimental-devel.sha256sum] = "ee17a5e978db7d30d93614540d4a2c1d7ed7b0c1bfbb14a291b85f23c817f433"

URI_aarch64_ghc9.14-ghc-experimental-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-experimental-doc-9.1401.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-experimental-doc}"
SRC_URI[aarch64_ghc9.14-ghc-experimental-doc.sha256sum] = "81185e24ba7a0d84f4a37d1425ecbc35a93c7266231b21a903d2b33c71adfbb8"

URI_aarch64_ghc9.14-ghc-experimental-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-experimental-prof-9.1401.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-experimental-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-experimental-prof}"
SRC_URI[aarch64_ghc9.14-ghc-experimental-prof.sha256sum] = "203ea5548b58a4451ace4ef8f25f9f02b3e0d1e0eeda23c9f594045597415a7d"

URI_aarch64_ghc9.14-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-heap-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-heap}"
SRC_URI[aarch64_ghc9.14-ghc-heap.sha256sum] = "db3e5a96ad07a3655b8b553a1edbd1e783557d9b95cbaef56e3eb3d94f22a163"

URI_aarch64_ghc9.14-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-heap-devel-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.14-ghc-heap-devel.sha256sum] = "283c9df3c72272caa3223804770a7ff53aba3e44b3018214b88fcdcd86a3942d"

URI_aarch64_ghc9.14-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-heap-doc-9.14.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.14-ghc-heap-doc.sha256sum] = "6ed20300f3f751c1feaa47b8e33bb62c5897f932e2e7c92f249dc7ab23fe51a0"

URI_aarch64_ghc9.14-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-heap-prof-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.14-ghc-heap-prof.sha256sum] = "b9a7331d18a89204dd470274abac6c5c03836f8985dfe368b377f6ff8ee88b04"

URI_aarch64_ghc9.14-ghc-platform = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-platform-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-platform}"
SRC_URI[aarch64_ghc9.14-ghc-platform.sha256sum] = "1e668b9b502ad992509141907f2873dc5d4999ab89c7173003f6c56e2c9082f0"

URI_aarch64_ghc9.14-ghc-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-platform-devel-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-platform-devel}"
SRC_URI[aarch64_ghc9.14-ghc-platform-devel.sha256sum] = "eb8eb4745982b3faebf942c31457e86637fa0bce253c4b043be1d83c7b2ae3f0"

URI_aarch64_ghc9.14-ghc-platform-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-platform-doc-0.1.0.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-platform-doc}"
SRC_URI[aarch64_ghc9.14-ghc-platform-doc.sha256sum] = "7f631b455c203db5b6dfe82b3a602a8d7201416af0814b71c662a932693c9735"

URI_aarch64_ghc9.14-ghc-platform-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-platform-prof-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-platform-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-platform-prof}"
SRC_URI[aarch64_ghc9.14-ghc-platform-prof.sha256sum] = "57d04a0eb2f1d9bce2e178059ff3f2928304a93dcd53473b2fe61f0b796658bd"

URI_aarch64_ghc9.14-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-prof-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-prof}"
SRC_URI[aarch64_ghc9.14-ghc-prof.sha256sum] = "9d85e7d8633f48cdb6a134004d43e94e9ac842cb96e88d8a3f23df71a29e8583"

URI_aarch64_ghc9.14-ghc-toolchain = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-toolchain-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-toolchain}"
SRC_URI[aarch64_ghc9.14-ghc-toolchain.sha256sum] = "3683b2965102a0d3490c1bbd1307d47a3afff69df474ad8a78950c1106df433c"

URI_aarch64_ghc9.14-ghc-toolchain-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-toolchain-devel-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-toolchain-devel}"
SRC_URI[aarch64_ghc9.14-ghc-toolchain-devel.sha256sum] = "cc2be1686ea9d1078957e835e75f2760b9c2dc3ad4570bd7090ea0b4a92238f2"

URI_aarch64_ghc9.14-ghc-toolchain-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-toolchain-doc-0.1.0.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-toolchain-doc}"
SRC_URI[aarch64_ghc9.14-ghc-toolchain-doc.sha256sum] = "93525b715917329b069f42aaef5cc25950cf9142a276682c6ec4eecd0fc6140d"

URI_aarch64_ghc9.14-ghc-toolchain-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghc-toolchain-prof-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghc-toolchain-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghc-toolchain-prof}"
SRC_URI[aarch64_ghc9.14-ghc-toolchain-prof.sha256sum] = "fb404ad391b22a8d18a4a50b942765e2d57b5ebba858d9b05c7d74e6a9980909"

URI_aarch64_ghc9.14-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghci-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghci}"
SRC_URI[aarch64_ghc9.14-ghci.sha256sum] = "a86af453e3fed23a4706b0239f47e0c1934b648188b04702f7f574d11f34fd88"

URI_aarch64_ghc9.14-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghci-devel-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghci-devel}"
SRC_URI[aarch64_ghc9.14-ghci-devel.sha256sum] = "6ac65dd9158a97850bd8f43762bd4c80e9a300fcb4697b7c20486ac891f75992"

URI_aarch64_ghc9.14-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghci-doc-9.14.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghci-doc}"
SRC_URI[aarch64_ghc9.14-ghci-doc.sha256sum] = "78ddfa35070bf3990766198a17007204f6835106022a950804eb5170ddfafde5"

URI_aarch64_ghc9.14-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-ghci-prof-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-ghci-prof}"
SRC_URI[aarch64_ghc9.14-ghci-prof.sha256sum] = "9d7d50f83e5a56afb4f4337d44473faecbb403cde62a000c77f1d32797f9a916"

URI_aarch64_ghc9.14-haddock-api = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haddock-api-2.33.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-haddock-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haddock-api}"
SRC_URI[aarch64_ghc9.14-haddock-api.sha256sum] = "c3991fab3b580776127fac018dbcea2402fbc7b898b382cc5fc41da7b526a2fb"

URI_aarch64_ghc9.14-haddock-api-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haddock-api-devel-2.33.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-haddock-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haddock-api-devel}"
SRC_URI[aarch64_ghc9.14-haddock-api-devel.sha256sum] = "ebe4456e33473ca76eaa969cbf3c34d981a8f7ba1c4976d7354270573ae479f1"

URI_aarch64_ghc9.14-haddock-api-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haddock-api-doc-2.33.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-haddock-api-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haddock-api-doc}"
SRC_URI[aarch64_ghc9.14-haddock-api-doc.sha256sum] = "c7e6508bf23ab842fc9b93b567f2bbb151729cf99f6f7f4a807107cbb3372ddd"

URI_aarch64_ghc9.14-haddock-api-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haddock-api-prof-2.33.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-haddock-api-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haddock-api-prof}"
SRC_URI[aarch64_ghc9.14-haddock-api-prof.sha256sum] = "0af086f7baad31cad1ed59a67c084a4cb391c16173ca5fe422bf6a6cb5650357"

URI_aarch64_ghc9.14-haddock-library = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haddock-library-1.11.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-haddock-library;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haddock-library}"
SRC_URI[aarch64_ghc9.14-haddock-library.sha256sum] = "9071893f8574b64b77d87e68176117408472a1078da6c7b70e5721809e755268"

URI_aarch64_ghc9.14-haddock-library-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haddock-library-devel-1.11.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-haddock-library-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haddock-library-devel}"
SRC_URI[aarch64_ghc9.14-haddock-library-devel.sha256sum] = "f9b6148c2ae85f6703101f5219d5f4a4ac488951dc20f911cbcf09c63825aee7"

URI_aarch64_ghc9.14-haddock-library-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haddock-library-doc-1.11.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-haddock-library-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haddock-library-doc}"
SRC_URI[aarch64_ghc9.14-haddock-library-doc.sha256sum] = "f50fbfd35dba3de6d1ccedcafaa3ba2b9bedaec1c2393e83e4a7cc2b40481cd6"

URI_aarch64_ghc9.14-haddock-library-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haddock-library-prof-1.11.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-haddock-library-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haddock-library-prof}"
SRC_URI[aarch64_ghc9.14-haddock-library-prof.sha256sum] = "634629bb21e4982dc7c1ae9a0e037cd002d3a07ec8b19f18ec8bc73182853c45"

URI_aarch64_ghc9.14-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-hadrian-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-hadrian}"
SRC_URI[aarch64_ghc9.14-hadrian.sha256sum] = "d6c35f9e103349d833178ac07551b50522416d92f505af71c0a5d0429c345e8f"

URI_aarch64_ghc9.14-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haskeline-0.8.3.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haskeline}"
SRC_URI[aarch64_ghc9.14-haskeline.sha256sum] = "f664e3379084990792d54da405cab65bc667618ae6a86e1eaa386ab27dfed6cb"

URI_aarch64_ghc9.14-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haskeline-devel-0.8.3.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haskeline-devel}"
SRC_URI[aarch64_ghc9.14-haskeline-devel.sha256sum] = "31e4d20baef486a8bcdb82523762206c2e01c459d957426cc0a3b831d1e35bf3"

URI_aarch64_ghc9.14-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haskeline-doc-0.8.3.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haskeline-doc}"
SRC_URI[aarch64_ghc9.14-haskeline-doc.sha256sum] = "5c8e7be7aee895eb88b24687aa1b0ea3ac1ed1322bcdf2072e41ac38768a5d74"

URI_aarch64_ghc9.14-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-haskeline-prof-0.8.3.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-haskeline-prof}"
SRC_URI[aarch64_ghc9.14-haskeline-prof.sha256sum] = "38109b4d8d15b4e1522ae4b181d200d3f0d00b49b6cae29d6c90a17b64705883"

URI_aarch64_ghc9.14-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-hpc-0.7.0.2-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-hpc}"
SRC_URI[aarch64_ghc9.14-hpc.sha256sum] = "6e9cd9556a01121fc53b17df9e990f8cf56c0ab42c8b6fb50d28e20221d7fbfe"

URI_aarch64_ghc9.14-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-hpc-devel-0.7.0.2-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-hpc-devel}"
SRC_URI[aarch64_ghc9.14-hpc-devel.sha256sum] = "e3355b6f9eddea05723e38ef70677c0b9ec6c3f4c8bf665ca518befd4068d97c"

URI_aarch64_ghc9.14-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-hpc-doc-0.7.0.2-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-hpc-doc}"
SRC_URI[aarch64_ghc9.14-hpc-doc.sha256sum] = "3ea5fe2022911847fb11d964642436528a38034ec069ad6b35a5568441a5c50a"

URI_aarch64_ghc9.14-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-hpc-prof-0.7.0.2-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-hpc-prof}"
SRC_URI[aarch64_ghc9.14-hpc-prof.sha256sum] = "3784fa298629d16522a9a6de96cfad3556d77240699d7dd653020e828f53d6e7"

URI_aarch64_ghc9.14-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-manual-9.14.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-manual}"
SRC_URI[aarch64_ghc9.14-manual.sha256sum] = "4b87ca473f5c72de2b1efc5abe7ec0d76cfa03f13867d59c1e46e85f96eb421c"

URI_aarch64_ghc9.14-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-mtl-2.3.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-mtl}"
SRC_URI[aarch64_ghc9.14-mtl.sha256sum] = "c1c98f97393ab948d02339a14d5bda812b2605b5e39f33334cf22a4517ab99cb"

URI_aarch64_ghc9.14-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-mtl-devel-2.3.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-mtl-devel}"
SRC_URI[aarch64_ghc9.14-mtl-devel.sha256sum] = "ce61dc1e147a199b84713c1758e596fe9c4973d13b32c3e6ce38b12313b6a7e9"

URI_aarch64_ghc9.14-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-mtl-doc-2.3.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-mtl-doc}"
SRC_URI[aarch64_ghc9.14-mtl-doc.sha256sum] = "28b9db1b85440b51fa8d2ded1c3b5fee434ca2043a4f1bca12ae5370a628b285"

URI_aarch64_ghc9.14-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-mtl-prof-2.3.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-mtl-prof}"
SRC_URI[aarch64_ghc9.14-mtl-prof.sha256sum] = "0984682758f63f36b70ed8e1b30d933daea11e746eba4023bd3f83db6be0a7fe"

URI_aarch64_ghc9.14-os-string = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-os-string-2.0.8-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-os-string;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-os-string}"
SRC_URI[aarch64_ghc9.14-os-string.sha256sum] = "59e2763f5d2d8d41eb7a4e9d0538ef28476edd35a4bf9bf83287da7c65effd45"

URI_aarch64_ghc9.14-os-string-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-os-string-devel-2.0.8-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-os-string-devel}"
SRC_URI[aarch64_ghc9.14-os-string-devel.sha256sum] = "49f7970ce05cb01e84b3a3aa568927f0f5d2fecd255db6172c3f081cbdbed391"

URI_aarch64_ghc9.14-os-string-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-os-string-doc-2.0.8-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-os-string-doc}"
SRC_URI[aarch64_ghc9.14-os-string-doc.sha256sum] = "a25c42d766dfc904336bfde3bd14dd833293c6ff4e3cedc66bb45f60590bd9ed"

URI_aarch64_ghc9.14-os-string-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-os-string-prof-2.0.8-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-os-string-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-os-string-prof}"
SRC_URI[aarch64_ghc9.14-os-string-prof.sha256sum] = "a1b2423aa29fabc69b58f525885a8eef1935be77bc7d977d83893aca8b824f41"

URI_aarch64_ghc9.14-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-parsec-3.1.18.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-parsec}"
SRC_URI[aarch64_ghc9.14-parsec.sha256sum] = "5c560aaf379729569af7018ac2701c84794d5bb2ca2fae4978d70f36eadcb916"

URI_aarch64_ghc9.14-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-parsec-devel-3.1.18.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-parsec-devel}"
SRC_URI[aarch64_ghc9.14-parsec-devel.sha256sum] = "33dd5fedc751142da9c3e374336dd9d65e08a20b5cbd68c963e441810f7d83c9"

URI_aarch64_ghc9.14-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-parsec-doc-3.1.18.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-parsec-doc}"
SRC_URI[aarch64_ghc9.14-parsec-doc.sha256sum] = "1064c1c0dd0e0104bda8d61ce58bb552fb1e030c082b6ab9c46425853fc63cae"

URI_aarch64_ghc9.14-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-parsec-prof-3.1.18.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-parsec-prof}"
SRC_URI[aarch64_ghc9.14-parsec-prof.sha256sum] = "c9a78611b87cb118f3bcc67464a32cf711c3bad9434cce5c854ff0d8433dda91"

URI_aarch64_ghc9.14-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-pretty-1.1.3.6-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-pretty}"
SRC_URI[aarch64_ghc9.14-pretty.sha256sum] = "1d92372f9aee95bed8a8d9592b78ddff585d77860b9aed50fd42cd3e46d12866"

URI_aarch64_ghc9.14-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-pretty-devel-1.1.3.6-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-pretty-devel}"
SRC_URI[aarch64_ghc9.14-pretty-devel.sha256sum] = "5622377ad21fcf818d7f10bdadb34b00ae248579a9a8004feb88079cbad9f0cf"

URI_aarch64_ghc9.14-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-pretty-doc-1.1.3.6-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-pretty-doc}"
SRC_URI[aarch64_ghc9.14-pretty-doc.sha256sum] = "732349fbc51c206e99b0bd453fa59afe34eedd5152068ddb198d8f190b6a6be5"

URI_aarch64_ghc9.14-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-pretty-prof-1.1.3.6-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-pretty-prof}"
SRC_URI[aarch64_ghc9.14-pretty-prof.sha256sum] = "ee4a8fa6b94e182c0289167a8fe16160c36c303fecf5e8c04449f72347597704"

URI_aarch64_ghc9.14-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-process-1.6.26.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-process}"
SRC_URI[aarch64_ghc9.14-process.sha256sum] = "90d95a2e3ef26e858e798dc8d7279cb269817b48018295620b8b747f961583ef"

URI_aarch64_ghc9.14-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-process-devel-1.6.26.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-process-devel}"
SRC_URI[aarch64_ghc9.14-process-devel.sha256sum] = "c0655decc902ad2a88c182e5ce680be2351bb8f9cd5c7176099d4606560d6178"

URI_aarch64_ghc9.14-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-process-doc-1.6.26.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-process-doc}"
SRC_URI[aarch64_ghc9.14-process-doc.sha256sum] = "3dbf2aa846b0676f4610cd29722ccba9cca5939fdc9a41888184400278f61f5d"

URI_aarch64_ghc9.14-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-process-prof-1.6.26.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-process-prof}"
SRC_URI[aarch64_ghc9.14-process-prof.sha256sum] = "e8c87b4546f9c3381573a5aa0e5dacabea51de56fc80f41f2d885d2a0834eb72"

URI_aarch64_ghc9.14-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-prof-9.14.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-prof}"
SRC_URI[aarch64_ghc9.14-prof.sha256sum] = "92c157449e0d3ed4ff413e8e5574f99319b00ca8cbf5b3a6d33ac0cf3e957997"

URI_aarch64_ghc9.14-semaphore-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-semaphore-compat-1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-semaphore-compat}"
SRC_URI[aarch64_ghc9.14-semaphore-compat.sha256sum] = "9a04f43815fdeabfb5ac8fd49ea589aac88ba1f2419fdaca418f76682084695a"

URI_aarch64_ghc9.14-semaphore-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-semaphore-compat-devel-1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-semaphore-compat-devel}"
SRC_URI[aarch64_ghc9.14-semaphore-compat-devel.sha256sum] = "8abed9ab79531f0132c136451a345c3684e567da34dd63ec1c9be44f2de9c7f4"

URI_aarch64_ghc9.14-semaphore-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-semaphore-compat-doc-1.0.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-semaphore-compat-doc}"
SRC_URI[aarch64_ghc9.14-semaphore-compat-doc.sha256sum] = "e9af5425f72f5559e376775fedecb7a74b4bd4bd0b43bc68642a7ba2e7ee1d12"

URI_aarch64_ghc9.14-semaphore-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-semaphore-compat-prof-1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-semaphore-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-semaphore-compat-prof}"
SRC_URI[aarch64_ghc9.14-semaphore-compat-prof.sha256sum] = "7f028ff16fada776affe1b2928bd619b1a4865f0d3d259bafd264c370ac9a1e2"

URI_aarch64_ghc9.14-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-stm-2.5.3.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-stm}"
SRC_URI[aarch64_ghc9.14-stm.sha256sum] = "3fd9b8091c2b88dc52ec85e4930df17dcd653c0581fe6591910a7f9ec356c2bd"

URI_aarch64_ghc9.14-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-stm-devel-2.5.3.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-stm-devel}"
SRC_URI[aarch64_ghc9.14-stm-devel.sha256sum] = "1ad90882b7c115a1bdeb4f568822e9cd519ddbe1229ae9ceeb99634097ca2f97"

URI_aarch64_ghc9.14-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-stm-doc-2.5.3.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-stm-doc}"
SRC_URI[aarch64_ghc9.14-stm-doc.sha256sum] = "10ce8ef01b97f7758cd7136e81024d248396d99e48bcd9ac396717ea5c727e2a"

URI_aarch64_ghc9.14-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-stm-prof-2.5.3.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-stm-prof}"
SRC_URI[aarch64_ghc9.14-stm-prof.sha256sum] = "a88726c2ead2f6757a68f4f1b5cd97de7587d435baf768e0f59ab10643deb29f"

URI_aarch64_ghc9.14-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-2.24.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell}"
SRC_URI[aarch64_ghc9.14-template-haskell.sha256sum] = "4f289e75767add0e2784e877caeb555734cff016d460f7fee2ee07735ad3217b"

URI_aarch64_ghc9.14-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-devel-2.24.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-devel}"
SRC_URI[aarch64_ghc9.14-template-haskell-devel.sha256sum] = "de090cf54fe8aa3e63c9a12c2ad652af98701e7f6225d07db6fabba75e901420"

URI_aarch64_ghc9.14-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-doc-2.24.0.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-doc}"
SRC_URI[aarch64_ghc9.14-template-haskell-doc.sha256sum] = "80d544d8cf338ddb4750d3dd0a0b7aedfc72d97853a819ce6746b3d8babdedd9"

URI_aarch64_ghc9.14-template-haskell-lift = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-lift-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-template-haskell-lift;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-lift}"
SRC_URI[aarch64_ghc9.14-template-haskell-lift.sha256sum] = "be26af2ce0f24c44a51eed181d751d5a7e964b4104d604e741bac61ab534d583"

URI_aarch64_ghc9.14-template-haskell-lift-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-lift-devel-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-template-haskell-lift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-lift-devel}"
SRC_URI[aarch64_ghc9.14-template-haskell-lift-devel.sha256sum] = "f86524429dc6069d037cb534d1888e4c49a460925c041780bc02cca1c4219e0f"

URI_aarch64_ghc9.14-template-haskell-lift-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-lift-doc-0.1.0.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-template-haskell-lift-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-lift-doc}"
SRC_URI[aarch64_ghc9.14-template-haskell-lift-doc.sha256sum] = "d7ec889ed0536d670ee47bfd5aea2a20ab0f5b29d88393da8ae6ba04392a784d"

URI_aarch64_ghc9.14-template-haskell-lift-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-lift-prof-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-template-haskell-lift-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-lift-prof}"
SRC_URI[aarch64_ghc9.14-template-haskell-lift-prof.sha256sum] = "b01b6739fc34b1f5324a99b17d1b5eaa831945ea50ec879f5025483961882ab2"

URI_aarch64_ghc9.14-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-prof-2.24.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-prof}"
SRC_URI[aarch64_ghc9.14-template-haskell-prof.sha256sum] = "ef80873089a256689f6ff94b4c6525aa124da1b318e365b0a9f0c11497596ef5"

URI_aarch64_ghc9.14-template-haskell-quasiquoter = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-quasiquoter-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-template-haskell-quasiquoter;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-quasiquoter}"
SRC_URI[aarch64_ghc9.14-template-haskell-quasiquoter.sha256sum] = "cf66919d271e4bd55ed388382a54a0afb71cb8cee3239fe5110afe8d290ad042"

URI_aarch64_ghc9.14-template-haskell-quasiquoter-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-quasiquoter-devel-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-template-haskell-quasiquoter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-quasiquoter-devel}"
SRC_URI[aarch64_ghc9.14-template-haskell-quasiquoter-devel.sha256sum] = "0d06d5c6814316edacb91197b488102ef7066fdf84cd1075e2cef4883d79bdea"

URI_aarch64_ghc9.14-template-haskell-quasiquoter-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-quasiquoter-doc-0.1.0.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-template-haskell-quasiquoter-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-quasiquoter-doc}"
SRC_URI[aarch64_ghc9.14-template-haskell-quasiquoter-doc.sha256sum] = "e9f930203bfdd4d11c5a63a49eec279b927bd94f061f7b0a0f405701db247928"

URI_aarch64_ghc9.14-template-haskell-quasiquoter-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-template-haskell-quasiquoter-prof-0.1.0.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-template-haskell-quasiquoter-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-template-haskell-quasiquoter-prof}"
SRC_URI[aarch64_ghc9.14-template-haskell-quasiquoter-prof.sha256sum] = "1b4a50159ff79e5410516f8c62e5ebed44662f3c6b7015e72b701547c6f2f5ce"

URI_aarch64_ghc9.14-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-terminfo-0.4.1.7-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-terminfo}"
SRC_URI[aarch64_ghc9.14-terminfo.sha256sum] = "9fed2fbc55382310634270aff0b597086c5abca3b55cbb0dd7afe8b1876a98c9"

URI_aarch64_ghc9.14-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-terminfo-devel-0.4.1.7-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-terminfo-devel}"
SRC_URI[aarch64_ghc9.14-terminfo-devel.sha256sum] = "e0760a2479dd8ad76eac0a7b40e1630a180d0861a22236a18d4689c3288d2a7f"

URI_aarch64_ghc9.14-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-terminfo-doc-0.4.1.7-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-terminfo-doc}"
SRC_URI[aarch64_ghc9.14-terminfo-doc.sha256sum] = "c4e8749e342e4eeb75aa09312cec932205f0b88cdd3ba8385f2c25d9ed53c475"

URI_aarch64_ghc9.14-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-terminfo-prof-0.4.1.7-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-terminfo-prof}"
SRC_URI[aarch64_ghc9.14-terminfo-prof.sha256sum] = "5e921d03dfbcdc6d4843f521a12653a9baf47fe3e3795fcd146928ce6ef0c058"

URI_aarch64_ghc9.14-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-text-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-text}"
SRC_URI[aarch64_ghc9.14-text.sha256sum] = "012830340b27fcc5f3e69bfe0e5bb8e955e26274e7b678544db483c31aed88a1"

URI_aarch64_ghc9.14-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-text-devel-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-text-devel}"
SRC_URI[aarch64_ghc9.14-text-devel.sha256sum] = "039b5bb120f96fd2227c2e5f92454e0332222cc972d2b75275fccb1b4b8fe887"

URI_aarch64_ghc9.14-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-text-doc-2.1.3-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-text-doc}"
SRC_URI[aarch64_ghc9.14-text-doc.sha256sum] = "207014c1ff4fdfdae78a385be5f7b0725f8d7733c2753b3959c182cfb794a97b"

URI_aarch64_ghc9.14-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-text-prof-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-text-prof}"
SRC_URI[aarch64_ghc9.14-text-prof.sha256sum] = "70c6d1628677ae70274a74cfebacd9953f9ab782dec2da7bacae7a6ab8d5d87f"

URI_aarch64_ghc9.14-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-time-1.15-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-time}"
SRC_URI[aarch64_ghc9.14-time.sha256sum] = "0b5143ac1b42ea1c501b865d758ceedf6eaa1ab92eb5c638bd629784c8b824be"

URI_aarch64_ghc9.14-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-time-devel-1.15-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-time-devel}"
SRC_URI[aarch64_ghc9.14-time-devel.sha256sum] = "a8620ccf83319b7957710faf8cb13557502773232b67c9ab15545ef1656957fb"

URI_aarch64_ghc9.14-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-time-doc-1.15-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-time-doc}"
SRC_URI[aarch64_ghc9.14-time-doc.sha256sum] = "332d114f9d31971c0e3fd36c9d2ec0be3ff92ea595d63ab77211fd9504e48ffd"

URI_aarch64_ghc9.14-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-time-prof-1.15-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-time-prof}"
SRC_URI[aarch64_ghc9.14-time-prof.sha256sum] = "dc7dec1953425ae75669f8a5d7c7d4cbe3fad0b2f1326609c1eecc23263de9fe"

URI_aarch64_ghc9.14-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-transformers-0.6.1.2-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-transformers}"
SRC_URI[aarch64_ghc9.14-transformers.sha256sum] = "e4f3c7e8d20c53e9cad5a3d2d33a5b790eb0e5a3c36ecd8d6310a9d3e34efa81"

URI_aarch64_ghc9.14-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-transformers-devel-0.6.1.2-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-transformers-devel}"
SRC_URI[aarch64_ghc9.14-transformers-devel.sha256sum] = "e1d49d7f4221fe5574df33bb87e12a803d8bde7b2f0ed2e21ad229f2f08d8efe"

URI_aarch64_ghc9.14-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-transformers-doc-0.6.1.2-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-transformers-doc}"
SRC_URI[aarch64_ghc9.14-transformers-doc.sha256sum] = "1a371572fb07051f07be4b2e7a35fcd3ec91d885a3fe8dee6cb6afbce119b145"

URI_aarch64_ghc9.14-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-transformers-prof-0.6.1.2-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-transformers-prof}"
SRC_URI[aarch64_ghc9.14-transformers-prof.sha256sum] = "18d05c308f1afaad992c3347ba4ec4db56668c27d278897549a01423baae37f4"

URI_aarch64_ghc9.14-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-unix-2.8.8.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-unix}"
SRC_URI[aarch64_ghc9.14-unix.sha256sum] = "76ec6ef06a70c83ed0a2df529264ba9a3d99cae148d53eab85d1d085b48c897e"

URI_aarch64_ghc9.14-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-unix-devel-2.8.8.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-unix-devel}"
SRC_URI[aarch64_ghc9.14-unix-devel.sha256sum] = "15f692e2f74c10e647085cbe3611610872119a211514190b7139d50b99473152"

URI_aarch64_ghc9.14-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-unix-doc-2.8.8.0-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-unix-doc}"
SRC_URI[aarch64_ghc9.14-unix-doc.sha256sum] = "ca181c65fc43770b822c7555f8f3f4a31d9e7c9170881ef135fd9d274788f71e"

URI_aarch64_ghc9.14-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-unix-prof-2.8.8.0-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-unix-prof}"
SRC_URI[aarch64_ghc9.14-unix-prof.sha256sum] = "0ade9e6560924c78d739f3253b2a59562b6698eb8b07aa60275818918021c756"

URI_aarch64_ghc9.14-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-xhtml-3000.2.2.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-xhtml}"
SRC_URI[aarch64_ghc9.14-xhtml.sha256sum] = "5f8ae1f2e9b4309356ad78d806f1f14a5fba6fda5dc0e21c02b1ee1e723a2d37"

URI_aarch64_ghc9.14-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-xhtml-devel-3000.2.2.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-xhtml-devel}"
SRC_URI[aarch64_ghc9.14-xhtml-devel.sha256sum] = "4605e17e9572170b3a0da001d1c55340d89980fa14c63f5334edd50789be0966"

URI_aarch64_ghc9.14-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-xhtml-doc-3000.2.2.1-1.el10_2.noarch.rpm;name=aarch64_ghc9.14-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-xhtml-doc}"
SRC_URI[aarch64_ghc9.14-xhtml-doc.sha256sum] = "8c33f8b0e77ab55a5f55a6aade90226182438c5268a48a8e11c2a4a49567ca57"

URI_aarch64_ghc9.14-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.14-xhtml-prof-3000.2.2.1-1.el10_2.aarch64.rpm;name=aarch64_ghc9.14-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.14-xhtml-prof}"
SRC_URI[aarch64_ghc9.14-xhtml-prof.sha256sum] = "c334f0f3de49ebcc9befa72070aa0f314e6696b2c75706e07b7377ec3bf978b5"

RDEPENDS:ghc9.14 = " \
 ghc9.14-compiler \
 ghc9.14-devel \
 ghc9.14-ghc-boot-devel \
 ghc9.14-ghc-compact-devel \
 ghc9.14-ghc-devel \
 ghc9.14-ghc-heap-devel \
 ghc9.14-ghci-devel \
 ghc9.14-hpc-devel \
 "
RDEPENDS:ghc9.14-Cabal = " \
 ghc9.14-Cabal-syntax \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-parsec \
 ghc9.14-pretty \
 ghc9.14-process \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-text \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-Cabal-devel = " \
 ghc9.14-Cabal \
 ghc9.14-Cabal-syntax-devel \
 ghc9.14-array-devel \
 ghc9.14-base-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-deepseq-devel \
 ghc9.14-directory-devel \
 ghc9.14-filepath-devel \
 ghc9.14-mtl-devel \
 ghc9.14-parsec-devel \
 ghc9.14-pretty-devel \
 ghc9.14-process-devel \
 ghc9.14-time-devel \
 ghc9.14-transformers-devel \
 ghc9.14-unix-devel \
 "
RDEPENDS:ghc9.14-Cabal-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-Cabal-syntax = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-parsec \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-text \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-Cabal-syntax-devel = " \
 ghc9.14-Cabal-syntax \
 ghc9.14-array-devel \
 ghc9.14-base-devel \
 ghc9.14-binary-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-deepseq-devel \
 ghc9.14-directory-devel \
 ghc9.14-filepath-devel \
 ghc9.14-mtl-devel \
 ghc9.14-parsec-devel \
 ghc9.14-pretty-devel \
 ghc9.14-text-devel \
 ghc9.14-time-devel \
 ghc9.14-transformers-devel \
 "
RDEPENDS:ghc9.14-Cabal-syntax-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-array = " \
 ghc9.14-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-array-devel = " \
 ghc9.14-array \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 "
RDEPENDS:ghc9.14-array-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-base = " \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.14-base-devel = " \
 ghc9.14-base \
 ghc9.14-compiler \
 gmp-devel \
 libffi-devel \
 numactl-devel \
 "
RDEPENDS:ghc9.14-base-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-binary = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-pretty \
 ghc9.14-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-binary-devel = " \
 ghc9.14-array-devel \
 ghc9.14-base-devel \
 ghc9.14-binary \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 "
RDEPENDS:ghc9.14-binary-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-bytestring = " \
 ghc9.14-base \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-pretty \
 ghc9.14-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-bytestring-devel = " \
 ghc9.14-base-devel \
 ghc9.14-bytestring \
 ghc9.14-compiler \
 ghc9.14-deepseq-devel \
 ghc9.14-template-haskell-devel \
 "
RDEPENDS:ghc9.14-bytestring-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-compiler = " \
 bash \
 binutils \
 gcc \
 ghc9.14-Cabal \
 ghc9.14-Cabal-syntax \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-base-devel \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-filesystem \
 ghc9.14-ghc \
 ghc9.14-ghc-boot \
 ghc9.14-ghc-boot-th \
 ghc9.14-ghc-heap \
 ghc9.14-ghc-platform \
 ghc9.14-ghc-toolchain \
 ghc9.14-ghci \
 ghc9.14-haddock-api \
 ghc9.14-haddock-library \
 ghc9.14-haskeline \
 ghc9.14-hpc \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-parsec \
 ghc9.14-pretty \
 ghc9.14-process \
 ghc9.14-semaphore-compat \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-terminfo \
 ghc9.14-text \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 ghc9.14-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 numactl-libs \
 "
RDEPENDS:ghc9.14-compiler-default = " \
 bash \
 ghc9.14-compiler \
 "
RDEPENDS:ghc9.14-containers = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-pretty \
 ghc9.14-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-containers-devel = " \
 ghc9.14-array-devel \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-containers \
 ghc9.14-deepseq-devel \
 ghc9.14-template-haskell-devel \
 "
RDEPENDS:ghc9.14-containers-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-deepseq = " \
 ghc9.14-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-deepseq-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-deepseq \
 "
RDEPENDS:ghc9.14-deepseq-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-devel = " \
 ghc9.14-Cabal-devel \
 ghc9.14-Cabal-syntax-devel \
 ghc9.14-array-devel \
 ghc9.14-base-devel \
 ghc9.14-binary-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-deepseq-devel \
 ghc9.14-directory-devel \
 ghc9.14-exceptions-devel \
 ghc9.14-file-io-devel \
 ghc9.14-filepath-devel \
 ghc9.14-ghc-boot-th-devel \
 ghc9.14-haddock-api-devel \
 ghc9.14-haddock-library-devel \
 ghc9.14-haskeline-devel \
 ghc9.14-mtl-devel \
 ghc9.14-os-string-devel \
 ghc9.14-parsec-devel \
 ghc9.14-pretty-devel \
 ghc9.14-process-devel \
 ghc9.14-semaphore-compat-devel \
 ghc9.14-stm-devel \
 ghc9.14-template-haskell-devel \
 ghc9.14-template-haskell-lift-devel \
 ghc9.14-template-haskell-quasiquoter-devel \
 ghc9.14-terminfo-devel \
 ghc9.14-text-devel \
 ghc9.14-time-devel \
 ghc9.14-transformers-devel \
 ghc9.14-unix-devel \
 ghc9.14-xhtml-devel \
 "
RDEPENDS:ghc9.14-directory = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-deepseq \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-directory-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-directory \
 ghc9.14-file-io-devel \
 ghc9.14-filepath-devel \
 ghc9.14-os-string-devel \
 ghc9.14-time-devel \
 ghc9.14-unix-devel \
 "
RDEPENDS:ghc9.14-directory-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-doc = " \
 "
RDEPENDS:ghc9.14-doc-index = " \
 ghc9.14-compiler \
 "
RDEPENDS:ghc9.14-exceptions = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-exceptions-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-exceptions \
 ghc9.14-mtl-devel \
 ghc9.14-stm-devel \
 ghc9.14-template-haskell-devel \
 ghc9.14-transformers-devel \
 "
RDEPENDS:ghc9.14-exceptions-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-file-io = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-deepseq \
 ghc9.14-exceptions \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-file-io-devel = " \
 ghc9.14-base-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-deepseq-devel \
 ghc9.14-file-io \
 ghc9.14-filepath-devel \
 ghc9.14-os-string-devel \
 ghc9.14-unix-devel \
 "
RDEPENDS:ghc9.14-file-io-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-filepath = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-deepseq \
 ghc9.14-exceptions \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-filepath-devel = " \
 ghc9.14-base-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-deepseq-devel \
 ghc9.14-exceptions-devel \
 ghc9.14-filepath \
 ghc9.14-os-string-devel \
 ghc9.14-template-haskell-devel \
 "
RDEPENDS:ghc9.14-filepath-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-filesystem = " \
 "
RDEPENDS:ghc9.14-ghc = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc-boot \
 ghc9.14-ghc-boot-th \
 ghc9.14-ghc-heap \
 ghc9.14-ghc-platform \
 ghc9.14-ghci \
 ghc9.14-hpc \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-process \
 ghc9.14-semaphore-compat \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-bignum = " \
 ghc9.14-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-bignum-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-ghc-bignum \
 "
RDEPENDS:ghc9.14-ghc-bignum-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-ghc-boot = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-ghc-platform \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-boot-devel = " \
 ghc9.14-base-devel \
 ghc9.14-binary-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-deepseq-devel \
 ghc9.14-directory-devel \
 ghc9.14-filepath-devel \
 ghc9.14-ghc-boot \
 ghc9.14-ghc-boot-th-devel \
 ghc9.14-ghc-platform-devel \
 ghc9.14-unix-devel \
 "
RDEPENDS:ghc9.14-ghc-boot-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-ghc-boot-th = " \
 ghc9.14-base \
 ghc9.14-deepseq \
 ghc9.14-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-boot-th-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-ghc-boot-th \
 ghc9.14-pretty-devel \
 "
RDEPENDS:ghc9.14-ghc-boot-th-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-ghc-compact = " \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-pretty \
 ghc9.14-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-compact-devel = " \
 ghc9.14-base-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-ghc-compact \
 "
RDEPENDS:ghc9.14-ghc-compact-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-ghc-devel = " \
 ghc9.14-array-devel \
 ghc9.14-base-devel \
 ghc9.14-binary-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-deepseq-devel \
 ghc9.14-directory-devel \
 ghc9.14-exceptions-devel \
 ghc9.14-filepath-devel \
 ghc9.14-ghc \
 ghc9.14-ghc-boot-devel \
 ghc9.14-ghc-boot-th-devel \
 ghc9.14-ghc-heap-devel \
 ghc9.14-ghci-devel \
 ghc9.14-hpc-devel \
 ghc9.14-os-string-devel \
 ghc9.14-process-devel \
 ghc9.14-semaphore-compat-devel \
 ghc9.14-stm-devel \
 ghc9.14-time-devel \
 ghc9.14-transformers-devel \
 ghc9.14-unix-devel \
 "
RDEPENDS:ghc9.14-ghc-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-ghc-experimental = " \
 ghc9.14-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-experimental-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-ghc-experimental \
 "
RDEPENDS:ghc9.14-ghc-experimental-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-ghc-heap = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-pretty \
 ghc9.14-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-heap-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-ghc-heap \
 "
RDEPENDS:ghc9.14-ghc-heap-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-ghc-platform = " \
 ghc9.14-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-platform-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-ghc-platform \
 "
RDEPENDS:ghc9.14-ghc-platform-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-ghc-toolchain = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-ghc-platform \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-process \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-text \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-toolchain-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-directory-devel \
 ghc9.14-filepath-devel \
 ghc9.14-ghc-platform-devel \
 ghc9.14-ghc-toolchain \
 ghc9.14-process-devel \
 ghc9.14-text-devel \
 ghc9.14-transformers-devel \
 "
RDEPENDS:ghc9.14-ghc-toolchain-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-ghci = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc-boot \
 ghc9.14-ghc-boot-th \
 ghc9.14-ghc-heap \
 ghc9.14-ghc-platform \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghci-devel = " \
 ghc9.14-array-devel \
 ghc9.14-base-devel \
 ghc9.14-binary-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-deepseq-devel \
 ghc9.14-filepath-devel \
 ghc9.14-ghc-boot-devel \
 ghc9.14-ghc-boot-th-devel \
 ghc9.14-ghc-heap-devel \
 ghc9.14-ghci \
 ghc9.14-transformers-devel \
 ghc9.14-unix-devel \
 "
RDEPENDS:ghc9.14-ghci-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-haddock-api = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc \
 ghc9.14-ghc-boot \
 ghc9.14-ghc-boot-th \
 ghc9.14-ghc-heap \
 ghc9.14-ghc-platform \
 ghc9.14-ghci \
 ghc9.14-haddock-library \
 ghc9.14-hpc \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-parsec \
 ghc9.14-pretty \
 ghc9.14-process \
 ghc9.14-semaphore-compat \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-text \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 ghc9.14-xhtml \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-haddock-api-devel = " \
 ghc9.14-array-devel \
 ghc9.14-base-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-deepseq-devel \
 ghc9.14-directory-devel \
 ghc9.14-exceptions-devel \
 ghc9.14-filepath-devel \
 ghc9.14-ghc-boot-devel \
 ghc9.14-ghc-devel \
 ghc9.14-haddock-api \
 ghc9.14-haddock-library-devel \
 ghc9.14-mtl-devel \
 ghc9.14-parsec-devel \
 ghc9.14-transformers-devel \
 ghc9.14-unix-devel \
 ghc9.14-xhtml-devel \
 "
RDEPENDS:ghc9.14-haddock-api-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-haddock-library = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-parsec \
 ghc9.14-pretty \
 ghc9.14-template-haskell \
 ghc9.14-text \
 ghc9.14-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-haddock-library-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-haddock-library \
 ghc9.14-parsec-devel \
 ghc9.14-text-devel \
 "
RDEPENDS:ghc9.14-haddock-library-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.14-haskeline = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-process \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-terminfo \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.14-haskeline-devel = " \
 ghc9.14-base-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-directory-devel \
 ghc9.14-exceptions-devel \
 ghc9.14-filepath-devel \
 ghc9.14-haskeline \
 ghc9.14-process-devel \
 ghc9.14-stm-devel \
 ghc9.14-terminfo-devel \
 ghc9.14-transformers-devel \
 ghc9.14-unix-devel \
 "
RDEPENDS:ghc9.14-haskeline-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-hpc = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-hpc-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-containers-devel \
 ghc9.14-deepseq-devel \
 ghc9.14-directory-devel \
 ghc9.14-filepath-devel \
 ghc9.14-hpc \
 ghc9.14-time-devel \
 "
RDEPENDS:ghc9.14-hpc-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-manual = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-mtl = " \
 ghc9.14-base \
 ghc9.14-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-mtl-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-mtl \
 ghc9.14-transformers-devel \
 "
RDEPENDS:ghc9.14-mtl-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-os-string = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-deepseq \
 ghc9.14-exceptions \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-os-string-devel = " \
 ghc9.14-base-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-deepseq-devel \
 ghc9.14-exceptions-devel \
 ghc9.14-os-string \
 ghc9.14-template-haskell-devel \
 "
RDEPENDS:ghc9.14-os-string-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-parsec = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-pretty \
 ghc9.14-template-haskell \
 ghc9.14-text \
 ghc9.14-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-parsec-devel = " \
 ghc9.14-base-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-mtl-devel \
 ghc9.14-parsec \
 ghc9.14-text-devel \
 "
RDEPENDS:ghc9.14-parsec-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-pretty = " \
 ghc9.14-base \
 ghc9.14-deepseq \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-pretty-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-deepseq-devel \
 ghc9.14-pretty \
 "
RDEPENDS:ghc9.14-pretty-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-process = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-deepseq \
 ghc9.14-directory \
 ghc9.14-exceptions \
 ghc9.14-file-io \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-process-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-deepseq-devel \
 ghc9.14-directory-devel \
 ghc9.14-filepath-devel \
 ghc9.14-os-string-devel \
 ghc9.14-process \
 ghc9.14-unix-devel \
 "
RDEPENDS:ghc9.14-process-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-semaphore-compat = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-deepseq \
 ghc9.14-exceptions \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-time \
 ghc9.14-transformers \
 ghc9.14-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-semaphore-compat-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-exceptions-devel \
 ghc9.14-semaphore-compat \
 ghc9.14-unix-devel \
 "
RDEPENDS:ghc9.14-semaphore-compat-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-stm = " \
 ghc9.14-array \
 ghc9.14-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-stm-devel = " \
 ghc9.14-array-devel \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-stm \
 "
RDEPENDS:ghc9.14-stm-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-template-haskell = " \
 ghc9.14-base \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-template-haskell-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-ghc-boot-th-devel \
 ghc9.14-template-haskell \
 "
RDEPENDS:ghc9.14-template-haskell-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-template-haskell-lift = " \
 ghc9.14-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-template-haskell-lift-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-template-haskell-lift \
 "
RDEPENDS:ghc9.14-template-haskell-lift-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-template-haskell-quasiquoter = " \
 ghc9.14-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-template-haskell-quasiquoter-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-template-haskell-quasiquoter \
 "
RDEPENDS:ghc9.14-template-haskell-quasiquoter-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-terminfo = " \
 ghc9.14-base \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.14-terminfo-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.14-terminfo-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-text = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-binary \
 ghc9.14-bytestring \
 ghc9.14-containers \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-pretty \
 ghc9.14-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-text-devel = " \
 ghc9.14-array-devel \
 ghc9.14-base-devel \
 ghc9.14-binary-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-deepseq-devel \
 ghc9.14-template-haskell-devel \
 ghc9.14-text \
 "
RDEPENDS:ghc9.14-text-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-time = " \
 ghc9.14-base \
 ghc9.14-deepseq \
 ghc9.14-ghc-boot-th \
 ghc9.14-pretty \
 ghc9.14-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-time-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-deepseq-devel \
 ghc9.14-template-haskell-devel \
 ghc9.14-time \
 "
RDEPENDS:ghc9.14-time-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-transformers = " \
 ghc9.14-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-transformers-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-transformers \
 "
RDEPENDS:ghc9.14-transformers-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-unix = " \
 ghc9.14-array \
 ghc9.14-base \
 ghc9.14-bytestring \
 ghc9.14-deepseq \
 ghc9.14-exceptions \
 ghc9.14-filepath \
 ghc9.14-ghc-boot-th \
 ghc9.14-mtl \
 ghc9.14-os-string \
 ghc9.14-pretty \
 ghc9.14-stm \
 ghc9.14-template-haskell \
 ghc9.14-time \
 ghc9.14-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-unix-devel = " \
 ghc9.14-base-devel \
 ghc9.14-bytestring-devel \
 ghc9.14-compiler \
 ghc9.14-filepath-devel \
 ghc9.14-os-string-devel \
 ghc9.14-time-devel \
 ghc9.14-unix \
 "
RDEPENDS:ghc9.14-unix-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-xhtml = " \
 ghc9.14-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-xhtml-devel = " \
 ghc9.14-base-devel \
 ghc9.14-compiler \
 ghc9.14-xhtml \
 "
RDEPENDS:ghc9.14-xhtml-doc = " \
 ghc9.14-filesystem \
 "
RDEPENDS:ghc9.14-Cabal-prof = " \
 ghc9.14-Cabal-devel \
 ghc9.14-Cabal-syntax-prof \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-parsec-prof \
 ghc9.14-pretty-prof \
 ghc9.14-process-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-text-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-Cabal-syntax-prof = " \
 ghc9.14-Cabal-syntax-devel \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-parsec-prof \
 ghc9.14-pretty-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-text-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-array-prof = " \
 ghc9.14-array-devel \
 ghc9.14-base-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-base-prof = " \
 ghc9.14-base-devel \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.14-binary-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-devel \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-pretty-prof \
 ghc9.14-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-bytestring-prof = " \
 ghc9.14-base-prof \
 ghc9.14-bytestring-devel \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-pretty-prof \
 ghc9.14-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-containers-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-containers-devel \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-pretty-prof \
 ghc9.14-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-deepseq-prof = " \
 ghc9.14-base-prof \
 ghc9.14-deepseq-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-directory-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-devel \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-exceptions-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-exceptions-devel \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-pretty-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-file-io-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-devel \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-filepath-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-filepath-devel \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-bignum-prof = " \
 ghc9.14-base-prof \
 ghc9.14-ghc-bignum-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-boot-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-devel \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-ghc-platform-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-boot-th-prof = " \
 ghc9.14-base-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-devel \
 ghc9.14-pretty-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-compact-prof = " \
 ghc9.14-base-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-ghc-compact-devel \
 ghc9.14-pretty-prof \
 ghc9.14-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-experimental-prof = " \
 ghc9.14-base-prof \
 ghc9.14-ghc-experimental-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-heap-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-ghc-heap-devel \
 ghc9.14-pretty-prof \
 ghc9.14-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-platform-prof = " \
 ghc9.14-base-prof \
 ghc9.14-ghc-platform-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-ghc-devel \
 ghc9.14-ghc-heap-prof \
 ghc9.14-ghc-platform-prof \
 ghc9.14-ghci-prof \
 ghc9.14-hpc-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-process-prof \
 ghc9.14-semaphore-compat-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghc-toolchain-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-ghc-platform-prof \
 ghc9.14-ghc-toolchain-devel \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-process-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-text-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-ghci-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-ghc-heap-prof \
 ghc9.14-ghc-platform-prof \
 ghc9.14-ghci-devel \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-haddock-api-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-ghc-heap-prof \
 ghc9.14-ghc-platform-prof \
 ghc9.14-ghc-prof \
 ghc9.14-ghci-prof \
 ghc9.14-haddock-api-devel \
 ghc9.14-haddock-library-prof \
 ghc9.14-hpc-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-parsec-prof \
 ghc9.14-pretty-prof \
 ghc9.14-process-prof \
 ghc9.14-semaphore-compat-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-text-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 ghc9.14-xhtml-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-haddock-library-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-haddock-library-devel \
 ghc9.14-mtl-prof \
 ghc9.14-parsec-prof \
 ghc9.14-pretty-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-text-prof \
 ghc9.14-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-haskeline-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-haskeline-devel \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-process-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-terminfo-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.14-hpc-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-hpc-devel \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-mtl-prof = " \
 ghc9.14-base-prof \
 ghc9.14-mtl-devel \
 ghc9.14-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-os-string-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-devel \
 ghc9.14-pretty-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-parsec-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-parsec-devel \
 ghc9.14-pretty-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-text-prof \
 ghc9.14-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-pretty-prof = " \
 ghc9.14-base-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-pretty-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-process-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-directory-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-file-io-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-process-devel \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-prof = " \
 ghc9.14-compiler \
 "
RDEPENDS:ghc9.14-semaphore-compat-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-semaphore-compat-devel \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-stm-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-stm-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-template-haskell-lift-prof = " \
 ghc9.14-base-prof \
 ghc9.14-template-haskell-lift-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-template-haskell-prof = " \
 ghc9.14-base-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-pretty-prof \
 ghc9.14-template-haskell-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-template-haskell-quasiquoter-prof = " \
 ghc9.14-base-prof \
 ghc9.14-template-haskell-quasiquoter-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-terminfo-prof = " \
 ghc9.14-base-prof \
 ghc9.14-terminfo-devel \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.14-text-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-binary-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-containers-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-pretty-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-text-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-time-prof = " \
 ghc9.14-base-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-pretty-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-time-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-transformers-prof = " \
 ghc9.14-base-prof \
 ghc9.14-transformers-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-unix-prof = " \
 ghc9.14-array-prof \
 ghc9.14-base-prof \
 ghc9.14-bytestring-prof \
 ghc9.14-deepseq-prof \
 ghc9.14-exceptions-prof \
 ghc9.14-filepath-prof \
 ghc9.14-ghc-boot-th-prof \
 ghc9.14-mtl-prof \
 ghc9.14-os-string-prof \
 ghc9.14-pretty-prof \
 ghc9.14-stm-prof \
 ghc9.14-template-haskell-prof \
 ghc9.14-time-prof \
 ghc9.14-transformers-prof \
 ghc9.14-unix-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.14-xhtml-prof = " \
 ghc9.14-base-prof \
 ghc9.14-xhtml-devel \
 glibc \
 gmp \
 "
