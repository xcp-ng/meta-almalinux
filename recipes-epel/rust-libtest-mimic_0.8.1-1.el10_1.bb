# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libtest-mimic"
PV = "0.8.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-libtest-mimic+default-devel \
 rust-libtest-mimic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libtest-mimic-0.8.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38fa95c7947f58a2b7a27cf43eb9aeab683f0ec60c0730998028178c02e816a7"

URI_x86_64_v2_rust-libtest-mimic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libtest-mimic+default-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libtest-mimic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libtest-mimic+default-devel}"
SRC_URI[x86_64_v2_rust-libtest-mimic+default-devel.sha256sum] = "438549870bfa2197522390566d76c39747bc34e27967e12defbde611081151c7"

URI_x86_64_v2_rust-libtest-mimic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libtest-mimic-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libtest-mimic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libtest-mimic-devel}"
SRC_URI[x86_64_v2_rust-libtest-mimic-devel.sha256sum] = "791b7e293bdcdf145b11571f51b13903c8e9c7f9ff4b66b1780196615f243f07"

URI_aarch64_rust-libtest-mimic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libtest-mimic+default-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-libtest-mimic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libtest-mimic+default-devel}"
SRC_URI[aarch64_rust-libtest-mimic+default-devel.sha256sum] = "f2c9a9e5d111ddc519cd1589e324ee8861acad263add39ca794ca83a2796c1ca"

URI_aarch64_rust-libtest-mimic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libtest-mimic-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-libtest-mimic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libtest-mimic-devel}"
SRC_URI[aarch64_rust-libtest-mimic-devel.sha256sum] = "f0f5ad40ca829e34450fe2fe61fbb02033a0f4662d84550373f6090796965e2d"

RDEPENDS:rust-libtest-mimic+default-devel = " \
 cargo \
 rust-libtest-mimic-devel \
 "
RDEPENDS:rust-libtest-mimic-devel = " \
 cargo \
 rust \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-escape8259+default-devel \
 "
