# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust"
PV = "1.92.0"
PR = "1.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-std-static-x86_64-unknown-none \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
"
PACKAGES:aarch64 = " \
 cargo \
 clippy \
 rust \
 rust-analyzer \
 rust-debugger-common \
 rust-doc \
 rust-gdb \
 rust-lldb \
 rust-src \
 rust-std-static \
 rust-std-static-aarch64-unknown-none-softfloat \
 rust-std-static-wasm32-unknown-unknown \
 rust-std-static-wasm32-wasip1 \
 rust-toolset \
 rust-toolset-srpm-macros \
 rustfmt \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-1.92.0-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bce3fcbe9bc20cba8cdbc03d6b948117f8a0331920fbb4e21316144deaaca56f"

URI_x86_64_v2_cargo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cargo-1.92.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_cargo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo}"
SRC_URI[x86_64_v2_cargo.sha256sum] = "7778915c00c23bd5da5b9a546990a7c406e7ef39f2401257d3763509a0a8dcfa"

URI_x86_64_v2_clippy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clippy-1.92.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clippy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clippy}"
SRC_URI[x86_64_v2_clippy.sha256sum] = "80a6ebcbdb532033ec6bd979b140ef389448f16de808986ee1905d119a572757"

URI_x86_64_v2_rust = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-1.92.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust}"
SRC_URI[x86_64_v2_rust.sha256sum] = "1464041d4a980f96c7abd1c00337b0fb73a00d038418f69bd09c4db6dc0ca3f5"

URI_x86_64_v2_rust-analyzer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-analyzer-1.92.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-analyzer}"
SRC_URI[x86_64_v2_rust-analyzer.sha256sum] = "2fd032ab3e8d3ebfb145652bd47ce4ca7b16dc249c9732769bcf3996ea67eadc"

URI_x86_64_v2_rust-debugger-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-debugger-common-1.92.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-debugger-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-debugger-common}"
SRC_URI[x86_64_v2_rust-debugger-common.sha256sum] = "bfb372870b2d07b86cf7cfaad0f41389be2eb96c96fa2acf589ed195e876354c"

URI_x86_64_v2_rust-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-doc-1.92.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc}"
SRC_URI[x86_64_v2_rust-doc.sha256sum] = "7e9cc7561f12c1b0b3718233ff3eda883534b448747a5858597b047837799f9b"

URI_x86_64_v2_rust-gdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-gdb-1.92.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gdb}"
SRC_URI[x86_64_v2_rust-gdb.sha256sum] = "90a1eb133276bf060a6e10c854a96704bb38738424f70959833cfa7ee29f97d8"

URI_x86_64_v2_rust-lldb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-lldb-1.92.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-lldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lldb}"
SRC_URI[x86_64_v2_rust-lldb.sha256sum] = "0c660513742191631e7939de08f7e202b482772513d12e19a4b29b8afd80a9f2"

URI_x86_64_v2_rust-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-src-1.92.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-src}"
SRC_URI[x86_64_v2_rust-src.sha256sum] = "9acdc535ea6e773ae3acdbbb6f74faf4ee4cf8393ed6f79d0f5ce19bad9343f4"

URI_x86_64_v2_rust-std-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-1.92.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static}"
SRC_URI[x86_64_v2_rust-std-static.sha256sum] = "94e8ff758a53894679bb9dcef14b173f3c93c217a2dfd115b23877047ffe8d5e"

URI_x86_64_v2_rust-std-static-wasm32-unknown-unknown = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-unknown-unknown-1.92.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-wasm32-unknown-unknown}"
SRC_URI[x86_64_v2_rust-std-static-wasm32-unknown-unknown.sha256sum] = "8e50961180afb2aa677c8318c85d043ef3154ac9adf87d124004ecb65882a891"

URI_x86_64_v2_rust-std-static-wasm32-wasip1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-std-static-wasm32-wasip1-1.92.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-wasm32-wasip1}"
SRC_URI[x86_64_v2_rust-std-static-wasm32-wasip1.sha256sum] = "2781a2359cd6e30742ccb79100c7fcc34f9050a8db2385c07b623c6d31622648"

URI_x86_64_v2_rust-std-static-x86_64-unknown-none = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rust-std-static-x86_64-unknown-none-1.92.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rust-std-static-x86_64-unknown-none;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-std-static-x86_64-unknown-none}"
SRC_URI[x86_64_v2_rust-std-static-x86_64-unknown-none.sha256sum] = "b5ba131efd8f6b51ee8e4af75f729939796481d51a08ece3eda91ca68b6c7851"

URI_x86_64_v2_rust-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-1.92.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toolset}"
SRC_URI[x86_64_v2_rust-toolset.sha256sum] = "334e8ec348f744f49b129b3ab70a52980bed6118c0ff448344362fa48a624eef"

URI_x86_64_v2_rust-toolset-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rust-toolset-srpm-macros-1.92.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_rust-toolset-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toolset-srpm-macros}"
SRC_URI[x86_64_v2_rust-toolset-srpm-macros.sha256sum] = "5f0b58d3b38dae85393ab2cf9c3c907f7441ecefa43894dec791c32a7a386438"

URI_x86_64_v2_rustfmt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rustfmt-1.92.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rustfmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rustfmt}"
SRC_URI[x86_64_v2_rustfmt.sha256sum] = "307dfadd5f28166121e91982ba07e8d2b6b20b9e5cb7e951bae2d437fcd68ffe"

URI_aarch64_cargo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cargo-1.92.0-1.el10.alma.1.aarch64.rpm;name=aarch64_cargo;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo}"
SRC_URI[aarch64_cargo.sha256sum] = "69bab8134ef7d6666d8c547bb7415aea4a2b6d7a6c06a2c83918ff9c4b2fb3d6"

URI_aarch64_clippy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clippy-1.92.0-1.el10.alma.1.aarch64.rpm;name=aarch64_clippy;unpack=0"
SRC_URI:append = " ${URI_aarch64_clippy}"
SRC_URI[aarch64_clippy.sha256sum] = "240f7c3af39c97cd214d1fda3da8b9a8a907d3996363f392b71821fc21432f9f"

URI_aarch64_rust = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-1.92.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust}"
SRC_URI[aarch64_rust.sha256sum] = "a57de87e02701e64b89e1b051b5eb9172beac7046a4de7365f69e1318c7293b5"

URI_aarch64_rust-analyzer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-analyzer-1.92.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-analyzer}"
SRC_URI[aarch64_rust-analyzer.sha256sum] = "45eb3f62b20a86ef2aa2c6f7aa146ada614d4cc8cccbf7c412a3050a88a5e6cd"

URI_aarch64_rust-debugger-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-debugger-common-1.92.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-debugger-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-debugger-common}"
SRC_URI[aarch64_rust-debugger-common.sha256sum] = "bfb372870b2d07b86cf7cfaad0f41389be2eb96c96fa2acf589ed195e876354c"

URI_aarch64_rust-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-doc-1.92.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc}"
SRC_URI[aarch64_rust-doc.sha256sum] = "40eeb0574bf4241e6c2974e2333fc262d4c8751a287c09866f7f30826846241e"

URI_aarch64_rust-gdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-gdb-1.92.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gdb}"
SRC_URI[aarch64_rust-gdb.sha256sum] = "90a1eb133276bf060a6e10c854a96704bb38738424f70959833cfa7ee29f97d8"

URI_aarch64_rust-lldb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-lldb-1.92.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-lldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lldb}"
SRC_URI[aarch64_rust-lldb.sha256sum] = "0c660513742191631e7939de08f7e202b482772513d12e19a4b29b8afd80a9f2"

URI_aarch64_rust-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-src-1.92.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-src}"
SRC_URI[aarch64_rust-src.sha256sum] = "9acdc535ea6e773ae3acdbbb6f74faf4ee4cf8393ed6f79d0f5ce19bad9343f4"

URI_aarch64_rust-std-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-1.92.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-std-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static}"
SRC_URI[aarch64_rust-std-static.sha256sum] = "a3b48780d218465cbc641f7a2e12190876ef82cb568009c07b2e936678b842ee"

URI_aarch64_rust-std-static-aarch64-unknown-none-softfloat = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rust-std-static-aarch64-unknown-none-softfloat-1.92.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rust-std-static-aarch64-unknown-none-softfloat;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-aarch64-unknown-none-softfloat}"
SRC_URI[aarch64_rust-std-static-aarch64-unknown-none-softfloat.sha256sum] = "736201d3a4e67c6cef1ddf7272553e24bf7651cf059032004619d3ce9bf2d413"

URI_aarch64_rust-std-static-wasm32-unknown-unknown = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-unknown-unknown-1.92.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-unknown-unknown;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-wasm32-unknown-unknown}"
SRC_URI[aarch64_rust-std-static-wasm32-unknown-unknown.sha256sum] = "8e50961180afb2aa677c8318c85d043ef3154ac9adf87d124004ecb65882a891"

URI_aarch64_rust-std-static-wasm32-wasip1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-std-static-wasm32-wasip1-1.92.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-std-static-wasm32-wasip1;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-std-static-wasm32-wasip1}"
SRC_URI[aarch64_rust-std-static-wasm32-wasip1.sha256sum] = "2781a2359cd6e30742ccb79100c7fcc34f9050a8db2385c07b623c6d31622648"

URI_aarch64_rust-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-1.92.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toolset}"
SRC_URI[aarch64_rust-toolset.sha256sum] = "334e8ec348f744f49b129b3ab70a52980bed6118c0ff448344362fa48a624eef"

URI_aarch64_rust-toolset-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rust-toolset-srpm-macros-1.92.0-1.el10.alma.1.noarch.rpm;name=aarch64_rust-toolset-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toolset-srpm-macros}"
SRC_URI[aarch64_rust-toolset-srpm-macros.sha256sum] = "5f0b58d3b38dae85393ab2cf9c3c907f7441ecefa43894dec791c32a7a386438"

URI_aarch64_rustfmt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rustfmt-1.92.0-1.el10.alma.1.aarch64.rpm;name=aarch64_rustfmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_rustfmt}"
SRC_URI[aarch64_rustfmt.sha256sum] = "6d85fad33aedc6d30c0e214e83861394d83c73d444db3f504cbbeda716b7f2cb"

RDEPENDS:cargo = " \
 glibc \
 libgcc \
 openssl-libs \
 rust \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clippy = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust = " \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 rust-std-static \
 "
RDEPENDS:rust-analyzer = " \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-debugger-common = " \
 "
RDEPENDS:rust-doc = " \
 "
RDEPENDS:rust-gdb = " \
 bash \
 gdb \
 rust \
 rust-debugger-common \
 "
RDEPENDS:rust-lldb = " \
 bash \
 lldb \
 python3-lldb \
 rust \
 rust-debugger-common \
 "
RDEPENDS:rust-src = " \
 "
RDEPENDS:rust-std-static = " \
 glibc \
 glibc-devel \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-unknown-unknown = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-wasm32-wasip1 = " \
 lld \
 rust \
 "
RDEPENDS:rust-std-static-x86_64-unknown-none = " \
 lld \
 rust \
 "
RDEPENDS:rust-toolset = " \
 cargo \
 python3 \
 rust \
 rust-toolset-srpm-macros \
 "
RDEPENDS:rust-toolset-srpm-macros = " \
 "
RDEPENDS:rustfmt = " \
 cargo \
 glibc \
 libgcc \
 rust \
 "
RDEPENDS:rust-std-static-aarch64-unknown-none-softfloat = " \
 lld \
 rust \
 "
