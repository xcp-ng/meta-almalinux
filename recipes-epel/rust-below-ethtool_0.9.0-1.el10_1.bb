# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-ethtool"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-below-ethtool+default-devel \
 rust-below-ethtool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-ethtool-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac892a2b2e07d77ed6c11b6f4d7d1f9ff740a4df0a5f6f6846f1434b34c1d248"

URI_x86_64_v2_rust-below-ethtool+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-ethtool+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-ethtool+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-ethtool+default-devel}"
SRC_URI[x86_64_v2_rust-below-ethtool+default-devel.sha256sum] = "5599866ad9f0256250deee34baf777528ec53773ee17c1a11ee940d862d06bf6"

URI_x86_64_v2_rust-below-ethtool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-ethtool-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-ethtool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-ethtool-devel}"
SRC_URI[x86_64_v2_rust-below-ethtool-devel.sha256sum] = "b2fbfe131339fa6de194b650223fd74fda08c412b399752df737da272b215001"

URI_aarch64_rust-below-ethtool+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-ethtool+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-ethtool+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-ethtool+default-devel}"
SRC_URI[aarch64_rust-below-ethtool+default-devel.sha256sum] = "cb371f3d3b93092cfe45f5380456989409edeb4478a2661e9d8348c501c2a112"

URI_aarch64_rust-below-ethtool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-ethtool-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-ethtool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-ethtool-devel}"
SRC_URI[aarch64_rust-below-ethtool-devel.sha256sum] = "3209ad5b02782db38ee6b539423fe03e733b49ed1855d26ee81f62db82f24ab9"

RDEPENDS:rust-below-ethtool+default-devel = " \
 cargo \
 rust-below-ethtool-devel \
 "
RDEPENDS:rust-below-ethtool-devel = " \
 cargo \
 rust-nix0.29+default-devel \
 rust-nix0.29+dir-devel \
 rust-nix0.29+event-devel \
 rust-nix0.29+hostname-devel \
 rust-nix0.29+inotify-devel \
 rust-nix0.29+ioctl-devel \
 rust-nix0.29+mman-devel \
 rust-nix0.29+mount-devel \
 rust-nix0.29+net-devel \
 rust-nix0.29+poll-devel \
 rust-nix0.29+ptrace-devel \
 rust-nix0.29+reboot-devel \
 rust-nix0.29+resource-devel \
 rust-nix0.29+sched-devel \
 rust-nix0.29+signal-devel \
 rust-nix0.29+term-devel \
 rust-nix0.29+time-devel \
 rust-nix0.29+user-devel \
 rust-nix0.29+zerocopy-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-thiserror+default-devel \
 "
