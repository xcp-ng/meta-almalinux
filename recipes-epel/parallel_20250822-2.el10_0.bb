# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parallel"
PV = "20250822"
PR = "2.el10_0"
PACKAGES = " \
 parallel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/parallel-20250822-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0100f195432a53ac37f41b30f3945bf73aaa8b6b8f47e8085342229db8dbd049"

URI_x86_64_v2_parallel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parallel-20250822-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_parallel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parallel}"
SRC_URI[x86_64_v2_parallel.sha256sum] = "a062d92758f3db7bcaf722344ac9a44a77c2e7d186dac63a4f71d568e8450272"

URI_aarch64_parallel = "${EPEL_MIRROR}/aarch64/Packages/p/parallel-20250822-2.el10_0.noarch.rpm;name=aarch64_parallel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parallel}"
SRC_URI[aarch64_parallel.sha256sum] = "007413669e261469b39b7c73371729d7e2bd98975c405646e63e81cf716d83a7"

RDEPENDS:parallel = " \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Symbol \
 perl-Thread-Queue \
 perl-interpreter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
