# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-resource-pool"
PV = "0.4.0.0"
PR = "4.el10_0"
PACKAGES = " \
 ghc-resource-pool \
 ghc-resource-pool-devel \
 ghc-resource-pool-doc \
 ghc-resource-pool-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-resource-pool-0.4.0.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e86256471681e026e2536a5c9353821639b19cd35e57d944baefc0327955d407"

URI_x86_64_v2_ghc-resource-pool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-resource-pool-0.4.0.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-resource-pool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-resource-pool}"
SRC_URI[x86_64_v2_ghc-resource-pool.sha256sum] = "9d4e5ed71513127e0e77afb4b9b04db65710eb1b353dbe323bcfa768740d8a09"

URI_x86_64_v2_ghc-resource-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-resource-pool-devel-0.4.0.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-resource-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-resource-pool-devel}"
SRC_URI[x86_64_v2_ghc-resource-pool-devel.sha256sum] = "b62eb7f3fab21865da87f6aba561b713dfee7deb1b2f37fdae1e47526e692e3f"

URI_x86_64_v2_ghc-resource-pool-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-resource-pool-doc-0.4.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-resource-pool-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-resource-pool-doc}"
SRC_URI[x86_64_v2_ghc-resource-pool-doc.sha256sum] = "f9e19ba15a48f654e54d561a02a92bf3d7a830c81d5bc0af5ae5e93e6c05f5c4"

URI_x86_64_v2_ghc-resource-pool-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-resource-pool-prof-0.4.0.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-resource-pool-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-resource-pool-prof}"
SRC_URI[x86_64_v2_ghc-resource-pool-prof.sha256sum] = "cd4a6b285358ff14f0eeec43c06dfd16412edfea1f99c98bf120cefcc354542f"

URI_aarch64_ghc-resource-pool = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-resource-pool-0.4.0.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-resource-pool;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-resource-pool}"
SRC_URI[aarch64_ghc-resource-pool.sha256sum] = "77d7cd49176ae28417e176136cd67462d3359d37ddfbaeab17b4c9ef162ae4ba"

URI_aarch64_ghc-resource-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-resource-pool-devel-0.4.0.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-resource-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-resource-pool-devel}"
SRC_URI[aarch64_ghc-resource-pool-devel.sha256sum] = "fc543c6e3dce05151db9cc0cebc592150a65724c327f3e965016ac22ad1ec863"

URI_aarch64_ghc-resource-pool-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-resource-pool-doc-0.4.0.0-4.el10_0.noarch.rpm;name=aarch64_ghc-resource-pool-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-resource-pool-doc}"
SRC_URI[aarch64_ghc-resource-pool-doc.sha256sum] = "c882a7a39e38f762ca64803d8fa8b8816d985a5da2da805136c916934544d1f1"

URI_aarch64_ghc-resource-pool-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-resource-pool-prof-0.4.0.0-4.el10_0.aarch64.rpm;name=aarch64_ghc-resource-pool-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-resource-pool-prof}"
SRC_URI[aarch64_ghc-resource-pool-prof.sha256sum] = "2f5b217719fa5f578edd8071441b9bde13647516310be06439582d378cdbb3e3"

RDEPENDS:ghc-resource-pool = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-resource-pool-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-hashable-devel \
 ghc-primitive-devel \
 ghc-resource-pool \
 ghc-time-devel \
 "
RDEPENDS:ghc-resource-pool-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-resource-pool-prof = " \
 ghc-base-prof \
 ghc-hashable-prof \
 ghc-primitive-prof \
 ghc-resource-pool-devel \
 ghc-time-prof \
 "
