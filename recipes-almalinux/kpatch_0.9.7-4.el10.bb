# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpatch"
PV = "0.9.7"
PR = "4.el10"
PACKAGES = " \
 kpatch \
 kpatch-dnf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kpatch-0.9.7-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03b02ccbfd27aa1fe4f6296606d367d9ebd5aa25f3db62c39a5897307fcef685"

URI_x86_64_v2_kpatch = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpatch-0.9.7-4.el10.noarch.rpm;name=x86_64_v2_kpatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpatch}"
SRC_URI[x86_64_v2_kpatch.sha256sum] = "72db9a615b79bd2ce462c1ed95c20b22eec16d4cc36a45560f107c5f4ae0f2cf"

URI_x86_64_v2_kpatch-dnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpatch-dnf-0.9.7_0.4-4.el10.noarch.rpm;name=x86_64_v2_kpatch-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpatch-dnf}"
SRC_URI[x86_64_v2_kpatch-dnf.sha256sum] = "03baa05e7958845e01505c4c70d02bdec388d8d1637c7523a1bdba8b737b6469"

URI_aarch64_kpatch = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpatch-0.9.7-4.el10.noarch.rpm;name=aarch64_kpatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpatch}"
SRC_URI[aarch64_kpatch.sha256sum] = "72db9a615b79bd2ce462c1ed95c20b22eec16d4cc36a45560f107c5f4ae0f2cf"

URI_aarch64_kpatch-dnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpatch-dnf-0.9.7_0.4-4.el10.noarch.rpm;name=aarch64_kpatch-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpatch-dnf}"
SRC_URI[aarch64_kpatch-dnf.sha256sum] = "03baa05e7958845e01505c4c70d02bdec388d8d1637c7523a1bdba8b737b6469"

RDEPENDS:kpatch = " \
 bash \
 binutils \
 kmod \
 "
RDEPENDS:kpatch-dnf = " \
 bash \
 python3 \
 python3-dnf \
 python3-hawkey \
 "
