# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "squashfuse"
PV = "0.5.2"
PR = "2.el10_0"
PACKAGES = " \
 squashfuse \
 squashfuse-devel \
 squashfuse-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/squashfuse-0.5.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37843bcde47a7a3f5295aaf26b03823beb1cb260d8accb0fb8781b4cfcfd8b7d"

URI_x86_64_v2_squashfuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squashfuse-0.5.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squashfuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squashfuse}"
SRC_URI[x86_64_v2_squashfuse.sha256sum] = "8c1f7482203d0d1f71e5f1ee6a95848edec7c73471ca6afa3ca15f692815e0b4"
RPROVIDES:squashfuse:x86_64_v2 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_x86_64_v2_squashfuse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squashfuse-devel-0.5.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squashfuse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squashfuse-devel}"
SRC_URI[x86_64_v2_squashfuse-devel.sha256sum] = "20257bcece60007182ca8108ff0b04eeb30eb28c6bac81f84e8cd1a6c099f4f0"

URI_x86_64_v2_squashfuse-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squashfuse-libs-0.5.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squashfuse-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squashfuse-libs}"
SRC_URI[x86_64_v2_squashfuse-libs.sha256sum] = "75e970512cd791f1d42c55fdbb217879d75ab05462c79a68fec6fff18de9e910"

URI_aarch64_squashfuse = "${EPEL_MIRROR}/aarch64/Packages/s/squashfuse-0.5.2-2.el10_0.aarch64.rpm;name=aarch64_squashfuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_squashfuse}"
SRC_URI[aarch64_squashfuse.sha256sum] = "fe5eeddfa2fe76139757aadb9cce8d040b95a77f874fe81255187bc6382ac55d"
RPROVIDES:squashfuse:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_squashfuse-devel = "${EPEL_MIRROR}/aarch64/Packages/s/squashfuse-devel-0.5.2-2.el10_0.aarch64.rpm;name=aarch64_squashfuse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_squashfuse-devel}"
SRC_URI[aarch64_squashfuse-devel.sha256sum] = "915cee02233feaa4dabfe6ff0909fda8a9370daafe56977b4fead5e7afff0d8d"

URI_aarch64_squashfuse-libs = "${EPEL_MIRROR}/aarch64/Packages/s/squashfuse-libs-0.5.2-2.el10_0.aarch64.rpm;name=aarch64_squashfuse-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_squashfuse-libs}"
SRC_URI[aarch64_squashfuse-libs.sha256sum] = "297c5b1b5f82aaa3f9a32de258f18f8a9b7859e0f5d75927d7d546f4c62e0905"

RDEPENDS:squashfuse = " \
 fuse-libs \
 glibc \
 libzstd \
 lz4-libs \
 squashfuse-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:squashfuse-devel = " \
 pkgconf-pkg-config \
 squashfuse-libs \
 "
RDEPENDS:squashfuse-libs = " \
 fuse-libs \
 glibc \
 libzstd \
 lz4-libs \
 xz-libs \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

PROVIDES:append:aarch64 = " rpm/virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"
