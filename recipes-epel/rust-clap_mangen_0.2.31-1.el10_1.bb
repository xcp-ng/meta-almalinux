# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_mangen"
PV = "0.2.31"
PR = "1.el10_1"
PACKAGES = " \
 rust-clap_mangen+debug-devel \
 rust-clap_mangen+default-devel \
 rust-clap_mangen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_mangen-0.2.31-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "588597d1e9b8f5b9695acb8a07c4ee1aedb86ac8f189a03830dbb08a469ded3f"

URI_x86_64_v2_rust-clap_mangen+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen+debug-devel-0.2.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen+debug-devel.sha256sum] = "758251643bdc1be130fa89e57d073740c19b52293ef6c2a46957336f3918edc6"

URI_x86_64_v2_rust-clap_mangen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen+default-devel-0.2.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen+default-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen+default-devel.sha256sum] = "467131638ec02ba864bc6fdf6e41787b4a848fac6316a1bdb0d7b3ab7d70d3d5"

URI_x86_64_v2_rust-clap_mangen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen-devel-0.2.31-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen-devel.sha256sum] = "1ab47fdc2b5bb1f87d7e907c81cacf10d48a3d03ef48fcf6e6ee2f758682ee2b"

URI_aarch64_rust-clap_mangen+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen+debug-devel-0.2.31-1.el10_1.noarch.rpm;name=aarch64_rust-clap_mangen+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen+debug-devel}"
SRC_URI[aarch64_rust-clap_mangen+debug-devel.sha256sum] = "6e995a32e2b3b2d9e8308b1cf551467becad9dfc0d0fdf9bd52c3aa8afe104f6"

URI_aarch64_rust-clap_mangen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen+default-devel-0.2.31-1.el10_1.noarch.rpm;name=aarch64_rust-clap_mangen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen+default-devel}"
SRC_URI[aarch64_rust-clap_mangen+default-devel.sha256sum] = "b3843967c31fd296a7d114ee86bf7998d7d127ee2f7e47fae1ff2014f7b67d2c"

URI_aarch64_rust-clap_mangen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen-devel-0.2.31-1.el10_1.noarch.rpm;name=aarch64_rust-clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen-devel}"
SRC_URI[aarch64_rust-clap_mangen-devel.sha256sum] = "b1139eb24ebbb80d3d2d188cafc76affe43d149b09d8551c551c623c7558907d"

RDEPENDS:rust-clap_mangen+debug-devel = " \
 cargo \
 rust-clap+debug-devel \
 rust-clap_mangen-devel \
 "
RDEPENDS:rust-clap_mangen+default-devel = " \
 cargo \
 rust-clap_mangen-devel \
 "
RDEPENDS:rust-clap_mangen-devel = " \
 cargo \
 rust \
 rust-clap+env-devel \
 rust-clap+std-devel \
 rust-clap-devel \
 rust-roff+default-devel \
 "
