# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distrobox"
PV = "1.8.2.5"
PR = "1.el10_3"
PACKAGES = " \
 distrobox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/distrobox-1.8.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "035b195a3c4b64eaed4cf8f712c19b82ab93aa31152d0e45ec10a169716d1d6a"

URI_x86_64_v2_distrobox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distrobox-1.8.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_distrobox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distrobox}"
SRC_URI[x86_64_v2_distrobox.sha256sum] = "51904d23bdc20bad7aa5a97d27438f49a5d44acabc80a26a6e1e9d9f64a049a3"

URI_aarch64_distrobox = "${EPEL_MIRROR}/aarch64/Packages/d/distrobox-1.8.2.5-1.el10_3.noarch.rpm;name=aarch64_distrobox;unpack=0"
SRC_URI:append = " ${URI_aarch64_distrobox}"
SRC_URI[aarch64_distrobox.sha256sum] = "0fedfdebef150d77f511de4fff0bdd2326eb6769c5bc82c187053ab11e7d4ea9"

RDEPENDS:distrobox = " \
 bash \
 findutils \
 grep \
 hicolor-icon-theme \
 sed \
 virtual//usr/bin/basename \
 virtual/podman_or_/usr/bin/docker \
 "
