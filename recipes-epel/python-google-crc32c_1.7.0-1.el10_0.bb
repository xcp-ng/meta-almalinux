# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-crc32c"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-google-crc32c \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-crc32c-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc3251bf0194413af7dddaa95771437bf75859b4a5bfbf23b54242ed9002ed7e"

URI_x86_64_v2_python3-google-crc32c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-crc32c-1.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-google-crc32c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-crc32c}"
SRC_URI[x86_64_v2_python3-google-crc32c.sha256sum] = "c8eb1f7c482d65117b48e3b48964e699d8908905bc947fafdc2d737b4d83d74b"

URI_aarch64_python3-google-crc32c = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-crc32c-1.7.0-1.el10_0.aarch64.rpm;name=aarch64_python3-google-crc32c;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-crc32c}"
SRC_URI[aarch64_python3-google-crc32c.sha256sum] = "0b909aa3192d91a291b1d22ca6c3d63c78c48abfc9ba266e19caaecd39b04cca"

RDEPENDS:python3-google-crc32c = " \
 glibc \
 google-crc32c \
 python3 \
 "
