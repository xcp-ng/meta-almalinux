# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bindgen"
PV = "0.71.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-bindgen+__cli-devel \
 rust-bindgen+__testing_only_extra_assertions-devel \
 rust-bindgen+__testing_only_libclang_16-devel \
 rust-bindgen+__testing_only_libclang_9-devel \
 rust-bindgen+default-devel \
 rust-bindgen+experimental-devel \
 rust-bindgen+logging-devel \
 rust-bindgen+prettyplease-devel \
 rust-bindgen+runtime-devel \
 rust-bindgen+static-devel \
 rust-bindgen+which-rustfmt-devel \
 rust-bindgen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bindgen-0.71.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6fedb61650d836f7f69b93b5e9f89b6a05e261a0a6106e81694614cdd859434"

URI_x86_64_v2_rust-bindgen+__cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__cli-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__cli-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__cli-devel.sha256sum] = "e45b60571c3d53e953ad4fad7068ba641bb5573046878a21c4a4ec8306e2c060"

URI_x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__testing_only_extra_assertions-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel.sha256sum] = "0efc7aecf667e85491fb48e865228323d0020b2c8890851efe81154d5f5e94ed"

URI_x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__testing_only_libclang_16-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel.sha256sum] = "496cc638ffd23bec80cb41d43a382acead8a313b28c898767eb2636389e43d50"

URI_x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__testing_only_libclang_9-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel.sha256sum] = "80466b4e7299f42d529d72e5d992edfaf49865649d58ee8a29c7027e84ce6ab1"

URI_x86_64_v2_rust-bindgen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+default-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+default-devel}"
SRC_URI[x86_64_v2_rust-bindgen+default-devel.sha256sum] = "aabc1803157908e92c6f11e49a273f55d1a4290b37138f7e694a717dc12f680b"

URI_x86_64_v2_rust-bindgen+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+experimental-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+experimental-devel}"
SRC_URI[x86_64_v2_rust-bindgen+experimental-devel.sha256sum] = "b894a33206b3f52cf91b29f5a52f67e020336f377defcb9fb554701ed9858867"

URI_x86_64_v2_rust-bindgen+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+logging-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+logging-devel}"
SRC_URI[x86_64_v2_rust-bindgen+logging-devel.sha256sum] = "e5761ae721ebfd8aec72c1dbd86b700070d97755ee9e199d288a8c7512943f10"

URI_x86_64_v2_rust-bindgen+prettyplease-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+prettyplease-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+prettyplease-devel}"
SRC_URI[x86_64_v2_rust-bindgen+prettyplease-devel.sha256sum] = "bf8b96f3ad34396877b8dc6aa9ed1f7a14ad049d73ffbcdad530c08e68b84465"

URI_x86_64_v2_rust-bindgen+runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+runtime-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+runtime-devel}"
SRC_URI[x86_64_v2_rust-bindgen+runtime-devel.sha256sum] = "b25ce2f947bc28eaa6e718d5c434b8c01fb94fc08237e0da9ee2e5967ba44c20"

URI_x86_64_v2_rust-bindgen+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+static-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+static-devel}"
SRC_URI[x86_64_v2_rust-bindgen+static-devel.sha256sum] = "76e9e049f016314abde03c0b0410f739daee8586bbfb4ad33bff86d9a0d29970"

URI_x86_64_v2_rust-bindgen+which-rustfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+which-rustfmt-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+which-rustfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+which-rustfmt-devel}"
SRC_URI[x86_64_v2_rust-bindgen+which-rustfmt-devel.sha256sum] = "e69a1aaedbc839f4b835dde8ef248ff76fe81f39ca078086115d38260c483527"

URI_x86_64_v2_rust-bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen-devel-0.71.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen-devel}"
SRC_URI[x86_64_v2_rust-bindgen-devel.sha256sum] = "37dd0b73609170fad0a34576e7c9c5f5e49987180ef47ca4c8061f63f876cb99"

URI_aarch64_rust-bindgen+__cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__cli-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+__cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__cli-devel}"
SRC_URI[aarch64_rust-bindgen+__cli-devel.sha256sum] = "f8c9b8aaf9ed8a2fc436e8490c30a43ee63619e7eb80ba48bd124fca68f10b44"

URI_aarch64_rust-bindgen+__testing_only_extra_assertions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__testing_only_extra_assertions-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+__testing_only_extra_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__testing_only_extra_assertions-devel}"
SRC_URI[aarch64_rust-bindgen+__testing_only_extra_assertions-devel.sha256sum] = "d0cf83abe23b3e33c2fb848628f368071dbaef7ecbf2985482c03dcfe3bd4fb3"

URI_aarch64_rust-bindgen+__testing_only_libclang_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__testing_only_libclang_16-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+__testing_only_libclang_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__testing_only_libclang_16-devel}"
SRC_URI[aarch64_rust-bindgen+__testing_only_libclang_16-devel.sha256sum] = "50dce004aa1bfc255763a856c201d24f911aa5486fc1fec7def2d04da4e5f1ca"

URI_aarch64_rust-bindgen+__testing_only_libclang_9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__testing_only_libclang_9-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+__testing_only_libclang_9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__testing_only_libclang_9-devel}"
SRC_URI[aarch64_rust-bindgen+__testing_only_libclang_9-devel.sha256sum] = "90af6766132ef21a623fae1feaa2e41c868acb6acbe6eddc783c88418ee9b793"

URI_aarch64_rust-bindgen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+default-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+default-devel}"
SRC_URI[aarch64_rust-bindgen+default-devel.sha256sum] = "be599d91e5701352dca1048b5a46cbd2ba8197d846b8acf39cdecf44b1018a8f"

URI_aarch64_rust-bindgen+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+experimental-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+experimental-devel}"
SRC_URI[aarch64_rust-bindgen+experimental-devel.sha256sum] = "148a3a7768c6d4edad7ec7cb3e9db8ab2537773553d39385714b10241092d9f7"

URI_aarch64_rust-bindgen+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+logging-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+logging-devel}"
SRC_URI[aarch64_rust-bindgen+logging-devel.sha256sum] = "4ef78d9361b13fd3d11546b6774e2ccc5d5cef8124e6b1631523a855ee6bb7d3"

URI_aarch64_rust-bindgen+prettyplease-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+prettyplease-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+prettyplease-devel}"
SRC_URI[aarch64_rust-bindgen+prettyplease-devel.sha256sum] = "4bd0c6668896f497ab3656b6cf93ae5315418d661143d6ebcfda34331cfcddbd"

URI_aarch64_rust-bindgen+runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+runtime-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+runtime-devel}"
SRC_URI[aarch64_rust-bindgen+runtime-devel.sha256sum] = "01cef2585c636b38004c745f52659438034f892959b920886dbb01b309e365c6"

URI_aarch64_rust-bindgen+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+static-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+static-devel}"
SRC_URI[aarch64_rust-bindgen+static-devel.sha256sum] = "9dfe88a14b0a23af6bb8900a4aaa1d814a7b43d59dd17effb9ddd65fa8901e24"

URI_aarch64_rust-bindgen+which-rustfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+which-rustfmt-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen+which-rustfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+which-rustfmt-devel}"
SRC_URI[aarch64_rust-bindgen+which-rustfmt-devel.sha256sum] = "b06a6630b37665e6f02a3472ee05b657e82d4f62da105113c22c663c10612ad5"

URI_aarch64_rust-bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen-devel-0.71.1-1.el10_1.noarch.rpm;name=aarch64_rust-bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen-devel}"
SRC_URI[aarch64_rust-bindgen-devel.sha256sum] = "b7f8fbf4e46bc0c1311f5aadbb4bc3808948bbca3b01683be4930a65d2285f99"

RDEPENDS:rust-bindgen+__cli-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap_complete+default-devel \
 "
RDEPENDS:rust-bindgen+__testing_only_extra_assertions-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+__testing_only_libclang_16-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+__testing_only_libclang_9-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+default-devel = " \
 cargo \
 rust-bindgen+logging-devel \
 rust-bindgen+prettyplease-devel \
 rust-bindgen+runtime-devel \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+experimental-devel = " \
 cargo \
 rust-annotate-snippets+default-devel \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+logging-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-bindgen+prettyplease-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-prettyplease+default-devel \
 rust-prettyplease+verbatim-devel \
 "
RDEPENDS:rust-bindgen+runtime-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-clang-sys+runtime-devel \
 "
RDEPENDS:rust-bindgen+static-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-clang-sys+static-devel \
 "
RDEPENDS:rust-bindgen+which-rustfmt-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cexpr+default-devel \
 rust-clang-sys+clang_11_0-devel \
 rust-clang-sys+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote-devel \
 rust-regex+std-devel \
 rust-regex+unicode-perl-devel \
 rust-regex-devel \
 rust-rustc-hash+default-devel \
 rust-shlex+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-mut-devel \
 virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.14.0~ \
 "
