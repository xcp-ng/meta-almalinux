# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-data-encoding"
PV = "2.11.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-data-encoding+alloc-devel \
 rust-data-encoding+default-devel \
 rust-data-encoding+std-devel \
 rust-data-encoding-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-data-encoding-2.11.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a7562a1f7647848900be27a28a32e2987b926f0bb8c9b1197512025e15aeccea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+alloc-devel-2.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-data-encoding+alloc-devel.sha256sum] = "982c51e5fe0e347448b9442716cd6c895f3edf7633299c14abaaacef8f93ea78"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+default-devel-2.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-data-encoding+default-devel.sha256sum] = "7a7eedbc941c886f29889fa72c449a61cfd3e28ab9ff00536a98dccd2c80e554"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+std-devel-2.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-data-encoding+std-devel.sha256sum] = "026ead4e6080f1e0ec505ca093ee94bde1c3accc2ea883b84e62b33243057607"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding-devel-2.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-data-encoding-devel.sha256sum] = "085b44144777be194d6308aa68891be1eff5f3bcbdb8b32895e3e76a67affe3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+alloc-devel-2.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-data-encoding+alloc-devel.sha256sum] = "8af8c90f1f60174c5aeaf1c81aa6ee4f0bc738aa5fe5e01489770c4044d9dd9e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+default-devel-2.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding+default-devel;unpack=0"
SRC_URI[aarch64_rust-data-encoding+default-devel.sha256sum] = "25022a05ce25c8bbd257cf6b94b43eff9906f9e81ebe03f0e0bb5773d240630b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+std-devel-2.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding+std-devel;unpack=0"
SRC_URI[aarch64_rust-data-encoding+std-devel.sha256sum] = "36def7fbdbd3932df0e17aed0a957952e5a6845a9f6d33f89a741d68e735a278"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding-devel-2.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding-devel;unpack=0"
SRC_URI[aarch64_rust-data-encoding-devel.sha256sum] = "d718ed8bb2be61fe0df86a8bd6563d1ebfbb9d2c98cf580fa92b82afa18b62df"

RDEPENDS:rust-data-encoding+alloc-devel = " \
 cargo \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding+default-devel = " \
 cargo \
 rust-data-encoding+std-devel \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding+std-devel = " \
 cargo \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding-devel = " \
 cargo \
 rust \
 "
