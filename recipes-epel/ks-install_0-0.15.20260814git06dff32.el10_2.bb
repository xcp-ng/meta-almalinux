# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ks-install"
PV = "0"
PR = "0.15.20260814git06dff32.el10_2"
PACKAGES = " \
 ks-install \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ks-install-0-0.15.20260814git06dff32.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fac8398e7709c786a649d4a9feee28ed6441a0d29397474b651148c5507a5d8"

URI_aarch64_ks-install = "${EPEL_MIRROR}/aarch64/Packages/k/ks-install-0-0.15.20260814git06dff32.el10_2.noarch.rpm;name=aarch64_ks-install;unpack=0"
SRC_URI:append = " ${URI_aarch64_ks-install}"
SRC_URI[aarch64_ks-install.sha256sum] = "5d1886b4cb5244d569995abdceaa27c954db8837dc8939655fe2a53295dca853"

RDEPENDS:ks-install = " \
 perl-Config-Tiny \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-LWP-Protocol-https \
 perl-Modern-Perl \
 perl-POSIX \
 perl-Pod-Usage \
 perl-Socket \
 perl-Sys-Virt \
 perl-XML-Simple \
 perl-autodie \
 perl-interpreter \
 perl-libwww-perl \
 virt-install \
 "
