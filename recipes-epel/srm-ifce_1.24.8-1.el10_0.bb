# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "srm-ifce"
PV = "1.24.8"
PR = "1.el10_0"
PACKAGES = " \
 srm-ifce \
 srm-ifce-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/srm-ifce-1.24.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "301937ae34b6bd8ae723d7b7231c346bd11e38cd2d6424021ddd0e71b5930bec"

URI_x86_64_v2_srm-ifce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/srm-ifce-1.24.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_srm-ifce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_srm-ifce}"
SRC_URI[x86_64_v2_srm-ifce.sha256sum] = "a1699893f9819248d69c7e05e686df4b1b1274771bbdbc3b68bd2b1ac4bd051f"

URI_x86_64_v2_srm-ifce-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/srm-ifce-devel-1.24.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_srm-ifce-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_srm-ifce-devel}"
SRC_URI[x86_64_v2_srm-ifce-devel.sha256sum] = "1a71a3014ac21ffb887929e8604643e62cb4b3e7d808c901534fce2bbb683947"

URI_aarch64_srm-ifce = "${EPEL_MIRROR}/aarch64/Packages/s/srm-ifce-1.24.8-1.el10_0.aarch64.rpm;name=aarch64_srm-ifce;unpack=0"
SRC_URI:append = " ${URI_aarch64_srm-ifce}"
SRC_URI[aarch64_srm-ifce.sha256sum] = "e65c4ac73e04476ef81a8b7a692ba13148d17cb0abc2bd0fc27b752e7ed08d3e"

URI_aarch64_srm-ifce-devel = "${EPEL_MIRROR}/aarch64/Packages/s/srm-ifce-devel-1.24.8-1.el10_0.aarch64.rpm;name=aarch64_srm-ifce-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_srm-ifce-devel}"
SRC_URI[aarch64_srm-ifce-devel.sha256sum] = "5bd7739145a34bf180661740981f320a255931c6d59ab6e6a150d4b4c5b20fc1"

RDEPENDS:srm-ifce = " \
 CGSI-gSOAP \
 glib2 \
 glibc \
 gsoap \
 "
RDEPENDS:srm-ifce-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 srm-ifce \
 "
