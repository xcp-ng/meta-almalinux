# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-deckarep-set"
PV = "1.8.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-deckarep-set-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-deckarep-set-1.8.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1348135482e3db8416a327f2bd5f8c4f6118e7dd11e16acacdf0ec612200b72f"

URI_x86_64_v2_golang-github-deckarep-set-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-deckarep-set-devel-1.8.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-deckarep-set-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-deckarep-set-devel}"
SRC_URI[x86_64_v2_golang-github-deckarep-set-devel.sha256sum] = "d26c0f29efbe724a6644c4e065fa65dd69e8336e336e49fa5fc8a6d9e7cabf22"

URI_aarch64_golang-github-deckarep-set-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-deckarep-set-devel-1.8.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-deckarep-set-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-deckarep-set-devel}"
SRC_URI[aarch64_golang-github-deckarep-set-devel.sha256sum] = "f9d0d75da4eac566d4030efd942252c8e45399cc2d0a2d8bc04fa171438dff4d"

RDEPENDS:golang-github-deckarep-set-devel = " \
 go-filesystem \
 "
