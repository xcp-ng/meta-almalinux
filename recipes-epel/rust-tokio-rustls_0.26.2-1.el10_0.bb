# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-rustls"
PV = "0.26.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-tokio-rustls+default-devel \
 rust-tokio-rustls+early-data-devel \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-rustls-0.26.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55f6178796d8fd5b263426ba2c4f1907822ef28a20a013bef2c0e16b5ca55568"

URI_x86_64_v2_rust-tokio-rustls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+default-devel-0.26.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+default-devel.sha256sum] = "96328b2e107451c8eefffaa9da9601b48fcea1d5a973d8e7c94cdb744468257f"

URI_x86_64_v2_rust-tokio-rustls+early-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+early-data-devel-0.26.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+early-data-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+early-data-devel.sha256sum] = "95606e3271b4bece9d65bcfffe755f01d629088c1f6aa1aa8aa44f29f40fb371"

URI_x86_64_v2_rust-tokio-rustls+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+logging-devel-0.26.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+logging-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+logging-devel.sha256sum] = "c1d2dd97860a0931f9bd50b8086bdd8121770132dd90c6745458f2d9fe95904f"

URI_x86_64_v2_rust-tokio-rustls+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+ring-devel-0.26.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+ring-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+ring-devel.sha256sum] = "e838eeae2ee6537c97a0d9d8183981c302c0e2fdb493d11e92ad5deffb8ebd32"

URI_x86_64_v2_rust-tokio-rustls+tls12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+tls12-devel-0.26.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+tls12-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+tls12-devel.sha256sum] = "37f959d991ac7cebbb19415178c0e26abe0ff1d5b5d0ce076646b673c4915404"

URI_x86_64_v2_rust-tokio-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls-devel-0.26.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls-devel.sha256sum] = "57ef2499cef62b8abbeaecb0d5dd0a925fcb87234c2a67299e118baed37a2dcd"

URI_aarch64_rust-tokio-rustls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+default-devel-0.26.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+default-devel}"
SRC_URI[aarch64_rust-tokio-rustls+default-devel.sha256sum] = "7d54105b9d4e38a12b97a93f3af75d2b55b5772f9d1b2a998f351ae3b025b756"

URI_aarch64_rust-tokio-rustls+early-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+early-data-devel-0.26.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+early-data-devel}"
SRC_URI[aarch64_rust-tokio-rustls+early-data-devel.sha256sum] = "1eb95b9f9fbb8a673b48f671fb0636c8ecdf6cd344b572f1415bea43837c4ca4"

URI_aarch64_rust-tokio-rustls+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+logging-devel-0.26.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+logging-devel}"
SRC_URI[aarch64_rust-tokio-rustls+logging-devel.sha256sum] = "6b7192c5e1479a1f3460733f8321dfef76dc8e519734d286e47ea64e6027543b"

URI_aarch64_rust-tokio-rustls+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+ring-devel-0.26.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+ring-devel}"
SRC_URI[aarch64_rust-tokio-rustls+ring-devel.sha256sum] = "3e8dee8384b6470c39e21c136b2426cb35925128afa1e9c3f7d9fcd7f90ef741"

URI_aarch64_rust-tokio-rustls+tls12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+tls12-devel-0.26.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+tls12-devel}"
SRC_URI[aarch64_rust-tokio-rustls+tls12-devel.sha256sum] = "3709861673c5f2ab7d3b620bc7b14cc438e3f9bc86b0a61331ce3f011830cd4f"

URI_aarch64_rust-tokio-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls-devel-0.26.2-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls-devel}"
SRC_URI[aarch64_rust-tokio-rustls-devel.sha256sum] = "c121a5b6373178382fc1e2fc39217dd2aad676a759dfd82d6915e044137b9601"

RDEPENDS:rust-tokio-rustls+default-devel = " \
 cargo \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+early-data-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+logging-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+ring-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+tls12-devel = " \
 cargo \
 rust-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls-devel = " \
 cargo \
 rust \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tokio+default-devel \
 "
