# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdegraphics-thumbnailers"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdegraphics-thumbnailers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdegraphics-thumbnailers-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f64e5e493dbce0e67afffc2458ddd39d4d046d095d932a70b283ee0226f5fb1e"

URI_x86_64_v2_kdegraphics-thumbnailers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-thumbnailers-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdegraphics-thumbnailers}"
SRC_URI[x86_64_v2_kdegraphics-thumbnailers.sha256sum] = "cef5a7ed6237a34793e6a49384833dc583a187caecdbba44848eef08b1bce43e"

URI_aarch64_kdegraphics-thumbnailers = "${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-thumbnailers-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdegraphics-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdegraphics-thumbnailers}"
SRC_URI[aarch64_kdegraphics-thumbnailers.sha256sum] = "49c97550c7067b30e1db24876aab17a47c6d9afaeb03862d9ff8c6651d707d51"

RDEPENDS:kdegraphics-thumbnailers = " \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libkdcraw \
 libkexiv2-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
