# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-pa"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-pa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-pa-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8c5a628bcd9b666278f2fc83f8ce7299c201b05cf3dd8c98ee87373a5e4d4eb"

URI_x86_64_v2_plasma-pa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-pa-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-pa}"
SRC_URI[x86_64_v2_plasma-pa.sha256sum] = "9cb49dec1efb96abba53129ad5ea97bdff28a2b90855945d40bd81a4b738db8e"

URI_aarch64_plasma-pa = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-pa-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-pa}"
SRC_URI[aarch64_plasma-pa.sha256sum] = "4d45d2244f7aa58d97fd8c4e84f173cf18b56e50055fc7a24a3026c133821e11"

RDEPENDS:plasma-pa = " \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kstatusnotifieritem \
 libcanberra \
 libplasma \
 libstdc++ \
 pipewire-pulseaudio \
 pulseaudio-libs \
 pulseaudio-qt-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
