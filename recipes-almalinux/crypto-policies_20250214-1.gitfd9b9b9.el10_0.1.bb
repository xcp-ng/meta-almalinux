# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crypto-policies"
PV = "20250214"
PR = "1.gitfd9b9b9.el10_0.1"
PACKAGES = " \
 crypto-policies \
 crypto-policies-pq-preview \
 crypto-policies-scripts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/crypto-policies-20250214-1.gitfd9b9b9.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abe2493fc44988741c068f0e45d693f53277e350bff1203b07d0ce451d4f7494"

URI_x86_64_v2_crypto-policies = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-20250214-1.gitfd9b9b9.el10_0.1.noarch.rpm;name=x86_64_v2_crypto-policies;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crypto-policies}"
SRC_URI[x86_64_v2_crypto-policies.sha256sum] = "401300e086e07e8209d25fbc25aaea8ce749a4f9595b623c7509239eebe3f693"

URI_x86_64_v2_crypto-policies-pq-preview = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crypto-policies-pq-preview-20250214-1.gitfd9b9b9.el10_0.1.noarch.rpm;name=x86_64_v2_crypto-policies-pq-preview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crypto-policies-pq-preview}"
SRC_URI[x86_64_v2_crypto-policies-pq-preview.sha256sum] = "5d23a1aaf06a4a8835357fa74889fb3fae1427fa87d9680cc09ed61fb316c689"

URI_x86_64_v2_crypto-policies-scripts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-scripts-20250214-1.gitfd9b9b9.el10_0.1.noarch.rpm;name=x86_64_v2_crypto-policies-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crypto-policies-scripts}"
SRC_URI[x86_64_v2_crypto-policies-scripts.sha256sum] = "8893abd142afaa061530e1d029164b4a8b3eb05758d8fc4958340174aad88e4c"

URI_aarch64_crypto-policies = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-20250214-1.gitfd9b9b9.el10_0.1.noarch.rpm;name=aarch64_crypto-policies;unpack=0"
SRC_URI:append = " ${URI_aarch64_crypto-policies}"
SRC_URI[aarch64_crypto-policies.sha256sum] = "401300e086e07e8209d25fbc25aaea8ce749a4f9595b623c7509239eebe3f693"

URI_aarch64_crypto-policies-pq-preview = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crypto-policies-pq-preview-20250214-1.gitfd9b9b9.el10_0.1.noarch.rpm;name=aarch64_crypto-policies-pq-preview;unpack=0"
SRC_URI:append = " ${URI_aarch64_crypto-policies-pq-preview}"
SRC_URI[aarch64_crypto-policies-pq-preview.sha256sum] = "5d23a1aaf06a4a8835357fa74889fb3fae1427fa87d9680cc09ed61fb316c689"

URI_aarch64_crypto-policies-scripts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-scripts-20250214-1.gitfd9b9b9.el10_0.1.noarch.rpm;name=aarch64_crypto-policies-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_crypto-policies-scripts}"
SRC_URI[aarch64_crypto-policies-scripts.sha256sum] = "8893abd142afaa061530e1d029164b4a8b3eb05758d8fc4958340174aad88e4c"

RDEPENDS:crypto-policies = " \
 bash \
 "
RDEPENDS:crypto-policies-pq-preview = " \
 crypto-policies \
 liboqs \
 oqsprovider \
 "
RDEPENDS:crypto-policies-scripts = " \
 bash \
 crypto-policies \
 python3 \
 "
