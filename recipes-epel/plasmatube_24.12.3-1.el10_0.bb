# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasmatube"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 plasmatube \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasmatube-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f47b4077bed92f17f254a68c3b56e44b666fc2255aa1ac567b570ffa29d21cf4"

URI_x86_64_v2_plasmatube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasmatube-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasmatube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasmatube}"
SRC_URI[x86_64_v2_plasmatube.sha256sum] = "05790cd66d3fd7f2e176c31118f360122b885b2974e8e7a79b017fbb2d0544c9"

URI_aarch64_plasmatube = "${EPEL_MIRROR}/aarch64/Packages/p/plasmatube-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_plasmatube;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasmatube}"
SRC_URI[aarch64_plasmatube.sha256sum] = "6b29579f7c0fa854911981a082c2744935d9a7986e01f03f0ebc51c82323556c"

RDEPENDS:plasmatube = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 libstdc++ \
 mpvqt \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qtkeychain-qt6 \
 "
