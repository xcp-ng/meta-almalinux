# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nix"
PV = "2.24.15"
PR = "2.el10_1"
PACKAGES = " \
 nix \
 nix-core \
 nix-daemon \
 nix-devel \
 nix-filesystem \
 nix-legacy \
 nix-system \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nix-2.24.15-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea300cd8aef653fe8af5c6dddeaa77eb36498d1fca41d1d248fe39e2dac387b1"

URI_x86_64_v2_nix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-2.24.15-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix}"
SRC_URI[x86_64_v2_nix.sha256sum] = "23250ef1ff331349b0b7ecf6bcd25e000a1b9a6b25d559df988d90427d356a6b"

URI_x86_64_v2_nix-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-core-2.24.15-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-core}"
SRC_URI[x86_64_v2_nix-core.sha256sum] = "f8468e16d88c9b664d132a36ed101828a619265fc287811ffdb46675fa587ff8"

URI_x86_64_v2_nix-daemon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-daemon-2.24.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nix-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-daemon}"
SRC_URI[x86_64_v2_nix-daemon.sha256sum] = "daebc531f97052d76461f026f33d60abde69b10b8f743e0e34a459ae8e8a1fdd"

URI_x86_64_v2_nix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-devel-2.24.15-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-devel}"
SRC_URI[x86_64_v2_nix-devel.sha256sum] = "07e4e73fad28e920475fcc18b3f11ea8eedd37959d671da2150d48b0210614fc"

URI_x86_64_v2_nix-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-filesystem-2.24.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nix-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-filesystem}"
SRC_URI[x86_64_v2_nix-filesystem.sha256sum] = "db087957fb3b69014bd28a219267850a81f87c637c7869dfbd01b29e5b3f771d"

URI_x86_64_v2_nix-legacy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-legacy-2.24.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nix-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-legacy}"
SRC_URI[x86_64_v2_nix-legacy.sha256sum] = "7992920ec0ef6f14494c11801095eb5ad5014a00abe2c5dc09d5b9a5916e5cd4"

URI_x86_64_v2_nix-system = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-system-2.24.15-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nix-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-system}"
SRC_URI[x86_64_v2_nix-system.sha256sum] = "5f04c68eafdb3e66f556c26e6e0bd87cb41f819ff3be31d21136a12b0b075683"

URI_aarch64_nix = "${EPEL_MIRROR}/aarch64/Packages/n/nix-2.24.15-2.el10_1.aarch64.rpm;name=aarch64_nix;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix}"
SRC_URI[aarch64_nix.sha256sum] = "f4e825a5300ee5763d9fa2e535b7e46b77ffa9a7da58100d202a4a4b19ccaf8a"

URI_aarch64_nix-core = "${EPEL_MIRROR}/aarch64/Packages/n/nix-core-2.24.15-2.el10_1.aarch64.rpm;name=aarch64_nix-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-core}"
SRC_URI[aarch64_nix-core.sha256sum] = "ae37005116788bc65eebced1b8c985c4b6ca74c7b8c503ff8d621438cde83428"

URI_aarch64_nix-daemon = "${EPEL_MIRROR}/aarch64/Packages/n/nix-daemon-2.24.15-2.el10_1.noarch.rpm;name=aarch64_nix-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-daemon}"
SRC_URI[aarch64_nix-daemon.sha256sum] = "b495d6d12b481ccbec93e4f7d842091b68a394d69d3371c7335694a6e9ac9b50"

URI_aarch64_nix-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nix-devel-2.24.15-2.el10_1.aarch64.rpm;name=aarch64_nix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-devel}"
SRC_URI[aarch64_nix-devel.sha256sum] = "ca4a84dc0b1a80aa92d051facd97674da3eb0f6da7744fa49150509c4de0b7ec"

URI_aarch64_nix-filesystem = "${EPEL_MIRROR}/aarch64/Packages/n/nix-filesystem-2.24.15-2.el10_1.noarch.rpm;name=aarch64_nix-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-filesystem}"
SRC_URI[aarch64_nix-filesystem.sha256sum] = "54c224bd227d5314255a5c455f3ea6728cf3508294274c06682bf1710f4df80e"

URI_aarch64_nix-legacy = "${EPEL_MIRROR}/aarch64/Packages/n/nix-legacy-2.24.15-2.el10_1.noarch.rpm;name=aarch64_nix-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-legacy}"
SRC_URI[aarch64_nix-legacy.sha256sum] = "0c569f6690b15773082ccf02b97a6fe90423371ac03058fa721353234c4b86ef"

URI_aarch64_nix-system = "${EPEL_MIRROR}/aarch64/Packages/n/nix-system-2.24.15-2.el10_1.noarch.rpm;name=aarch64_nix-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-system}"
SRC_URI[aarch64_nix-system.sha256sum] = "022777827aaa9d53fdb25d57825030db3c9a4d4d3738a7b5eabe3a2e6d178279"

RDEPENDS:nix = " \
 nix-core \
 nix-system \
 "
RDEPENDS:nix-core = " \
 boost-context \
 gc \
 glibc \
 libarchive \
 libbrotli \
 libgcc \
 libgit2 \
 libseccomp \
 libsodium \
 libstdc++ \
 lowdown-libs \
 openssl-libs \
 readline \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:nix-daemon = " \
 bash \
 nix-core \
 nix-system \
 systemd \
 "
RDEPENDS:nix-devel = " \
 gc-devel \
 nix \
 nix-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nix-filesystem = " \
 bash \
 "
RDEPENDS:nix-legacy = " \
 nix-core \
 "
RDEPENDS:nix-system = " \
 bash \
 nix-filesystem \
 "
