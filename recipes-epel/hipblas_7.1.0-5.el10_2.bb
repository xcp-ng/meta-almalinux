# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipblas"
PV = "7.1.0"
PR = "5.el10_2"
PACKAGES:x86_64_v2 = " \
 hipblas \
 hipblas-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipblas-7.1.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ffa2be8f4d85cd9c6b95acadf5492aab066b6b590de5dc38402e30e8932d36e"

URI_x86_64_v2_hipblas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblas-7.1.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblas}"
SRC_URI[x86_64_v2_hipblas.sha256sum] = "667a12e555d077ffd2cbba9efe33d4f1880845c8d6c1854979bd2ea2426eadf1"

URI_x86_64_v2_hipblas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblas-devel-7.1.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblas-devel}"
SRC_URI[x86_64_v2_hipblas-devel.sha256sum] = "84de998293ad33b9e3d63b273901f8ceaa87c10520582221e1790fb2d6d50fc9"

RDEPENDS:hipblas = " \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocsolver \
 "
RDEPENDS:hipblas-devel = " \
 cmake-filesystem \
 hipblas \
 hipblas-common-devel \
 "
