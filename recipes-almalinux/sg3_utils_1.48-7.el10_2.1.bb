# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sg3_utils"
PV = "1.48"
PR = "7.el10_2.1"
PACKAGES = " \
 sg3_utils \
 sg3_utils-devel \
 sg3_utils-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sg3_utils-1.48-7.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6c76c94982fa60174a177b9f9e68d97de61682c99deb1d592122487975412153"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sg3_utils-1.48-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sg3_utils;unpack=0"
SRC_URI[x86_64_v2_sg3_utils.sha256sum] = "35f2b0722476cdae4470214fd5c0ca6c241b127615dfe852ce34465e17d3eaf4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sg3_utils-devel-1.48-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sg3_utils-devel;unpack=0"
SRC_URI[x86_64_v2_sg3_utils-devel.sha256sum] = "706fad6104a1c8592782c9d82abac4d8ac722322f8c2f811e2c092cb94a1c58b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sg3_utils-libs-1.48-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_sg3_utils-libs;unpack=0"
SRC_URI[x86_64_v2_sg3_utils-libs.sha256sum] = "c18b4cc451f33750835c048475bd4998eb13e34243f73203a71311677d46f26a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sg3_utils-1.48-7.el10_2.1.aarch64.rpm;name=aarch64_sg3_utils;unpack=0"
SRC_URI[aarch64_sg3_utils.sha256sum] = "27891583b2be4ed218cd2706a31db6178e03331d36c7a901eea5db97a6356c6e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sg3_utils-devel-1.48-7.el10_2.1.aarch64.rpm;name=aarch64_sg3_utils-devel;unpack=0"
SRC_URI[aarch64_sg3_utils-devel.sha256sum] = "28204128ae61582b2f8c8e8512549384925946f5c38672ef9688b86884778bb7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sg3_utils-libs-1.48-7.el10_2.1.aarch64.rpm;name=aarch64_sg3_utils-libs;unpack=0"
SRC_URI[aarch64_sg3_utils-libs.sha256sum] = "2c586c9e7f1d519535c96989eb2bd9ee47191542a0212eb51568b092cfd85b9c"

RDEPENDS:sg3_utils = " \
 bash \
 glibc \
 libgcc \
 sg3_utils-libs \
 "
RDEPENDS:sg3_utils-devel = " \
 sg3_utils-libs \
 "
RDEPENDS:sg3_utils-libs = " \
 glibc \
 "
