# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vte291"
PV = "0.78.7"
PR = "2.el10"
PACKAGES = " \
 vte-profile \
 vte291 \
 vte291-devel \
 vte291-gtk4 \
 vte291-gtk4-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vte291-0.78.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c680cda4a29b05bcfd85c48402883e9462fa6494447ba5911aed9fa1aa5250de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte-profile-0.78.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_vte-profile;unpack=0"
SRC_URI[x86_64_v2_vte-profile.sha256sum] = "f8456739d3e4a72a0882fced9e98fc29079a70eeb1323bfbddbd84b634ac6191"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte291-0.78.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_vte291;unpack=0"
SRC_URI[x86_64_v2_vte291.sha256sum] = "0e868d9a7260aae3c1fae94af5e44f2c349c6fa8476db3316b2a595c57dd5f23"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vte291-devel-0.78.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-devel;unpack=0"
SRC_URI[x86_64_v2_vte291-devel.sha256sum] = "15c9c16d0b401dc6ae078264b61862a017d2626b19be0aa67f9e5519be1bf5ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte291-gtk4-0.78.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-gtk4;unpack=0"
SRC_URI[x86_64_v2_vte291-gtk4.sha256sum] = "6a82661ecb6d6e29a88cf1585a1f6d5fd3ca0c5521b4d9b01b021ccb7d64f419"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vte291-gtk4-devel-0.78.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-gtk4-devel;unpack=0"
SRC_URI[x86_64_v2_vte291-gtk4-devel.sha256sum] = "8ce06eaac2ef07ee7dc59ac4ec0ce8d235b13f3b66e446f6de48734eee4c6f41"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte-profile-0.78.7-2.el10.aarch64.rpm;name=aarch64_vte-profile;unpack=0"
SRC_URI[aarch64_vte-profile.sha256sum] = "6bf056e26525900b8be56e2b2c7dd02d1d3305e2037446698ffff80b53b70681"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte291-0.78.7-2.el10.aarch64.rpm;name=aarch64_vte291;unpack=0"
SRC_URI[aarch64_vte291.sha256sum] = "1bf3933b3a2d6e8f373e76ba28f51e6a54fe9f688b0e2d8b465ed229906711e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vte291-devel-0.78.7-2.el10.aarch64.rpm;name=aarch64_vte291-devel;unpack=0"
SRC_URI[aarch64_vte291-devel.sha256sum] = "1552dafd14e6c465d9043bb5d6e7ee00146b9ffd50fa01f549f5961395cf2a63"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte291-gtk4-0.78.7-2.el10.aarch64.rpm;name=aarch64_vte291-gtk4;unpack=0"
SRC_URI[aarch64_vte291-gtk4.sha256sum] = "0f799ede0e8f41f2f1bcd3d249af859572687059276a85b2a492e843dcf79f21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vte291-gtk4-devel-0.78.7-2.el10.aarch64.rpm;name=aarch64_vte291-gtk4-devel;unpack=0"
SRC_URI[aarch64_vte291-gtk4-devel.sha256sum] = "ef035795ff369631728adcf897c96fa99befb38336a2140a658f2daee488c34d"

RDEPENDS:vte-profile = " \
 glibc \
 "
RDEPENDS:vte291 = " \
 atk \
 cairo \
 cairo-gobject \
 fribidi \
 glib2 \
 glibc \
 gnutls \
 gtk3 \
 libgcc \
 libicu \
 libstdc++ \
 lz4-libs \
 pango \
 pcre2 \
 systemd-libs \
 vte-profile \
 "
RDEPENDS:vte291-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 gtk3 \
 gtk3-devel \
 libgcc \
 libstdc++ \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vte291 \
 "
RDEPENDS:vte291-gtk4 = " \
 cairo \
 cairo-gobject \
 fribidi \
 glib2 \
 glibc \
 gnutls \
 graphene \
 gtk4 \
 libgcc \
 libicu \
 libstdc++ \
 lz4-libs \
 pango \
 pcre2 \
 systemd-libs \
 vte291 \
 "
RDEPENDS:vte291-gtk4-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 gtk4 \
 gtk4-devel \
 libgcc \
 libstdc++ \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vte291-devel \
 vte291-gtk4 \
 "
