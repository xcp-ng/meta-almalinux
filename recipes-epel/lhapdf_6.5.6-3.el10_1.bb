# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lhapdf"
PV = "6.5.6"
PR = "3.el10_1"
PACKAGES = " \
 lhapdf \
 lhapdf-devel \
 lhapdf-doc \
 python3-lhapdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lhapdf-6.5.6-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3aa4c806c4bee75c0d178339b2d64266f0884266bb49174a86b4a9f110ca9034"

URI_x86_64_v2_lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-6.5.6-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf}"
SRC_URI[x86_64_v2_lhapdf.sha256sum] = "2a68bbe0de596955121bc412d06fbcac1f8688d8ff44e0cc91faae8677993139"

URI_x86_64_v2_lhapdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-devel-6.5.6-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lhapdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf-devel}"
SRC_URI[x86_64_v2_lhapdf-devel.sha256sum] = "3c7da15f87ff5dc5348dfd69310272419d2df9d9c3bfdb80b8ade8a1a2e30335"

URI_x86_64_v2_lhapdf-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-doc-6.5.6-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lhapdf-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf-doc}"
SRC_URI[x86_64_v2_lhapdf-doc.sha256sum] = "24a45e0c7ab218e0b05d6f13126b084da63c2f9692ef53fc3906a5cfee970117"

URI_x86_64_v2_python3-lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lhapdf-6.5.6-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lhapdf}"
SRC_URI[x86_64_v2_python3-lhapdf.sha256sum] = "a379208a06ba13a0e85f0e57d5f8d4d4c65ef34a31305482c97e85ab4e1c67bf"

URI_aarch64_lhapdf = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-6.5.6-3.el10_1.aarch64.rpm;name=aarch64_lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf}"
SRC_URI[aarch64_lhapdf.sha256sum] = "ae3fc601406cfb2460b63d42868f46b09c852c46c5a75902ad63bee3c8830cee"

URI_aarch64_lhapdf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-devel-6.5.6-3.el10_1.aarch64.rpm;name=aarch64_lhapdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf-devel}"
SRC_URI[aarch64_lhapdf-devel.sha256sum] = "47b7f8a4bea4ba84adfef09c9cce5fe38f58598c58f5bec7ecf559bbd5bfc281"

URI_aarch64_lhapdf-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-doc-6.5.6-3.el10_1.noarch.rpm;name=aarch64_lhapdf-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf-doc}"
SRC_URI[aarch64_lhapdf-doc.sha256sum] = "94ccd8ab1eea3c3e79ac5695a5d2e03d3ab785b275650757c5e4f6b2c268786a"

URI_aarch64_python3-lhapdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lhapdf-6.5.6-3.el10_1.aarch64.rpm;name=aarch64_python3-lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lhapdf}"
SRC_URI[aarch64_python3-lhapdf.sha256sum] = "45f03f2dc0b329a06d578b87a39bd30f008509cc59fe4eeca1f0b4054395b3d4"

RDEPENDS:lhapdf = " \
 glibc \
 libgcc \
 libstdc++ \
 yaml-cpp \
 "
RDEPENDS:lhapdf-devel = " \
 bash \
 lhapdf \
 pkgconf-pkg-config \
 yaml-cpp-devel \
 "
RDEPENDS:lhapdf-doc = " \
 "
RDEPENDS:python3-lhapdf = " \
 glibc \
 lhapdf \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 "
