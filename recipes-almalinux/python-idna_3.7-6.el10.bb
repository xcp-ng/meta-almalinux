# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-idna"
PV = "3.7"
PR = "6.el10"
PACKAGES = " \
 python3-idna \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-idna-3.7-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "94a4bc3a5b8b5461197f9d5afb480033bae484e84d92e9d6c6eeefeccb1de539"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-idna-3.7-6.el10.noarch.rpm;name=x86_64_v2_python3-idna;unpack=0"
SRC_URI[x86_64_v2_python3-idna.sha256sum] = "497db0bef47ffc57fd6d8ac82a4bdca8f104891a89b56a58a4347c4731815ed8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-idna-3.7-6.el10.noarch.rpm;name=aarch64_python3-idna;unpack=0"
SRC_URI[aarch64_python3-idna.sha256sum] = "497db0bef47ffc57fd6d8ac82a4bdca8f104891a89b56a58a4347c4731815ed8"

RDEPENDS:python3-idna = " \
 python3 \
 "
