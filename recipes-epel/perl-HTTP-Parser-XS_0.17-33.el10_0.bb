# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Parser-XS"
PV = "0.17"
PR = "33.el10_0"
PACKAGES = " \
 perl-HTTP-Parser-XS \
 perl-HTTP-Parser-XS-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTTP-Parser-XS-0.17-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ad6b476516f88935988460ab7e683362f9e58bcb262e42d350088e75ced036d"

URI_x86_64_v2_perl-HTTP-Parser-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Parser-XS-0.17-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-HTTP-Parser-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Parser-XS}"
SRC_URI[x86_64_v2_perl-HTTP-Parser-XS.sha256sum] = "398a92fab75b5dfc0d85814e58f84841b62ada4d7220cdd2577f48a7fba23213"

URI_x86_64_v2_perl-HTTP-Parser-XS-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Parser-XS-tests-0.17-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-HTTP-Parser-XS-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Parser-XS-tests}"
SRC_URI[x86_64_v2_perl-HTTP-Parser-XS-tests.sha256sum] = "1e9f6d987de1e07817673c68bed84e5768fdf756d97917479070ee59758e3cad"

URI_aarch64_perl-HTTP-Parser-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Parser-XS-0.17-33.el10_0.aarch64.rpm;name=aarch64_perl-HTTP-Parser-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Parser-XS}"
SRC_URI[aarch64_perl-HTTP-Parser-XS.sha256sum] = "56c45a96f1038061e6bae0d08d708a518d91c786a7f01a8dc9c0a8b130f38dec"

URI_aarch64_perl-HTTP-Parser-XS-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Parser-XS-tests-0.17-33.el10_0.aarch64.rpm;name=aarch64_perl-HTTP-Parser-XS-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Parser-XS-tests}"
SRC_URI[aarch64_perl-HTTP-Parser-XS-tests.sha256sum] = "9f54e1c92a1b92f3337261fb1ca55959b50db42b2e202ae298ba4fd125e25337"

RDEPENDS:perl-HTTP-Parser-XS = " \
 glibc \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-HTTP-Parser-XS-tests = " \
 perl-HTTP-Parser-XS \
 perl-Test-Harness \
 "
