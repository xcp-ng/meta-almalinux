# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gflags"
PV = "2.2.2"
PR = "16.el10_0"
PACKAGES = " \
 gflags \
 gflags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gflags-2.2.2-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "beca8613f4e13f233d528ef1bd6a60890494e2a275f182ab953d0e5f76bf2a12"

URI_x86_64_v2_gflags = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gflags-2.2.2-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gflags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gflags}"
SRC_URI[x86_64_v2_gflags.sha256sum] = "155d1eaca1a70e30eb29507ff78bce081d3803110ae3afa0bb5a7788e9bc3d37"

URI_x86_64_v2_gflags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gflags-devel-2.2.2-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gflags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gflags-devel}"
SRC_URI[x86_64_v2_gflags-devel.sha256sum] = "15a0778389ca35bfd0f906944ec0baabf82132cc8c6d1cbbd587b8001c03edd7"

URI_aarch64_gflags = "${EPEL_MIRROR}/aarch64/Packages/g/gflags-2.2.2-16.el10_0.aarch64.rpm;name=aarch64_gflags;unpack=0"
SRC_URI:append = " ${URI_aarch64_gflags}"
SRC_URI[aarch64_gflags.sha256sum] = "d3e9bf01d5e72e4f1dd3aa5536bda8865f10ae5da088d9bafe7928e1ea567450"

URI_aarch64_gflags-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gflags-devel-2.2.2-16.el10_0.aarch64.rpm;name=aarch64_gflags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gflags-devel}"
SRC_URI[aarch64_gflags-devel.sha256sum] = "b22f0c9d218d99143a3e2dbec6cdcba205ac64bc9555fbae78d89afa24a9f441"

RDEPENDS:gflags = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gflags-devel = " \
 cmake-filesystem \
 gflags \
 pkgconf-pkg-config \
 "
