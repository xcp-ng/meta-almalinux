# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "monitor-edid"
PV = "3.4"
PR = "9.el10_0"
PACKAGES = " \
 monitor-edid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/monitor-edid-3.4-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c98fc4f218b209e9b627730cdb5479b4b1fd4f8568c6b9a4652ade159a11b84d"

URI_x86_64_v2_monitor-edid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/monitor-edid-3.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_monitor-edid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_monitor-edid}"
SRC_URI[x86_64_v2_monitor-edid.sha256sum] = "657a2a37978ac0be0dbc8d29971d0b9dd780e768e5ebdb76379584eba64ba3fd"

URI_aarch64_monitor-edid = "${EPEL_MIRROR}/aarch64/Packages/m/monitor-edid-3.4-9.el10_0.aarch64.rpm;name=aarch64_monitor-edid;unpack=0"
SRC_URI:append = " ${URI_aarch64_monitor-edid}"
SRC_URI[aarch64_monitor-edid.sha256sum] = "8d4b7f09600a4c0c74f989a08f154294b366d76f9286994bac4ce640041bece3"

RDEPENDS:monitor-edid:x86_64_v2 = " \
 glibc \
 libx86 \
 perl-Data-Dumper \
 perl-File-Find \
 perl-Getopt-Long \
 perl-Parse-EDID \
 perl-interpreter \
"
RDEPENDS:monitor-edid:aarch64 = " \
 perl-Data-Dumper \
 perl-File-Find \
 perl-Getopt-Long \
 perl-Parse-EDID \
 perl-interpreter \
"
