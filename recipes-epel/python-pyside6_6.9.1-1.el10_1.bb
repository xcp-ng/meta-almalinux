# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyside6"
PV = "6.9.1"
PR = "1.el10_1"
PACKAGES = " \
 pyside6-tools \
 python3-pyside6 \
 python3-pyside6-devel \
 python3-shiboken6 \
 python3-shiboken6-devel \
 shiboken6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyside6-6.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bc09ff1b137445d965d0ad837074f92d0989c555488c3c7679732af6233ee35"

URI_x86_64_v2_pyside6-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyside6-tools-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pyside6-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyside6-tools}"
SRC_URI[x86_64_v2_pyside6-tools.sha256sum] = "d9acd0698ec4beff16c38b46820b174d5314890e7026302cb201236322dd6ffc"

URI_x86_64_v2_python3-pyside6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyside6-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyside6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyside6}"
SRC_URI[x86_64_v2_python3-pyside6.sha256sum] = "23b7be426c71de5fab4caa97ef250ec04f0771d447d552140dc135e03ed15c86"

URI_x86_64_v2_python3-pyside6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyside6-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyside6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyside6-devel}"
SRC_URI[x86_64_v2_python3-pyside6-devel.sha256sum] = "a773580f103cb808a07036ebba5c18330f509584c9330cd144af93fadb13d8b6"

URI_x86_64_v2_python3-shiboken6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-shiboken6-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-shiboken6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-shiboken6}"
SRC_URI[x86_64_v2_python3-shiboken6.sha256sum] = "6360e0ecbef3bd56b3cb52203efbbdcfec464e4748fd0d5a7bec43a268b08f4f"

URI_x86_64_v2_python3-shiboken6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-shiboken6-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-shiboken6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-shiboken6-devel}"
SRC_URI[x86_64_v2_python3-shiboken6-devel.sha256sum] = "757a05bab98fc5fc3d792ab7aadebee7ba13a8ddad350d26de18e247d8a91490"

URI_x86_64_v2_shiboken6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shiboken6-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_shiboken6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shiboken6}"
SRC_URI[x86_64_v2_shiboken6.sha256sum] = "333bcf27ac65fd573e3b4a4c1e78cc954da72c08d9fd007e300d56167ba7098b"

URI_aarch64_pyside6-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pyside6-tools-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_pyside6-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyside6-tools}"
SRC_URI[aarch64_pyside6-tools.sha256sum] = "b220f627beb3f6e0271cb554e4236cc1d88f063c1ea7e2ea57cc68783a08fed0"

URI_aarch64_python3-pyside6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyside6-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_python3-pyside6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyside6}"
SRC_URI[aarch64_python3-pyside6.sha256sum] = "8349a060eb68c443fb35b3021126e324d006193dd39ba8b9576e059df7010a7a"

URI_aarch64_python3-pyside6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyside6-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_python3-pyside6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyside6-devel}"
SRC_URI[aarch64_python3-pyside6-devel.sha256sum] = "4be0e96aa2b8301b2a23e129a04e617a7c7e23512bdaa36db3f01b126d1170fe"

URI_aarch64_python3-shiboken6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-shiboken6-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_python3-shiboken6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-shiboken6}"
SRC_URI[aarch64_python3-shiboken6.sha256sum] = "dd6ae093e1d734794e95a50e56984178f896b244cb57e821cb06c230c3afa301"

URI_aarch64_python3-shiboken6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-shiboken6-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_python3-shiboken6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-shiboken6-devel}"
SRC_URI[aarch64_python3-shiboken6-devel.sha256sum] = "779709d036e69dfd6dec062f4ca0d57fe1380ddf08faa02f51558f98124c8414"

URI_aarch64_shiboken6 = "${EPEL_MIRROR}/aarch64/Packages/s/shiboken6-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_shiboken6;unpack=0"
SRC_URI:append = " ${URI_aarch64_shiboken6}"
SRC_URI[aarch64_shiboken6.sha256sum] = "3bb5cf90510355513103fe63aac1e1d68bcdedcda1321be88b6e5b85eb8e8f45"

RDEPENDS:pyside6-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 qt6-assistant \
 qt6-designer \
 qt6-linguist \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:python3-pyside6 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-shiboken6 \
 qt6-qt3d \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtconnectivity \
 qt6-qtdatavis3d \
 qt6-qtdeclarative \
 qt6-qtgraphs \
 qt6-qthttpserver \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtnetworkauth \
 qt6-qtpdf \
 qt6-qtpositioning \
 qt6-qtquick3d \
 qt6-qtremoteobjects \
 qt6-qtscxml \
 qt6-qtsensors \
 qt6-qtserialbus \
 qt6-qtserialport \
 qt6-qtspeech \
 qt6-qtsvg \
 qt6-qttools \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-help \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 qt6-qtwebsockets \
 qt6-qtwebview \
 "
RDEPENDS:python3-pyside6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pyside6-tools \
 python3-pyside6 \
 python3-shiboken6-devel \
 shiboken6 \
 "
RDEPENDS:python3-shiboken6 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 "
RDEPENDS:python3-shiboken6-devel = " \
 clang-libs \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 libxslt \
 pkgconf-pkg-config \
 python3 \
 python3-shiboken6 \
 qt6-qtbase \
 shiboken6 \
 "
RDEPENDS:shiboken6 = " \
 cmake-filesystem \
 "
