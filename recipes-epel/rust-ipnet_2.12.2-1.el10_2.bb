# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ipnet"
PV = "2.12.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-ipnet+default-devel \
 rust-ipnet+heapless-devel \
 rust-ipnet+schemars08-devel \
 rust-ipnet+schemars1-devel \
 rust-ipnet+ser_as_str-devel \
 rust-ipnet+serde-devel \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ipnet-2.12.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "567df876c00c8099919424d706265d8394219d38219fa23e3969e895196fef62"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+default-devel-2.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+default-devel.sha256sum] = "f0c12762ad93b59b19ab33235664f9457827c2c43e36f512951f8c1560899b0c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+heapless-devel-2.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+heapless-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+heapless-devel.sha256sum] = "8cc5a249a3a9cc44a787f60ca587985921c5b10988b68cd5b4d2d797d29cfd3b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+schemars08-devel-2.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+schemars08-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+schemars08-devel.sha256sum] = "0270c91451f833822c270b3355c282a2ab95dde64b6e6040ce0ca2d63746090e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+schemars1-devel-2.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+schemars1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+schemars1-devel.sha256sum] = "6134e105777e715d5ca90fab0ed6f229b6a0a5f94877c62773b6913d972e863b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+ser_as_str-devel-2.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+ser_as_str-devel.sha256sum] = "8f22633b92ce9392d85c4506b576662f79fb9fade32947f52dd5dace677ae5ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+serde-devel-2.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+serde-devel.sha256sum] = "2ead1f40f18e6d85bb168e030ca8277ad3674863b4ad37c60f8bc48f2f1cbe97"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet+std-devel-2.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet+std-devel.sha256sum] = "16bd9375b36a28ccb6fe8cce97b322efb02109a463b1bbf870c1aee6e782b228"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ipnet-devel-2.12.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ipnet-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ipnet-devel.sha256sum] = "ed4776f95e1c27e732bbdb53287e987b8e6e821e1a55af39b16bb8bf0773fcf3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+default-devel-2.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+default-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+default-devel.sha256sum] = "660d8c14f9f9dcba7d68d6ebd7a1c1d0013738cef37a06d2655f30642e61f85f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+heapless-devel-2.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+heapless-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+heapless-devel.sha256sum] = "a45aee0cf228d28fc7849aacbd976b745a17ddb73c7932d6076c779af951ad82"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+schemars08-devel-2.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+schemars08-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+schemars08-devel.sha256sum] = "e576e0a6edc381ee4cee638387b37563fc9ca781eda7b9ef79ef4294cd0dad04"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+schemars1-devel-2.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+schemars1-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+schemars1-devel.sha256sum] = "bbe4df8bb3102a799a7a65b62384015c3e5d1d372d0c5b862436f6122599a52b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+ser_as_str-devel-2.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+ser_as_str-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+ser_as_str-devel.sha256sum] = "a4279af50d3864dde72d57049bce52328e5a2f848d72e775bd9ecb8a25a3261d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+serde-devel-2.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+serde-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+serde-devel.sha256sum] = "6842e70816af042c64f0c0d35e286ad2bb36358eb99935499c47cf4cc9b9344e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet+std-devel-2.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet+std-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet+std-devel.sha256sum] = "5de6d2d1ea86ce44bfab3d11809fafe8db29d2f622dca538b934256e046051ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ipnet-devel-2.12.2-1.el10_2.noarch.rpm;name=aarch64_rust-ipnet-devel;unpack=0"
SRC_URI[aarch64_rust-ipnet-devel.sha256sum] = "561ee4baf59f0b6399ddc0b2a40760bfbad3f6d0c4f4060510e830c6c1dbb91f"

RDEPENDS:rust-ipnet+default-devel = " \
 cargo \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet+heapless-devel = " \
 cargo \
 rust-ipnet+serde-devel \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+schemars08-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-schemars0.8-devel \
 "
RDEPENDS:rust-ipnet+schemars1-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-ipnet+ser_as_str-devel = " \
 cargo \
 rust-ipnet-devel \
 virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~ \
 "
RDEPENDS:rust-ipnet+serde-devel = " \
 cargo \
 rust-ipnet-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ipnet+std-devel = " \
 cargo \
 rust-ipnet-devel \
 "
RDEPENDS:rust-ipnet-devel = " \
 cargo \
 "
