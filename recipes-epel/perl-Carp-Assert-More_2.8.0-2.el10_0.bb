# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Carp-Assert-More"
PV = "2.8.0"
PR = "2.el10_0"
PACKAGES = " \
 perl-Carp-Assert-More \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Carp-Assert-More-2.8.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74b71733b8b54fa2bd4ecfaa86b189bc7ae91a2802c6491f20c55dc024df9a00"

URI_x86_64_v2_perl-Carp-Assert-More = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Carp-Assert-More-2.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Carp-Assert-More;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Carp-Assert-More}"
SRC_URI[x86_64_v2_perl-Carp-Assert-More.sha256sum] = "c6d23b59037aca925aeeba2755cd6faa0daf2a2924e1d4e428a18af29f91c12a"

URI_aarch64_perl-Carp-Assert-More = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Carp-Assert-More-2.8.0-2.el10_0.noarch.rpm;name=aarch64_perl-Carp-Assert-More;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Carp-Assert-More}"
SRC_URI[aarch64_perl-Carp-Assert-More.sha256sum] = "e41a80199aa5c7e17f2569a10e80f8ea1a1b2ef7092a770d77662ae8a17f941d"

RDEPENDS:perl-Carp-Assert-More = " \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-parent \
 perl-vars \
 "
