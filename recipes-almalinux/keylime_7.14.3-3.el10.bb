# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keylime"
PV = "7.14.3"
PR = "3.el10"
PACKAGES = " \
 keylime \
 keylime-base \
 keylime-registrar \
 keylime-selinux \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keylime-7.14.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bcfede43bb896ce525679b553f80f9da1ee76db4896f523bf6b02b13c75952a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-7.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_keylime;unpack=0"
SRC_URI[x86_64_v2_keylime.sha256sum] = "bf7490a17ac75100cd325d1b10c99ebb0befdc678c3ac201605a3049f15da7ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-base-7.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-base;unpack=0"
SRC_URI[x86_64_v2_keylime-base.sha256sum] = "20e48ae05ea037f4734b3dff22b9fd235f8fa0842e6f7d9af7dd765dfd740f7a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-registrar-7.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-registrar;unpack=0"
SRC_URI[x86_64_v2_keylime-registrar.sha256sum] = "908d722cc19d83cb7de6a07d00b51fd894e87352b0e5390936dce28b155f3e22"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-selinux-7.14.3-3.el10.noarch.rpm;name=x86_64_v2_keylime-selinux;unpack=0"
SRC_URI[x86_64_v2_keylime-selinux.sha256sum] = "b1a2f6ed2096a0e029c4207b8f171aa1dadcc4e2e7b8c42eacc0a3a21093ae18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-tenant-7.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-tenant;unpack=0"
SRC_URI[x86_64_v2_keylime-tenant.sha256sum] = "63f546bc5cba2c876ab811d70d5fc38308aacfc17c1ce0ad25570a0c3108a790"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-tools-7.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-tools;unpack=0"
SRC_URI[x86_64_v2_keylime-tools.sha256sum] = "613ab7d9ef5d5bf4e065fe01dd119d0d0dee4e5fdc564971a4435f60070a81fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-verifier-7.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-verifier;unpack=0"
SRC_URI[x86_64_v2_keylime-verifier.sha256sum] = "a62f49b114ac68b39715605192f36bdabb2da575d14ea23b34af826b762b0f83"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-keylime-7.14.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-keylime;unpack=0"
SRC_URI[x86_64_v2_python3-keylime.sha256sum] = "f893c5fca8c9b97608cd062eb2557439fbefd56ea64bf784593db3193cbef501"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-7.14.3-3.el10.aarch64.rpm;name=aarch64_keylime;unpack=0"
SRC_URI[aarch64_keylime.sha256sum] = "882aeda995eb103707aaf1f9839ecf4443a44d36366578873b07ce42e7d5d52a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-base-7.14.3-3.el10.aarch64.rpm;name=aarch64_keylime-base;unpack=0"
SRC_URI[aarch64_keylime-base.sha256sum] = "c57ad4f343be58c795f85d95fe048c164dac2bceb78c085103dbcefb5e93a5a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-registrar-7.14.3-3.el10.aarch64.rpm;name=aarch64_keylime-registrar;unpack=0"
SRC_URI[aarch64_keylime-registrar.sha256sum] = "7b2565ff3dd97c20b74133835e2e6e129c9ee0f0b0e2ead10c884da7b08804af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-selinux-7.14.3-3.el10.noarch.rpm;name=aarch64_keylime-selinux;unpack=0"
SRC_URI[aarch64_keylime-selinux.sha256sum] = "b1a2f6ed2096a0e029c4207b8f171aa1dadcc4e2e7b8c42eacc0a3a21093ae18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-tenant-7.14.3-3.el10.aarch64.rpm;name=aarch64_keylime-tenant;unpack=0"
SRC_URI[aarch64_keylime-tenant.sha256sum] = "220ce2ef6f40214820ed8677d8952b397ba81d5c7363738bc1a8995d1c1368dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-tools-7.14.3-3.el10.aarch64.rpm;name=aarch64_keylime-tools;unpack=0"
SRC_URI[aarch64_keylime-tools.sha256sum] = "17151a52fc31048a3fecafc485c781053ceb875050de7aca56e5d249baddd6eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-verifier-7.14.3-3.el10.aarch64.rpm;name=aarch64_keylime-verifier;unpack=0"
SRC_URI[aarch64_keylime-verifier.sha256sum] = "935e577808dea9a490f5432de1b5d47c7b827c62fdfe057e6b531d05e240e876"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-keylime-7.14.3-3.el10.aarch64.rpm;name=aarch64_python3-keylime;unpack=0"
SRC_URI[aarch64_python3-keylime.sha256sum] = "af55b30e2b4649536fd11bd6855e96e35e7f12fb923834b0a340ca0413468a33"

RDEPENDS:keylime = " \
 keylime-base \
 keylime-registrar \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
 virtual/keylime-agent \
 "
RDEPENDS:keylime-base = " \
 bash \
 efivar-libs \
 openssl \
 procps-ng \
 python3 \
 python3-jinja2 \
 shadow-utils \
 tpm2-tss \
 "
RDEPENDS:keylime-registrar = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:keylime-tenant = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-tools = " \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-verifier = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:python3-keylime = " \
 keylime-base \
 python3 \
 python3-alembic \
 python3-cryptography \
 python3-gpg \
 python3-jsonschema \
 python3-lark \
 python3-packaging \
 python3-psutil \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyyaml \
 python3-requests \
 python3-sqlalchemy \
 python3-tornado \
 python3-typing-extensions \
 tpm2-tools \
 "
