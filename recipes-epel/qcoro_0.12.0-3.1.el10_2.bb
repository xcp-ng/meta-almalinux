# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qcoro"
PV = "0.12.0"
PR = "3.1.el10_2"
PACKAGES = " \
 qcoro-qt5 \
 qcoro-qt5-devel \
 qcoro-qt6 \
 qcoro-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qcoro-0.12.0-3.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b0f7bef20a72dc6235448e33fb491b58032a4d2fafb2312b2d7bf426d9befd0"

URI_x86_64_v2_qcoro-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt5-0.12.0-3.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt5}"
SRC_URI[x86_64_v2_qcoro-qt5.sha256sum] = "321b18fcad909c1ff1b880327204d47dedef3097fa230c3aef6aaa7f0c8433f4"

URI_x86_64_v2_qcoro-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt5-devel-0.12.0-3.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt5-devel}"
SRC_URI[x86_64_v2_qcoro-qt5-devel.sha256sum] = "90d646a31e5e8773e932040ac55bed290b304c338a5c6888c36a8b992d7b3982"

URI_x86_64_v2_qcoro-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt6-0.12.0-3.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt6}"
SRC_URI[x86_64_v2_qcoro-qt6.sha256sum] = "26bbf39cafefe3d965e81b6a9a98f4d391a15c15e7851093446248f32c441224"

URI_x86_64_v2_qcoro-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt6-devel-0.12.0-3.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt6-devel}"
SRC_URI[x86_64_v2_qcoro-qt6-devel.sha256sum] = "338861a4729eb7bdac11d7c543c57f1210613acbccdc287b22e28cae3e16ecf4"

URI_aarch64_qcoro-qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt5-0.12.0-3.1.el10_2.aarch64.rpm;name=aarch64_qcoro-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt5}"
SRC_URI[aarch64_qcoro-qt5.sha256sum] = "fd0af2ed85fac89ba6a5974db90776f85583a96c06ce316f65223961123589e4"

URI_aarch64_qcoro-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt5-devel-0.12.0-3.1.el10_2.aarch64.rpm;name=aarch64_qcoro-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt5-devel}"
SRC_URI[aarch64_qcoro-qt5-devel.sha256sum] = "f51fc321292b70b8bd2ebc49bd0897df0a150f19a084b399e657e9fad1c53c4a"

URI_aarch64_qcoro-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt6-0.12.0-3.1.el10_2.aarch64.rpm;name=aarch64_qcoro-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt6}"
SRC_URI[aarch64_qcoro-qt6.sha256sum] = "8ef7ad22acf9ba015854600f3b4f14e10ff9d286e62d4258221fcd15f50befef"

URI_aarch64_qcoro-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt6-devel-0.12.0-3.1.el10_2.aarch64.rpm;name=aarch64_qcoro-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt6-devel}"
SRC_URI[aarch64_qcoro-qt6-devel.sha256sum] = "95498cc06641fcafa1e917945eb3578e5b8db9ea9b2bb14388f348c6802c3284"

RDEPENDS:qcoro-qt5 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwebsockets \
 "
RDEPENDS:qcoro-qt5-devel = " \
 cmake-filesystem \
 qcoro-qt5 \
 qt5-qtbase-devel \
 "
RDEPENDS:qcoro-qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:qcoro-qt6-devel = " \
 cmake-filesystem \
 qcoro-qt6 \
 qt6-qtbase-devel \
 "
