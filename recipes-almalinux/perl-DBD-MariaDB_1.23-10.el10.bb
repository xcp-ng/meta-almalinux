# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBD-MariaDB"
PV = "1.23"
PR = "10.el10"
PACKAGES = " \
 perl-DBD-MariaDB \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-DBD-MariaDB-1.23-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ecc052b0aa658374a8fe2fd6a656d4524e285a11558add62eda68d04643ab87"

URI_x86_64_v2_perl-DBD-MariaDB = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBD-MariaDB-1.23-10.el10.x86_64_v2.rpm;name=x86_64_v2_perl-DBD-MariaDB;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DBD-MariaDB}"
SRC_URI[x86_64_v2_perl-DBD-MariaDB.sha256sum] = "07c24b7ee07c113ef653ee3d70bf8856b27847fd59059d4fbc78cda086081528"

URI_aarch64_perl-DBD-MariaDB = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBD-MariaDB-1.23-10.el10.aarch64.rpm;name=aarch64_perl-DBD-MariaDB;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DBD-MariaDB}"
SRC_URI[aarch64_perl-DBD-MariaDB.sha256sum] = "2005e6f602ca354174b8887ccdd8c68ebcb89651a2bc5015bd182747d68aba1f"

RDEPENDS:perl-DBD-MariaDB = " \
 glibc \
 mariadb-connector-c \
 perl-DBI \
 perl-DynaLoader \
 perl-libs \
 "
