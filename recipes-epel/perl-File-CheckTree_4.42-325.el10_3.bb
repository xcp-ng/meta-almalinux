# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-CheckTree"
PV = "4.42"
PR = "325.el10_3"
PACKAGES = " \
 perl-File-CheckTree \
 perl-File-CheckTree-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-File-CheckTree-4.42-325.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "58543dce25a74ffd807ea962a031845c4d5ba0f863fec48724b8b943459c9994"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-CheckTree-4.42-325.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-CheckTree;unpack=0"
SRC_URI[x86_64_v2_perl-File-CheckTree.sha256sum] = "563dde8e7f8712f846995e4a5668519be5ed7ff5a581b89a69da58fac2d07ee4"
RPROVIDES:perl-File-CheckTree:append:x86_64_v2 = " virtual/perl_File__CheckTree_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-CheckTree-tests-4.42-325.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-CheckTree-tests;unpack=0"
SRC_URI[x86_64_v2_perl-File-CheckTree-tests.sha256sum] = "4912b9f68acd9ef1ba7a1045ede64e1ea6d608e7db0438f6e2645711e82a7ee9"
RPROVIDES:perl-File-CheckTree-tests:append:x86_64_v2 = " virtual/perl_File__CheckTree_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-File-CheckTree-4.42-325.el10_3.noarch.rpm;name=aarch64_perl-File-CheckTree;unpack=0"
SRC_URI[aarch64_perl-File-CheckTree.sha256sum] = "29d113aac797e599b299177bc012823e80607fa6a834f9a350841bd8990374fc"
RPROVIDES:perl-File-CheckTree:append:aarch64 = " virtual/perl_File__CheckTree_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-File-CheckTree-tests-4.42-325.el10_3.noarch.rpm;name=aarch64_perl-File-CheckTree-tests;unpack=0"
SRC_URI[aarch64_perl-File-CheckTree-tests.sha256sum] = "117ca4a07961af0a56a0809df5155d638e4bfb4bad688ee67390b11af10af3dd"
RPROVIDES:perl-File-CheckTree-tests:append:aarch64 = " virtual/perl_File__CheckTree_"

RDEPENDS:perl-File-CheckTree = " \
 perl-Exporter \
 perl-PathTools \
 perl-deprecate \
 perl-if \
 perl-libs \
 "
RDEPENDS:perl-File-CheckTree-tests = " \
 bash \
 perl-Exporter \
 perl-File-CheckTree \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-if \
 perl-interpreter \
 perl-libs \
 perl-overload \
 virtual/perl_File__CheckTree_ \
 "
