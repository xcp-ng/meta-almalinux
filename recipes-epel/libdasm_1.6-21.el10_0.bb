# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdasm"
PV = "1.6"
PR = "21.el10_0"
PACKAGES = " \
 libdasm \
 libdasm-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libdasm-1.6-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5a2ba8aab1e952e7bb4578d074de5fb1985b7638dc5e75453104bb277428e72a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdasm-1.6-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdasm;unpack=0"
SRC_URI[x86_64_v2_libdasm.sha256sum] = "b3178e0b43add87a886cf68411f305715d4c1324b37ea3aba0d88434224f4300"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdasm-devel-1.6-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdasm-devel;unpack=0"
SRC_URI[x86_64_v2_libdasm-devel.sha256sum] = "734964891244e921bbeff6ba3ef3ba0074a096ef3099311e58f42b5ff012ca71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdasm-1.6-21.el10_0.aarch64.rpm;name=aarch64_libdasm;unpack=0"
SRC_URI[aarch64_libdasm.sha256sum] = "7f3f80a8da391eb3f4f6837af6369b9c664745412e3a154c5e46b9fe50576853"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdasm-devel-1.6-21.el10_0.aarch64.rpm;name=aarch64_libdasm-devel;unpack=0"
SRC_URI[aarch64_libdasm-devel.sha256sum] = "09fea0c0faedc0534017bce38eddc02234bab973bf2bbcad8632576cc528c54e"

RDEPENDS:libdasm = " \
 glibc \
 "
RDEPENDS:libdasm-devel = " \
 libdasm \
 "
