# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isa-l"
PV = "2.32.1"
PR = "1.el10_3"
PACKAGES = " \
 isa-l \
 isa-l-devel \
 isa-l-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/isa-l-2.32.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fa26a87cf63fa99f17586b1a4a0f70c1ae0b21865a3f0a58a7034d6b6640425"

URI_x86_64_v2_isa-l = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-2.32.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l}"
SRC_URI[x86_64_v2_isa-l.sha256sum] = "c348f90c1f6c14b1eea1be3fbd09a9816a0349907cb09dc67a6c6bd850e5179d"

URI_x86_64_v2_isa-l-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-devel-2.32.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l-devel}"
SRC_URI[x86_64_v2_isa-l-devel.sha256sum] = "d38bc9ed4863068e5d34086e9820f19faf1412047e9df8c9140cb4a377aa12d2"

URI_x86_64_v2_isa-l-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-tools-2.32.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l-tools}"
SRC_URI[x86_64_v2_isa-l-tools.sha256sum] = "7ca0f778b8e6655f78790df159426a5f2fe71686f72185a6248ba8569e1f42d7"

URI_aarch64_isa-l = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-2.32.1-1.el10_3.aarch64.rpm;name=aarch64_isa-l;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l}"
SRC_URI[aarch64_isa-l.sha256sum] = "fe6084bd3685e6f9b8fa01af7fd3509da4c0c7362f467443daa1cce83a75e02a"

URI_aarch64_isa-l-devel = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-devel-2.32.1-1.el10_3.aarch64.rpm;name=aarch64_isa-l-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l-devel}"
SRC_URI[aarch64_isa-l-devel.sha256sum] = "7dd5a683713fc62899867ccbeab892c00419a8b3cef3334be56f1ae552818e7f"

URI_aarch64_isa-l-tools = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-tools-2.32.1-1.el10_3.aarch64.rpm;name=aarch64_isa-l-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l-tools}"
SRC_URI[aarch64_isa-l-tools.sha256sum] = "52ae03ab4b8a25d61b2d964da539d04e213cfcc9f3fc2016101a7ec2551d45ac"

RDEPENDS:isa-l = " \
 glibc \
 "
RDEPENDS:isa-l-devel = " \
 isa-l \
 pkgconf-pkg-config \
 "
RDEPENDS:isa-l-tools = " \
 glibc \
 isa-l \
 "
