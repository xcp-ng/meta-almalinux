# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dracut-sshd"
PV = "0.7.1"
PR = "1.el10_1"
PACKAGES = " \
 dracut-sshd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dracut-sshd-0.7.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58b11affb62f8bb31b3bc2341d5036cf0cf1a6bce7d67fbe955a633b77f1cff1"

URI_x86_64_v2_dracut-sshd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-sshd-0.7.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-sshd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-sshd}"
SRC_URI[x86_64_v2_dracut-sshd.sha256sum] = "9e63ac54a76adc2e3b7aec29204441d18ef28053737b349915d161515dc20756"

URI_aarch64_dracut-sshd = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-sshd-0.7.1-1.el10_1.noarch.rpm;name=aarch64_dracut-sshd;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-sshd}"
SRC_URI[aarch64_dracut-sshd.sha256sum] = "4e8db622c12b2e65e601a1f02c5a1c1712955ca0c0a7609eb6b45a083d499aa0"

RDEPENDS:dracut-sshd = " \
 bash \
 dracut \
 openssh-server \
 "
