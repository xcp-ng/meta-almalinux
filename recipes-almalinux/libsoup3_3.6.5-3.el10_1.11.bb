# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsoup3"
PV = "3.6.5"
PR = "3.el10_1.11"
PACKAGES = " \
 libsoup3 \
 libsoup3-devel \
 libsoup3-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsoup3-3.6.5-3.el10_1.11.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "651467da39bd355734066b60151bfbd3e60a023f18c932d03d91374b3e31a78c"

URI_x86_64_v2_libsoup3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsoup3-3.6.5-3.el10_1.11.x86_64_v2.rpm;name=x86_64_v2_libsoup3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsoup3}"
SRC_URI[x86_64_v2_libsoup3.sha256sum] = "2996fe5b1224ad52e8f29c35d054235efc0abc1eb9252aeaf96ba900d9bed95e"

URI_x86_64_v2_libsoup3-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsoup3-devel-3.6.5-3.el10_1.11.x86_64_v2.rpm;name=x86_64_v2_libsoup3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsoup3-devel}"
SRC_URI[x86_64_v2_libsoup3-devel.sha256sum] = "c5342d1bee7ed7f2767ffcc9aebe1ca26229789892817ab58529834c10592b05"

URI_x86_64_v2_libsoup3-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsoup3-doc-3.6.5-3.el10_1.11.noarch.rpm;name=x86_64_v2_libsoup3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsoup3-doc}"
SRC_URI[x86_64_v2_libsoup3-doc.sha256sum] = "ddbf5771fe4042e2e5ad17e58df1bbc5546ec7fbda1024158f0ab6750669fbe9"

URI_aarch64_libsoup3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsoup3-3.6.5-3.el10_1.11.aarch64.rpm;name=aarch64_libsoup3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsoup3}"
SRC_URI[aarch64_libsoup3.sha256sum] = "4f39069f5703e56da320fb8a93792d03457c3d022f7909f451665d9bad454da2"

URI_aarch64_libsoup3-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsoup3-devel-3.6.5-3.el10_1.11.aarch64.rpm;name=aarch64_libsoup3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsoup3-devel}"
SRC_URI[aarch64_libsoup3-devel.sha256sum] = "2a7fbae2c6daa0fb7a3acae86927dd815d9be785ea411a272e85809beabad8b6"

URI_aarch64_libsoup3-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsoup3-doc-3.6.5-3.el10_1.11.noarch.rpm;name=aarch64_libsoup3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsoup3-doc}"
SRC_URI[aarch64_libsoup3-doc.sha256sum] = "ddbf5771fe4042e2e5ad17e58df1bbc5546ec7fbda1024158f0ab6750669fbe9"

RDEPENDS:libsoup3 = " \
 glib2 \
 glibc \
 krb5-libs \
 libbrotli \
 libnghttp2 \
 libpsl \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:libsoup3-devel = " \
 brotli-devel \
 glib2-devel \
 krb5-devel \
 libnghttp2-devel \
 libpsl-devel \
 libsoup3 \
 pkgconf-pkg-config \
 sqlite-devel \
 sysprof-capture-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libsoup3-doc = " \
 "
