# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isa-l"
PV = "2.32.0"
PR = "1.el10_1"
PACKAGES = " \
 isa-l \
 isa-l-devel \
 isa-l-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/isa-l-2.32.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7af5e1b7013e46c1fc4a84ed3bd3268a7ccff9251752e0e1d63eb93e3d343529"

URI_x86_64_v2_isa-l = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-2.32.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l}"
SRC_URI[x86_64_v2_isa-l.sha256sum] = "3cd4e18cb89cedf23e9fed5b2b9bff06e2a1eaadfdef28fbdf32ed8b9a42a511"

URI_x86_64_v2_isa-l-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-devel-2.32.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l-devel}"
SRC_URI[x86_64_v2_isa-l-devel.sha256sum] = "b3cbb0e5d976e81343bcc1fbe2368cc6cecbea420288512af0d05ea649e13f98"

URI_x86_64_v2_isa-l-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isa-l-tools-2.32.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isa-l-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isa-l-tools}"
SRC_URI[x86_64_v2_isa-l-tools.sha256sum] = "160bc59b4ebd8d8794a1dd6deb8d88609f56c8d43d45b3faa563e4c4e0cf16be"

URI_aarch64_isa-l = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-2.32.0-1.el10_1.aarch64.rpm;name=aarch64_isa-l;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l}"
SRC_URI[aarch64_isa-l.sha256sum] = "20470f98087856c2b4aba7a8b42171f16089bc16d0aea45fd147ec520e0e05cb"

URI_aarch64_isa-l-devel = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-devel-2.32.0-1.el10_1.aarch64.rpm;name=aarch64_isa-l-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l-devel}"
SRC_URI[aarch64_isa-l-devel.sha256sum] = "7013dae514b75bc21a0d48c63d2ebaf2f207366371d07b27c3ae225455c9c494"

URI_aarch64_isa-l-tools = "${EPEL_MIRROR}/aarch64/Packages/i/isa-l-tools-2.32.0-1.el10_1.aarch64.rpm;name=aarch64_isa-l-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_isa-l-tools}"
SRC_URI[aarch64_isa-l-tools.sha256sum] = "3ac38bf9eaf6be5504c52af459472b11c9efd9ac19b2764f2662af5c8a740c26"

RDEPENDS:isa-l = " \
 glibc \
 "
RDEPENDS:isa-l-devel = " \
 isa-l \
 pkgconf-pkg-config \
 "
RDEPENDS:isa-l-tools = " \
 glibc \
 isa-l \
 "
