# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-test"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-test+default-devel \
 rust-futures-test+std-devel \
 rust-futures-test-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-test-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e566e89d9ec9364c4704de5dc11121bb291260899062730264a3b12fcf55ae51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-test+default-devel.sha256sum] = "8d2da65b27ea80095bb1ecb05b26078036d03c48edefa824f738da42e95fba2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test+std-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-test+std-devel.sha256sum] = "38386afcbf33059ee15e3001003bed69166c5f35c9bfcc5619821c8b6ac841be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-test-devel.sha256sum] = "17e3c2ba24b0e46a36dbd7f431566c72b0f753de57208ca8c11abbbea52a5ab5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-test+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures-test+default-devel.sha256sum] = "675cf6954030b4da162bfcd1a61faf0cebbefb3c760e00b68434c82d40b32cb8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test+std-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-test+std-devel;unpack=0"
SRC_URI[aarch64_rust-futures-test+std-devel.sha256sum] = "af26e320c793cc3ceb2a988bf13390fcada771d7b521ca147f6aac25f8a71da6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-test-devel;unpack=0"
SRC_URI[aarch64_rust-futures-test-devel.sha256sum] = "1ac08080d0359f79a85600abc422852b4410489f8f2c7e091c453b2842f0a070"

RDEPENDS:rust-futures-test+default-devel = " \
 cargo \
 rust-futures-test+std-devel \
 rust-futures-test-devel \
 "
RDEPENDS:rust-futures-test+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-executor+std-devel \
 rust-futures-io+std-devel \
 rust-futures-task+std-devel \
 rust-futures-test-devel \
 rust-futures-util+io-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures-test-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-executor-devel \
 rust-futures-io-devel \
 rust-futures-macro-devel \
 rust-futures-sink-devel \
 rust-futures-task-devel \
 rust-futures-util-devel \
 rust-pin-project+default-devel \
 "
