# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vapoursynth"
PV = "68"
PR = "7.el10_0"
PACKAGES = " \
 python3-vapoursynth \
 vapoursynth-devel \
 vapoursynth-libs \
 vapoursynth-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vapoursynth-68-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96982e7c0c3fd128576c06eb2d73d1b89d63d0859c2738f8dc136c11598f5fe8"

URI_x86_64_v2_python3-vapoursynth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vapoursynth-68-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-vapoursynth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vapoursynth}"
SRC_URI[x86_64_v2_python3-vapoursynth.sha256sum] = "3421a34791d13dfab08a92733089b13a5bafa0580f08c38abbf90b8ac6953cdd"

URI_x86_64_v2_vapoursynth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vapoursynth-devel-68-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vapoursynth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vapoursynth-devel}"
SRC_URI[x86_64_v2_vapoursynth-devel.sha256sum] = "842356c40f20b5d0deeb7868dc68e6add90717ae83e128aaef9e8923c84df718"

URI_x86_64_v2_vapoursynth-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vapoursynth-libs-68-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vapoursynth-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vapoursynth-libs}"
SRC_URI[x86_64_v2_vapoursynth-libs.sha256sum] = "ae6ee081910bb7c1bb1d9ba1816edf35a6b04dc4b9a3f72642c38cae1f8b9d64"

URI_x86_64_v2_vapoursynth-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vapoursynth-tools-68-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vapoursynth-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vapoursynth-tools}"
SRC_URI[x86_64_v2_vapoursynth-tools.sha256sum] = "143472eab5501181e76bf7cc3a1a6a46a382fb1190ed8bdf3f30d32cd634bb06"

URI_aarch64_python3-vapoursynth = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vapoursynth-68-7.el10_0.aarch64.rpm;name=aarch64_python3-vapoursynth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vapoursynth}"
SRC_URI[aarch64_python3-vapoursynth.sha256sum] = "d1f9687ece10fe5a0926afde8f0eb8c5b4900913c383e81d5d0a54341818b0c9"

URI_aarch64_vapoursynth-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vapoursynth-devel-68-7.el10_0.aarch64.rpm;name=aarch64_vapoursynth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vapoursynth-devel}"
SRC_URI[aarch64_vapoursynth-devel.sha256sum] = "7d5a0d39ce55623c7cecf20d022d46a9ac26e31d80569e0c42e31d63a11c31ae"

URI_aarch64_vapoursynth-libs = "${EPEL_MIRROR}/aarch64/Packages/v/vapoursynth-libs-68-7.el10_0.aarch64.rpm;name=aarch64_vapoursynth-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_vapoursynth-libs}"
SRC_URI[aarch64_vapoursynth-libs.sha256sum] = "ecb317341532cfa10a45dc242f33efb1960626a3485e2f1e7805c7f06113cf81"

URI_aarch64_vapoursynth-tools = "${EPEL_MIRROR}/aarch64/Packages/v/vapoursynth-tools-68-7.el10_0.aarch64.rpm;name=aarch64_vapoursynth-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vapoursynth-tools}"
SRC_URI[aarch64_vapoursynth-tools.sha256sum] = "a2104aed6c597409b7e223199db21c9ae3e41697071ea678dc36979ee0c86602"

RDEPENDS:python3-vapoursynth = " \
 glibc \
 python3 \
 vapoursynth-libs \
 zimg \
 "
RDEPENDS:vapoursynth-devel = " \
 pkgconf-pkg-config \
 python3-devel \
 vapoursynth-devel \
 vapoursynth-libs \
 zimg-devel \
 "
RDEPENDS:vapoursynth-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 zimg \
 "
RDEPENDS:vapoursynth-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-vapoursynth \
 vapoursynth-libs \
 "
