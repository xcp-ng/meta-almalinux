# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-parse-integer"
PV = "1.0.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-lexical-parse-integer+compact-devel \
 rust-lexical-parse-integer+default-devel \
 rust-lexical-parse-integer+format-devel \
 rust-lexical-parse-integer+lint-devel \
 rust-lexical-parse-integer+power-of-two-devel \
 rust-lexical-parse-integer+radix-devel \
 rust-lexical-parse-integer+std-devel \
 rust-lexical-parse-integer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-parse-integer-1.0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e423d94128c3758896edd5d5ac697e1a38e814e00383478db56b58e043d0d9c"

URI_x86_64_v2_rust-lexical-parse-integer+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+compact-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+compact-devel.sha256sum] = "30a8c9a325fc914b67f632dc87d657721874d4e54f6c2e68392d58aca52f0903"

URI_x86_64_v2_rust-lexical-parse-integer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+default-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+default-devel.sha256sum] = "dab7c59340c557f7629efdd8b2a15ddec1e6d082c9a93ec9afe18d86373e6191"

URI_x86_64_v2_rust-lexical-parse-integer+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+format-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+format-devel.sha256sum] = "74e4afbdda14581a33108dfe3bc3bdbc3eabde0f897c75f9e785f84a7802a266"

URI_x86_64_v2_rust-lexical-parse-integer+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+lint-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+lint-devel.sha256sum] = "5fd71edb4c43b58f02e80fd5949cf18e511d0d68a686b2efefc9d4f8f6a77995"

URI_x86_64_v2_rust-lexical-parse-integer+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+power-of-two-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+power-of-two-devel.sha256sum] = "71fdeee14215cb32fe8b1d52e6c70898a07efcb96e8e8707dd1f7bbf9a8dcdb5"

URI_x86_64_v2_rust-lexical-parse-integer+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+radix-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+radix-devel.sha256sum] = "ec96ef37e773c9a2bc72f390f73b118a3cf698444c20582a2f7bd4f3c5f50495"

URI_x86_64_v2_rust-lexical-parse-integer+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+std-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+std-devel.sha256sum] = "8e86c8db4b85d693c8b97522bcc9afd006791a69ebbf7bb3679dd73bc312e5e2"

URI_x86_64_v2_rust-lexical-parse-integer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer-devel.sha256sum] = "9aac4ee0ef5218316226b6dc9896b87867cd4d71b78d51e2328bddc4d174087a"

URI_aarch64_rust-lexical-parse-integer+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+compact-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-integer+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+compact-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+compact-devel.sha256sum] = "9b91895534e6b02ef1cea5f1516fa4dbdd80868fd08e005ed973b16764cc7063"

URI_aarch64_rust-lexical-parse-integer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+default-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+default-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+default-devel.sha256sum] = "6d0245e571f49212979604566837f2855cd3d70a6067c754bbbd8b9bbe62a1ca"

URI_aarch64_rust-lexical-parse-integer+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+format-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-integer+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+format-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+format-devel.sha256sum] = "279ce736c496e87768f55ae27eb24cd8953a41820aa89120b7fe7b10863f966a"

URI_aarch64_rust-lexical-parse-integer+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+lint-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-integer+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+lint-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+lint-devel.sha256sum] = "035ce3811e3a366b42a14bc94f9becf58b87267f1ad5fe583f0af301fb6deb11"

URI_aarch64_rust-lexical-parse-integer+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+power-of-two-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-integer+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+power-of-two-devel.sha256sum] = "5c3624440eeb158d88ae7096bb09022613fe93c2ee4819fa03fccc5e52e3fd03"

URI_aarch64_rust-lexical-parse-integer+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+radix-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-integer+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+radix-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+radix-devel.sha256sum] = "00e9f785993ca1e56c68703ecb1c1be355d744f56968e50439254c04e0dbb181"

URI_aarch64_rust-lexical-parse-integer+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+std-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+std-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+std-devel.sha256sum] = "f5c3df104c747df04ba568f2bdb018cab25b31e9f4c9e9cdcb1a01f10deb094b"

URI_aarch64_rust-lexical-parse-integer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-lexical-parse-integer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer-devel.sha256sum] = "6b2d42eeeca932c8733c5aea714291a1e1ab65fc9971856e0ac70ff4844e2e39"

RDEPENDS:rust-lexical-parse-integer+compact-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+compact-devel \
 "
RDEPENDS:rust-lexical-parse-integer+default-devel = " \
 cargo \
 rust-lexical-parse-integer+std-devel \
 rust-lexical-parse-integer-devel \
 "
RDEPENDS:rust-lexical-parse-integer+format-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+format-devel \
 "
RDEPENDS:rust-lexical-parse-integer+lint-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+lint-devel \
 "
RDEPENDS:rust-lexical-parse-integer+power-of-two-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+power-of-two-devel \
 "
RDEPENDS:rust-lexical-parse-integer+radix-devel = " \
 cargo \
 rust-lexical-parse-integer+power-of-two-devel \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+radix-devel \
 "
RDEPENDS:rust-lexical-parse-integer+std-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+std-devel \
 "
RDEPENDS:rust-lexical-parse-integer-devel = " \
 cargo \
 rust \
 rust-lexical-util+parse-integers-devel \
 rust-lexical-util-devel \
 "
