# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strsim"
PV = "0.11.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-strsim+default-devel \
 rust-strsim-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strsim-0.11.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3227494c6e82b98b9cb861891c54c7ab07f401cd78b9a3a618f3f283f295488e"

URI_x86_64_v2_rust-strsim+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strsim+default-devel-0.11.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strsim+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strsim+default-devel}"
SRC_URI[x86_64_v2_rust-strsim+default-devel.sha256sum] = "e46544721fb92051c85d3a02b08a78fb3ec57cc1a4e4be6824f80b401998c30e"

URI_x86_64_v2_rust-strsim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strsim-devel-0.11.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strsim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strsim-devel}"
SRC_URI[x86_64_v2_rust-strsim-devel.sha256sum] = "2029c08f42038dc4e08511fbb3343cf8959a2fd22aacd7e2f515ccfbbdcb6c75"

URI_aarch64_rust-strsim+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strsim+default-devel-0.11.1-2.el10_0.noarch.rpm;name=aarch64_rust-strsim+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strsim+default-devel}"
SRC_URI[aarch64_rust-strsim+default-devel.sha256sum] = "613553a2e76428b783d561f114584d144eb3632eb8095eb97f2b707161b93b1e"

URI_aarch64_rust-strsim-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strsim-devel-0.11.1-2.el10_0.noarch.rpm;name=aarch64_rust-strsim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strsim-devel}"
SRC_URI[aarch64_rust-strsim-devel.sha256sum] = "4586352ee22355e70b7541beb8d0a60be1590520f698427b271b808b5c743dff"

RDEPENDS:rust-strsim+default-devel = " \
 cargo \
 rust-strsim-devel \
 "
RDEPENDS:rust-strsim-devel = " \
 cargo \
 rust \
 "
