# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-objc"
PV = "3.0.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-objc+default-devel \
 rust-tree-sitter-objc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-objc-3.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d163374c28c201fdfabe410b52d19939c040189e2286ee892c00d65162357d89"

URI_x86_64_v2_rust-tree-sitter-objc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-objc+default-devel-3.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-objc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-objc+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-objc+default-devel.sha256sum] = "0dc7b7f98e383935cf98e1ee222b750df3998bcb2a66d5ac3b3b123508021483"

URI_x86_64_v2_rust-tree-sitter-objc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-objc-devel-3.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-objc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-objc-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-objc-devel.sha256sum] = "fcc6365fd03653638cc38ccb5836bab606cc46b4707d0bb529d4a21c099c35cc"

URI_aarch64_rust-tree-sitter-objc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-objc+default-devel-3.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-objc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-objc+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-objc+default-devel.sha256sum] = "755644cec17ba51155451912090f66ea767ff2a2d5c31027d56aecc69e9a6f82"

URI_aarch64_rust-tree-sitter-objc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-objc-devel-3.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-objc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-objc-devel}"
SRC_URI[aarch64_rust-tree-sitter-objc-devel.sha256sum] = "9f22c436213644ab623bd3906b1dc70e190c63036bbc0763f87e3e1ef25a22ea"

RDEPENDS:rust-tree-sitter-objc+default-devel = " \
 cargo \
 rust-tree-sitter-objc-devel \
 "
RDEPENDS:rust-tree-sitter-objc-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
