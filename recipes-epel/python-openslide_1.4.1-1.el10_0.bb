# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openslide"
PV = "1.4.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-openslide \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openslide-1.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c50a582881edee1378eb07b29b6c4704db714255a3ae1514e4cfc1fc71cdda10"

URI_x86_64_v2_python3-openslide = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openslide-1.4.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-openslide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openslide}"
SRC_URI[x86_64_v2_python3-openslide.sha256sum] = "67ec62ef5176eba004088f6eeb0c2d6bfd7ca29c6cb9a06a88ebe793e7d5203d"

URI_aarch64_python3-openslide = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openslide-1.4.1-1.el10_0.aarch64.rpm;name=aarch64_python3-openslide;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openslide}"
SRC_URI[aarch64_python3-openslide.sha256sum] = "5f17009ee48f890fde8cfbddd6f4401e894a4df6bec01a7798af27c154603450"

RDEPENDS:python3-openslide = " \
 glibc \
 openslide \
 python3 \
 python3-pillow \
 "
