# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-firmware-rs"
PV = "26.4"
PR = "1.el10.alma.1"
PACKAGES = " \
 virt-firmware-rs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-firmware-rs-26.4-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "973832fe282484b229d8d5117007ab51b4d4850131ac1635b8efabc749053403"

URI_x86_64_v2_virt-firmware-rs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-firmware-rs-26.4-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_virt-firmware-rs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-firmware-rs}"
SRC_URI[x86_64_v2_virt-firmware-rs.sha256sum] = "829c3b65c36bac80a138e0d6aeb5793714496c03d13d68c774586c397ea6521d"

URI_aarch64_virt-firmware-rs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-firmware-rs-26.4-1.el10.alma.1.aarch64.rpm;name=aarch64_virt-firmware-rs;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-firmware-rs}"
SRC_URI[aarch64_virt-firmware-rs.sha256sum] = "084fdc2ff0bc1e8b3ad747eb3cd75593cbf68448063b24821b0dc1fbad86faba"

RDEPENDS:virt-firmware-rs = " \
 glibc \
 libgcc \
 systemd-libs \
 "
