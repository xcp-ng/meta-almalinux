# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-LibXML"
PE = "1"
PV = "2.0210"
PR = "5.el10"
PACKAGES = " \
 perl-XML-LibXML \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-XML-LibXML-2.0210-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "23830e779268deb607ae1b05bb682d5de1de3a1b8232d318e54276cbfd342f7f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-XML-LibXML-2.0210-5.el10.x86_64_v2.rpm;name=x86_64_v2_perl-XML-LibXML;unpack=0"
SRC_URI[x86_64_v2_perl-XML-LibXML.sha256sum] = "abc6ab94b7e1a76d3cfde39d29c9a001dc688b1c1011a7aa688f8ee922be747d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-XML-LibXML-2.0210-5.el10.aarch64.rpm;name=aarch64_perl-XML-LibXML;unpack=0"
SRC_URI[aarch64_perl-XML-LibXML.sha256sum] = "d5117e28f2f0f483e221faf5c0ccdc43e3a015b9d0b77172f567f65a91014a16"

RDEPENDS:perl-XML-LibXML = " \
 bash \
 glibc \
 libxml2 \
 perl-Carp \
 perl-Data-Dumper \
 perl-Encode \
 perl-Exporter \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-XML-LibXML \
 perl-XML-NamespaceSupport \
 perl-XML-SAX \
 perl-XML-SAX-Base \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-parent \
 perl-vars \
 "
