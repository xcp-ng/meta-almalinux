# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-ng-sys"
PV = "1.1.28"
PR = "1.el10_1"
PACKAGES = " \
 rust-libz-ng-sys+default-devel \
 rust-libz-ng-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-ng-sys-1.1.28-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd2d82713a70ac1054fc179bc5c467f6a9683e9452df81f441b2074b94c01a9d"

URI_x86_64_v2_rust-libz-ng-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-ng-sys+default-devel-1.1.28-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-ng-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-ng-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-ng-sys+default-devel.sha256sum] = "2021b1c09619fe22b5591d8dd656f144e9e8493b57940f7c5a9a683f7c44d85d"

URI_x86_64_v2_rust-libz-ng-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-ng-sys-devel-1.1.28-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-ng-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-ng-sys-devel.sha256sum] = "ececdd892f7bb886bb42e929a6d881d6ec0f907e88ae3bcac7968cf75c674932"

URI_aarch64_rust-libz-ng-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-ng-sys+default-devel-1.1.28-1.el10_1.noarch.rpm;name=aarch64_rust-libz-ng-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-ng-sys+default-devel}"
SRC_URI[aarch64_rust-libz-ng-sys+default-devel.sha256sum] = "9170f6af94583a9f1743345ec4ad46a031e692bc932496072d02fb696da28a44"

URI_aarch64_rust-libz-ng-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-ng-sys-devel-1.1.28-1.el10_1.noarch.rpm;name=aarch64_rust-libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-ng-sys-devel}"
SRC_URI[aarch64_rust-libz-ng-sys-devel.sha256sum] = "2bbf8fcf390aee6911dbe03fed057318cd2b2765cfce296ada7a559a5ff88bd0"

RDEPENDS:rust-libz-ng-sys+default-devel = " \
 cargo \
 rust-libz-ng-sys-devel \
 "
RDEPENDS:rust-libz-ng-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 zlib-ng-devel \
 "
