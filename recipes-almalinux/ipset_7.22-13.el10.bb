# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipset"
PV = "7.22"
PR = "13.el10"
PACKAGES = " \
 ipset \
 ipset-devel \
 ipset-libs \
 ipset-service \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ipset-7.22-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e59ed3124cfee95f60423651021bddf88924914e10f5384f96cc01fe307c7e53"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipset-7.22-13.el10.x86_64_v2.rpm;name=x86_64_v2_ipset;unpack=0"
SRC_URI[x86_64_v2_ipset.sha256sum] = "1a5e8b3aafa609c5af8721c6f98fb316d56a5640e10a5294290332547a2b5659"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ipset-devel-7.22-13.el10.x86_64_v2.rpm;name=x86_64_v2_ipset-devel;unpack=0"
SRC_URI[x86_64_v2_ipset-devel.sha256sum] = "18321ee5bc7139f098ebe4381f73cd8149daa51d90f1ad20017ae565e5ab43cb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipset-libs-7.22-13.el10.x86_64_v2.rpm;name=x86_64_v2_ipset-libs;unpack=0"
SRC_URI[x86_64_v2_ipset-libs.sha256sum] = "14cf56a0d83fdfb200822409ef72ab04a2623ea465dd9c1eee81d5365bb41f9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipset-service-7.22-13.el10.noarch.rpm;name=x86_64_v2_ipset-service;unpack=0"
SRC_URI[x86_64_v2_ipset-service.sha256sum] = "163cd22e0bb298e72361e30b11cd1c83086f7a5316bdf18f961457fd503c846a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipset-7.22-13.el10.aarch64.rpm;name=aarch64_ipset;unpack=0"
SRC_URI[aarch64_ipset.sha256sum] = "c3642f64472b5a26bd7929adee17888d70bb6ec97a6d7ea0600dc3d6397547a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ipset-devel-7.22-13.el10.aarch64.rpm;name=aarch64_ipset-devel;unpack=0"
SRC_URI[aarch64_ipset-devel.sha256sum] = "ca4c22b70aa5b519d12f46f316fbc77811d0e557650a203f2e359a1e17d9150e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipset-libs-7.22-13.el10.aarch64.rpm;name=aarch64_ipset-libs;unpack=0"
SRC_URI[aarch64_ipset-libs.sha256sum] = "096b0ff16bfb2e7040e73203dbfa9ab8205a042a98476bb252d7c546137491e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipset-service-7.22-13.el10.noarch.rpm;name=aarch64_ipset-service;unpack=0"
SRC_URI[aarch64_ipset-service.sha256sum] = "163cd22e0bb298e72361e30b11cd1c83086f7a5316bdf18f961457fd503c846a"

RDEPENDS:ipset = " \
 bash \
 glibc \
 ipset-libs \
 "
RDEPENDS:ipset-devel = " \
 ipset-libs \
 kernel-headers \
 libmnl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ipset-libs = " \
 glibc \
 libmnl \
 "
RDEPENDS:ipset-service = " \
 bash \
 ipset \
 iptables-nft-services \
 systemd \
 "
