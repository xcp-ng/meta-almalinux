# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bstring"
PV = "1.0.3"
PR = "1.el10_2"
PACKAGES = " \
 bstring \
 bstring-devel \
 bstring-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bstring-1.0.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c53274fa172000a408c2c340a437ac1c5f01d3f0940f204ce86293cf5d22e04f"

URI_x86_64_v2_bstring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bstring-1.0.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bstring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bstring}"
SRC_URI[x86_64_v2_bstring.sha256sum] = "67f886ae7ca00c6c71f856d957afcf372a2a3ad8da23d15df5774c2d3e2e061a"

URI_x86_64_v2_bstring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bstring-devel-1.0.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bstring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bstring-devel}"
SRC_URI[x86_64_v2_bstring-devel.sha256sum] = "5144faf320c7b39eb96851339d4258f707a7edabde8d99722e0d77fcbc366677"

URI_x86_64_v2_bstring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bstring-doc-1.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bstring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bstring-doc}"
SRC_URI[x86_64_v2_bstring-doc.sha256sum] = "d9db65f2ee538a72ab7b066e7e9c39a204e1eed5168199ed6f5f64a1344aa251"

URI_aarch64_bstring = "${EPEL_MIRROR}/aarch64/Packages/b/bstring-1.0.3-1.el10_2.aarch64.rpm;name=aarch64_bstring;unpack=0"
SRC_URI:append = " ${URI_aarch64_bstring}"
SRC_URI[aarch64_bstring.sha256sum] = "89c67b53f97bc49443c2b338b8b7c71b9d32f785def3fe9be63b6d6ae44f4e48"

URI_aarch64_bstring-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bstring-devel-1.0.3-1.el10_2.aarch64.rpm;name=aarch64_bstring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bstring-devel}"
SRC_URI[aarch64_bstring-devel.sha256sum] = "9424d98a99d37141e799d3e859f3b9ba7686d36ac11f6d2ed783d2f623b19327"

URI_aarch64_bstring-doc = "${EPEL_MIRROR}/aarch64/Packages/b/bstring-doc-1.0.3-1.el10_2.noarch.rpm;name=aarch64_bstring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bstring-doc}"
SRC_URI[aarch64_bstring-doc.sha256sum] = "3e3c805dfe5444a134d402ff0433d3b21509a66395d15c11eeccbb5ecb9beb81"

RDEPENDS:bstring = " \
 glibc \
 "
RDEPENDS:bstring-devel = " \
 bstring \
 pkgconf-pkg-config \
 "
RDEPENDS:bstring-doc = " \
 "
