# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-object"
PV = "0.47.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-object+default-devel \
 rust-gix-object+document-features-devel \
 rust-gix-object+serde-devel \
 rust-gix-object+verbose-object-parsing-errors-devel \
 rust-gix-object-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-object-0.47.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1373cd14013c8dc14d9db043c35a755b1904fa706b0fe9a18ce3d18937191a3d"

URI_x86_64_v2_rust-gix-object+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+default-devel-0.47.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+default-devel}"
SRC_URI[x86_64_v2_rust-gix-object+default-devel.sha256sum] = "4a0e23d8bc9a1922abbff145b5b28231c00a1e8c1c9d8725676c926a341af09e"

URI_x86_64_v2_rust-gix-object+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+document-features-devel-0.47.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-object+document-features-devel.sha256sum] = "5a5fd8e12494737e099911d2873635dfb824a28d380aff2435c17fd65a2120fb"

URI_x86_64_v2_rust-gix-object+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+serde-devel-0.47.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-object+serde-devel.sha256sum] = "13697e4c645f3999367eff8cebea3da6ba4746e89a957729923789bac2c41f87"

URI_x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+verbose-object-parsing-errors-devel-0.47.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel}"
SRC_URI[x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel.sha256sum] = "38476c9aaa98862a6cb8828f432626cd9c14f7953000fa2f54d5691b6df49d7e"

URI_x86_64_v2_rust-gix-object-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object-devel-0.47.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object-devel}"
SRC_URI[x86_64_v2_rust-gix-object-devel.sha256sum] = "fc3b95b00819dfb5083c4113ef40a130469795763cc91d0e7940409cf8ace998"

URI_aarch64_rust-gix-object+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+default-devel-0.47.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+default-devel}"
SRC_URI[aarch64_rust-gix-object+default-devel.sha256sum] = "9bed91bad8057c8c34175af4354aee2eb5761698b3810df78df49c6efc7ca10b"

URI_aarch64_rust-gix-object+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+document-features-devel-0.47.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-object+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+document-features-devel}"
SRC_URI[aarch64_rust-gix-object+document-features-devel.sha256sum] = "db50cf7a356563f04afd03cc9b11f9682b7c7b13c2985a35ad2324b4759381b5"

URI_aarch64_rust-gix-object+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+serde-devel-0.47.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-object+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+serde-devel}"
SRC_URI[aarch64_rust-gix-object+serde-devel.sha256sum] = "d0ef859a011eeb6fb7abd189841d6800026c1b83153c8a4e766a7bf35d8089f5"

URI_aarch64_rust-gix-object+verbose-object-parsing-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+verbose-object-parsing-errors-devel-0.47.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-object+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+verbose-object-parsing-errors-devel}"
SRC_URI[aarch64_rust-gix-object+verbose-object-parsing-errors-devel.sha256sum] = "b09f10fed2b7a68ec63b13af25b20da7d320c3b97693a5ab9065fc1e9bfe5c6d"

URI_aarch64_rust-gix-object-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object-devel-0.47.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-object-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object-devel}"
SRC_URI[aarch64_rust-gix-object-devel.sha256sum] = "00b4eb9e43a53503ef3fac3abd8cfb1d4aaf653f4b2154320ea3c74f0f07b681"

RDEPENDS:rust-gix-object+default-devel = " \
 cargo \
 rust-gix-object-devel \
 "
RDEPENDS:rust-gix-object+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-object-devel \
 "
RDEPENDS:rust-gix-object+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-object-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-smallvec+serde-devel \
 "
RDEPENDS:rust-gix-object+verbose-object-parsing-errors-devel = " \
 cargo \
 rust-gix-object-devel \
 rust-winnow0.6+std-devel \
 "
RDEPENDS:rust-gix-object-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-actor+default-devel \
 rust-gix-date+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-features+rustsha1-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-path+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-itoa+default-devel \
 rust-smallvec+default-devel \
 rust-smallvec+write-devel \
 rust-thiserror+default-devel \
 rust-winnow0.6+default-devel \
 rust-winnow0.6+simd-devel \
 "
