# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "usermode"
PV = "1.114"
PR = "13.el10"
PACKAGES = " \
 usermode \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/usermode-1.114-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97f4658c74b11a5d86f9d71da0fbb04d794535316a0008c176579dba9b080ff2"

URI_x86_64_v2_usermode = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/usermode-1.114-13.el10.x86_64_v2.rpm;name=x86_64_v2_usermode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_usermode}"
SRC_URI[x86_64_v2_usermode.sha256sum] = "cfb6fb888828539e2c824000769d809c62a421a88854ed502af520ce7a432703"

URI_aarch64_usermode = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/usermode-1.114-13.el10.aarch64.rpm;name=aarch64_usermode;unpack=0"
SRC_URI:append = " ${URI_aarch64_usermode}"
SRC_URI[aarch64_usermode.sha256sum] = "1e865925f40241b16880aec87fc416dd13dbf61fc48559d09c65da11f3be1d50"

RDEPENDS:usermode = " \
 glib2 \
 glibc \
 libselinux \
 libuser \
 pam \
 pam-libs \
 shadow-utils \
 util-linux \
 "
