# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-LibIDN2"
PV = "1.02"
PR = "8.el10_0"
PACKAGES = " \
 perl-Net-LibIDN2 \
 perl-Net-LibIDN2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-LibIDN2-1.02-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d61a33cb5fd846f34d65c224e2be3f6d12b3bff4d79881acc942c39f62b8e3a4"

URI_x86_64_v2_perl-Net-LibIDN2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-LibIDN2-1.02-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Net-LibIDN2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-LibIDN2}"
SRC_URI[x86_64_v2_perl-Net-LibIDN2.sha256sum] = "c0ddf686d642a46d7b35ced6c0f6e54b9aaa76acac91ccecb878da3b866f7f3e"

URI_x86_64_v2_perl-Net-LibIDN2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-LibIDN2-tests-1.02-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Net-LibIDN2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-LibIDN2-tests}"
SRC_URI[x86_64_v2_perl-Net-LibIDN2-tests.sha256sum] = "abc186574a566a8e6e2dc59605429ec99a38b0d81b29946546ddeac7f4678287"

URI_aarch64_perl-Net-LibIDN2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-LibIDN2-1.02-8.el10_0.aarch64.rpm;name=aarch64_perl-Net-LibIDN2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-LibIDN2}"
SRC_URI[aarch64_perl-Net-LibIDN2.sha256sum] = "d223024ad3c1f6b8fb1fd0fb9fdc22de03e9a1a4c2b2414114344999c8747b0c"

URI_aarch64_perl-Net-LibIDN2-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-LibIDN2-tests-1.02-8.el10_0.aarch64.rpm;name=aarch64_perl-Net-LibIDN2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-LibIDN2-tests}"
SRC_URI[aarch64_perl-Net-LibIDN2-tests.sha256sum] = "84c8516f522387e64587c2de68be8732f61d4c66ee14fcb25c5c1ef36cbfc75b"

RDEPENDS:perl-Net-LibIDN2 = " \
 glibc \
 libidn2 \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Net-LibIDN2-tests = " \
 bash \
 perl-Encode \
 perl-Net-LibIDN2 \
 perl-POSIX \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
