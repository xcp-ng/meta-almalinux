# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-socket2"
PV = "0.6.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-socket2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-socket2-0.6.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a6a5535401493f317ed66aa1ab54c852f0c7a4dc8ca5605457c87cf47e25131"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2+all-devel-0.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2+all-devel;unpack=0"
SRC_URI[x86_64_v2_rust-socket2+all-devel.sha256sum] = "a17b35fd6d9870db89bdcdc01f2c0d177b1b80df8f889af5cfa14e7cd0033925"
RPROVIDES:rust-socket2+all-devel:append:x86_64_v2 = " virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2+default-devel-0.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-socket2+default-devel.sha256sum] = "e1c4ed51016065fe62a983a1a635d9ce4f56e193caff584e06b06a4aea6869b8"
RPROVIDES:rust-socket2+default-devel:append:x86_64_v2 = " virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2-devel-0.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-socket2-devel.sha256sum] = "fce0190b29581fde3f4b0a5e4e8d6c6f06bfc568b8ed1e9a52681fabed8acb69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2+all-devel-0.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-socket2+all-devel;unpack=0"
SRC_URI[aarch64_rust-socket2+all-devel.sha256sum] = "969ad6f26ee8ee1ee312de96a261f598fec31bbacedf3c437465a7e28222d15c"
RPROVIDES:rust-socket2+all-devel:append:aarch64 = " virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2+default-devel-0.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-socket2+default-devel;unpack=0"
SRC_URI[aarch64_rust-socket2+default-devel.sha256sum] = "4958c9ca05f02807f5a2f17dec5295fcb38731075c723c8ef00b0fe557d2830b"
RPROVIDES:rust-socket2+default-devel:append:aarch64 = " virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2-devel-0.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-socket2-devel;unpack=0"
SRC_URI[aarch64_rust-socket2-devel.sha256sum] = "de9ff75b61209fa42f3a05b392ebf895ba372bc8ab6df973ba046f36a4cd70d1"

RDEPENDS:rust-socket2+all-devel = " \
 cargo \
 rust-socket2-devel \
 "
RDEPENDS:rust-socket2+default-devel = " \
 cargo \
 rust-socket2-devel \
 "
RDEPENDS:rust-socket2-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
