# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdeplasma-addons"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kate-krunner-plugin \
 kdeplasma-addons \
 kdeplasma-addons-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdeplasma-addons-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3b7acdc9175d56d1274dc3f0c54c51c11f4be433353954bab1e4259f2b86be13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-krunner-plugin-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-krunner-plugin;unpack=0"
SRC_URI[x86_64_v2_kate-krunner-plugin.sha256sum] = "0de0055a23bdcbf394f1937db75b121497a29c3f4459162959652988623be5c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeplasma-addons-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeplasma-addons;unpack=0"
SRC_URI[x86_64_v2_kdeplasma-addons.sha256sum] = "d6be7fc89339a1651c5ea84083be99b636814372a7f53f85db42d75686811a78"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeplasma-addons-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeplasma-addons-devel;unpack=0"
SRC_URI[x86_64_v2_kdeplasma-addons-devel.sha256sum] = "a1712efab36d2dc664b63440c78a79ad922f668a8f4675a1cad0ac106fdb805b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kate-krunner-plugin-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kate-krunner-plugin;unpack=0"
SRC_URI[aarch64_kate-krunner-plugin.sha256sum] = "c2ffd5934d18605a13a4143726c079f29f55bb48ddb164adbe772cb0b7a6f9e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdeplasma-addons-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kdeplasma-addons;unpack=0"
SRC_URI[aarch64_kdeplasma-addons.sha256sum] = "3ef4e1277ed1a60752c89cd629fdb9f2d5842439313c67d5129365694b2c4ae2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdeplasma-addons-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kdeplasma-addons-devel;unpack=0"
SRC_URI[aarch64_kdeplasma-addons-devel.sha256sum] = "41dc02d6acc196b9d090ec64f85c92ebd44c71477093db74dbe534cef66c5563"

RDEPENDS:kate-krunner-plugin = " \
 glibc \
 kate \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-krunner \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kdeplasma-addons = " \
 glibc \
 hidapi \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kunitconversion \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libgcc \
 libicu \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 qt6-qtwebengine \
 "
RDEPENDS:kdeplasma-addons-devel = " \
 cmake-filesystem \
 kdeplasma-addons \
 kf6-kcoreaddons-devel \
 qt6-qtbase-devel \
 "
