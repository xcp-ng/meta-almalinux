# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "composer"
PV = "2.10.3"
PR = "1.el10_3"
PACKAGES = " \
 composer \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/composer-2.10.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "324c67e92a35e21850b8bc23622993e7ced30277d33145d61aaa434333dd32d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/composer-2.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_composer;unpack=0"
SRC_URI[x86_64_v2_composer.sha256sum] = "1bf8b690c06c070830458a5dcce021cbea791eb07beb1ce8cd749d74788afd61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/composer-2.10.3-1.el10_3.noarch.rpm;name=aarch64_composer;unpack=0"
SRC_URI[aarch64_composer.sha256sum] = "5a986f88836a6d6bc67754f9ee1154274f1661231864caf0f3d21438384f2885"

RDEPENDS:composer = " \
 bash \
 ca-certificates \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-date \
 virtual/php-dom \
 virtual/php-filter \
 virtual/php-hash \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-openssl \
 virtual/php-pcntl \
 virtual/php-pcre \
 virtual/php-phar \
 virtual/php-posix \
 virtual/php-reflection \
 virtual/php-spl \
 virtual/php-tokenizer \
 virtual/php-xsl \
 virtual/php-zip \
 virtual/php-zlib \
 virtual/php_language__ge_7.2.5 \
 "
