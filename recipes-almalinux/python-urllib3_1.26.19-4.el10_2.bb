# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-urllib3"
PV = "1.26.19"
PR = "4.el10_2"
PACKAGES = " \
 python3-urllib3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-urllib3-1.26.19-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c5a551a4a7aaf4642debc71cac25762f3133e159fb6a5e7ecf960d96e7e2ee1"

URI_x86_64_v2_python3-urllib3 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-urllib3-1.26.19-4.el10_2.noarch.rpm;name=x86_64_v2_python3-urllib3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-urllib3}"
SRC_URI[x86_64_v2_python3-urllib3.sha256sum] = "061d0569e4a91346a411d49abf8049ee7807bb60b072e83f681e85f401a3fdb5"

URI_aarch64_python3-urllib3 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-urllib3-1.26.19-4.el10_2.noarch.rpm;name=aarch64_python3-urllib3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-urllib3}"
SRC_URI[aarch64_python3-urllib3.sha256sum] = "061d0569e4a91346a411d49abf8049ee7807bb60b072e83f681e85f401a3fdb5"

RDEPENDS:python3-urllib3 = " \
 ca-certificates \
 python3 \
 python3-idna \
 "
