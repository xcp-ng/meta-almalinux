# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-ugly-free"
PV = "1.26.7"
PR = "4.el10"
PACKAGES = " \
 gstreamer1-plugins-ugly-free \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-ugly-free-1.26.7-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "20f1a1ef186f44d64a2fd8fad2633b115e17c99b4257f12b700f5e2a6c894974"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-ugly-free-1.26.7-4.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-ugly-free.sha256sum] = "cfd4f56d384a6c20cc47b1da680aab939548d3952bca08f856d769096b71981c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-ugly-free-1.26.7-4.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-ugly-free.sha256sum] = "622c14d39ce771c5917a67aa8e3845b2e24ff6fc29c99b9529a4849cf6cc867c"

RDEPENDS:gstreamer1-plugins-ugly-free = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 liba52 \
 libcdio \
 libdvdread \
 libmpeg2 \
 orc \
 "
