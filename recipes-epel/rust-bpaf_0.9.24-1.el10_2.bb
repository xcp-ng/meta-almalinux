# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bpaf"
PV = "0.9.24"
PR = "1.el10_2"
PACKAGES = " \
 rust-bpaf+autocomplete-devel \
 rust-bpaf+batteries-devel \
 rust-bpaf+bpaf_derive-devel \
 rust-bpaf+bright-color-devel \
 rust-bpaf+color-devel \
 rust-bpaf+default-devel \
 rust-bpaf+derive-devel \
 rust-bpaf+docgen-devel \
 rust-bpaf+dull-color-devel \
 rust-bpaf+extradocs-devel \
 rust-bpaf+owo-colors-devel \
 rust-bpaf+supports-color-devel \
 rust-bpaf+unstable-docs-devel \
 rust-bpaf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bpaf-0.9.24-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de195c0fb667e4def94e05ee6368339ed5b3840b54c433b628a5fc0c0caf7490"

URI_x86_64_v2_rust-bpaf+autocomplete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+autocomplete-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+autocomplete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+autocomplete-devel}"
SRC_URI[x86_64_v2_rust-bpaf+autocomplete-devel.sha256sum] = "b57d87971188f81b321c9e29eb0192bc3d4e7a8ad8e1809bf2c23ad4be0dbdf7"

URI_x86_64_v2_rust-bpaf+batteries-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+batteries-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+batteries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+batteries-devel}"
SRC_URI[x86_64_v2_rust-bpaf+batteries-devel.sha256sum] = "622b7f09d88b8875a00118aba4336cd01dcb6cd78a29c022d2f29f083bb9c6ce"

URI_x86_64_v2_rust-bpaf+bpaf_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+bpaf_derive-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+bpaf_derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf+bpaf_derive-devel.sha256sum] = "0be72f6a30dbd4681f12663ae57450f5d985e1dc44cf7a3f32beb585d7a7c81a"

URI_x86_64_v2_rust-bpaf+bright-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+bright-color-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+bright-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+bright-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+bright-color-devel.sha256sum] = "f48b3328947c7ed7cd72d17e82c0d5b00937e0f4e11b3833e88ee8e24ffe5a0d"

URI_x86_64_v2_rust-bpaf+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+color-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+color-devel.sha256sum] = "5d52106e1e47daa397b092c2805065b27852e9c9a8ebdab23454b9a97f5e1ea9"

URI_x86_64_v2_rust-bpaf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+default-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+default-devel}"
SRC_URI[x86_64_v2_rust-bpaf+default-devel.sha256sum] = "dc6560ed20eed150780ecbddcdc73ff06a5e2add5cef60a5ad67128a3083082b"

URI_x86_64_v2_rust-bpaf+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+derive-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf+derive-devel.sha256sum] = "fe5fe0b9cf1f91072753708b19abd521328327eddc21cb5837eed557c1b7f83f"

URI_x86_64_v2_rust-bpaf+docgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+docgen-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+docgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+docgen-devel}"
SRC_URI[x86_64_v2_rust-bpaf+docgen-devel.sha256sum] = "604714806871c7bca45e12550da05702b12e30470dd9b4633465aead2a35b20e"

URI_x86_64_v2_rust-bpaf+dull-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+dull-color-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+dull-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+dull-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+dull-color-devel.sha256sum] = "f7e7e8b43938499d53a63c05b4f504fb77d89738a00445660292f4b800cd80db"

URI_x86_64_v2_rust-bpaf+extradocs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+extradocs-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+extradocs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+extradocs-devel}"
SRC_URI[x86_64_v2_rust-bpaf+extradocs-devel.sha256sum] = "98a5c78707df41c08ae8490316dcb500917b9836d7991c5d2f4af828b3df4c67"

URI_x86_64_v2_rust-bpaf+owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+owo-colors-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+owo-colors-devel}"
SRC_URI[x86_64_v2_rust-bpaf+owo-colors-devel.sha256sum] = "821cee2a9b35d9c3cb29e2848ca0dbbbb217d3a23f65290dad7560259dca5cb2"

URI_x86_64_v2_rust-bpaf+supports-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+supports-color-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+supports-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+supports-color-devel.sha256sum] = "c91a5c339d7bfea8c24c519c9215a2c0dcbbc53187b37595ee92eeadd956479b"

URI_x86_64_v2_rust-bpaf+unstable-docs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+unstable-docs-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+unstable-docs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+unstable-docs-devel}"
SRC_URI[x86_64_v2_rust-bpaf+unstable-docs-devel.sha256sum] = "e07afda16be9edd4046270cc82a060fcc24c82129963a8c7a9ee29665a6cad6a"

URI_x86_64_v2_rust-bpaf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf-devel-0.9.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf-devel}"
SRC_URI[x86_64_v2_rust-bpaf-devel.sha256sum] = "32a8f7418c8f4445fcb7401da68ac56c5c27185c55d534e531fec5a7700586ba"

URI_aarch64_rust-bpaf+autocomplete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+autocomplete-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+autocomplete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+autocomplete-devel}"
SRC_URI[aarch64_rust-bpaf+autocomplete-devel.sha256sum] = "d922820ac4a071ff097eb2a0517761c7917d1a44bb8597e81da3f94573ba9871"

URI_aarch64_rust-bpaf+batteries-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+batteries-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+batteries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+batteries-devel}"
SRC_URI[aarch64_rust-bpaf+batteries-devel.sha256sum] = "d0fd4fd33a44c5fce84801367b174c87844905d9027f0fb3241e87025e7659a0"

URI_aarch64_rust-bpaf+bpaf_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+bpaf_derive-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+bpaf_derive-devel}"
SRC_URI[aarch64_rust-bpaf+bpaf_derive-devel.sha256sum] = "e94e9e5e497ad3e7f8706c53b2e1f1fe2e244cf5bbdea3a7357ab7c16b674f12"

URI_aarch64_rust-bpaf+bright-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+bright-color-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+bright-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+bright-color-devel}"
SRC_URI[aarch64_rust-bpaf+bright-color-devel.sha256sum] = "18bae225db2dfab011f749d228b7c3968dbf9667fba83b3706d9d9d33f16db4f"

URI_aarch64_rust-bpaf+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+color-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+color-devel}"
SRC_URI[aarch64_rust-bpaf+color-devel.sha256sum] = "2863fe08e416f283000c4bd9c02094113ac5b84dc7d0a05dbcaf679bae4e1b94"

URI_aarch64_rust-bpaf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+default-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+default-devel}"
SRC_URI[aarch64_rust-bpaf+default-devel.sha256sum] = "f015b10649fa7ec1a8cca6e7471815c75862ebc9fb65ebd4b65870468523fb81"

URI_aarch64_rust-bpaf+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+derive-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+derive-devel}"
SRC_URI[aarch64_rust-bpaf+derive-devel.sha256sum] = "0d645b4bbc285b30d385ed2ad8f1ffef6860c61c9806b431c41854a81f3270dc"

URI_aarch64_rust-bpaf+docgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+docgen-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+docgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+docgen-devel}"
SRC_URI[aarch64_rust-bpaf+docgen-devel.sha256sum] = "ae22002f4181dde9501ba6162144878ba10e5aedf808ffff3d3256d59243bff3"

URI_aarch64_rust-bpaf+dull-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+dull-color-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+dull-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+dull-color-devel}"
SRC_URI[aarch64_rust-bpaf+dull-color-devel.sha256sum] = "3d75861bd4fe42c59f586a3aa1612350f52e4cdd22232c746acc603c787e9b19"

URI_aarch64_rust-bpaf+extradocs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+extradocs-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+extradocs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+extradocs-devel}"
SRC_URI[aarch64_rust-bpaf+extradocs-devel.sha256sum] = "4755e16b03ad335347e7acccfd0722e369bc7fdeec04f5fd4b2312e92af49473"

URI_aarch64_rust-bpaf+owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+owo-colors-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+owo-colors-devel}"
SRC_URI[aarch64_rust-bpaf+owo-colors-devel.sha256sum] = "75db268dc1ff26d213f089900224e55f0086ee7c03a30a6d0ea1e4cdbc0d0af8"

URI_aarch64_rust-bpaf+supports-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+supports-color-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+supports-color-devel}"
SRC_URI[aarch64_rust-bpaf+supports-color-devel.sha256sum] = "58f185afd98a2799c6a09b2a9acb21be5bd553730e2cd6a790b87e5aaa52d2a9"

URI_aarch64_rust-bpaf+unstable-docs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+unstable-docs-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf+unstable-docs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+unstable-docs-devel}"
SRC_URI[aarch64_rust-bpaf+unstable-docs-devel.sha256sum] = "4a26f35fb4224dddf288835c99baa3c2daada9755e08d73e05d69d4c535b33a0"

URI_aarch64_rust-bpaf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf-devel-0.9.24-1.el10_2.noarch.rpm;name=aarch64_rust-bpaf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf-devel}"
SRC_URI[aarch64_rust-bpaf-devel.sha256sum] = "2666c96b6c3a40001806ba6d13f72b1027bcbe5df19d228f83558d5a981762a2"

RDEPENDS:rust-bpaf+autocomplete-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+batteries-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+bpaf_derive-devel = " \
 cargo \
 rust-bpaf-devel \
 rust-bpaf_derive+default-devel \
 "
RDEPENDS:rust-bpaf+bright-color-devel = " \
 cargo \
 rust-bpaf+color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+color-devel = " \
 cargo \
 rust-bpaf+owo-colors-devel \
 rust-bpaf+supports-color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+default-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+derive-devel = " \
 cargo \
 rust-bpaf+bpaf_derive-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+docgen-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+dull-color-devel = " \
 cargo \
 rust-bpaf+color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+extradocs-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+owo-colors-devel = " \
 cargo \
 rust-bpaf-devel \
 virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~ \
 "
RDEPENDS:rust-bpaf+supports-color-devel = " \
 cargo \
 rust-bpaf-devel \
 virtual/crate_supports-color/default__ge_2.0.0_with_crate_supports-color/default__lt_4.0.0~ \
 "
RDEPENDS:rust-bpaf+unstable-docs-devel = " \
 cargo \
 rust-bpaf+autocomplete-devel \
 rust-bpaf+batteries-devel \
 rust-bpaf+derive-devel \
 rust-bpaf+docgen-devel \
 rust-bpaf+extradocs-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf-devel = " \
 cargo \
 rust \
 "
