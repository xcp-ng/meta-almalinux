# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virtiofsd"
PV = "1.13.2"
PR = "1.el10_0.alma.1"
PACKAGES = " \
 virtiofsd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virtiofsd-1.13.2-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fa101b95d4c5c9ba516e50fdd944e87ebed4f30615ad8ff999bd888e6882687"

URI_x86_64_v2_virtiofsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virtiofsd-1.13.2-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_virtiofsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virtiofsd}"
SRC_URI[x86_64_v2_virtiofsd.sha256sum] = "f7b8f333581394cfeb6b82a98a4ca3be8ee8b3fdab7b89feec398274f53ab347"

URI_aarch64_virtiofsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virtiofsd-1.13.2-1.el10_0.alma.1.aarch64.rpm;name=aarch64_virtiofsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_virtiofsd}"
SRC_URI[aarch64_virtiofsd.sha256sum] = "59bc70e5d3cbaf5599bd3b9ff65c4ba292cd884a6a6add2bcc762705375193d6"

RDEPENDS:virtiofsd = " \
 glibc \
 libcap-ng \
 libgcc \
 libseccomp \
 qemu-kvm-common \
 shadow-utils \
 "
