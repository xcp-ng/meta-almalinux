# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openblas"
PV = "0.3.28"
PR = "1.el10"
PACKAGES = " \
 openblas \
 openblas-devel \
 openblas-openmp \
 openblas-openmp64 \
 openblas-openmp64_ \
 openblas-serial \
 openblas-serial64 \
 openblas-serial64_ \
 openblas-static \
 openblas-threads \
 openblas-threads64 \
 openblas-threads64_ \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openblas-0.3.28-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf59953af366f511a62c2fa6c465ad413ec83ae58fe234dbb276912658a8ce2f"

URI_x86_64_v2_openblas = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas}"
SRC_URI[x86_64_v2_openblas.sha256sum] = "cbcf1c4db99c4be6eeb9e8480f811a108a891a79b0b2da3f0b2752acc2093b04"

URI_x86_64_v2_openblas-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-devel-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-devel}"
SRC_URI[x86_64_v2_openblas-devel.sha256sum] = "b3296c0b07e6cad63c201841043da993f034f510553171c852678decce3b8e6c"

URI_x86_64_v2_openblas-openmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-openmp-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-openmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-openmp}"
SRC_URI[x86_64_v2_openblas-openmp.sha256sum] = "6dabc7c352ad9712f7c382925e2587c13dbe5219beb87691ee8884079ecdc02f"

URI_x86_64_v2_openblas-openmp64 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-openmp64-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-openmp64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-openmp64}"
SRC_URI[x86_64_v2_openblas-openmp64.sha256sum] = "1702ab113a904b43d4fc22a3388066ad2a5e91c677e5395bcbba8099970ace5d"

URI_x86_64_v2_openblas-openmp64_ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-openmp64_-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-openmp64_;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-openmp64_}"
SRC_URI[x86_64_v2_openblas-openmp64_.sha256sum] = "e623010c69444ab245997f8bccdb09457d1ed392f43d39efe2081829418c44d6"

URI_x86_64_v2_openblas-serial = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-serial-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-serial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-serial}"
SRC_URI[x86_64_v2_openblas-serial.sha256sum] = "a5b906497cbba98624517231b16d3f601640ebbe99400f9a6cd67b45cb3a8bc4"

URI_x86_64_v2_openblas-serial64 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-serial64-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-serial64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-serial64}"
SRC_URI[x86_64_v2_openblas-serial64.sha256sum] = "e402ba9a3b41963763e6ccf734f35ae0424e2c349a9b6a110ace89aba9b91f53"

URI_x86_64_v2_openblas-serial64_ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-serial64_-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-serial64_;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-serial64_}"
SRC_URI[x86_64_v2_openblas-serial64_.sha256sum] = "1c846fa85e19e7bcc0820c5f52b5545d3fd383b2203497e95bff8f86b093a416"

URI_x86_64_v2_openblas-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-static-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-static}"
SRC_URI[x86_64_v2_openblas-static.sha256sum] = "2ac618b2aa43f8c252b40eb760e9b6a4b16d19695150da666383cd8ad79c35ac"

URI_x86_64_v2_openblas-threads = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-threads-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-threads;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-threads}"
SRC_URI[x86_64_v2_openblas-threads.sha256sum] = "359a98c1f0592f759d8ca2efa1556373eaecc645ad1d7cdb3194720d6f59a307"

URI_x86_64_v2_openblas-threads64 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-threads64-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-threads64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-threads64}"
SRC_URI[x86_64_v2_openblas-threads64.sha256sum] = "8333c7fe71fd22ff2812d9c2ba8fcf2e4b0009be96ac3b81bc31bc57be6d3ee9"

URI_x86_64_v2_openblas-threads64_ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openblas-threads64_-0.3.28-1.el10.x86_64_v2.rpm;name=x86_64_v2_openblas-threads64_;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openblas-threads64_}"
SRC_URI[x86_64_v2_openblas-threads64_.sha256sum] = "17842ce17821fc5e31c23d099b1aff6070bf161c9468aa855960a1055ab6f486"

URI_aarch64_openblas = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas}"
SRC_URI[aarch64_openblas.sha256sum] = "c590091e7a469fce4f463903a436ece984671c0a5532ba407a1110af740030c0"

URI_aarch64_openblas-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-devel-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-devel}"
SRC_URI[aarch64_openblas-devel.sha256sum] = "4ec911385e037fc47ee1ac04b37f81366006694fc50b17a6efb7b47922ad148f"

URI_aarch64_openblas-openmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-openmp-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-openmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-openmp}"
SRC_URI[aarch64_openblas-openmp.sha256sum] = "279487b5d9b6a677cf7fc9236c659be26057425366fdda50397c861b083caace"

URI_aarch64_openblas-openmp64 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-openmp64-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-openmp64;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-openmp64}"
SRC_URI[aarch64_openblas-openmp64.sha256sum] = "2a2ac23e329171a95fd87d64b2dfdc2b3a68ccba226f406864f79bb2f9370746"

URI_aarch64_openblas-openmp64_ = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-openmp64_-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-openmp64_;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-openmp64_}"
SRC_URI[aarch64_openblas-openmp64_.sha256sum] = "3f7d745ed2286beb939e69d5a41b0e6e0151af088b9fc11f4d99b72c3b263c8a"

URI_aarch64_openblas-serial = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-serial-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-serial;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-serial}"
SRC_URI[aarch64_openblas-serial.sha256sum] = "63557a1591da02ab56b7a5a5d08fab62c854807ec72ff51b49bc85df9e5d0ad1"

URI_aarch64_openblas-serial64 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-serial64-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-serial64;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-serial64}"
SRC_URI[aarch64_openblas-serial64.sha256sum] = "ce8fe8fd2b0c9a1770e6ba35c2f1f80e77220a6ba4a003a3fefcc22742c46dad"

URI_aarch64_openblas-serial64_ = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-serial64_-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-serial64_;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-serial64_}"
SRC_URI[aarch64_openblas-serial64_.sha256sum] = "2598ced44ebd67759f392b8fd8e4b04c18a0fa1663de245c7538095774b9b75f"

URI_aarch64_openblas-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-static-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-static}"
SRC_URI[aarch64_openblas-static.sha256sum] = "173856d57e5d95d65ebcafe6feed334a829c4fa0c5c1fd6674408378ffcae656"

URI_aarch64_openblas-threads = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-threads-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-threads;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-threads}"
SRC_URI[aarch64_openblas-threads.sha256sum] = "e5364e166dc3ee1dea0c5aa445dd37a0fb875c721a2ba78fedc4bada4f697913"

URI_aarch64_openblas-threads64 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-threads64-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-threads64;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-threads64}"
SRC_URI[aarch64_openblas-threads64.sha256sum] = "d7771b847090264fbecfd962a451629cb88b967acb2574bc33b9434ea90a251a"

URI_aarch64_openblas-threads64_ = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openblas-threads64_-0.3.28-1.el10.aarch64.rpm;name=aarch64_openblas-threads64_;unpack=0"
SRC_URI:append = " ${URI_aarch64_openblas-threads64_}"
SRC_URI[aarch64_openblas-threads64_.sha256sum] = "973159f88756e209859e632c256a61066315297b1726ad48ffd46d08a5abef9c"

RDEPENDS:openblas = " \
 "
RDEPENDS:openblas-devel = " \
 openblas \
 openblas-openmp \
 openblas-openmp64 \
 openblas-openmp64_ \
 openblas-serial \
 openblas-serial64 \
 openblas-serial64_ \
 openblas-srpm-macros \
 openblas-threads \
 openblas-threads64 \
 openblas-threads64_ \
 "
RDEPENDS:openblas-openmp = " \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 openblas \
 "
RDEPENDS:openblas-openmp64 = " \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 openblas \
 "
RDEPENDS:openblas-openmp64_ = " \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 openblas \
 "
RDEPENDS:openblas-serial = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-serial64 = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-serial64_ = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-static = " \
 openblas-devel \
 "
RDEPENDS:openblas-threads = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-threads64 = " \
 glibc \
 libgfortran \
 openblas \
 "
RDEPENDS:openblas-threads64_ = " \
 glibc \
 libgfortran \
 openblas \
 "
