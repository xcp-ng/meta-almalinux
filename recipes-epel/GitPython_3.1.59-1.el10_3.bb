# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "GitPython"
PV = "3.1.59"
PR = "1.el10_3"
PACKAGES = " \
 python3-GitPython \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/GitPython-3.1.59-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e50e6fe585a4afc8afa7f77b6eb3c7fd744c0ed2fb718143b8dd874aa5346632"

URI_x86_64_v2_python3-GitPython = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-GitPython-3.1.59-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-GitPython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-GitPython}"
SRC_URI[x86_64_v2_python3-GitPython.sha256sum] = "154e754d4760958fe6e46a3f05d300e899af9782463edc784c0ec9eb9589b134"

URI_aarch64_python3-GitPython = "${EPEL_MIRROR}/aarch64/Packages/p/python3-GitPython-3.1.59-1.el10_3.noarch.rpm;name=aarch64_python3-GitPython;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-GitPython}"
SRC_URI[aarch64_python3-GitPython.sha256sum] = "0204bde45f072f18f42a686c614c92c489e43ed9fd20b2d978a1afec0ac92704"

RDEPENDS:python3-GitPython = " \
 git-core \
 python3 \
 python3-gitdb \
 "
