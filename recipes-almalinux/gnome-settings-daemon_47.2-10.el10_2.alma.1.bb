# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-settings-daemon"
PV = "47.2"
PR = "10.el10_2.alma.1"
PACKAGES = " \
 gnome-settings-daemon \
 gnome-settings-daemon-devel \
 gnome-settings-daemon-server-defaults \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-settings-daemon-47.2-10.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "886dec19b87f93ecb7185ea04102b767cdc6c9c2eb2c21f712fbafcfe8938639"

URI_x86_64_v2_gnome-settings-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-settings-daemon-47.2-10.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-settings-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-settings-daemon}"
SRC_URI[x86_64_v2_gnome-settings-daemon.sha256sum] = "3d4ff0d049a396e33bfbc249b87ff8b909ff78325af31de4c54f43705e85b5bd"

URI_x86_64_v2_gnome-settings-daemon-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-settings-daemon-devel-47.2-10.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-settings-daemon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-settings-daemon-devel}"
SRC_URI[x86_64_v2_gnome-settings-daemon-devel.sha256sum] = "623ad2f12c301bb3dd378b1443f870f6ddaacf65d8aec3b6154c3c91c717a5b6"

URI_x86_64_v2_gnome-settings-daemon-server-defaults = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-settings-daemon-server-defaults-47.2-10.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-settings-daemon-server-defaults;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-settings-daemon-server-defaults}"
SRC_URI[x86_64_v2_gnome-settings-daemon-server-defaults.sha256sum] = "edb776edd99c2bc48ebcc7f29cd925487797fb4248712e925aae1688e7ceccc5"

URI_aarch64_gnome-settings-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-settings-daemon-47.2-10.el10_2.alma.1.aarch64.rpm;name=aarch64_gnome-settings-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-settings-daemon}"
SRC_URI[aarch64_gnome-settings-daemon.sha256sum] = "09566bbea3deecab686d37afd5a6afc4ca1f1882e834a4db7869d3c5eb08d2d6"

URI_aarch64_gnome-settings-daemon-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-settings-daemon-devel-47.2-10.el10_2.alma.1.aarch64.rpm;name=aarch64_gnome-settings-daemon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-settings-daemon-devel}"
SRC_URI[aarch64_gnome-settings-daemon-devel.sha256sum] = "4b9bfee5b03b7fb087d015ad05b7bab5c3591e609dda81d5b9f4f2c9562315e5"

URI_aarch64_gnome-settings-daemon-server-defaults = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-settings-daemon-server-defaults-47.2-10.el10_2.alma.1.aarch64.rpm;name=aarch64_gnome-settings-daemon-server-defaults;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-settings-daemon-server-defaults}"
SRC_URI[aarch64_gnome-settings-daemon-server-defaults.sha256sum] = "5b44b07671e93f0331c519df924a08bb78d9249eeae92038dd061ee98d8d0cc6"

RDEPENDS:gnome-settings-daemon = " \
 ModemManager-glib \
 NetworkManager-libnm \
 alsa-lib \
 bash \
 cairo \
 colord \
 colord-libs \
 cups-libs \
 fontconfig \
 gcr-libs \
 geoclue2 \
 geoclue2-libs \
 geocode-glib \
 glib2 \
 glibc \
 gnome-desktop3 \
 gsettings-desktop-schemas \
 gtk3 \
 iio-sensor-proxy \
 libX11 \
 libXext \
 libXfixes \
 libXi \
 libcanberra \
 libcanberra-gtk3 \
 libgcc \
 libgudev \
 libgweather \
 libnotify \
 libwacom \
 libwayland-client \
 p11-kit \
 pango \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 systemd-libs \
 upower-libs \
 "
RDEPENDS:gnome-settings-daemon-devel = " \
 gnome-settings-daemon \
 pkgconf-pkg-config \
 "
RDEPENDS:gnome-settings-daemon-server-defaults = " \
 gnome-settings-daemon \
 "
