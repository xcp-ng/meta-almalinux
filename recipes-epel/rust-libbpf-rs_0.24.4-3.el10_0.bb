# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbpf-rs"
PV = "0.24.4"
PR = "3.el10_0"
PACKAGES = " \
 rust-libbpf-rs+default-devel \
 rust-libbpf-rs+dont-generate-test-files-devel \
 rust-libbpf-rs+generate-test-files-devel \
 rust-libbpf-rs+libbpf-sys-devel \
 rust-libbpf-rs+static-devel \
 rust-libbpf-rs+vendored-devel \
 rust-libbpf-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbpf-rs-0.24.4-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd0be5c810cb3bff1a8afdb729cbd374b95ac01919ef499bdd1f3d0a08fcc92b"

URI_x86_64_v2_rust-libbpf-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+default-devel-0.24.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+default-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+default-devel.sha256sum] = "be58f4f3185669e32555613be20436e40a3893fbacb96651217e803ef1aa4e6f"

URI_x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+dont-generate-test-files-devel-0.24.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel.sha256sum] = "99117deb1c41dbabd597b686a49e2392aa97835927362e6e41f7c8f3fff98495"

URI_x86_64_v2_rust-libbpf-rs+generate-test-files-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+generate-test-files-devel-0.24.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+generate-test-files-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+generate-test-files-devel.sha256sum] = "86d9db2bccc499a3afaa163189ed4e177d33022855f0a59df0002f13e87324c2"

URI_x86_64_v2_rust-libbpf-rs+libbpf-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+libbpf-sys-devel-0.24.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+libbpf-sys-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+libbpf-sys-devel.sha256sum] = "214df10139181bab4fe575469986b04f668cb3839b323a63241b96f3fc45303f"

URI_x86_64_v2_rust-libbpf-rs+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+static-devel-0.24.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+static-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+static-devel.sha256sum] = "50f034074559197f19dd6dd8afef53ee4af732896b51f7a129dda6b34d93cef1"

URI_x86_64_v2_rust-libbpf-rs+vendored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+vendored-devel-0.24.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+vendored-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+vendored-devel.sha256sum] = "f2cfcdb09b65188c6dad77e55ecc0a1c623d6b42317252a71a0c79fa46ccad23"

URI_x86_64_v2_rust-libbpf-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs-devel-0.24.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs-devel.sha256sum] = "ac0e59f1277ec17602f9887a1a093c0e55ff1c54d7557ff6bbd6d82b8e14f8ab"

URI_aarch64_rust-libbpf-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+default-devel-0.24.4-3.el10_0.noarch.rpm;name=aarch64_rust-libbpf-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+default-devel}"
SRC_URI[aarch64_rust-libbpf-rs+default-devel.sha256sum] = "3c9041ff3a81356e8222cca6fdd177af77c3c0bcf7caaccb311adcfe1c8a168d"

URI_aarch64_rust-libbpf-rs+dont-generate-test-files-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+dont-generate-test-files-devel-0.24.4-3.el10_0.noarch.rpm;name=aarch64_rust-libbpf-rs+dont-generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+dont-generate-test-files-devel}"
SRC_URI[aarch64_rust-libbpf-rs+dont-generate-test-files-devel.sha256sum] = "ff2f8be24e2ab0a4e51021c37afda9259cbd904d0f1b5ae2da3868870b6e48bc"

URI_aarch64_rust-libbpf-rs+generate-test-files-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+generate-test-files-devel-0.24.4-3.el10_0.noarch.rpm;name=aarch64_rust-libbpf-rs+generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+generate-test-files-devel}"
SRC_URI[aarch64_rust-libbpf-rs+generate-test-files-devel.sha256sum] = "c2ea7a4d76c1ede0338ffaa5dc49fba91aa00615fd1877f9f4f2196335bcbbc4"

URI_aarch64_rust-libbpf-rs+libbpf-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+libbpf-sys-devel-0.24.4-3.el10_0.noarch.rpm;name=aarch64_rust-libbpf-rs+libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+libbpf-sys-devel}"
SRC_URI[aarch64_rust-libbpf-rs+libbpf-sys-devel.sha256sum] = "42d96e522702afd99d8850e4cbbabee2e43e648d340f8e57ea220489f81c4237"

URI_aarch64_rust-libbpf-rs+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+static-devel-0.24.4-3.el10_0.noarch.rpm;name=aarch64_rust-libbpf-rs+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+static-devel}"
SRC_URI[aarch64_rust-libbpf-rs+static-devel.sha256sum] = "2f2fd824d12030a5b067a181af1009c6e6e87c5943d90503ac7ac55964e44ed1"

URI_aarch64_rust-libbpf-rs+vendored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+vendored-devel-0.24.4-3.el10_0.noarch.rpm;name=aarch64_rust-libbpf-rs+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+vendored-devel}"
SRC_URI[aarch64_rust-libbpf-rs+vendored-devel.sha256sum] = "2d36e9a0f79cf4b788eec0f499f273d99904c450f2dab5aab3dca0b7e4dd9fd6"

URI_aarch64_rust-libbpf-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs-devel-0.24.4-3.el10_0.noarch.rpm;name=aarch64_rust-libbpf-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs-devel}"
SRC_URI[aarch64_rust-libbpf-rs-devel.sha256sum] = "31a5a4f5cb911bef85c73ebda0cd9a22c9dd33882065bb85b6f5549c851e50fd"

RDEPENDS:rust-libbpf-rs+default-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs+dont-generate-test-files-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 "
RDEPENDS:rust-libbpf-rs+generate-test-files-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 rust-tempfile+default-devel \
 "
RDEPENDS:rust-libbpf-rs+libbpf-sys-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs+static-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+static-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs+vendored-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+vendored-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-libbpf-sys-devel \
 rust-libc+default-devel \
 rust-vsprintf+default-devel \
 "
