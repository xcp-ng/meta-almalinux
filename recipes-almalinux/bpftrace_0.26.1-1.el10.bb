# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bpftrace"
PV = "0.26.1"
PR = "1.el10"
PACKAGES = " \
 bpftrace \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bpftrace-0.26.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "130ca38682a8b1ad6fba192e6b35d67d2dfd782095d701691827e5ade9d0eded"

URI_x86_64_v2_bpftrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bpftrace-0.26.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_bpftrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpftrace}"
SRC_URI[x86_64_v2_bpftrace.sha256sum] = "f8c51d83109c6526989e7a90066c124064e518b1810655c26f6c33778feb06b0"

URI_aarch64_bpftrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bpftrace-0.26.1-1.el10.aarch64.rpm;name=aarch64_bpftrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpftrace}"
SRC_URI[aarch64_bpftrace.sha256sum] = "b7f6e50e29a83ca59ee43fdcb124d7965b2ee2e70304ac797c7a7ada77037bb3"

RDEPENDS:bpftrace = " \
 bcc \
 clang-libs \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 zlib-ng-compat \
 "
