# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "umoci"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 umoci \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/umoci-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0d4d08766364f4a1e3abb7f10ee1fdd3755799336e2303cb81791933995f9866"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/umoci-0.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_umoci;unpack=0"
SRC_URI[x86_64_v2_umoci.sha256sum] = "c2917f9eb54cf6b7b565b875301b044a19c9ed46fb41d01344849b1b445e4727"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/umoci-0.6.0-1.el10_2.aarch64.rpm;name=aarch64_umoci;unpack=0"
SRC_URI[aarch64_umoci.sha256sum] = "e69d40abb2fa47910c74349ee8069e0b8d1829b8316c4be56c823c48c0277721"

RDEPENDS:umoci = " \
 glibc \
 "
