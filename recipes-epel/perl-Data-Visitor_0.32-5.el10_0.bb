# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Visitor"
PV = "0.32"
PR = "5.el10_0"
PACKAGES = " \
 perl-Data-Visitor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Visitor-0.32-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "844361c4ed1c1f999dd84b6c1ec2805f3fbed3aeb94217338ee094f2cc60b1ac"

URI_x86_64_v2_perl-Data-Visitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Visitor-0.32-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Visitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Visitor}"
SRC_URI[x86_64_v2_perl-Data-Visitor.sha256sum] = "b8a6fbedc9118f79d2a4042fd4f330671c9f1d96aab57c059253277bb6ce0db7"

URI_aarch64_perl-Data-Visitor = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Visitor-0.32-5.el10_0.noarch.rpm;name=aarch64_perl-Data-Visitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Visitor}"
SRC_URI[aarch64_perl-Data-Visitor.sha256sum] = "c676bf901f33c5be812b89ee5ca2d11d759551ad70185884e29a15394d6c42c9"

RDEPENDS:perl-Data-Visitor = " \
 perl-Carp \
 perl-Data-Visitor \
 perl-Moose \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-Tie-ToObject \
 perl-constant \
 perl-libs \
 perl-namespace-clean \
 perl-overload \
 "
