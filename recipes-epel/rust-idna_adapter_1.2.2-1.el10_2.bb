# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-idna_adapter"
PV = "1.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-idna_adapter+compiled_data-devel \
 rust-idna_adapter+default-devel \
 rust-idna_adapter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-idna_adapter-1.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bf9129425958a7d600cf08cc39c0aeefca36e52bb281674ec4e3ee942dc35a1"

URI_x86_64_v2_rust-idna_adapter+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter+compiled_data-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter+compiled_data-devel.sha256sum] = "a41cd784fafbea8ef670d9f9787f8719ce5ffcd405ca896d25ee82e1bc3f1fdf"

URI_x86_64_v2_rust-idna_adapter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter+default-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter+default-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter+default-devel.sha256sum] = "25b89646016e56e534bd2f44071aa3cf3d64bcd83147a61ee6460c53e8b711cd"

URI_x86_64_v2_rust-idna_adapter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna_adapter-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna_adapter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna_adapter-devel}"
SRC_URI[x86_64_v2_rust-idna_adapter-devel.sha256sum] = "5ad02c12a4f07397ad173aa68f544f73f5f87e6671825ca87fcdf62228717e6d"

URI_aarch64_rust-idna_adapter+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter+compiled_data-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-idna_adapter+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter+compiled_data-devel}"
SRC_URI[aarch64_rust-idna_adapter+compiled_data-devel.sha256sum] = "68647e9b6bb8b2cb0d1c0a588a9ee8fb40bd1470d1abe1842e515fa73ed79690"

URI_aarch64_rust-idna_adapter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter+default-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-idna_adapter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter+default-devel}"
SRC_URI[aarch64_rust-idna_adapter+default-devel.sha256sum] = "391351802db644f6b94e4f63f7f8fefd20e72d790e6a962a8532bb71ee51e292"

URI_aarch64_rust-idna_adapter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna_adapter-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-idna_adapter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna_adapter-devel}"
SRC_URI[aarch64_rust-idna_adapter-devel.sha256sum] = "bfb02afe583591757020e9fc08a8e1883a59375c60cf21e3564bfd384b7736c6"

RDEPENDS:rust-idna_adapter+compiled_data-devel = " \
 cargo \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_properties+compiled_data-devel \
 rust-idna_adapter-devel \
 "
RDEPENDS:rust-idna_adapter+default-devel = " \
 cargo \
 rust-idna_adapter-devel \
 "
RDEPENDS:rust-idna_adapter-devel = " \
 cargo \
 rust \
 rust-icu_normalizer-devel \
 rust-icu_properties-devel \
 "
