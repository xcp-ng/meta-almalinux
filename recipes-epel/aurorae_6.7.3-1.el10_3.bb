# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aurorae"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 aurorae \
 aurorae-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aurorae-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9aece776cff7666684d9843e41ec7780a51931aac8aa6cf19151328a96c7a1d"

URI_x86_64_v2_aurorae = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aurorae-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aurorae;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aurorae}"
SRC_URI[x86_64_v2_aurorae.sha256sum] = "5de07a4faac189b0f1ce7c163140b4a51f9ca764ee6e47596c41989c8b0cb5ef"

URI_x86_64_v2_aurorae-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aurorae-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aurorae-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aurorae-devel}"
SRC_URI[x86_64_v2_aurorae-devel.sha256sum] = "b4889aeece86f6b43d805fafe3fcfbed942fce7d20adc28a0d85746184664f2d"

URI_aarch64_aurorae = "${EPEL_MIRROR}/aarch64/Packages/a/aurorae-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_aurorae;unpack=0"
SRC_URI:append = " ${URI_aarch64_aurorae}"
SRC_URI[aarch64_aurorae.sha256sum] = "ca4f5983ed9a5c7e14536102c92e24a7f7a7da425d4088b83ce2438817ab844f"

URI_aarch64_aurorae-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aurorae-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_aurorae-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aurorae-devel}"
SRC_URI[aarch64_aurorae-devel.sha256sum] = "f12dd896d57177d1018888f1400f6e8ddd4a5d61069520cd6c7a5c09ed2f81a4"

RDEPENDS:aurorae = " \
 bash \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-ksvg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 "
RDEPENDS:aurorae-devel = " \
 aurorae \
 cmake-filesystem \
 "
