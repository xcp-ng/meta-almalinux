# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Time-Piece-MySQL"
PV = "0.06"
PR = "22.el10_3"
PACKAGES = " \
 perl-Time-Piece-MySQL \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Time-Piece-MySQL-0.06-22.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00b4f69d69c78808d3390caa526c28c32a9691ac7175484c79ec7788c18fd7c5"

URI_x86_64_v2_perl-Time-Piece-MySQL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Time-Piece-MySQL-0.06-22.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Time-Piece-MySQL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Time-Piece-MySQL}"
SRC_URI[x86_64_v2_perl-Time-Piece-MySQL.sha256sum] = "5a2b2d045d6140cbf7e897d4b5fd93ad47b1985b4207619341d6b9479de1a06f"

URI_aarch64_perl-Time-Piece-MySQL = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Time-Piece-MySQL-0.06-22.el10_3.noarch.rpm;name=aarch64_perl-Time-Piece-MySQL;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Time-Piece-MySQL}"
SRC_URI[aarch64_perl-Time-Piece-MySQL.sha256sum] = "d091870934518df9a49a14e8bd60d55f493fb52da843ea59835133737fcbc282"

RDEPENDS:perl-Time-Piece-MySQL = " \
 perl-Time-Piece \
 perl-libs \
 perl-vars \
 "
