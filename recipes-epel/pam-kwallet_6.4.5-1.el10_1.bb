# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam-kwallet"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 pam-kwallet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam-kwallet-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86492a16551a1502c3b7537ae11bf5b4f411378e210951a3ba251af9b86820ac"

URI_x86_64_v2_pam-kwallet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam-kwallet-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam-kwallet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-kwallet}"
SRC_URI[x86_64_v2_pam-kwallet.sha256sum] = "b97464bd8e60ec71b528f05d9951abee4dd397c4ed1b3da6df89165e930e7288"

URI_aarch64_pam-kwallet = "${EPEL_MIRROR}/aarch64/Packages/p/pam-kwallet-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_pam-kwallet;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-kwallet}"
SRC_URI[aarch64_pam-kwallet.sha256sum] = "bd14dc38388e94ebe48a844bd877aa63647798e33cfa49103ffcb05ecee81ac9"

RDEPENDS:pam-kwallet = " \
 bash \
 glibc \
 kf6-kwallet \
 libgcrypt \
 pam-libs \
 socat \
 "
