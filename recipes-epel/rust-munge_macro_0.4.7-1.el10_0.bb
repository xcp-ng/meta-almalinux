# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-munge_macro"
PV = "0.4.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-munge_macro+default-devel \
 rust-munge_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-munge_macro-0.4.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5157f69f54c9b451632eea23d6cabf0377f70bfbb25a44c33e000e953678326"

URI_x86_64_v2_rust-munge_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-munge_macro+default-devel-0.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-munge_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-munge_macro+default-devel}"
SRC_URI[x86_64_v2_rust-munge_macro+default-devel.sha256sum] = "7b9485bae2303ebc1cdba92fbe419886f128c3faf1b10ab662a4b88d482633b0"

URI_x86_64_v2_rust-munge_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-munge_macro-devel-0.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-munge_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-munge_macro-devel}"
SRC_URI[x86_64_v2_rust-munge_macro-devel.sha256sum] = "00920011814998c855a88e76736b394bbfe63ea1b3941cb8dbe398b13a92b2c5"

URI_aarch64_rust-munge_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-munge_macro+default-devel-0.4.7-1.el10_0.noarch.rpm;name=aarch64_rust-munge_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-munge_macro+default-devel}"
SRC_URI[aarch64_rust-munge_macro+default-devel.sha256sum] = "da30650e4aecc7280527de0f34ffdd88d5faf6cf31a3418c834623612c817f22"

URI_aarch64_rust-munge_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-munge_macro-devel-0.4.7-1.el10_0.noarch.rpm;name=aarch64_rust-munge_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-munge_macro-devel}"
SRC_URI[aarch64_rust-munge_macro-devel.sha256sum] = "5a6e37dc348d0000c44a351e1980f87b8b78aa22341fa8ea3312755136ebc9fe"

RDEPENDS:rust-munge_macro+default-devel = " \
 cargo \
 rust-munge_macro-devel \
 "
RDEPENDS:rust-munge_macro-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
