# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Params-Util"
PV = "1.102"
PR = "19.el10"
PACKAGES = " \
 perl-Params-Util \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Params-Util-1.102-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8898466f2815634de115a533c382cf51535cebfaf56ea1f0b01e8ca894c83a78"

URI_x86_64_v2_perl-Params-Util = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Params-Util-1.102-19.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Params-Util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Params-Util}"
SRC_URI[x86_64_v2_perl-Params-Util.sha256sum] = "ac59bbb594b113f68799ca15ec6b53453e5a284c8e13c87db9691a21b5a017bc"

URI_aarch64_perl-Params-Util = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Params-Util-1.102-19.el10.aarch64.rpm;name=aarch64_perl-Params-Util;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Params-Util}"
SRC_URI[aarch64_perl-Params-Util.sha256sum] = "56fdb00d29a519ef41171f1351980cb53153906bf552345dd81d538efc29d462"

RDEPENDS:perl-Params-Util = " \
 glibc \
 perl-Exporter \
 perl-Params-Util \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 perl-parent \
 "
