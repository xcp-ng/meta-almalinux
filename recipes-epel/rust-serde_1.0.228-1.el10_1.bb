# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde"
PV = "1.0.228"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde+alloc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde+serde_derive-devel \
 rust-serde+std-devel \
 rust-serde+unstable-devel \
 rust-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde-1.0.228-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "434a9995d455ec9c243b41a9d775c27b58a7d10ee369633fc575035df6704ebe"

URI_x86_64_v2_rust-serde+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+alloc-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde+alloc-devel.sha256sum] = "e02b1585dd4882389ea8bc3cbb8a0826fbeb1c6e557ad87e9fe9a34ea9c60015"

URI_x86_64_v2_rust-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+default-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+default-devel}"
SRC_URI[x86_64_v2_rust-serde+default-devel.sha256sum] = "86aa6525856d342c6fdc5280438ee881c28bde2dc10d7b6775819222e5c031e5"

URI_x86_64_v2_rust-serde+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+derive-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+derive-devel}"
SRC_URI[x86_64_v2_rust-serde+derive-devel.sha256sum] = "165bdbbd3b8e9631b6ecb7d8455449b88c035800606b7d1d43c57251e5ff56df"

URI_x86_64_v2_rust-serde+rc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+rc-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+rc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+rc-devel}"
SRC_URI[x86_64_v2_rust-serde+rc-devel.sha256sum] = "6466980c49e8d01d90a3aeaa2f868bc3be670a4051e11f4fd4b9c2e36d26b056"

URI_x86_64_v2_rust-serde+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+serde_derive-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-serde+serde_derive-devel.sha256sum] = "c7fdc633cc8e488aa1a363059bcb53e55dd81f102c847046ef59192498352948"

URI_x86_64_v2_rust-serde+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+std-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+std-devel}"
SRC_URI[x86_64_v2_rust-serde+std-devel.sha256sum] = "04c1f2759efa3453a1c77e0dfcb4ba61a2cf7d41f0d3b77b71546f0df4b6a577"

URI_x86_64_v2_rust-serde+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+unstable-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+unstable-devel}"
SRC_URI[x86_64_v2_rust-serde+unstable-devel.sha256sum] = "50ec257710f056e5c1d2c52efa57aaccdf685abe578e32c187419a9e3707697e"

URI_x86_64_v2_rust-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-devel-1.0.228-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-devel}"
SRC_URI[x86_64_v2_rust-serde-devel.sha256sum] = "f1dd5fe48934e5789c18cdb1d76a256c473e02adff880341dd61f45588d68fdf"

URI_aarch64_rust-serde+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+alloc-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+alloc-devel}"
SRC_URI[aarch64_rust-serde+alloc-devel.sha256sum] = "4e9bc5713564871f02ae041f1cb1c32fef1586f1f466acf2f853e4678a48cff4"

URI_aarch64_rust-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+default-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+default-devel}"
SRC_URI[aarch64_rust-serde+default-devel.sha256sum] = "87f04656ea31a207c3573adc94cead1ef59d998a0bf7a2e3ff1e18c765f048c4"

URI_aarch64_rust-serde+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+derive-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+derive-devel}"
SRC_URI[aarch64_rust-serde+derive-devel.sha256sum] = "8c45501d67e9eae4a1dfe4470ab97701e4400089fb1e119fd7926788797f42ca"

URI_aarch64_rust-serde+rc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+rc-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde+rc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+rc-devel}"
SRC_URI[aarch64_rust-serde+rc-devel.sha256sum] = "33c6422de5c922466b84b0d9ca73c8bb15b5490d0ec65b3b24dffaf5eec77331"

URI_aarch64_rust-serde+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+serde_derive-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+serde_derive-devel}"
SRC_URI[aarch64_rust-serde+serde_derive-devel.sha256sum] = "d9c012885ae06d5fadf2c21fc215dbaa8c2d70c42f9fd21a619c034967be701f"

URI_aarch64_rust-serde+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+std-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+std-devel}"
SRC_URI[aarch64_rust-serde+std-devel.sha256sum] = "cc8a585ba531c241be81a68692885851f53431d963f0ef26d634c8b191396b16"

URI_aarch64_rust-serde+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+unstable-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+unstable-devel}"
SRC_URI[aarch64_rust-serde+unstable-devel.sha256sum] = "9f70904b27f4083fdcfeda729b751f147de96df0c3edfb648a48a55998f3c6a6"

URI_aarch64_rust-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-devel-1.0.228-1.el10_1.noarch.rpm;name=aarch64_rust-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-devel}"
SRC_URI[aarch64_rust-serde-devel.sha256sum] = "5fe50aca224974aa9973d956c8f538938361353650914d2ac51f4588a5ccd020"

RDEPENDS:rust-serde+alloc-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 "
RDEPENDS:rust-serde+default-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-serde+derive-devel = " \
 cargo \
 rust-serde+serde_derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-serde+rc-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+rc-devel \
 "
RDEPENDS:rust-serde+serde_derive-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-serde+std-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+std-devel \
 "
RDEPENDS:rust-serde+unstable-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+unstable-devel \
 "
RDEPENDS:rust-serde-devel = " \
 cargo \
 rust \
 rust-serde_core+result-devel \
 rust-serde_core-devel \
 "
