# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CBOR-XS"
PV = "1.87"
PR = "1.el10_0"
PACKAGES = " \
 perl-CBOR-XS \
 perl-CBOR-XS-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CBOR-XS-1.87-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fd284cda02dd8a4d6526c4dd6f8abdce0d2080cfa3d2e41239325612fef2aba"

URI_x86_64_v2_perl-CBOR-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CBOR-XS-1.87-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-CBOR-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CBOR-XS}"
SRC_URI[x86_64_v2_perl-CBOR-XS.sha256sum] = "6ef66cecd650a1f1a7a448aac15c702827b2d6f09a00182472f6705da0bbc689"

URI_x86_64_v2_perl-CBOR-XS-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CBOR-XS-tests-1.87-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CBOR-XS-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CBOR-XS-tests}"
SRC_URI[x86_64_v2_perl-CBOR-XS-tests.sha256sum] = "0ef21eb062718945e81114c743fb71fd5484668357b46013ce0245824abe5792"

URI_aarch64_perl-CBOR-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CBOR-XS-1.87-1.el10_0.aarch64.rpm;name=aarch64_perl-CBOR-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CBOR-XS}"
SRC_URI[aarch64_perl-CBOR-XS.sha256sum] = "ae70d4ebaa77636c9a0153cb786b43f3e4a0daf26ffa9e595b05efd63309ce98"

URI_aarch64_perl-CBOR-XS-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CBOR-XS-tests-1.87-1.el10_0.noarch.rpm;name=aarch64_perl-CBOR-XS-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CBOR-XS-tests}"
SRC_URI[aarch64_perl-CBOR-XS-tests.sha256sum] = "1c7f6bde187475353e4e7706cb646429bd1dd157652a3cadf1f135627b75d74f"

RDEPENDS:perl-CBOR-XS = " \
 glibc \
 perl-Exporter \
 perl-Math-BigInt \
 perl-Time-Piece \
 perl-Types-Serialiser \
 perl-URI \
 perl-common-sense \
 perl-libs \
 "
RDEPENDS:perl-CBOR-XS-tests = " \
 bash \
 perl-CBOR-XS \
 perl-Data-Dumper \
 perl-Math-BigInt \
 perl-Math-BigInt-FastCalc \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Types-Serialiser \
 "
