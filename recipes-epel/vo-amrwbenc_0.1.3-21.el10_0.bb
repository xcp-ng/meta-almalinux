# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vo-amrwbenc"
PV = "0.1.3"
PR = "21.el10_0"
PACKAGES = " \
 vo-amrwbenc \
 vo-amrwbenc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vo-amrwbenc-0.1.3-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d94dfa7568136e794c21eff25e9816c6560de11cc05bee8201d9811153b40320"

URI_x86_64_v2_vo-amrwbenc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vo-amrwbenc-0.1.3-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vo-amrwbenc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vo-amrwbenc}"
SRC_URI[x86_64_v2_vo-amrwbenc.sha256sum] = "65da7513420aba0e4f7f718c9949dbe868fc4371bd683b7e5ef5acb9cdcd67de"

URI_x86_64_v2_vo-amrwbenc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vo-amrwbenc-devel-0.1.3-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vo-amrwbenc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vo-amrwbenc-devel}"
SRC_URI[x86_64_v2_vo-amrwbenc-devel.sha256sum] = "e8e1aac147893f512fa428240a554deeccd062f3b1b26ede50b4ba1ce3071a0d"

URI_aarch64_vo-amrwbenc = "${EPEL_MIRROR}/aarch64/Packages/v/vo-amrwbenc-0.1.3-21.el10_0.aarch64.rpm;name=aarch64_vo-amrwbenc;unpack=0"
SRC_URI:append = " ${URI_aarch64_vo-amrwbenc}"
SRC_URI[aarch64_vo-amrwbenc.sha256sum] = "2c2cb306c7b9bfb6f17a6e17fdf7d25ad35a09d9aaf8129a3c2bde82a384235f"

URI_aarch64_vo-amrwbenc-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vo-amrwbenc-devel-0.1.3-21.el10_0.aarch64.rpm;name=aarch64_vo-amrwbenc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vo-amrwbenc-devel}"
SRC_URI[aarch64_vo-amrwbenc-devel.sha256sum] = "9c7aea145f99d08832ff2e68047a3915d0922c565f767603322a01080a8c317a"

RDEPENDS:vo-amrwbenc = " \
 glibc \
 "
RDEPENDS:vo-amrwbenc-devel = " \
 pkgconf-pkg-config \
 vo-amrwbenc \
 "
