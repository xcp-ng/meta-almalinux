# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "enchant2"
PV = "2.6.9"
PR = "1.el10"
PACKAGES = " \
 enchant2 \
 enchant2-devel \
 enchant2-voikko \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/enchant2-2.6.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "299c74e11ccd5cdf7e00c6ca89160fd321cd3de25c741c64908fa0b58ca3e8a9"

URI_x86_64_v2_enchant2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/enchant2-2.6.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_enchant2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_enchant2}"
SRC_URI[x86_64_v2_enchant2.sha256sum] = "13f6583f624ca1795e74e6c57d2dfe04db22fb46794086e38fce1f7220e25d76"

URI_x86_64_v2_enchant2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/enchant2-devel-2.6.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_enchant2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_enchant2-devel}"
SRC_URI[x86_64_v2_enchant2-devel.sha256sum] = "20b1b560e4d7230d46146a45c315414f4579059ef15fb42fc82e942095455e55"

URI_x86_64_v2_enchant2-voikko = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/enchant2-voikko-2.6.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_enchant2-voikko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_enchant2-voikko}"
SRC_URI[x86_64_v2_enchant2-voikko.sha256sum] = "5ff05b29382b9c1da447d8ceb2425203b7001d54760f6cce37cae6007c753df0"

URI_aarch64_enchant2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/enchant2-2.6.9-1.el10.aarch64.rpm;name=aarch64_enchant2;unpack=0"
SRC_URI:append = " ${URI_aarch64_enchant2}"
SRC_URI[aarch64_enchant2.sha256sum] = "2379ebb8c8670ee606125313a361a3d8945fb83894fb3eb786410262677f98fe"

URI_aarch64_enchant2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/enchant2-devel-2.6.9-1.el10.aarch64.rpm;name=aarch64_enchant2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_enchant2-devel}"
SRC_URI[aarch64_enchant2-devel.sha256sum] = "b8c771048cc4ffcee607dbbf288fea08704ccfbbdb2f0afd6ffaf5fd52f836d4"

URI_aarch64_enchant2-voikko = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/enchant2-voikko-2.6.9-1.el10.aarch64.rpm;name=aarch64_enchant2-voikko;unpack=0"
SRC_URI:append = " ${URI_aarch64_enchant2-voikko}"
SRC_URI[aarch64_enchant2-voikko.sha256sum] = "6518216b0342c9583d68474dc53a6594eb7be28f97d7b3ae7ebd0c7781ec62d0"

RDEPENDS:enchant2 = " \
 glib2 \
 glibc \
 hunspell \
 libgcc \
 libstdc++ \
 "
RDEPENDS:enchant2-devel = " \
 enchant2 \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:enchant2-voikko = " \
 enchant2 \
 glib2 \
 glibc \
 libvoikko \
 "
