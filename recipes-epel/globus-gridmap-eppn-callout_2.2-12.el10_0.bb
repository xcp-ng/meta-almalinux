# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gridmap-eppn-callout"
PV = "2.2"
PR = "12.el10_0"
PACKAGES = " \
 globus-gridmap-eppn-callout \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gridmap-eppn-callout-2.2-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69522391448d9d23e7d4bf4b5fa23c063f5a51f31aceb716aed0f905d4908a5e"

URI_x86_64_v2_globus-gridmap-eppn-callout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridmap-eppn-callout-2.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridmap-eppn-callout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridmap-eppn-callout}"
SRC_URI[x86_64_v2_globus-gridmap-eppn-callout.sha256sum] = "0febf08bcd2669cebb9da7405ba7dd2f7a0942ff3ff30c42ba7b5a6bc0a29e59"

URI_aarch64_globus-gridmap-eppn-callout = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridmap-eppn-callout-2.2-12.el10_0.aarch64.rpm;name=aarch64_globus-gridmap-eppn-callout;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridmap-eppn-callout}"
SRC_URI[aarch64_globus-gridmap-eppn-callout.sha256sum] = "b86faa13d3e014ee7c75dc5223334baaced60d5e0f8f9d3e2fec62e8803739f3"

RDEPENDS:globus-gridmap-eppn-callout = " \
 glibc \
 globus-common \
 globus-gridmap-callout-error \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gsi-openssl-error \
 globus-gss-assist \
 globus-gssapi-error \
 globus-gssapi-gsi \
 openssl-libs \
 "
