# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "quota"
PE = "1"
PV = "4.09"
PR = "9.el10"
PACKAGES = " \
 quota \
 quota-devel \
 quota-doc \
 quota-nld \
 quota-nls \
 quota-rpc \
 quota-warnquota \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/quota-4.09-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee43a2746d057ec41b295eb91a2fac64d03c2096032eebb7d5d0d7f69a83c805"

URI_x86_64_v2_quota = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/quota-4.09-9.el10.x86_64_v2.rpm;name=x86_64_v2_quota;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_quota}"
SRC_URI[x86_64_v2_quota.sha256sum] = "5a258c7877e2af69d1c9cafd95ded6249c0cf6c66cb4eb0e5263e43ba1286f6b"

URI_x86_64_v2_quota-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/quota-devel-4.09-9.el10.x86_64_v2.rpm;name=x86_64_v2_quota-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_quota-devel}"
SRC_URI[x86_64_v2_quota-devel.sha256sum] = "b247a61a8553f435a6abadd14e91dbabc9a88dc813f6078fc35089b0d9687abc"

URI_x86_64_v2_quota-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/quota-doc-4.09-9.el10.noarch.rpm;name=x86_64_v2_quota-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_quota-doc}"
SRC_URI[x86_64_v2_quota-doc.sha256sum] = "b9c9b1457bbf8887675e43e680c92853ee09367b0f9330d6a1ea4626f2443547"

URI_x86_64_v2_quota-nld = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/quota-nld-4.09-9.el10.x86_64_v2.rpm;name=x86_64_v2_quota-nld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_quota-nld}"
SRC_URI[x86_64_v2_quota-nld.sha256sum] = "1262617ef7c89b72840376cd51348d39ae77d1eb8f1f27d85e4c09f8ff3038d6"

URI_x86_64_v2_quota-nls = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/quota-nls-4.09-9.el10.noarch.rpm;name=x86_64_v2_quota-nls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_quota-nls}"
SRC_URI[x86_64_v2_quota-nls.sha256sum] = "0b67cc0b51418d1cb7e14f3bba95765a98152a64f028add27b2cd3b6fa62d67e"

URI_x86_64_v2_quota-rpc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/quota-rpc-4.09-9.el10.x86_64_v2.rpm;name=x86_64_v2_quota-rpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_quota-rpc}"
SRC_URI[x86_64_v2_quota-rpc.sha256sum] = "34a54d640aaed5376916763b4e3ed86449bba030e6679de670f46ae08230d8c5"

URI_x86_64_v2_quota-warnquota = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/quota-warnquota-4.09-9.el10.x86_64_v2.rpm;name=x86_64_v2_quota-warnquota;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_quota-warnquota}"
SRC_URI[x86_64_v2_quota-warnquota.sha256sum] = "ff4c5ce8c781929af509dc0818183d56637cd9d5fb69d4178ba2ec43111cd956"

URI_aarch64_quota = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/quota-4.09-9.el10.aarch64.rpm;name=aarch64_quota;unpack=0"
SRC_URI:append = " ${URI_aarch64_quota}"
SRC_URI[aarch64_quota.sha256sum] = "4f5ed14093e2291530c6bf4599e552d9e6175a5eb063571fb176c4cdeebb6ccc"

URI_aarch64_quota-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/quota-devel-4.09-9.el10.aarch64.rpm;name=aarch64_quota-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_quota-devel}"
SRC_URI[aarch64_quota-devel.sha256sum] = "31817c92050eb13776bb18f9bc31caf5062578bc988690a6204e6df9140460df"

URI_aarch64_quota-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/quota-doc-4.09-9.el10.noarch.rpm;name=aarch64_quota-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_quota-doc}"
SRC_URI[aarch64_quota-doc.sha256sum] = "b9c9b1457bbf8887675e43e680c92853ee09367b0f9330d6a1ea4626f2443547"

URI_aarch64_quota-nld = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/quota-nld-4.09-9.el10.aarch64.rpm;name=aarch64_quota-nld;unpack=0"
SRC_URI:append = " ${URI_aarch64_quota-nld}"
SRC_URI[aarch64_quota-nld.sha256sum] = "d6da33a09f26563211d4f3f4a09905ce09c807f6437b3b59fae266457ae4f606"

URI_aarch64_quota-nls = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/quota-nls-4.09-9.el10.noarch.rpm;name=aarch64_quota-nls;unpack=0"
SRC_URI:append = " ${URI_aarch64_quota-nls}"
SRC_URI[aarch64_quota-nls.sha256sum] = "0b67cc0b51418d1cb7e14f3bba95765a98152a64f028add27b2cd3b6fa62d67e"

URI_aarch64_quota-rpc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/quota-rpc-4.09-9.el10.aarch64.rpm;name=aarch64_quota-rpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_quota-rpc}"
SRC_URI[aarch64_quota-rpc.sha256sum] = "53c89f3cb234ccb28ddb75043d7ff35125869920541ea053beef125adbe56d72"

URI_aarch64_quota-warnquota = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/quota-warnquota-4.09-9.el10.aarch64.rpm;name=aarch64_quota-warnquota;unpack=0"
SRC_URI:append = " ${URI_aarch64_quota-warnquota}"
SRC_URI[aarch64_quota-warnquota.sha256sum] = "b7c1045b0eb3da7952ecce72ace284ff2126dc241f57bc7f8bbf36f64cd6db31"

RDEPENDS:quota = " \
 e2fsprogs-libs \
 glibc \
 libtirpc \
 quota-nls \
 "
RDEPENDS:quota-devel = " \
 libtirpc-devel \
 "
RDEPENDS:quota-doc = " \
 quota \
 "
RDEPENDS:quota-nld = " \
 bash \
 dbus-libs \
 glibc \
 libnl3 \
 quota-nls \
 systemd \
 "
RDEPENDS:quota-nls = " \
 "
RDEPENDS:quota-rpc = " \
 bash \
 glibc \
 libtirpc \
 quota-nls \
 rpcbind \
 systemd \
 "
RDEPENDS:quota-warnquota = " \
 glibc \
 libtirpc \
 openldap \
 quota-nls \
 "
