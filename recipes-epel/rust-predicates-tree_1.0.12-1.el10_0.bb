# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-predicates-tree"
PV = "1.0.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-predicates-tree+default-devel \
 rust-predicates-tree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-predicates-tree-1.0.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a083e3f4c14fd742c0c8c6c9cfe1c9c096276982b0b4a9ba96a1af1199db0599"

URI_x86_64_v2_rust-predicates-tree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-tree+default-devel-1.0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-tree+default-devel}"
SRC_URI[x86_64_v2_rust-predicates-tree+default-devel.sha256sum] = "35b759ebf22cad0a4fb0caf899e04d97c7db1b49663ffbe2235df206920da052"

URI_x86_64_v2_rust-predicates-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-tree-devel-1.0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-tree-devel}"
SRC_URI[x86_64_v2_rust-predicates-tree-devel.sha256sum] = "864e5ead6f873f83ea171efac09cf541405912d10151f84dfc18a7f300c7e499"

URI_aarch64_rust-predicates-tree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-tree+default-devel-1.0.12-1.el10_0.noarch.rpm;name=aarch64_rust-predicates-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-tree+default-devel}"
SRC_URI[aarch64_rust-predicates-tree+default-devel.sha256sum] = "70253c75afcf17127ee9d4da09fd8dd5a5ae0fddae13ce594dbe580c535cd2e6"

URI_aarch64_rust-predicates-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-tree-devel-1.0.12-1.el10_0.noarch.rpm;name=aarch64_rust-predicates-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-tree-devel}"
SRC_URI[aarch64_rust-predicates-tree-devel.sha256sum] = "69e3b5e5bd1a8c7a3a3a7bf6e58ac78fe0bf655e2fb2b6e2bac4233b0d9ad815"

RDEPENDS:rust-predicates-tree+default-devel = " \
 cargo \
 rust-predicates-tree-devel \
 "
RDEPENDS:rust-predicates-tree-devel = " \
 cargo \
 rust \
 rust-predicates-core+default-devel \
 rust-termtree+default-devel \
 "
