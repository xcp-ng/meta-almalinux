# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eventviews"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 eventviews \
 eventviews-devel \
 eventviews-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/eventviews-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e55b7f12cab2fefe21c9a83adef840a3ebb87a4301f760790169571a935bc551"

URI_x86_64_v2_eventviews = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eventviews;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews}"
SRC_URI[x86_64_v2_eventviews.sha256sum] = "37664704f6607c2408f75835a8123a9689113f03ab0cd33b0d1e3f06407d16ff"

URI_x86_64_v2_eventviews-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eventviews-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews-devel}"
SRC_URI[x86_64_v2_eventviews-devel.sha256sum] = "e9b3d958a1fd13cb72e7db2c3d5f9b1ebb442e4db0cc32205d1bf49fed8fa30b"

URI_x86_64_v2_eventviews-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_eventviews-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews-doc}"
SRC_URI[x86_64_v2_eventviews-doc.sha256sum] = "75a8ebd75338a13b9242b619731f14725fd949551d9257dceaef90595c841c7d"

URI_aarch64_eventviews = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_eventviews;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews}"
SRC_URI[aarch64_eventviews.sha256sum] = "f8ffcf67a60c6a5da8148d346f50b4693b424b523a5b38f3da2cfe499ed50b46"

URI_aarch64_eventviews-devel = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_eventviews-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews-devel}"
SRC_URI[aarch64_eventviews-devel.sha256sum] = "570f7ba102007cf08f4647cdc385a65ec740bd4a33030d3421a9a2761e76af2c"

URI_aarch64_eventviews-doc = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_eventviews-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews-doc}"
SRC_URI[aarch64_eventviews-doc.sha256sum] = "9e5396107ed563a7044ed2d36c8fe9ff4bc6b773eef0d69d9bf4fb5460096b1f"

RDEPENDS:eventviews = " \
 akonadi-calendar \
 akonadi-server \
 calendarsupport \
 glibc \
 kcalutils \
 kdiagram \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 libgcc \
 libkdepim \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:eventviews-devel = " \
 akonadi-calendar-devel \
 akonadi-server-devel \
 calendarsupport-devel \
 cmake-filesystem \
 eventviews \
 kcalutils-devel \
 kf6-kcalendarcore-devel \
 "
RDEPENDS:eventviews-doc = " \
 "
