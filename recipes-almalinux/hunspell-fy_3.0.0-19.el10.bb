# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-fy"
PV = "3.0.0"
PR = "19.el10"
PACKAGES = " \
 hunspell-fy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-fy-3.0.0-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20ab13a8afb178d7a6f1e01379ef6d0176d54ed8dbc495d845623a5104bff05e"

URI_x86_64_v2_hunspell-fy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-fy-3.0.0-19.el10.noarch.rpm;name=x86_64_v2_hunspell-fy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-fy}"
SRC_URI[x86_64_v2_hunspell-fy.sha256sum] = "8f57143dd92ce03874d8dd53359c39b631be849ee3fcdc985ceade0e959790db"

URI_aarch64_hunspell-fy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-fy-3.0.0-19.el10.noarch.rpm;name=aarch64_hunspell-fy;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-fy}"
SRC_URI[aarch64_hunspell-fy.sha256sum] = "8f57143dd92ce03874d8dd53359c39b631be849ee3fcdc985ceade0e959790db"

RDEPENDS:hunspell-fy = " \
 hunspell-filesystem \
 "
