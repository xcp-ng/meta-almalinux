# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fence-agents"
PV = "4.16.0"
PR = "34.el10"
PACKAGES:x86_64_v2 = " \
 fence-agents-aliyun \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-aws \
 fence-agents-azure-arm \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-gce \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-nutanix-ahv \
 fence-agents-openstack \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
 fence-virtd \
 fence-virtd-cpg \
 fence-virtd-libvirt \
 fence-virtd-multicast \
 fence-virtd-serial \
 fence-virtd-tcp \
 ha-cloud-support \
"
PACKAGES:aarch64 = " \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-nutanix-ahv \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fence-agents-4.16.0-34.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "74e13fc5f71b73c57bac15478d081dbfc61fa9564d2887c84771dc0588701398"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aliyun-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aliyun;unpack=0"
SRC_URI[x86_64_v2_fence-agents-aliyun.sha256sum] = "71657781e0ac6b6c47f9aa07c3d615b735a510e3d5690a4d72f4ceee2ab6f654"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-all-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-all;unpack=0"
SRC_URI[x86_64_v2_fence-agents-all.sha256sum] = "86a412e04a52e032c7f2e4613279fafa333f92eceea6866238cc6c12ec025f3f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-amt-ws-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-amt-ws;unpack=0"
SRC_URI[x86_64_v2_fence-agents-amt-ws.sha256sum] = "681141121879a1086ccd63c831509cf4022ff740c27fb8ab2e580bd50cb51676"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-apc;unpack=0"
SRC_URI[x86_64_v2_fence-agents-apc.sha256sum] = "178e85fdd1bf871aa648af72a141e984a0e24d80ff1a5197c152e175056f776d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-snmp-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-apc-snmp;unpack=0"
SRC_URI[x86_64_v2_fence-agents-apc-snmp.sha256sum] = "3f8527a92a10377ea6fe069ac657d8dbe9e9480c35a17de0d5fa8acd811c3431"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aws-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aws;unpack=0"
SRC_URI[x86_64_v2_fence-agents-aws.sha256sum] = "ed6003c04817edd13adb45577e85d5c87d4c339e4c34a1bd81aac09ebec8839c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-azure-arm-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-azure-arm;unpack=0"
SRC_URI[x86_64_v2_fence-agents-azure-arm.sha256sum] = "a7e869274e7e85d0636f4873f77b96ecbaa60c62ad812827a68a16fccfc49d99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-bladecenter-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-bladecenter;unpack=0"
SRC_URI[x86_64_v2_fence-agents-bladecenter.sha256sum] = "cfa59d57f5af53fcd7b39d578bd70b183d54c87cd122b39fe6d80b61b06ad19d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-brocade-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-brocade;unpack=0"
SRC_URI[x86_64_v2_fence-agents-brocade.sha256sum] = "34e4c892908e6ded48277181e8fbba0e6d42b9382c8b691baf9886f22c6735e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-mds-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-cisco-mds;unpack=0"
SRC_URI[x86_64_v2_fence-agents-cisco-mds.sha256sum] = "2d734b1494112e248724a0337f937661e7263cb740edfbf173ca972f729d8c34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-ucs-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-cisco-ucs;unpack=0"
SRC_URI[x86_64_v2_fence-agents-cisco-ucs.sha256sum] = "6ff9ff75008121f5520d2cba196f3b77f76f8318ceba6fba554dbe8c51d6cd72"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-common-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-common;unpack=0"
SRC_URI[x86_64_v2_fence-agents-common.sha256sum] = "396e1518bd58246340519c10b47e73786b6c458341dc61b6ca1aa16914939e00"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-drac5-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-drac5;unpack=0"
SRC_URI[x86_64_v2_fence-agents-drac5.sha256sum] = "4c0cca83a6aee971e1606af01a4d7d1aa2f5c43e7bc920b2d2c0ec879146078c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eaton-snmp-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-eaton-snmp;unpack=0"
SRC_URI[x86_64_v2_fence-agents-eaton-snmp.sha256sum] = "20f47cd365bc287d2b0c460a566894f955aa6d81758738e08fe7f6d7b2fefd26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-emerson-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-emerson;unpack=0"
SRC_URI[x86_64_v2_fence-agents-emerson.sha256sum] = "8bc470eb46a3788ba565115aebb55da190d4da85beb7a07ece330f3449972497"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eps-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-eps;unpack=0"
SRC_URI[x86_64_v2_fence-agents-eps.sha256sum] = "ab3e0bf9d45d465d393340062d20053a2ff33066d8423516a928d7a652187d91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-gce-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-gce;unpack=0"
SRC_URI[x86_64_v2_fence-agents-gce.sha256sum] = "4b3394459025c6653d0b3ceabdb261e800e7244c7fecbb66089d698fcf1e28db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-heuristics-ping-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-heuristics-ping;unpack=0"
SRC_URI[x86_64_v2_fence-agents-heuristics-ping.sha256sum] = "f93f315a1fe148e065711898477d4fccdd3f02c61a732f7b9f87a076835b3f80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-hpblade-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-hpblade;unpack=0"
SRC_URI[x86_64_v2_fence-agents-hpblade.sha256sum] = "5b48cee27628167ba3b832e63e3ccbe23ce91a230936d406609ed7393a6b21fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-powervs-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-ibm-powervs;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ibm-powervs.sha256sum] = "eb4cf480abb0b086bf853d66decd35eff01d3555f298bc6b5ef632c563ab3953"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-vpc-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-ibm-vpc;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ibm-vpc.sha256sum] = "f02e5ca88859b81e973044b585d321c17526af3e923c82667e9d70b694c5cb03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibmblade-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-ibmblade;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ibmblade.sha256sum] = "05a20e26ef4d9d3d2d3dfb5ac11711c2bafaaeb002ccdb0a1d425e2b4ed88892"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ifmib-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-ifmib;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ifmib.sha256sum] = "179d266de5057587062ea6fde98a7c8bf7c8a6e4512dde4addf21720d9627078"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-moonshot-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-ilo-moonshot;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ilo-moonshot.sha256sum] = "16e2adf2dfb436e378e3981af9ac974cb652c24db7fd381301b30c64805a8e04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-mp-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-ilo-mp;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ilo-mp.sha256sum] = "eafb1797ed4c31bb0b57c68ae2e72ade0a690a87d6183eb7ea9cf749bfd1ff24"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-ssh-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-ilo-ssh;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ilo-ssh.sha256sum] = "7b97b09cf3cf5eb928ca368b4a39a3fcf1e909a40e08b19c39d7420425df3900"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo2-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-ilo2;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ilo2.sha256sum] = "d4df777c8a4e091d48a960e2af4b9f6aa55f62eb1168a02d904cf6360261a96b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-intelmodular-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-intelmodular;unpack=0"
SRC_URI[x86_64_v2_fence-agents-intelmodular.sha256sum] = "35399f90ab7bf592916193d108112ff7ca19263023761d560eeab9fbc6151f76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipdu-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-ipdu;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ipdu.sha256sum] = "95b232ae9f2651c56ffe303d6cfb61a678938b622be00db9130c09284fbf5176"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipmilan-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-ipmilan;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ipmilan.sha256sum] = "055ccc21512b2ea529d98b1c59c9628fd4896dde1bcdcbaac27c0a2adf543da9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kdump-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kdump;unpack=0"
SRC_URI[x86_64_v2_fence-agents-kdump.sha256sum] = "7f77a3edf3418b0fa531cfef26fc242acc590230a87a42d01e0986e37f2d6698"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kubevirt-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kubevirt;unpack=0"
SRC_URI[x86_64_v2_fence-agents-kubevirt.sha256sum] = "b8260bca73c6f2e29e421b53ce2d6e26379f637182cf0b50bd755f5ce5eb6be7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-lpar-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-lpar;unpack=0"
SRC_URI[x86_64_v2_fence-agents-lpar.sha256sum] = "6cc7eedddaa199cd49764673a106c4e28b47f7683bfa3fcd0193c167d021528c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-mpath-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-mpath;unpack=0"
SRC_URI[x86_64_v2_fence-agents-mpath.sha256sum] = "c7fc0ea382ce758b316dd27a5a52fbd6a13d0efb2d6f07715484e06284fb09f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-nutanix-ahv-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-nutanix-ahv;unpack=0"
SRC_URI[x86_64_v2_fence-agents-nutanix-ahv.sha256sum] = "1c76bc4e1982b565361a86fadfa8fceab911e6d5473766fcdf2d30bf7f5a057d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-openstack-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-openstack;unpack=0"
SRC_URI[x86_64_v2_fence-agents-openstack.sha256sum] = "da30517efe5052d53b7af6980f57f1f2bf0dff1f92aa04a40bbbd6811daa8be5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-redfish-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-agents-redfish;unpack=0"
SRC_URI[x86_64_v2_fence-agents-redfish.sha256sum] = "2e7ed4db8c27edf5f15392d03f05a2973c41e15f901f75a03ed2ac4da788f6a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rhevm-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-rhevm;unpack=0"
SRC_URI[x86_64_v2_fence-agents-rhevm.sha256sum] = "d5a2bc912828e66462cc3ad6e2aaddec7a882d061a359cc2970e527500d8b122"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsa-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-rsa;unpack=0"
SRC_URI[x86_64_v2_fence-agents-rsa.sha256sum] = "9add7d3d00c9ae6b2ad3f5a0fee1b2db1a9e8ae487a52d7492d18d8d30cb685b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsb-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-rsb;unpack=0"
SRC_URI[x86_64_v2_fence-agents-rsb.sha256sum] = "b49721672926681fcd6e612c1d7f02552ac8d2857d19c42117aa010598e0a471"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-sbd-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-sbd;unpack=0"
SRC_URI[x86_64_v2_fence-agents-sbd.sha256sum] = "e08a3c3688bdd3f219483af8dff6a14ab60cbdc6571a1c53f1f5f13922554b0e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-scsi-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-scsi;unpack=0"
SRC_URI[x86_64_v2_fence-agents-scsi.sha256sum] = "6d8dff9987858d96d615fe0202ed166a25876d38ddaaa9a4a9f4db2ed07ac046"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-virsh-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-virsh;unpack=0"
SRC_URI[x86_64_v2_fence-agents-virsh.sha256sum] = "f0406ddb2b1b559b47a1cdb44d20ff7a5b7e5def7a91171d109f43291ced809f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-rest-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-vmware-rest;unpack=0"
SRC_URI[x86_64_v2_fence-agents-vmware-rest.sha256sum] = "7925c62462017b09f330528560d679a401aec2b4d450e86b24d2966d5e9caf06"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-soap-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-vmware-soap;unpack=0"
SRC_URI[x86_64_v2_fence-agents-vmware-soap.sha256sum] = "81f4e7785767f21d104a51684fc130cd68d24bd8e7fececb8be8ec8a43f8624b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-wti-4.16.0-34.el10.noarch.rpm;name=x86_64_v2_fence-agents-wti;unpack=0"
SRC_URI[x86_64_v2_fence-agents-wti.sha256sum] = "c0e40afb220bb90cbb0dad6c27c68cbf27e7b936296b06e58a363499f976e8a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virt-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virt;unpack=0"
SRC_URI[x86_64_v2_fence-virt.sha256sum] = "86cea2b86e829541b0aaceefcf4c7691618aa17e42946a241d15d9d3cd26fa7e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd;unpack=0"
SRC_URI[x86_64_v2_fence-virtd.sha256sum] = "a3a166964db27d9af174ef16de21e2fb20ee1cbb54fa242880c571c94db28bec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-cpg-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-cpg;unpack=0"
SRC_URI[x86_64_v2_fence-virtd-cpg.sha256sum] = "062c13f0fcffa0d7b0dcf3ae1080f143d1519cbec013a1b1e39a6c81552139ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-libvirt-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-libvirt;unpack=0"
SRC_URI[x86_64_v2_fence-virtd-libvirt.sha256sum] = "0e4eab25908b642e1f6dcf94b414e6fa934e0836b96f07a3925569741adb49db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-multicast-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-multicast;unpack=0"
SRC_URI[x86_64_v2_fence-virtd-multicast.sha256sum] = "0616bf8404b7e28c21b951636cc7038b08f08e0922656fd51c6ac27a15442701"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-serial-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-serial;unpack=0"
SRC_URI[x86_64_v2_fence-virtd-serial.sha256sum] = "bbfaa7f31d2ecb838134d775ddef129e86a48b23d760bd17f31c57b1afc7dd94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-tcp-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-tcp;unpack=0"
SRC_URI[x86_64_v2_fence-virtd-tcp.sha256sum] = "7399ad8e1342a3e408d688e57f0925f67bdc91d2c7b61a4e85b74e3efbf5207e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ha-cloud-support-4.16.0-34.el10.x86_64_v2.rpm;name=x86_64_v2_ha-cloud-support;unpack=0"
SRC_URI[x86_64_v2_ha-cloud-support.sha256sum] = "c6c8e93b92e757e7fbe50c684450c07d5da61b273780a261286af40d2378270f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-all-4.16.0-34.el10.aarch64.rpm;name=aarch64_fence-agents-all;unpack=0"
SRC_URI[aarch64_fence-agents-all.sha256sum] = "146d0eaf09580ad99bc56192e67f390c66cb4b0359874a29736fba9974774328"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-amt-ws-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-amt-ws;unpack=0"
SRC_URI[aarch64_fence-agents-amt-ws.sha256sum] = "681141121879a1086ccd63c831509cf4022ff740c27fb8ab2e580bd50cb51676"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-apc;unpack=0"
SRC_URI[aarch64_fence-agents-apc.sha256sum] = "178e85fdd1bf871aa648af72a141e984a0e24d80ff1a5197c152e175056f776d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-snmp-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-apc-snmp;unpack=0"
SRC_URI[aarch64_fence-agents-apc-snmp.sha256sum] = "3f8527a92a10377ea6fe069ac657d8dbe9e9480c35a17de0d5fa8acd811c3431"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-bladecenter-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-bladecenter;unpack=0"
SRC_URI[aarch64_fence-agents-bladecenter.sha256sum] = "cfa59d57f5af53fcd7b39d578bd70b183d54c87cd122b39fe6d80b61b06ad19d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-brocade-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-brocade;unpack=0"
SRC_URI[aarch64_fence-agents-brocade.sha256sum] = "34e4c892908e6ded48277181e8fbba0e6d42b9382c8b691baf9886f22c6735e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-mds-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-cisco-mds;unpack=0"
SRC_URI[aarch64_fence-agents-cisco-mds.sha256sum] = "2d734b1494112e248724a0337f937661e7263cb740edfbf173ca972f729d8c34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-ucs-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-cisco-ucs;unpack=0"
SRC_URI[aarch64_fence-agents-cisco-ucs.sha256sum] = "6ff9ff75008121f5520d2cba196f3b77f76f8318ceba6fba554dbe8c51d6cd72"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-common-4.16.0-34.el10.aarch64.rpm;name=aarch64_fence-agents-common;unpack=0"
SRC_URI[aarch64_fence-agents-common.sha256sum] = "fcd09ea6b2d848b9cfebad558be8f2e8fe66ae89002dfed611b0e6afc1930633"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-drac5-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-drac5;unpack=0"
SRC_URI[aarch64_fence-agents-drac5.sha256sum] = "4c0cca83a6aee971e1606af01a4d7d1aa2f5c43e7bc920b2d2c0ec879146078c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eaton-snmp-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-eaton-snmp;unpack=0"
SRC_URI[aarch64_fence-agents-eaton-snmp.sha256sum] = "20f47cd365bc287d2b0c460a566894f955aa6d81758738e08fe7f6d7b2fefd26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-emerson-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-emerson;unpack=0"
SRC_URI[aarch64_fence-agents-emerson.sha256sum] = "8bc470eb46a3788ba565115aebb55da190d4da85beb7a07ece330f3449972497"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eps-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-eps;unpack=0"
SRC_URI[aarch64_fence-agents-eps.sha256sum] = "ab3e0bf9d45d465d393340062d20053a2ff33066d8423516a928d7a652187d91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-heuristics-ping-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-heuristics-ping;unpack=0"
SRC_URI[aarch64_fence-agents-heuristics-ping.sha256sum] = "f93f315a1fe148e065711898477d4fccdd3f02c61a732f7b9f87a076835b3f80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-hpblade-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-hpblade;unpack=0"
SRC_URI[aarch64_fence-agents-hpblade.sha256sum] = "5b48cee27628167ba3b832e63e3ccbe23ce91a230936d406609ed7393a6b21fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-powervs-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-ibm-powervs;unpack=0"
SRC_URI[aarch64_fence-agents-ibm-powervs.sha256sum] = "eb4cf480abb0b086bf853d66decd35eff01d3555f298bc6b5ef632c563ab3953"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-vpc-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-ibm-vpc;unpack=0"
SRC_URI[aarch64_fence-agents-ibm-vpc.sha256sum] = "f02e5ca88859b81e973044b585d321c17526af3e923c82667e9d70b694c5cb03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibmblade-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-ibmblade;unpack=0"
SRC_URI[aarch64_fence-agents-ibmblade.sha256sum] = "05a20e26ef4d9d3d2d3dfb5ac11711c2bafaaeb002ccdb0a1d425e2b4ed88892"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ifmib-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-ifmib;unpack=0"
SRC_URI[aarch64_fence-agents-ifmib.sha256sum] = "179d266de5057587062ea6fde98a7c8bf7c8a6e4512dde4addf21720d9627078"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-moonshot-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-ilo-moonshot;unpack=0"
SRC_URI[aarch64_fence-agents-ilo-moonshot.sha256sum] = "16e2adf2dfb436e378e3981af9ac974cb652c24db7fd381301b30c64805a8e04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-mp-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-ilo-mp;unpack=0"
SRC_URI[aarch64_fence-agents-ilo-mp.sha256sum] = "eafb1797ed4c31bb0b57c68ae2e72ade0a690a87d6183eb7ea9cf749bfd1ff24"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-ssh-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-ilo-ssh;unpack=0"
SRC_URI[aarch64_fence-agents-ilo-ssh.sha256sum] = "7b97b09cf3cf5eb928ca368b4a39a3fcf1e909a40e08b19c39d7420425df3900"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo2-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-ilo2;unpack=0"
SRC_URI[aarch64_fence-agents-ilo2.sha256sum] = "d4df777c8a4e091d48a960e2af4b9f6aa55f62eb1168a02d904cf6360261a96b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-intelmodular-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-intelmodular;unpack=0"
SRC_URI[aarch64_fence-agents-intelmodular.sha256sum] = "35399f90ab7bf592916193d108112ff7ca19263023761d560eeab9fbc6151f76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipdu-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-ipdu;unpack=0"
SRC_URI[aarch64_fence-agents-ipdu.sha256sum] = "95b232ae9f2651c56ffe303d6cfb61a678938b622be00db9130c09284fbf5176"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipmilan-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-ipmilan;unpack=0"
SRC_URI[aarch64_fence-agents-ipmilan.sha256sum] = "055ccc21512b2ea529d98b1c59c9628fd4896dde1bcdcbaac27c0a2adf543da9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kdump-4.16.0-34.el10.aarch64.rpm;name=aarch64_fence-agents-kdump;unpack=0"
SRC_URI[aarch64_fence-agents-kdump.sha256sum] = "1596fff772983cdea30475560b7fc97674ae6bc9d5ebd4fd348b7eb966a53578"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kubevirt-4.16.0-34.el10.aarch64.rpm;name=aarch64_fence-agents-kubevirt;unpack=0"
SRC_URI[aarch64_fence-agents-kubevirt.sha256sum] = "0a6979e8b3c9ce33203a8ebcb176531b2f4ec7dfc2532f52989f7dce5430203e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-lpar-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-lpar;unpack=0"
SRC_URI[aarch64_fence-agents-lpar.sha256sum] = "6cc7eedddaa199cd49764673a106c4e28b47f7683bfa3fcd0193c167d021528c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-mpath-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-mpath;unpack=0"
SRC_URI[aarch64_fence-agents-mpath.sha256sum] = "c7fc0ea382ce758b316dd27a5a52fbd6a13d0efb2d6f07715484e06284fb09f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-nutanix-ahv-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-nutanix-ahv;unpack=0"
SRC_URI[aarch64_fence-agents-nutanix-ahv.sha256sum] = "1c76bc4e1982b565361a86fadfa8fceab911e6d5473766fcdf2d30bf7f5a057d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-redfish-4.16.0-34.el10.aarch64.rpm;name=aarch64_fence-agents-redfish;unpack=0"
SRC_URI[aarch64_fence-agents-redfish.sha256sum] = "87bbe1bfd2e90f0781f6083c4c0789d1ffa81b6626288f912f6888f4c85e0285"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rhevm-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-rhevm;unpack=0"
SRC_URI[aarch64_fence-agents-rhevm.sha256sum] = "d5a2bc912828e66462cc3ad6e2aaddec7a882d061a359cc2970e527500d8b122"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsa-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-rsa;unpack=0"
SRC_URI[aarch64_fence-agents-rsa.sha256sum] = "9add7d3d00c9ae6b2ad3f5a0fee1b2db1a9e8ae487a52d7492d18d8d30cb685b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsb-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-rsb;unpack=0"
SRC_URI[aarch64_fence-agents-rsb.sha256sum] = "b49721672926681fcd6e612c1d7f02552ac8d2857d19c42117aa010598e0a471"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-sbd-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-sbd;unpack=0"
SRC_URI[aarch64_fence-agents-sbd.sha256sum] = "e08a3c3688bdd3f219483af8dff6a14ab60cbdc6571a1c53f1f5f13922554b0e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-scsi-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-scsi;unpack=0"
SRC_URI[aarch64_fence-agents-scsi.sha256sum] = "6d8dff9987858d96d615fe0202ed166a25876d38ddaaa9a4a9f4db2ed07ac046"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-virsh-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-virsh;unpack=0"
SRC_URI[aarch64_fence-agents-virsh.sha256sum] = "f0406ddb2b1b559b47a1cdb44d20ff7a5b7e5def7a91171d109f43291ced809f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-rest-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-vmware-rest;unpack=0"
SRC_URI[aarch64_fence-agents-vmware-rest.sha256sum] = "7925c62462017b09f330528560d679a401aec2b4d450e86b24d2966d5e9caf06"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-soap-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-vmware-soap;unpack=0"
SRC_URI[aarch64_fence-agents-vmware-soap.sha256sum] = "81f4e7785767f21d104a51684fc130cd68d24bd8e7fececb8be8ec8a43f8624b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-wti-4.16.0-34.el10.noarch.rpm;name=aarch64_fence-agents-wti;unpack=0"
SRC_URI[aarch64_fence-agents-wti.sha256sum] = "c0e40afb220bb90cbb0dad6c27c68cbf27e7b936296b06e58a363499f976e8a3"

RDEPENDS:fence-agents-aliyun = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 python3-jmespath \
 "
RDEPENDS:fence-agents-all:x86_64_v2 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
"
RDEPENDS:fence-agents-all:aarch64 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"
RDEPENDS:fence-agents-amt-ws = " \
 fence-agents-common \
 openwsman-python3 \
 python3 \
 "
RDEPENDS:fence-agents-apc = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-apc-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-aws = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-azure-arm = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-bladecenter = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-brocade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-cisco-mds = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-cisco-ucs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-common = " \
 glibc \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-pexpect \
 python3-ptyprocess \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:fence-agents-drac5 = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-eaton-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-emerson = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-eps = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-gce = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-heuristics-ping = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-hpblade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ibm-powervs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibm-vpc = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibmblade = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ifmib = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ilo-moonshot = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-mp = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-ssh = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo2 = " \
 fence-agents-common \
 gnutls-utils \
 python3 \
 "
RDEPENDS:fence-agents-intelmodular = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipdu = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipmilan = " \
 fence-agents-common \
 ipmitool \
 python3 \
 "
RDEPENDS:fence-agents-kdump = " \
 fence-agents-common \
 glibc \
 "
RDEPENDS:fence-agents-kubevirt = " \
 fence-agents-common \
 python3 \
 python3-charset-normalizer \
 python3-dateutil \
 python3-oauthlib \
 python3-pyasn1 \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-urllib3 \
 "
RDEPENDS:fence-agents-lpar = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-mpath = " \
 device-mapper-multipath \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-nutanix-ahv = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-openstack = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-redfish = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-rhevm = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-rsa = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-rsb = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-sbd = " \
 fence-agents-common \
 python3 \
 sbd \
 "
RDEPENDS:fence-agents-scsi = " \
 fence-agents-common \
 python3 \
 sg3_utils \
 "
RDEPENDS:fence-agents-virsh = " \
 fence-agents-common \
 libvirt-client \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-vmware-rest = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-vmware-soap = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-wti = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-virt = " \
 glibc \
 nss \
 systemd \
 "
RDEPENDS:fence-virtd = " \
 glibc \
 libuuid \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-cpg = " \
 corosynclib \
 fence-virtd \
 glibc \
 libqb \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-libvirt = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-multicast = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-serial = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 libxml2 \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-tcp = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:ha-cloud-support = " \
 awscli2 \
 glibc \
 python3-cffi \
 python3-charset-normalizer \
 python3-colorama \
 python3-cryptography \
 python3-dateutil \
 python3-docutils \
 python3-idna \
 python3-jmespath \
 python3-oauthlib \
 python3-packaging \
 python3-protobuf \
 python3-pyasn1 \
 python3-pycparser \
 python3-pyparsing \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-typing-extensions \
 python3-urllib3 \
 "
