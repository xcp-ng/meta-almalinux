# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Archive-Tar"
PV = "3.02"
PR = "512.el10_2.2"
PACKAGES = " \
 perl-Archive-Tar \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Archive-Tar-3.02-512.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54b6784f74468ae2ce4fc118988c231d11f43cf66c34e402ff96223c05b7bcc5"

URI_x86_64_v2_perl-Archive-Tar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Archive-Tar-3.02-512.el10_2.2.noarch.rpm;name=x86_64_v2_perl-Archive-Tar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Archive-Tar}"
SRC_URI[x86_64_v2_perl-Archive-Tar.sha256sum] = "d2c6df33777b5bff8ce63f4a073d414a7c9afac6e1da152d7b5a41393951e548"

URI_aarch64_perl-Archive-Tar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Archive-Tar-3.02-512.el10_2.2.noarch.rpm;name=aarch64_perl-Archive-Tar;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Archive-Tar}"
SRC_URI[aarch64_perl-Archive-Tar.sha256sum] = "d2c6df33777b5bff8ce63f4a073d414a7c9afac6e1da152d7b5a41393951e548"

RDEPENDS:perl-Archive-Tar = " \
 perl-Archive-Tar \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Compress-Lzma \
 perl-IO-Zlib \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Text-Diff \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
