# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simba"
PV = "0.9.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-simba+cordic-devel \
 rust-simba+default-devel \
 rust-simba+fixed-devel \
 rust-simba+libm-devel \
 rust-simba+libm_force-devel \
 rust-simba+partial_fixed_point_support-devel \
 rust-simba+portable_simd-devel \
 rust-simba+rand-devel \
 rust-simba+rkyv-devel \
 rust-simba+rkyv-serialize-devel \
 rust-simba+serde-devel \
 rust-simba+serde_serialize-devel \
 rust-simba+std-devel \
 rust-simba+wide-devel \
 rust-simba-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-simba-0.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f534d26b83891047f5144d598c1acec30aa005015ec5bba04e583275b00c4fa"

URI_x86_64_v2_rust-simba+cordic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+cordic-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+cordic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+cordic-devel}"
SRC_URI[x86_64_v2_rust-simba+cordic-devel.sha256sum] = "69bcbf74a08cd2fcb8dd5662a924e5e46e0399146a349c1f7b5edb5c5dcea875"

URI_x86_64_v2_rust-simba+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+default-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+default-devel}"
SRC_URI[x86_64_v2_rust-simba+default-devel.sha256sum] = "10bf09dfeeca3b9e392403630d94108769146ff39b188a3c01a14bf6026075cb"

URI_x86_64_v2_rust-simba+fixed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+fixed-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+fixed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+fixed-devel}"
SRC_URI[x86_64_v2_rust-simba+fixed-devel.sha256sum] = "f676cd8be9054e6a55dad148cbc67d8bf02b4546ca7a4cbbb91eed23b50046fc"

URI_x86_64_v2_rust-simba+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+libm-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+libm-devel}"
SRC_URI[x86_64_v2_rust-simba+libm-devel.sha256sum] = "80d7ffa827082de6f88a029c17f575cb6a4e7a77f36befc11a418d3d9809208a"

URI_x86_64_v2_rust-simba+libm_force-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+libm_force-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+libm_force-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+libm_force-devel}"
SRC_URI[x86_64_v2_rust-simba+libm_force-devel.sha256sum] = "9df6476d3690c7960725fc0b700136bd08f3b165ed15471dbe769869d10ea5ec"

URI_x86_64_v2_rust-simba+partial_fixed_point_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+partial_fixed_point_support-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+partial_fixed_point_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+partial_fixed_point_support-devel}"
SRC_URI[x86_64_v2_rust-simba+partial_fixed_point_support-devel.sha256sum] = "4458bf622d85ab4b3b00cd036f0a869f20d3c3d3b7cb9c16be3765c94e6abed5"

URI_x86_64_v2_rust-simba+portable_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+portable_simd-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+portable_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+portable_simd-devel}"
SRC_URI[x86_64_v2_rust-simba+portable_simd-devel.sha256sum] = "869f84a5d22952d68740e8a83366c5be3652e1e94f6ae5b21b866053224636f6"

URI_x86_64_v2_rust-simba+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+rand-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+rand-devel}"
SRC_URI[x86_64_v2_rust-simba+rand-devel.sha256sum] = "c77608d60c3f44ea633888e963e039cb7e0428e59c019cefe0d8433f69648b5c"

URI_x86_64_v2_rust-simba+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+rkyv-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+rkyv-devel}"
SRC_URI[x86_64_v2_rust-simba+rkyv-devel.sha256sum] = "a3b40eae83144d5022d18d1bbe79d85ecf0897dd423a90fd33425e1530794e1d"

URI_x86_64_v2_rust-simba+rkyv-serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+rkyv-serialize-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+rkyv-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+rkyv-serialize-devel}"
SRC_URI[x86_64_v2_rust-simba+rkyv-serialize-devel.sha256sum] = "a77ffe9b42647c513c7cb5e42fa085e180fdb5c55fb75a4f94398ba1bc2440cf"

URI_x86_64_v2_rust-simba+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+serde-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+serde-devel}"
SRC_URI[x86_64_v2_rust-simba+serde-devel.sha256sum] = "0cd97c99a0fcbc02e19e51b0c2f20d827c1fd102643dd37b6801661feb36986a"

URI_x86_64_v2_rust-simba+serde_serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+serde_serialize-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+serde_serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+serde_serialize-devel}"
SRC_URI[x86_64_v2_rust-simba+serde_serialize-devel.sha256sum] = "5663d88ce31a665c9a67350798c7c3bdee35b09fc7d51dd9319bfb9d2de28c0a"

URI_x86_64_v2_rust-simba+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+std-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+std-devel}"
SRC_URI[x86_64_v2_rust-simba+std-devel.sha256sum] = "32e233ed8f9d7ce7e332bb832285efd41655d157e381432a9ada21efc1b9de53"

URI_x86_64_v2_rust-simba+wide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba+wide-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba+wide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba+wide-devel}"
SRC_URI[x86_64_v2_rust-simba+wide-devel.sha256sum] = "1778656a004fba675821f0273402217b98f360ee9c6c3a407af5a96b8535cd84"

URI_x86_64_v2_rust-simba-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simba-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simba-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simba-devel}"
SRC_URI[x86_64_v2_rust-simba-devel.sha256sum] = "7adb3c16eb9822798a1597a3c737480a154d87b099f0695960ad46b3d78b81cb"

URI_aarch64_rust-simba+cordic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+cordic-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+cordic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+cordic-devel}"
SRC_URI[aarch64_rust-simba+cordic-devel.sha256sum] = "c2dc672ee93e6f49551dee11f50be114e153bcb9f77b393185b966e6d24eac89"

URI_aarch64_rust-simba+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+default-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+default-devel}"
SRC_URI[aarch64_rust-simba+default-devel.sha256sum] = "cb40e8cd7d2373c5ca8ac22d138cdd3900a101a5315950f11cd04c6c520eb63c"

URI_aarch64_rust-simba+fixed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+fixed-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+fixed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+fixed-devel}"
SRC_URI[aarch64_rust-simba+fixed-devel.sha256sum] = "b078c608d6450aac1f74dd8a70467aced3ced7edec2d1971621af2dbcfa90eee"

URI_aarch64_rust-simba+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+libm-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+libm-devel}"
SRC_URI[aarch64_rust-simba+libm-devel.sha256sum] = "ea1a3caad922e45e37c9f5820332e4f9d9136aaff4367a594ce5566bd023f1d0"

URI_aarch64_rust-simba+libm_force-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+libm_force-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+libm_force-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+libm_force-devel}"
SRC_URI[aarch64_rust-simba+libm_force-devel.sha256sum] = "c9eb904ae40f3f17c3b05010187ead342645f5027267cff303f1022732f6bd40"

URI_aarch64_rust-simba+partial_fixed_point_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+partial_fixed_point_support-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+partial_fixed_point_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+partial_fixed_point_support-devel}"
SRC_URI[aarch64_rust-simba+partial_fixed_point_support-devel.sha256sum] = "a7643f1a1d8053bf1d02ab2bd0580e404bb6ea47b4841f054bbe522f31a509dd"

URI_aarch64_rust-simba+portable_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+portable_simd-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+portable_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+portable_simd-devel}"
SRC_URI[aarch64_rust-simba+portable_simd-devel.sha256sum] = "b34adad5c3618ef83660aa63c3a051e01d87ce96ef04a721c2aa625f3f1b9d85"

URI_aarch64_rust-simba+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+rand-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+rand-devel}"
SRC_URI[aarch64_rust-simba+rand-devel.sha256sum] = "c1a2e5841ed237fbda8711e08757ec3e4dc5b739064393af51138d825cecd15e"

URI_aarch64_rust-simba+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+rkyv-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+rkyv-devel}"
SRC_URI[aarch64_rust-simba+rkyv-devel.sha256sum] = "f372df6a695ddf0bf776ca9b7da91a73121db4656111c99162cff5e2aec43a25"

URI_aarch64_rust-simba+rkyv-serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+rkyv-serialize-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+rkyv-serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+rkyv-serialize-devel}"
SRC_URI[aarch64_rust-simba+rkyv-serialize-devel.sha256sum] = "d3d892d898b83a8760d8a500c5a79562f455e7a3bcd02726d9cb963439ab0239"

URI_aarch64_rust-simba+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+serde-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+serde-devel}"
SRC_URI[aarch64_rust-simba+serde-devel.sha256sum] = "9c3a011410cd2f29c323c6577f8655aca8d8e69cb85b9afbbf19d326a3f82b41"

URI_aarch64_rust-simba+serde_serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+serde_serialize-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+serde_serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+serde_serialize-devel}"
SRC_URI[aarch64_rust-simba+serde_serialize-devel.sha256sum] = "6395bddd5a23b5fd73a252dac4fa86fc93535a1cd982421110dd71c25817fd3d"

URI_aarch64_rust-simba+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+std-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+std-devel}"
SRC_URI[aarch64_rust-simba+std-devel.sha256sum] = "0daa6faeadd084c2c84cfb99762f419f3885f6a1d408f659e6a72ed562769405"

URI_aarch64_rust-simba+wide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba+wide-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba+wide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba+wide-devel}"
SRC_URI[aarch64_rust-simba+wide-devel.sha256sum] = "7e1e8b88757e4697729fd7f230130007311933ade69d9b8a1b5da44854b959b0"

URI_aarch64_rust-simba-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simba-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-simba-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simba-devel}"
SRC_URI[aarch64_rust-simba-devel.sha256sum] = "80d71ce853a12ccbf5205b5b478372bcf992d329d4d8da8254fd56e4162bde69"

RDEPENDS:rust-simba+cordic-devel = " \
 cargo \
 rust-cordic+default-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+default-devel = " \
 cargo \
 rust-simba+std-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+fixed-devel = " \
 cargo \
 rust-fixed+default-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+libm-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+libm_force-devel = " \
 cargo \
 rust-libm+default-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+partial_fixed_point_support-devel = " \
 cargo \
 rust-simba+cordic-devel \
 rust-simba+fixed-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+portable_simd-devel = " \
 cargo \
 rust-simba+std-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+rand-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+rkyv-devel = " \
 cargo \
 rust-rkyv0.7+default-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+rkyv-serialize-devel = " \
 cargo \
 rust-simba+rkyv-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+serde_serialize-devel = " \
 cargo \
 rust-fixed+default-devel \
 rust-fixed+serde-devel \
 rust-simba+serde-devel \
 rust-simba-devel \
 "
RDEPENDS:rust-simba+std-devel = " \
 cargo \
 rust-simba-devel \
 rust-wide+std-devel \
 rust-wide-devel \
 "
RDEPENDS:rust-simba+wide-devel = " \
 cargo \
 rust-simba-devel \
 rust-wide-devel \
 "
RDEPENDS:rust-simba-devel = " \
 cargo \
 rust-approx-devel \
 rust-num-complex-devel \
 rust-num-traits-devel \
 rust-paste+default-devel \
 "
