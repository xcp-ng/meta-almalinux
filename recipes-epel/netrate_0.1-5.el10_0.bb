# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netrate"
PV = "0.1"
PR = "5.el10_0"
PACKAGES = " \
 netrate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netrate-0.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12a387b6ffa332a7de58b65e6807a90d58c36a19289313a5dd0ae2845561e998"

URI_x86_64_v2_netrate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netrate-0.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netrate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netrate}"
SRC_URI[x86_64_v2_netrate.sha256sum] = "010ba719a2919b1fc50d486081fc63f3df7095dd07fe43525902db11018f67c6"

URI_aarch64_netrate = "${EPEL_MIRROR}/aarch64/Packages/n/netrate-0.1-5.el10_0.aarch64.rpm;name=aarch64_netrate;unpack=0"
SRC_URI:append = " ${URI_aarch64_netrate}"
SRC_URI[aarch64_netrate.sha256sum] = "0015cf5a1200af3dc559819c8063ba7b5ebb2ab9ad019e49fa8d6acd8650be6e"

RDEPENDS:netrate = " \
 glibc \
 "
