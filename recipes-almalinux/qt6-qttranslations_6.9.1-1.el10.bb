# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qttranslations"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qttranslations \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qttranslations-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c36d45ef97bd911cb4d555e5dee11e2af46837f8b9d2c077d65aa00c6cf73271"

URI_x86_64_v2_qt6-qttranslations = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttranslations-6.9.1-1.el10.noarch.rpm;name=x86_64_v2_qt6-qttranslations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttranslations}"
SRC_URI[x86_64_v2_qt6-qttranslations.sha256sum] = "7c474bafb1164c2266b06a03d4f4131b0ebfe5af35074b5fe017a06dc2cf0541"

URI_aarch64_qt6-qttranslations = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttranslations-6.9.1-1.el10.noarch.rpm;name=aarch64_qt6-qttranslations;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttranslations}"
SRC_URI[aarch64_qt6-qttranslations.sha256sum] = "7c474bafb1164c2266b06a03d4f4131b0ebfe5af35074b5fe017a06dc2cf0541"

RDEPENDS:qt6-qttranslations = " \
 "
