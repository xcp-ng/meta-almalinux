# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goaccess"
PV = "1.10.2"
PR = "1.el10_1"
PACKAGES = " \
 goaccess \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/goaccess-1.10.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b82467d76d3728cefbc28288774302c10a6ef4551c111d02dd32cca6f7f9910"

URI_x86_64_v2_goaccess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goaccess-1.10.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goaccess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_goaccess}"
SRC_URI[x86_64_v2_goaccess.sha256sum] = "5fc934bc1cf82ab084dda986d0be01d488fc05a267597234a861c5dc8819e77b"

URI_aarch64_goaccess = "${EPEL_MIRROR}/aarch64/Packages/g/goaccess-1.10.2-1.el10_1.aarch64.rpm;name=aarch64_goaccess;unpack=0"
SRC_URI:append = " ${URI_aarch64_goaccess}"
SRC_URI[aarch64_goaccess.sha256sum] = "7f499f839336f52009d51ca6a90b3c86e4f527900f2f4848085d2a2b4de2abb9"

RDEPENDS:goaccess = " \
 glibc \
 libmaxminddb \
 ncurses-libs \
 openssl-libs \
 "
