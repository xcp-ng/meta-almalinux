# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-reflink"
PV = "0.2.2"
PR = "2.el10_2"
PACKAGES = " \
 python-reflink-doc \
 python3-reflink \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-reflink-0.2.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df1cabbd4a3e883d83c70e0a2a39d8cffda5c34997168b8fb61251bf11cdad10"

URI_x86_64_v2_python-reflink-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-reflink-doc-0.2.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-reflink-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-reflink-doc}"
SRC_URI[x86_64_v2_python-reflink-doc.sha256sum] = "e9eb175884ec5fa3b432bea0b44d90a9ea1cfd1b6d12f77d20447c5a54ae6496"

URI_x86_64_v2_python3-reflink = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-reflink-0.2.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-reflink;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-reflink}"
SRC_URI[x86_64_v2_python3-reflink.sha256sum] = "6a36709ae2304a8a0fd29152f4a4a075cc57f5253289c7071cbe311ef7d48c89"

URI_aarch64_python-reflink-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-reflink-doc-0.2.2-2.el10_2.aarch64.rpm;name=aarch64_python-reflink-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-reflink-doc}"
SRC_URI[aarch64_python-reflink-doc.sha256sum] = "24f95c66b8dbf7a17b95e2b87b16568c37569643518da1becd18dce0b6c03d5a"

URI_aarch64_python3-reflink = "${EPEL_MIRROR}/aarch64/Packages/p/python3-reflink-0.2.2-2.el10_2.aarch64.rpm;name=aarch64_python3-reflink;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-reflink}"
SRC_URI[aarch64_python3-reflink.sha256sum] = "518f8e5c586d3b9bee2a0b6731425161ff40343be9725d6c9436620dbd3d51cc"

RDEPENDS:python-reflink-doc = " \
 "
RDEPENDS:python3-reflink = " \
 glibc \
 python3 \
 python3-cffi \
 "
