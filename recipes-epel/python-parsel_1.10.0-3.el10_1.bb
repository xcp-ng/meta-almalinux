# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-parsel"
PV = "1.10.0"
PR = "3.el10_1"
PACKAGES = " \
 python3-parsel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-parsel-1.10.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61e96308422693e8fe759599cce9b26e5d4adb0d7cc9bda725628aa22f29a304"

URI_x86_64_v2_python3-parsel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-parsel-1.10.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-parsel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-parsel}"
SRC_URI[x86_64_v2_python3-parsel.sha256sum] = "c36dc236ca39ffed42fc12995f71769c32a35b0854b11c37650dbabf77a3b6a4"

URI_aarch64_python3-parsel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-parsel-1.10.0-3.el10_1.noarch.rpm;name=aarch64_python3-parsel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-parsel}"
SRC_URI[aarch64_python3-parsel.sha256sum] = "f11f40bc993f8324115909d9c418d26b27dd41a5b9af91be0b9cd0bd5d1b7dfe"

RDEPENDS:python3-parsel = " \
 python3 \
 python3-cssselect \
 python3-jmespath \
 python3-lxml \
 python3-packaging \
 python3-w3lib \
 "
