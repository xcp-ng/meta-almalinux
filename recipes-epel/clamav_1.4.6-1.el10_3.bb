# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clamav"
PV = "1.4.6"
PR = "1.el10_3"
PACKAGES = " \
 clamav \
 clamav-data \
 clamav-devel \
 clamav-doc \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 clamav-milter \
 clamd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clamav-1.4.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5ed605b6142c94f80de3723d8598b7a7acf1994abba887ea03120f7388f830c"

URI_x86_64_v2_clamav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-1.4.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav}"
SRC_URI[x86_64_v2_clamav.sha256sum] = "088a9494b82af0367e7617e8975932af7e3f199c7a2f1c79642c663356242bea"

URI_x86_64_v2_clamav-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-data-1.4.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-data}"
SRC_URI[x86_64_v2_clamav-data.sha256sum] = "518a40ff8d97f40e6a09c43cc25a21be2574518c24aec8ffbf1b88127c0cfe1b"
RPROVIDES:clamav-data:x86_64_v2 = "virtual/data_clamav_"

URI_x86_64_v2_clamav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-devel-1.4.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-devel}"
SRC_URI[x86_64_v2_clamav-devel.sha256sum] = "5c870b33be0d0ccccedf39454c530b3b9e94bafa17e54ba5d06e0b9c48936c10"

URI_x86_64_v2_clamav-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-doc-1.4.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-doc}"
SRC_URI[x86_64_v2_clamav-doc.sha256sum] = "a76ff9879b659cd63e2a4804ce2e45a1650507f5bdaa8d214ff3c494fa4d2e0d"

URI_x86_64_v2_clamav-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-filesystem-1.4.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-filesystem}"
SRC_URI[x86_64_v2_clamav-filesystem.sha256sum] = "35ea1ccbbb26c42baa7d44b25dc5b54a992b7de85f64fc895c22e7181c183e7e"

URI_x86_64_v2_clamav-freshclam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-freshclam-1.4.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-freshclam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-freshclam}"
SRC_URI[x86_64_v2_clamav-freshclam.sha256sum] = "1330a4e8a72a2c5ff6848b66f4ce7ff8dba743a7976290d969851bacc28e2e93"
RPROVIDES:clamav-freshclam:x86_64_v2 = "virtual/data_clamav_"

URI_x86_64_v2_clamav-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-lib-1.4.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-lib}"
SRC_URI[x86_64_v2_clamav-lib.sha256sum] = "d6f1326127be55edcc092578b3e028c757c2d3764103f24efb730862c74836df"

URI_x86_64_v2_clamav-milter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-milter-1.4.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-milter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamav-milter}"
SRC_URI[x86_64_v2_clamav-milter.sha256sum] = "291391848e9918034521a1cd0a02844db230d112613596561465613925e2cdf0"

URI_x86_64_v2_clamd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamd-1.4.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clamd}"
SRC_URI[x86_64_v2_clamd.sha256sum] = "b3127911641e507b78a767167be17345af98101842fb6eb7b5ad9117ff587d36"

URI_aarch64_clamav = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-1.4.6-1.el10_3.aarch64.rpm;name=aarch64_clamav;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav}"
SRC_URI[aarch64_clamav.sha256sum] = "7362872f73611bb351ecf4d65bcf5dcac90066c9d1f636f858c74c7544388010"

URI_aarch64_clamav-data = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-data-1.4.6-1.el10_3.noarch.rpm;name=aarch64_clamav-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-data}"
SRC_URI[aarch64_clamav-data.sha256sum] = "8e187b80163d7da067e57f86b4d6a67b0b32c686d1e53bb88400b41fd231f047"
RPROVIDES:clamav-data:aarch64 = "virtual/data_clamav_"

URI_aarch64_clamav-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-devel-1.4.6-1.el10_3.aarch64.rpm;name=aarch64_clamav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-devel}"
SRC_URI[aarch64_clamav-devel.sha256sum] = "41c13493504f74011407ba280ccecbfe6cb8c4c1f243fb79d1547eaee8593825"

URI_aarch64_clamav-doc = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-doc-1.4.6-1.el10_3.noarch.rpm;name=aarch64_clamav-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-doc}"
SRC_URI[aarch64_clamav-doc.sha256sum] = "e88ca357ec99e3491db1a78afeaaa0f1dfaf7b71fe069df321330281ddf01592"

URI_aarch64_clamav-filesystem = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-filesystem-1.4.6-1.el10_3.noarch.rpm;name=aarch64_clamav-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-filesystem}"
SRC_URI[aarch64_clamav-filesystem.sha256sum] = "23da7b92573873e3bdcb29c203e4ed9763e8e94c957a0f6f27f12726f5064a07"

URI_aarch64_clamav-freshclam = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-freshclam-1.4.6-1.el10_3.aarch64.rpm;name=aarch64_clamav-freshclam;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-freshclam}"
SRC_URI[aarch64_clamav-freshclam.sha256sum] = "1df145649c7a3d857bdbe2291c385fc96691c0c0b61f4dd5a79829b0e2026094"
RPROVIDES:clamav-freshclam:aarch64 = "virtual/data_clamav_"

URI_aarch64_clamav-lib = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-lib-1.4.6-1.el10_3.aarch64.rpm;name=aarch64_clamav-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-lib}"
SRC_URI[aarch64_clamav-lib.sha256sum] = "07dcd8f0cf32d1b9de08edfdb90dcb44affd0b58b236ecf810d1d42a8b11ceb8"

URI_aarch64_clamav-milter = "${EPEL_MIRROR}/aarch64/Packages/c/clamav-milter-1.4.6-1.el10_3.aarch64.rpm;name=aarch64_clamav-milter;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamav-milter}"
SRC_URI[aarch64_clamav-milter.sha256sum] = "416210c2d8a009b4e6f772dc68e041b763926baff1261da327e81fcbc04c5b27"

URI_aarch64_clamd = "${EPEL_MIRROR}/aarch64/Packages/c/clamd-1.4.6-1.el10_3.aarch64.rpm;name=aarch64_clamd;unpack=0"
SRC_URI:append = " ${URI_aarch64_clamd}"
SRC_URI[aarch64_clamd.sha256sum] = "e9c0923abd7b3d00930f824b7d4fd18fd509d61f354726a3bb85100f480d26ce"

RDEPENDS:clamav = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 json-c \
 libgcc \
 ncurses-libs \
 systemd \
 virtual/data_clamav_ \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-data = " \
 bash \
 clamav-filesystem \
 "
RDEPENDS:clamav-devel = " \
 bash \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:clamav-doc = " \
 clamav-filesystem \
 "
RDEPENDS:clamav-filesystem = " \
 "
RDEPENDS:clamav-freshclam = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 libgcc \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-lib = " \
 bzip2-libs \
 glibc \
 json-c \
 libgcc \
 libxml2 \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:clamav-milter = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 clamd \
 glibc \
 sendmail-milter \
 "
RDEPENDS:clamd = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 systemd-libs \
 virtual/coreutils \
 virtual/data_clamav_ \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/data_clamav_"

PROVIDES:append:aarch64 = " rpm/virtual/data_clamav_"
