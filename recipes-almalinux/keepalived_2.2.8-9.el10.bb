# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keepalived"
PV = "2.2.8"
PR = "9.el10"
PACKAGES = " \
 keepalived \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keepalived-2.2.8-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8892b6d8d7e85967c16d727a6dda787fd972bddbab7f75927fa39a9dae5e8329"

URI_x86_64_v2_keepalived = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keepalived-2.2.8-9.el10.x86_64_v2.rpm;name=x86_64_v2_keepalived;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keepalived}"
SRC_URI[x86_64_v2_keepalived.sha256sum] = "67a1557ef88fb05cea9b2a544ec96b86cf4f2c10c7bf02c71e4af4caa335cf2d"

URI_aarch64_keepalived = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keepalived-2.2.8-9.el10.aarch64.rpm;name=aarch64_keepalived;unpack=0"
SRC_URI:append = " ${URI_aarch64_keepalived}"
SRC_URI[aarch64_keepalived.sha256sum] = "de1e5f2449a9bfd363b69fcd4cba1768f4fc8a2f99a30895fb00dbe96670b980"

RDEPENDS:keepalived = " \
 bash \
 file-libs \
 glibc \
 libmnl \
 libnftnl \
 libnl3 \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-libs \
 systemd \
 systemd-libs \
 "
