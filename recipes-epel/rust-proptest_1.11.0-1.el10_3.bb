# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proptest"
PV = "1.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-proptest+alloc-devel \
 rust-proptest+atomic64bit-devel \
 rust-proptest+attr-macro-devel \
 rust-proptest+bit-set-devel \
 rust-proptest+default-code-coverage-devel \
 rust-proptest+default-devel \
 rust-proptest+f16-devel \
 rust-proptest+fork-devel \
 rust-proptest+handle-panics-devel \
 rust-proptest+no_std-devel \
 rust-proptest+proptest-macro-devel \
 rust-proptest+regex-syntax-devel \
 rust-proptest+rusty-fork-devel \
 rust-proptest+std-devel \
 rust-proptest+tempfile-devel \
 rust-proptest+timeout-devel \
 rust-proptest+unstable-devel \
 rust-proptest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proptest-1.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0ef774adacb49c2acc1323a02bc063540c20fcc13c75a9aebb6e89335af30ea"

URI_x86_64_v2_rust-proptest+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+alloc-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+alloc-devel}"
SRC_URI[x86_64_v2_rust-proptest+alloc-devel.sha256sum] = "0878189d355bfef73fd919f619bdefb9849ec7f5c919f7ebca1f60bdf56a05d2"

URI_x86_64_v2_rust-proptest+atomic64bit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+atomic64bit-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+atomic64bit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+atomic64bit-devel}"
SRC_URI[x86_64_v2_rust-proptest+atomic64bit-devel.sha256sum] = "b2c59da4f304fca3774a221377bcf0cb4dd46d859452640b786cb7929bf5ce0c"

URI_x86_64_v2_rust-proptest+attr-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+attr-macro-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+attr-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+attr-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest+attr-macro-devel.sha256sum] = "94fc8d950477762afdd18ae8d12fd55e0d1b25ea049308b054ef45acd5149fbb"

URI_x86_64_v2_rust-proptest+bit-set-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+bit-set-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+bit-set-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+bit-set-devel}"
SRC_URI[x86_64_v2_rust-proptest+bit-set-devel.sha256sum] = "f2919e100d92d3a82b137daaa74c385bd43c2f36ccb2f5f13619db2f50c830f7"

URI_x86_64_v2_rust-proptest+default-code-coverage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+default-code-coverage-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+default-code-coverage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+default-code-coverage-devel}"
SRC_URI[x86_64_v2_rust-proptest+default-code-coverage-devel.sha256sum] = "8fc2dec58edd92564cfa34c9973f0851f0d74403b20bb4c1087b36d07862a237"

URI_x86_64_v2_rust-proptest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+default-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+default-devel}"
SRC_URI[x86_64_v2_rust-proptest+default-devel.sha256sum] = "893df9627a485581a1b89a4e873b0bc3e53edb0ad0bb02ea26793d5900daef2d"

URI_x86_64_v2_rust-proptest+f16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+f16-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+f16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+f16-devel}"
SRC_URI[x86_64_v2_rust-proptest+f16-devel.sha256sum] = "484c26d859bb1a3071068d1783fca900b7ec60098bda3ba6be0b3a080742695a"

URI_x86_64_v2_rust-proptest+fork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+fork-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+fork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+fork-devel}"
SRC_URI[x86_64_v2_rust-proptest+fork-devel.sha256sum] = "39395a36b7a17fd54497175e2b5cf829d0cd41fc99901aff1aa1d79984c2c317"

URI_x86_64_v2_rust-proptest+handle-panics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+handle-panics-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+handle-panics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+handle-panics-devel}"
SRC_URI[x86_64_v2_rust-proptest+handle-panics-devel.sha256sum] = "09944cad46ef3a98df3f51e42d32fa733d7862825f6a158e6914565d289a2259"

URI_x86_64_v2_rust-proptest+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+no_std-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+no_std-devel}"
SRC_URI[x86_64_v2_rust-proptest+no_std-devel.sha256sum] = "282ef4579c50c447790a2646f490953b409a980ad026d2d5eca5893125d70635"

URI_x86_64_v2_rust-proptest+proptest-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+proptest-macro-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+proptest-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest+proptest-macro-devel.sha256sum] = "5a053672bee9b022ebea32f64c33cc8243ed634bfabdff12d3a83f14a8560873"

URI_x86_64_v2_rust-proptest+regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+regex-syntax-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-proptest+regex-syntax-devel.sha256sum] = "db07c97616d1d5f87739f85cdf5af6fabb5551c681df576e19e5ffbc249b853f"

URI_x86_64_v2_rust-proptest+rusty-fork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+rusty-fork-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+rusty-fork-devel}"
SRC_URI[x86_64_v2_rust-proptest+rusty-fork-devel.sha256sum] = "237819612b70a7a209faf4aa511f1b1afed865661ff42b511433789db523bafa"

URI_x86_64_v2_rust-proptest+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+std-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+std-devel}"
SRC_URI[x86_64_v2_rust-proptest+std-devel.sha256sum] = "e66b748c0b67e96eae6378faee2c1a2c02e299d35170f3e0c3fe470d3ef6deb1"

URI_x86_64_v2_rust-proptest+tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+tempfile-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+tempfile-devel}"
SRC_URI[x86_64_v2_rust-proptest+tempfile-devel.sha256sum] = "70abbf719ace3f2832a2614ed648ebb1ae8107e7500d5a385351d197e2285b76"

URI_x86_64_v2_rust-proptest+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+timeout-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+timeout-devel}"
SRC_URI[x86_64_v2_rust-proptest+timeout-devel.sha256sum] = "51661174ed200d29acf2701684409b1c046c41d8e0649b2d6e69f133defc6e97"

URI_x86_64_v2_rust-proptest+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest+unstable-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest+unstable-devel}"
SRC_URI[x86_64_v2_rust-proptest+unstable-devel.sha256sum] = "ceb04e4b4081acd417c92a25eb0f3b3d3e25cc84f0504ba4bc6c82d9a9dc0d5a"

URI_x86_64_v2_rust-proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-devel-1.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-devel}"
SRC_URI[x86_64_v2_rust-proptest-devel.sha256sum] = "e898fd7a91fb53b180580adee5eb25ed86cfaded8ead7e18aba15fdd44ab4274"

URI_aarch64_rust-proptest+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+alloc-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+alloc-devel}"
SRC_URI[aarch64_rust-proptest+alloc-devel.sha256sum] = "76a7e6236d8020e1750e3e6be3c773906a79bca8b9dea497040da2cd800f6052"

URI_aarch64_rust-proptest+atomic64bit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+atomic64bit-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+atomic64bit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+atomic64bit-devel}"
SRC_URI[aarch64_rust-proptest+atomic64bit-devel.sha256sum] = "ae8f25a949122dceb9a5073cab53ad123c3e94fe1e419b39f6df4b4df73ea5d3"

URI_aarch64_rust-proptest+attr-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+attr-macro-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+attr-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+attr-macro-devel}"
SRC_URI[aarch64_rust-proptest+attr-macro-devel.sha256sum] = "b56a3fa03ea0395631181856d3a02afff9732f3c32720c7425476f6f04985464"

URI_aarch64_rust-proptest+bit-set-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+bit-set-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+bit-set-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+bit-set-devel}"
SRC_URI[aarch64_rust-proptest+bit-set-devel.sha256sum] = "6434988ece489d711060be9247afb5f61f64a4dd9555ec9491f957a452ba2a89"

URI_aarch64_rust-proptest+default-code-coverage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+default-code-coverage-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+default-code-coverage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+default-code-coverage-devel}"
SRC_URI[aarch64_rust-proptest+default-code-coverage-devel.sha256sum] = "5de21bf140e9402750413ad62d26580d0e998540061779ff82447837744e192a"

URI_aarch64_rust-proptest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+default-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+default-devel}"
SRC_URI[aarch64_rust-proptest+default-devel.sha256sum] = "86f709f32ab10dd6f34c8d5e73af1745f7aa6571ea60b5356418285c33f18503"

URI_aarch64_rust-proptest+f16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+f16-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+f16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+f16-devel}"
SRC_URI[aarch64_rust-proptest+f16-devel.sha256sum] = "8eaaea80996984ecc5fb465085c74f9fdcaf195d960996c00209579d64678042"

URI_aarch64_rust-proptest+fork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+fork-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+fork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+fork-devel}"
SRC_URI[aarch64_rust-proptest+fork-devel.sha256sum] = "e4ff5d71f959cac139bffeeb9c2408e23fc8e7ed9af9b5bfca08f6c978b08829"

URI_aarch64_rust-proptest+handle-panics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+handle-panics-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+handle-panics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+handle-panics-devel}"
SRC_URI[aarch64_rust-proptest+handle-panics-devel.sha256sum] = "c6a8bab4c251244b1fc7f601b1c8d67c8da190b40d0cd517be6af4563a0690d2"

URI_aarch64_rust-proptest+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+no_std-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+no_std-devel}"
SRC_URI[aarch64_rust-proptest+no_std-devel.sha256sum] = "75b3c904323a319117069d0cf7db4337f2bcbd0d03df9f2728eefeb271ac49f1"

URI_aarch64_rust-proptest+proptest-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+proptest-macro-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+proptest-macro-devel}"
SRC_URI[aarch64_rust-proptest+proptest-macro-devel.sha256sum] = "367a1a6d5e2d34e530d91f052a9e9d9ef017df3d4ffd13171c03fb4488dda731"

URI_aarch64_rust-proptest+regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+regex-syntax-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+regex-syntax-devel}"
SRC_URI[aarch64_rust-proptest+regex-syntax-devel.sha256sum] = "cec384eb60c14336e89f066824130d3de8eda61c8db3eae6133cb1824670d636"

URI_aarch64_rust-proptest+rusty-fork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+rusty-fork-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+rusty-fork-devel}"
SRC_URI[aarch64_rust-proptest+rusty-fork-devel.sha256sum] = "8298e2ce708bbd52573b6430a6c90be7f7bcdbcfc3b48839723e19ba06c35ec3"

URI_aarch64_rust-proptest+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+std-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+std-devel}"
SRC_URI[aarch64_rust-proptest+std-devel.sha256sum] = "0f951f24c6671ca29619dbd642f5881081f21620bbdecee5624b94052653efaa"

URI_aarch64_rust-proptest+tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+tempfile-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+tempfile-devel}"
SRC_URI[aarch64_rust-proptest+tempfile-devel.sha256sum] = "9d840e7f1cba95b5f0b6e242d6c56dfd8de09a35750a996493d3d3acb5b809bf"

URI_aarch64_rust-proptest+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+timeout-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+timeout-devel}"
SRC_URI[aarch64_rust-proptest+timeout-devel.sha256sum] = "08083695f03c836da3acb4e44123fca6feeaadefe44dcc740744a10f6b418613"

URI_aarch64_rust-proptest+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest+unstable-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest+unstable-devel}"
SRC_URI[aarch64_rust-proptest+unstable-devel.sha256sum] = "f78b7dcb7cdb217a43f8900447bfa7cdae7af53f6f373210faba477e72587fc9"

URI_aarch64_rust-proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-devel-1.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-devel}"
SRC_URI[aarch64_rust-proptest-devel.sha256sum] = "f85bb1be7f9185fe438c05652e9e9f629581d7d72ab2176a0edb1b68446ad9fa"

RDEPENDS:rust-proptest+alloc-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+atomic64bit-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+attr-macro-devel = " \
 cargo \
 rust-proptest+proptest-macro-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+bit-set-devel = " \
 cargo \
 rust-bit-set+default-devel \
 rust-bit-vec+default-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+default-code-coverage-devel = " \
 cargo \
 rust-proptest+bit-set-devel \
 rust-proptest+fork-devel \
 rust-proptest+std-devel \
 rust-proptest+timeout-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+default-devel = " \
 cargo \
 rust-proptest+bit-set-devel \
 rust-proptest+fork-devel \
 rust-proptest+std-devel \
 rust-proptest+timeout-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+f16-devel = " \
 cargo \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+fork-devel = " \
 cargo \
 rust-proptest+rusty-fork-devel \
 rust-proptest+std-devel \
 rust-proptest+tempfile-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+handle-panics-devel = " \
 cargo \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+no_std-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest+proptest-macro-devel = " \
 cargo \
 rust-proptest-devel \
 rust-proptest-macro+default-devel \
 "
RDEPENDS:rust-proptest+regex-syntax-devel = " \
 cargo \
 rust-proptest-devel \
 rust-regex-syntax+default-devel \
 "
RDEPENDS:rust-proptest+rusty-fork-devel = " \
 cargo \
 rust-proptest-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-proptest+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-proptest+regex-syntax-devel \
 rust-proptest-devel \
 rust-rand0.9+os_rng-devel \
 rust-rand0.9+std-devel \
 "
RDEPENDS:rust-proptest+tempfile-devel = " \
 cargo \
 rust-proptest-devel \
 rust-tempfile+default-devel \
 "
RDEPENDS:rust-proptest+timeout-devel = " \
 cargo \
 rust-proptest+fork-devel \
 rust-proptest-devel \
 rust-rusty-fork+timeout-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-proptest+unstable-devel = " \
 cargo \
 rust-proptest+f16-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-proptest-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-num-traits-devel \
 rust-rand0.9+alloc-devel \
 rust-rand0.9-devel \
 rust-rand_chacha0.9-devel \
 rust-rand_xorshift0.4+default-devel \
 rust-unarray+default-devel \
 "
