# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_derive_internals"
PV = "0.29.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_derive_internals+default-devel \
 rust-serde_derive_internals-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_derive_internals-0.29.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f41d70a717262a9b04bc80aff630a3d771cdccc4d538b32be99bcd8a3aff0fe"

URI_x86_64_v2_rust-serde_derive_internals+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive_internals+default-devel-0.29.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive_internals+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive_internals+default-devel}"
SRC_URI[x86_64_v2_rust-serde_derive_internals+default-devel.sha256sum] = "1b238ced67d4147080a698c5301c0c015b85eb3d2bcb640d10ff4bb8e1a62b13"

URI_x86_64_v2_rust-serde_derive_internals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive_internals-devel-0.29.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive_internals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive_internals-devel}"
SRC_URI[x86_64_v2_rust-serde_derive_internals-devel.sha256sum] = "12c4953ae3b41771cc09330a10adcd41eac93c0612eb33747b6f12de7f05d1fb"

URI_aarch64_rust-serde_derive_internals+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive_internals+default-devel-0.29.1-1.el10_0.noarch.rpm;name=aarch64_rust-serde_derive_internals+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive_internals+default-devel}"
SRC_URI[aarch64_rust-serde_derive_internals+default-devel.sha256sum] = "40917e2602dd07e2241e7c04e0e23af17d6c810a3dcf8accd35a4772f0636e75"

URI_aarch64_rust-serde_derive_internals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive_internals-devel-0.29.1-1.el10_0.noarch.rpm;name=aarch64_rust-serde_derive_internals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive_internals-devel}"
SRC_URI[aarch64_rust-serde_derive_internals-devel.sha256sum] = "809fde97ad4c9ab758d98e2c6d78e56b0277ed748ba9407a27b904f914761f79"

RDEPENDS:rust-serde_derive_internals+default-devel = " \
 cargo \
 rust-serde_derive_internals-devel \
 "
RDEPENDS:rust-serde_derive_internals-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn2+clone-impls-devel \
 rust-syn2+derive-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2-devel \
 "
