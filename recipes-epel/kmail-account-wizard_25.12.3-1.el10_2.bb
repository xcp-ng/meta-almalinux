# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmail-account-wizard"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmail-account-wizard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmail-account-wizard-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b15368c92a16bc45135314802b93295c81d3535b444c40ccafb01fdbd2b610f"

URI_x86_64_v2_kmail-account-wizard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-account-wizard-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail-account-wizard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail-account-wizard}"
SRC_URI[x86_64_v2_kmail-account-wizard.sha256sum] = "bf52979b0306178ef31c86524bc46d6d8a87253d46d0ffda467f3a2dc733bf16"

URI_aarch64_kmail-account-wizard = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-account-wizard-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmail-account-wizard;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail-account-wizard}"
SRC_URI[aarch64_kmail-account-wizard.sha256sum] = "57edd3a56d5d498d5b153f550cfe4694c24c54444d1a42a2108abd79f9005521"

RDEPENDS:kmail-account-wizard = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
