# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Archive-Tar"
PV = "3.02"
PR = "514.el10"
PACKAGES = " \
 perl-Archive-Tar \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Archive-Tar-3.02-514.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "baf575cd88b5a6583537ee644e72ff9b4af190aa5e8a3c61910d28d82e779f20"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Archive-Tar-3.02-514.el10.noarch.rpm;name=x86_64_v2_perl-Archive-Tar;unpack=0"
SRC_URI[x86_64_v2_perl-Archive-Tar.sha256sum] = "59c951618d65d3442a5a2d17f7cbb96970b5364da2ebcd4a5db1fa2878769230"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Archive-Tar-3.02-514.el10.noarch.rpm;name=aarch64_perl-Archive-Tar;unpack=0"
SRC_URI[aarch64_perl-Archive-Tar.sha256sum] = "59c951618d65d3442a5a2d17f7cbb96970b5364da2ebcd4a5db1fa2878769230"

RDEPENDS:perl-Archive-Tar = " \
 perl-Archive-Tar \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Compress-Lzma \
 perl-IO-Zlib \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Text-Diff \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
