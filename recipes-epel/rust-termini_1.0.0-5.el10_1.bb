# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-termini"
PV = "1.0.0"
PR = "5.el10_1"
PACKAGES = " \
 rust-termini+default-devel \
 rust-termini-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-termini-1.0.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "844e3b9ce1d11c5371bf1e5fc062f2a29b3d8a9683b516b127598e7ade9d5997"

URI_x86_64_v2_rust-termini+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termini+default-devel-1.0.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termini+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termini+default-devel}"
SRC_URI[x86_64_v2_rust-termini+default-devel.sha256sum] = "22a5f53f2913fcd89351a49194e792c71b69fb50dbd8c2f969ebd741bb7344ad"

URI_x86_64_v2_rust-termini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termini-devel-1.0.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termini-devel}"
SRC_URI[x86_64_v2_rust-termini-devel.sha256sum] = "86cc71c0841e8a975cf66cdae953d063f1e800b1066cda265249a7eeb00149a9"

URI_aarch64_rust-termini+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termini+default-devel-1.0.0-5.el10_1.noarch.rpm;name=aarch64_rust-termini+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termini+default-devel}"
SRC_URI[aarch64_rust-termini+default-devel.sha256sum] = "b043752d8118c7c946d0353060df831b4591d8489207875705740b652f6f7709"

URI_aarch64_rust-termini-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termini-devel-1.0.0-5.el10_1.noarch.rpm;name=aarch64_rust-termini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termini-devel}"
SRC_URI[aarch64_rust-termini-devel.sha256sum] = "f850ed5ea62e991aea011389eb444ecb245cf0af04090b0345e95fd06ad46ab6"

RDEPENDS:rust-termini+default-devel = " \
 cargo \
 rust-termini-devel \
 "
RDEPENDS:rust-termini-devel = " \
 cargo \
 rust-home+default-devel \
 "
