# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libidn"
PV = "1.42"
PR = "4.el10_0"
PACKAGES = " \
 libidn \
 libidn-devel \
 libidn-java \
 libidn-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libidn-1.42-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "166478bb634f225feb21ced901681ce003a8eb5c99b72bfaa5338d33b930bd3a"

URI_x86_64_v2_libidn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libidn-1.42-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libidn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libidn}"
SRC_URI[x86_64_v2_libidn.sha256sum] = "1306a03599884927e3d86f1a3eef6c92a308676a1792c7a172dc3f72f50a639b"

URI_x86_64_v2_libidn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libidn-devel-1.42-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libidn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libidn-devel}"
SRC_URI[x86_64_v2_libidn-devel.sha256sum] = "6571ada2e45f46a5bd79db972fc48d9787c1544df9aa76e3709babe023a10737"

URI_x86_64_v2_libidn-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libidn-java-1.42-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libidn-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libidn-java}"
SRC_URI[x86_64_v2_libidn-java.sha256sum] = "f8c77b305bf63f43fcae35b0b06e11cb42f2080270f06f025f986e4408d73e8e"

URI_x86_64_v2_libidn-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libidn-javadoc-1.42-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libidn-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libidn-javadoc}"
SRC_URI[x86_64_v2_libidn-javadoc.sha256sum] = "231fd81b5c446a8ed88a755b428ab7fd502a4f558fa1bce477b6a617c5efbd1c"

URI_aarch64_libidn = "${EPEL_MIRROR}/aarch64/Packages/l/libidn-1.42-4.el10_0.aarch64.rpm;name=aarch64_libidn;unpack=0"
SRC_URI:append = " ${URI_aarch64_libidn}"
SRC_URI[aarch64_libidn.sha256sum] = "78115e02d20f07107a0edc052fc6a7a8cb9761c8f90d54c5bc30d028db0c840f"

URI_aarch64_libidn-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libidn-devel-1.42-4.el10_0.aarch64.rpm;name=aarch64_libidn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libidn-devel}"
SRC_URI[aarch64_libidn-devel.sha256sum] = "ae6b50d612c51edd71dc7621a75e9f71dcfc627ed7fa9376b16a98017e5cd6e9"

URI_aarch64_libidn-java = "${EPEL_MIRROR}/aarch64/Packages/l/libidn-java-1.42-4.el10_0.noarch.rpm;name=aarch64_libidn-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_libidn-java}"
SRC_URI[aarch64_libidn-java.sha256sum] = "d863146c05482d46b0d09b58a9fb8cd059ced5c397d6b7780cb4aeee34730e29"

URI_aarch64_libidn-javadoc = "${EPEL_MIRROR}/aarch64/Packages/l/libidn-javadoc-1.42-4.el10_0.noarch.rpm;name=aarch64_libidn-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libidn-javadoc}"
SRC_URI[aarch64_libidn-javadoc.sha256sum] = "afe3da2645fe6485227e13b4a1dcfe8ca5c2748c7b3708a5ea6f9d848f4abbac"

RDEPENDS:libidn = " \
 emacs-filesystem \
 glibc \
 "
RDEPENDS:libidn-devel = " \
 libidn \
 pkgconf-pkg-config \
 "
RDEPENDS:libidn-java = " \
 javapackages-filesystem \
 "
RDEPENDS:libidn-javadoc = " \
 javapackages-filesystem \
 "
