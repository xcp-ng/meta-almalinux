# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bumpversion"
PV = "1.0.1"
PR = "16.el10_2"
PACKAGES = " \
 bumpversion \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bumpversion-1.0.1-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4058963f53a51fc6369e1e2461a98b448d89b3de4e34d26d14c47b3fe28dea53"

URI_x86_64_v2_bumpversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bumpversion-1.0.1-16.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bumpversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bumpversion}"
SRC_URI[x86_64_v2_bumpversion.sha256sum] = "181d6758c98210185e6d9a878e26dff31d0eac44c6a39fbed30f2323d544d4a9"

URI_aarch64_bumpversion = "${EPEL_MIRROR}/aarch64/Packages/b/bumpversion-1.0.1-16.el10_2.noarch.rpm;name=aarch64_bumpversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_bumpversion}"
SRC_URI[aarch64_bumpversion.sha256sum] = "4354f00ecc64a408f828904ae4a51f29262979e102ea71740c795877bcfbb183"

RDEPENDS:bumpversion = " \
 python3 \
 "
