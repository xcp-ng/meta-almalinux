# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knewstuff"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-knewstuff \
 kf6-knewstuff-devel \
 kf6-knewstuff-doc \
 kf6-knewstuff-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knewstuff-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29503d39511818b847ec45bcc0537d0d7fa072ebd9268b02b56ed971596095d2"

URI_x86_64_v2_kf6-knewstuff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knewstuff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff}"
SRC_URI[x86_64_v2_kf6-knewstuff.sha256sum] = "a9b479d05a16319eb26a16e1d71e6c3f8edfd59fef9fd6299cc8eedd3dfc0f8a"

URI_x86_64_v2_kf6-knewstuff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knewstuff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-devel}"
SRC_URI[x86_64_v2_kf6-knewstuff-devel.sha256sum] = "c38b3e9b2230f651bd2ace37252a6abd8aa66c5051c4e110ce46519b07b668df"

URI_x86_64_v2_kf6-knewstuff-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knewstuff-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-doc}"
SRC_URI[x86_64_v2_kf6-knewstuff-doc.sha256sum] = "8e25292465096d6b3fe3af1e3b094866412b1e6c57b76262634d6f8c4ebf3d84"

URI_x86_64_v2_kf6-knewstuff-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knewstuff-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-html}"
SRC_URI[x86_64_v2_kf6-knewstuff-html.sha256sum] = "9545a3ef583ae3892a139c83519e806b838908f7769ceb44c5b54a7c4ace3284"

URI_aarch64_kf6-knewstuff = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knewstuff;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff}"
SRC_URI[aarch64_kf6-knewstuff.sha256sum] = "014ff70d54652f9f367b253f711bdfb271f02dc14aeb24733d70dcd58e809509"

URI_aarch64_kf6-knewstuff-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knewstuff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-devel}"
SRC_URI[aarch64_kf6-knewstuff-devel.sha256sum] = "8f7aa3c3246bf704ff814d5920463d146976acbed05a16654339b216e4da64c8"

URI_aarch64_kf6-knewstuff-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knewstuff-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-doc}"
SRC_URI[aarch64_kf6-knewstuff-doc.sha256sum] = "58d0e84e7f8eb4207239636986b4ad3f727c97341c3038505f38bbaf4ec2e8ca"

URI_aarch64_kf6-knewstuff-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knewstuff-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-html}"
SRC_URI[aarch64_kf6-knewstuff-html.sha256sum] = "bce40671ccd9fc47c005b49be210cb2b692db6b218cc95d0b8dc4c1039d01352"

RDEPENDS:kf6-knewstuff = " \
 glibc \
 kf6-attica \
 kf6-filesystem \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kwidgetsaddons \
 kf6-syndication \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-knewstuff-devel = " \
 cmake-filesystem \
 glibc \
 kf6-attica-devel \
 kf6-knewstuff \
 kf6-kservice-devel \
 kf6-kxmlgui-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-knewstuff-doc = " \
 "
RDEPENDS:kf6-knewstuff-html = " \
 "
