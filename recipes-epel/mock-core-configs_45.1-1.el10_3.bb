# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mock-core-configs"
PV = "45.1"
PR = "1.el10_3"
PACKAGES = " \
 mock-core-configs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mock-core-configs-45.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6743e97e420a44fd2bf7d72c53e02386c922ee863a6c66dfd6c0b911f515dde6"

URI_x86_64_v2_mock-core-configs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-core-configs-45.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mock-core-configs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-core-configs}"
SRC_URI[x86_64_v2_mock-core-configs.sha256sum] = "a023cec5f23067bd2c0dfff7bcf2cd0a7c6ba8415bd895a2a96bf4239d50c403"

URI_aarch64_mock-core-configs = "${EPEL_MIRROR}/aarch64/Packages/m/mock-core-configs-45.1-1.el10_3.noarch.rpm;name=aarch64_mock-core-configs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-core-configs}"
SRC_URI[aarch64_mock-core-configs.sha256sum] = "2cb23fdfff14a4747c9eb1fda3f7c893790ef2a6fdfa00bf9564eb57335d4c14"

RDEPENDS:mock-core-configs = " \
 almalinux-kitten-release \
 bash \
 distribution-gpg-keys \
 mock \
 mock-filesystem \
 python3 \
 virtual/coreutils \
 virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_ \
 "
