# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-AppConfig"
PV = "1.71"
PR = "31.el10_0"
PACKAGES = " \
 perl-AppConfig \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-AppConfig-1.71-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3089ce1fa8da1507645139708e16c64c6a4abcfccf4554c6f57503e35b941588"

URI_x86_64_v2_perl-AppConfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-AppConfig-1.71-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-AppConfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-AppConfig}"
SRC_URI[x86_64_v2_perl-AppConfig.sha256sum] = "2e43804a563f0a4ce3aa234d27ec97da4dcee53f1fdff0b6cbf25661d4f8f808"

URI_aarch64_perl-AppConfig = "${EPEL_MIRROR}/aarch64/Packages/p/perl-AppConfig-1.71-31.el10_0.noarch.rpm;name=aarch64_perl-AppConfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-AppConfig}"
SRC_URI[aarch64_perl-AppConfig.sha256sum] = "a1a974e697a2fd4c93c638b63567f863a85a6c53b104c95750b9546746e61bb6"

RDEPENDS:perl-AppConfig = " \
 perl-AppConfig \
 perl-Exporter \
 perl-Getopt-Long \
 perl-POSIX \
 perl-base \
 perl-constant \
 perl-libs \
 "
