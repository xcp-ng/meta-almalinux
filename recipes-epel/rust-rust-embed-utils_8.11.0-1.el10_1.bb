# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-embed-utils"
PV = "8.11.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rust-embed-utils+debug-embed-devel \
 rust-rust-embed-utils+default-devel \
 rust-rust-embed-utils+globset-devel \
 rust-rust-embed-utils+include-exclude-devel \
 rust-rust-embed-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-embed-utils-8.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3abcdbc386cf2004d622b4e1f9b83b8ab47d3e1472cc778c2417a515168759a"

URI_x86_64_v2_rust-rust-embed-utils+debug-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+debug-embed-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+debug-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+debug-embed-devel.sha256sum] = "8a7b94a0b6e8213306eecdc4de7cba0f40170f20648917217e69aaeb9e7aa837"

URI_x86_64_v2_rust-rust-embed-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+default-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+default-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+default-devel.sha256sum] = "cddd57586c07c3556f8d5e2fba51b45c92d1827a9917ccdb84cf12d7d0bae390"

URI_x86_64_v2_rust-rust-embed-utils+globset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+globset-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+globset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+globset-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+globset-devel.sha256sum] = "b68932d0ff8bcb6ca54359c66da12b4a82c5ea1f26c19ff65143de71d814b360"

URI_x86_64_v2_rust-rust-embed-utils+include-exclude-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils+include-exclude-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils+include-exclude-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils+include-exclude-devel.sha256sum] = "b0355bcd7d1cefcf0dc718b00a5afa6bc89e249eb7bf9ee0ebc8e623600501a5"

URI_x86_64_v2_rust-rust-embed-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-utils-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-utils-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-utils-devel.sha256sum] = "54978855c6e652b5af6b08ed496c29e43aa00bf2af0125b58414fceb961f3102"

URI_aarch64_rust-rust-embed-utils+debug-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+debug-embed-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-utils+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+debug-embed-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+debug-embed-devel.sha256sum] = "1dbf096a271fa74d65a05bf1fb115a76c5ddfca70349cc3b7c7863b1e4bf51b6"

URI_aarch64_rust-rust-embed-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+default-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+default-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+default-devel.sha256sum] = "e9f1bd051131dda61e1d31e520061aeae9685f06bd7c931696a63e22b04ac409"

URI_aarch64_rust-rust-embed-utils+globset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+globset-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-utils+globset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+globset-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+globset-devel.sha256sum] = "1c13945c15fabdf48eefec301a7cadc18ca9151917a43c606a97b61655dd2ec2"

URI_aarch64_rust-rust-embed-utils+include-exclude-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils+include-exclude-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-utils+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils+include-exclude-devel}"
SRC_URI[aarch64_rust-rust-embed-utils+include-exclude-devel.sha256sum] = "bd1f44b2b9576a69b2345e747624381aed7e665ac89992d00cbfb3e43eb8c27c"

URI_aarch64_rust-rust-embed-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-utils-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-utils-devel}"
SRC_URI[aarch64_rust-rust-embed-utils-devel.sha256sum] = "ac8c47dafe4f0daad33c9874102c526c824e32e9f7c737c9f44b339ec02af960"

RDEPENDS:rust-rust-embed-utils+debug-embed-devel = " \
 cargo \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils+default-devel = " \
 cargo \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils+globset-devel = " \
 cargo \
 rust-globset+default-devel \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils+include-exclude-devel = " \
 cargo \
 rust-rust-embed-utils+globset-devel \
 rust-rust-embed-utils-devel \
 "
RDEPENDS:rust-rust-embed-utils-devel = " \
 cargo \
 rust-sha2+default-devel \
 rust-walkdir+default-devel \
 "
