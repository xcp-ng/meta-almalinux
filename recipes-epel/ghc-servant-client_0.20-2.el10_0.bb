# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-servant-client"
PV = "0.20"
PR = "2.el10_0"
PACKAGES = " \
 ghc-servant-client \
 ghc-servant-client-devel \
 ghc-servant-client-doc \
 ghc-servant-client-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-servant-client-0.20-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40dc2144f2c2eb248dc4a170b6f8f0fa0bbb022ec3ff4d0877955a766602d8ff"

URI_x86_64_v2_ghc-servant-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-client-0.20-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-client}"
SRC_URI[x86_64_v2_ghc-servant-client.sha256sum] = "e88b1be7e9021bd980c76ca376af93f326b9715b1f8b22cc1c72afea23263493"

URI_x86_64_v2_ghc-servant-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-client-devel-0.20-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-client-devel}"
SRC_URI[x86_64_v2_ghc-servant-client-devel.sha256sum] = "ea38420574a7a2b791f09835b9e3c0408d5cf1de127a59b886192ebc6e3516ce"

URI_x86_64_v2_ghc-servant-client-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-client-doc-0.20-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-servant-client-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-client-doc}"
SRC_URI[x86_64_v2_ghc-servant-client-doc.sha256sum] = "99f8f861c3801eef1be002b97bbca41c532dd0d5fb2de1af3e96d3eeb37fe163"

URI_x86_64_v2_ghc-servant-client-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-client-prof-0.20-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-client-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-client-prof}"
SRC_URI[x86_64_v2_ghc-servant-client-prof.sha256sum] = "4cba8af33debefd9e4cd677033de07e02d31e51cb3862b516f4e04596d2907a9"

URI_aarch64_ghc-servant-client = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-client-0.20-2.el10_0.aarch64.rpm;name=aarch64_ghc-servant-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-client}"
SRC_URI[aarch64_ghc-servant-client.sha256sum] = "cf4b502518e313f52fed6e427b671af25ee1a3f2f20b35ee85946c8e783e5782"

URI_aarch64_ghc-servant-client-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-client-devel-0.20-2.el10_0.aarch64.rpm;name=aarch64_ghc-servant-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-client-devel}"
SRC_URI[aarch64_ghc-servant-client-devel.sha256sum] = "a569203afd5790c9186c7f04ef73e3ef13f5656ccc1fe34103718386db52f54e"

URI_aarch64_ghc-servant-client-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-client-doc-0.20-2.el10_0.noarch.rpm;name=aarch64_ghc-servant-client-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-client-doc}"
SRC_URI[aarch64_ghc-servant-client-doc.sha256sum] = "5e2763d12a2abdaeef1317a5a31fab1a0a1a66704e6942db3305b35c6ca3dac2"

URI_aarch64_ghc-servant-client-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-client-prof-0.20-2.el10_0.aarch64.rpm;name=aarch64_ghc-servant-client-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-client-prof}"
SRC_URI[aarch64_ghc-servant-client-prof.sha256sum] = "36d746ce861c69f7aa534e5d62ff7c4a8db757e5b526fe81aef4e2eb0bcb3913"

RDEPENDS:ghc-servant-client = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-adjunctions \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-attoparsec-iso8601 \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-blaze-builder \
 ghc-boring \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-constraints \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-dec \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-free \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-api-data \
 ghc-http-client \
 ghc-http-media \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-conversion \
 ghc-integer-logarithms \
 ghc-invariant \
 ghc-iproute \
 ghc-kan-extensions \
 ghc-mime-types \
 ghc-mmorph \
 ghc-monad-control \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-profunctors \
 ghc-random \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-semigroups \
 ghc-servant \
 ghc-servant-client-core \
 ghc-singleton-bool \
 ghc-some \
 ghc-sop-core \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-string-conversions \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-stream \
 ghc-void \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-servant-client-devel = " \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-exceptions-devel \
 ghc-http-client-devel \
 ghc-http-media-devel \
 ghc-http-types-devel \
 ghc-kan-extensions-devel \
 ghc-monad-control-devel \
 ghc-mtl-devel \
 ghc-semigroupoids-devel \
 ghc-servant-client \
 ghc-servant-client-core-devel \
 ghc-servant-devel \
 ghc-stm-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-base-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-servant-client-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-servant-client-prof = " \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-exceptions-prof \
 ghc-http-client-prof \
 ghc-http-media-prof \
 ghc-http-types-prof \
 ghc-kan-extensions-prof \
 ghc-monad-control-prof \
 ghc-mtl-prof \
 ghc-semigroupoids-prof \
 ghc-servant-client-core-prof \
 ghc-servant-client-devel \
 ghc-servant-prof \
 ghc-stm-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-base-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 "
