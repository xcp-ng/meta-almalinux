# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "easyloggingpp"
PE = "1"
PV = "9.97.1"
PR = "6.el10_0"
PACKAGES = " \
 easyloggingpp-devel \
 easyloggingpp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/easyloggingpp-9.97.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dcfbd5a08ad5074a1902aee7e1a8be9e9908896cebdf24750ec1be0d8ae8408"

URI_x86_64_v2_easyloggingpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/easyloggingpp-devel-9.97.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_easyloggingpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_easyloggingpp-devel}"
SRC_URI[x86_64_v2_easyloggingpp-devel.sha256sum] = "4e4fd7fa62db4ea09b5e82ac04a47c6792824185a7f3652b568928ff8aca2135"

URI_x86_64_v2_easyloggingpp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/easyloggingpp-doc-9.97.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_easyloggingpp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_easyloggingpp-doc}"
SRC_URI[x86_64_v2_easyloggingpp-doc.sha256sum] = "176771a84fba7af84da78bde7fcaaf8ff545bc7d952a841746db3ff6e163e849"

URI_aarch64_easyloggingpp-devel = "${EPEL_MIRROR}/aarch64/Packages/e/easyloggingpp-devel-9.97.1-6.el10_0.noarch.rpm;name=aarch64_easyloggingpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_easyloggingpp-devel}"
SRC_URI[aarch64_easyloggingpp-devel.sha256sum] = "779d2bbdfba7cca3912ca04b935b75fe02e5937aa54df5e8fc5e339cbdc35d3a"

URI_aarch64_easyloggingpp-doc = "${EPEL_MIRROR}/aarch64/Packages/e/easyloggingpp-doc-9.97.1-6.el10_0.noarch.rpm;name=aarch64_easyloggingpp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_easyloggingpp-doc}"
SRC_URI[aarch64_easyloggingpp-doc.sha256sum] = "65fa8961d668ff269ae3d5825f063a5988a47a20a90af0bf601c03ba1ba2b74a"

RDEPENDS:easyloggingpp-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:easyloggingpp-doc = " \
 easyloggingpp-devel \
 "
