# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netplan"
PV = "1.2.1"
PR = "2.el10_2"
PACKAGES = " \
 netplan \
 netplan-default-backend-NetworkManager \
 netplan-default-backend-networkd \
 netplan-devel \
 netplan-libs \
 python3-netplan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netplan-1.2.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d24ae9a3405115ba4fb426cb890ccce8ce3b5ec06d2a6b54073512d0da278cd6"

URI_x86_64_v2_netplan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-1.2.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netplan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netplan}"
SRC_URI[x86_64_v2_netplan.sha256sum] = "1b528dd90cec70bcfafdcc0a115906baed42baa5c5f174e492a1c426dbb0a92f"

URI_x86_64_v2_netplan-default-backend-NetworkManager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-default-backend-NetworkManager-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_netplan-default-backend-NetworkManager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netplan-default-backend-NetworkManager}"
SRC_URI[x86_64_v2_netplan-default-backend-NetworkManager.sha256sum] = "2b1beeff64a1d50b27154f23b8b8eee498642e50059db3c0125f27a366a5aaba"
RPROVIDES:netplan-default-backend-NetworkManager:x86_64_v2 = "virtual/netplan-default-backend"

URI_x86_64_v2_netplan-default-backend-networkd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-default-backend-networkd-1.2.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_netplan-default-backend-networkd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netplan-default-backend-networkd}"
SRC_URI[x86_64_v2_netplan-default-backend-networkd.sha256sum] = "165fa148f9850234257827e5cc80ffa3c2b327f41a3e6190074809f0f2d56101"
RPROVIDES:netplan-default-backend-networkd:x86_64_v2 = "virtual/netplan-default-backend"

URI_x86_64_v2_netplan-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-devel-1.2.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netplan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netplan-devel}"
SRC_URI[x86_64_v2_netplan-devel.sha256sum] = "8df339d4768dadfc8a6d27a890197b3a2cdb5064a02f3c3fd7240a06e6a55077"

URI_x86_64_v2_netplan-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-libs-1.2.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netplan-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netplan-libs}"
SRC_URI[x86_64_v2_netplan-libs.sha256sum] = "8518e19cb7719306c5033bb40b2181b065e3970861266b297a25a7906fc9b418"

URI_x86_64_v2_python3-netplan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-netplan-1.2.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-netplan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-netplan}"
SRC_URI[x86_64_v2_python3-netplan.sha256sum] = "82d49a00159fa1da6c1eeb26d3e83baecfc44bda9fa771c6518b47756e06dd57"

URI_aarch64_netplan = "${EPEL_MIRROR}/aarch64/Packages/n/netplan-1.2.1-2.el10_2.aarch64.rpm;name=aarch64_netplan;unpack=0"
SRC_URI:append = " ${URI_aarch64_netplan}"
SRC_URI[aarch64_netplan.sha256sum] = "6f39878dbe48e3c823be903c7f6fa090e55bb78869074d78cc8f5b469dfbb9a2"

URI_aarch64_netplan-default-backend-NetworkManager = "${EPEL_MIRROR}/aarch64/Packages/n/netplan-default-backend-NetworkManager-1.2.1-2.el10_2.noarch.rpm;name=aarch64_netplan-default-backend-NetworkManager;unpack=0"
SRC_URI:append = " ${URI_aarch64_netplan-default-backend-NetworkManager}"
SRC_URI[aarch64_netplan-default-backend-NetworkManager.sha256sum] = "a5fcad538672a91c8b5dbc72cd6db010989cb8a272d3157d3c3611687aaf8132"
RPROVIDES:netplan-default-backend-NetworkManager:aarch64 = "virtual/netplan-default-backend"

URI_aarch64_netplan-default-backend-networkd = "${EPEL_MIRROR}/aarch64/Packages/n/netplan-default-backend-networkd-1.2.1-2.el10_2.noarch.rpm;name=aarch64_netplan-default-backend-networkd;unpack=0"
SRC_URI:append = " ${URI_aarch64_netplan-default-backend-networkd}"
SRC_URI[aarch64_netplan-default-backend-networkd.sha256sum] = "b89cbce05e0b89c54b1a3381fa3cd535c0b68354d267133540b4e619758b3002"
RPROVIDES:netplan-default-backend-networkd:aarch64 = "virtual/netplan-default-backend"

URI_aarch64_netplan-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netplan-devel-1.2.1-2.el10_2.aarch64.rpm;name=aarch64_netplan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netplan-devel}"
SRC_URI[aarch64_netplan-devel.sha256sum] = "a615a20bfe4ee0ff10db167775361793cb1eb24cbfa274568c37e31738f48a3a"

URI_aarch64_netplan-libs = "${EPEL_MIRROR}/aarch64/Packages/n/netplan-libs-1.2.1-2.el10_2.aarch64.rpm;name=aarch64_netplan-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_netplan-libs}"
SRC_URI[aarch64_netplan-libs.sha256sum] = "0d4707275b9b1a08dfc8afb6359ad2254964d5eed3a1274139d6c914bf27c9c0"

URI_aarch64_python3-netplan = "${EPEL_MIRROR}/aarch64/Packages/p/python3-netplan-1.2.1-2.el10_2.aarch64.rpm;name=aarch64_python3-netplan;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-netplan}"
SRC_URI[aarch64_python3-netplan.sha256sum] = "28669ad6bb685b7fc920f87ec2a4263c7098634bb2c0112b6908b735044f3726"

RDEPENDS:netplan = " \
 dbus-common \
 glib2 \
 glibc \
 iproute \
 libgcc \
 netplan-libs \
 python3 \
 python3-netifaces \
 python3-netplan \
 python3-pyyaml \
 systemd-libs \
 virtual/netplan-default-backend \
 "
RDEPENDS:netplan-default-backend-NetworkManager = " \
 NetworkManager \
 NetworkManager-config-server \
 netplan \
 "
RDEPENDS:netplan-default-backend-networkd = " \
 netplan \
 systemd-networkd \
 "
RDEPENDS:netplan-devel = " \
 glib2-devel \
 libuuid-devel \
 libyaml-devel \
 netplan-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:netplan-libs = " \
 glib2 \
 glibc \
 libgcc \
 libuuid \
 libyaml \
 "
RDEPENDS:python3-netplan = " \
 glibc \
 netplan-libs \
 python3 \
 python3-cffi \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/netplan-default-backend"

PROVIDES:append:aarch64 = " rpm/virtual/netplan-default-backend"
