# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-EV-Glib"
PV = "2.01"
PR = "8.el10_1"
PACKAGES = " \
 perl-EV-Glib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-EV-Glib-2.01-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2827cb7e5beb786d47f1f64eacc085ccb84ea9c271a7cd94a8686d0434250dce"

URI_x86_64_v2_perl-EV-Glib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-EV-Glib-2.01-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-EV-Glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-EV-Glib}"
SRC_URI[x86_64_v2_perl-EV-Glib.sha256sum] = "ab55fa5cd2f7ba95e20037aa5977e46ef991d37c9c6426eeb28105b18409040c"

URI_aarch64_perl-EV-Glib = "${EPEL_MIRROR}/aarch64/Packages/p/perl-EV-Glib-2.01-8.el10_1.aarch64.rpm;name=aarch64_perl-EV-Glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-EV-Glib}"
SRC_URI[aarch64_perl-EV-Glib.sha256sum] = "1c63ed94673f996f4cce312cfd7c52495d1749ab0f158b2de6d19769ba9585ba"

RDEPENDS:perl-EV-Glib = " \
 glib2 \
 glibc \
 perl-Carp \
 perl-EV \
 perl-libs \
 "
