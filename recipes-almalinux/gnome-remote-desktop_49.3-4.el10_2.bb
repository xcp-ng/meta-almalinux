# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-remote-desktop"
PV = "49.3"
PR = "4.el10_2"
PACKAGES = " \
 gnome-remote-desktop \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-remote-desktop-49.3-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40e60b4d0a6e755318e7bfffb7144646e80192a472d2c5014174e6a65ab992b3"

URI_x86_64_v2_gnome-remote-desktop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-remote-desktop-49.3-4.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnome-remote-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-remote-desktop}"
SRC_URI[x86_64_v2_gnome-remote-desktop.sha256sum] = "e8b38e84c51e4ce40ed30bb276827e88466ac1af9cd24f6134a7d74957cb82b6"

URI_aarch64_gnome-remote-desktop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-remote-desktop-49.3-4.el10_2.aarch64.rpm;name=aarch64_gnome-remote-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-remote-desktop}"
SRC_URI[aarch64_gnome-remote-desktop.sha256sum] = "2921fa40e6f906a3e82b4ab7702c87ae2b4d44e3c2a0d55a95e26cbe30763b2f"

RDEPENDS:gnome-remote-desktop = " \
 bash \
 cairo \
 fdk-aac-free \
 freerdp-libs \
 fuse3-libs \
 glib2 \
 glibc \
 libei \
 libepoxy \
 libgcc \
 libnotify \
 libsecret \
 libva \
 libwinpr \
 libxkbcommon \
 opus \
 pipewire \
 pipewire-libs \
 polkit-libs \
 systemd-libs \
 tpm2-tss \
 vulkan-loader \
 "
