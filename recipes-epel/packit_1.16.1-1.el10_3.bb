# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "packit"
PV = "1.16.1"
PR = "1.el10_3"
PACKAGES = " \
 packit \
 python3-packit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/packit-1.16.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a05eb3787f4720479286af7cb582f564b14b4d7c97318939a0ed40f8204136b"

URI_x86_64_v2_packit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/packit-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_packit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_packit}"
SRC_URI[x86_64_v2_packit.sha256sum] = "b4b56c2bbd911413813ba9e41360de8913d47de9b7f248de4af94954e6cba13c"

URI_x86_64_v2_python3-packit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-packit-1.16.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-packit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-packit}"
SRC_URI[x86_64_v2_python3-packit.sha256sum] = "e531644f6057894701396d22f1b49a44ffc63eb0f056684b3400c074ab09f6a2"

URI_aarch64_packit = "${EPEL_MIRROR}/aarch64/Packages/p/packit-1.16.1-1.el10_3.noarch.rpm;name=aarch64_packit;unpack=0"
SRC_URI:append = " ${URI_aarch64_packit}"
SRC_URI[aarch64_packit.sha256sum] = "4b574f2b888a3a69989846eb8982c15a07e1395a607b1e3efc8d256ab4694cc2"

URI_aarch64_python3-packit = "${EPEL_MIRROR}/aarch64/Packages/p/python3-packit-1.16.1-1.el10_3.noarch.rpm;name=aarch64_python3-packit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-packit}"
SRC_URI[aarch64_python3-packit.sha256sum] = "ddb32686e5851a51b44910609fa48a2d858af1d37e5facf54ffcd21e5a0b77a0"

RDEPENDS:packit = " \
 python3 \
 python3-packit \
 "
RDEPENDS:python3-packit = " \
 bash \
 bodhi-client \
 fedpkg \
 git-core \
 krb5-workstation \
 osc \
 python3 \
 python3-GitPython \
 python3-backoff \
 python3-bugzilla \
 python3-cachetools \
 python3-cccolutils \
 python3-click \
 python3-copr \
 python3-fedora-distro-aliases \
 python3-gnupg \
 python3-koji \
 python3-lazy-object-proxy \
 python3-marshmallow \
 python3-munch \
 python3-ogr \
 python3-opensuse-distro-aliases \
 python3-packaging \
 python3-pyyaml \
 python3-requests \
 python3-requests-kerberos \
 python3-rpkg \
 python3-specfile \
 python3-tabulate \
 rpm-build \
 rpmdevtools \
 rsync \
 "
