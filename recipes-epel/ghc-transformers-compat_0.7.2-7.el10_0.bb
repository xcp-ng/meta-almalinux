# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-transformers-compat"
PV = "0.7.2"
PR = "7.el10_0"
PACKAGES = " \
 ghc-transformers-compat \
 ghc-transformers-compat-devel \
 ghc-transformers-compat-doc \
 ghc-transformers-compat-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-transformers-compat-0.7.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91a4fcb7f61a3ad7e11750740acd09a25901af33188cb8058c2eea6279481188"

URI_x86_64_v2_ghc-transformers-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-compat-0.7.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-transformers-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-compat}"
SRC_URI[x86_64_v2_ghc-transformers-compat.sha256sum] = "d22151a740734ac67f436b3c49635927f895f8d525f1dec7a7e5f108cc2792de"

URI_x86_64_v2_ghc-transformers-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-compat-devel-0.7.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-transformers-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-compat-devel}"
SRC_URI[x86_64_v2_ghc-transformers-compat-devel.sha256sum] = "bf2fc5ce6cda3f3739165817b361c5a1c9499e7bf209ac8f7499e3efabb64b12"

URI_x86_64_v2_ghc-transformers-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-compat-doc-0.7.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-transformers-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-compat-doc}"
SRC_URI[x86_64_v2_ghc-transformers-compat-doc.sha256sum] = "996ba354cb599e61aea40ccfb7c43a29f7b0c3c7dd7be37675d9a0221e7e167e"

URI_x86_64_v2_ghc-transformers-compat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-transformers-compat-prof-0.7.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-transformers-compat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-transformers-compat-prof}"
SRC_URI[x86_64_v2_ghc-transformers-compat-prof.sha256sum] = "3eb5c57638a58a847725172cb3e43f7e414371035b470ff4e2844fd13e04df45"

URI_aarch64_ghc-transformers-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-compat-0.7.2-7.el10_0.aarch64.rpm;name=aarch64_ghc-transformers-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-compat}"
SRC_URI[aarch64_ghc-transformers-compat.sha256sum] = "7fcae5bcea532f277375b3f150ad0b9157e4944893fdf369f7e0ba34341ad82e"

URI_aarch64_ghc-transformers-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-compat-devel-0.7.2-7.el10_0.aarch64.rpm;name=aarch64_ghc-transformers-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-compat-devel}"
SRC_URI[aarch64_ghc-transformers-compat-devel.sha256sum] = "05b5e064490bb9ed4158785aa420404e2c73628ab6724e1b92cd89c55879343a"

URI_aarch64_ghc-transformers-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-compat-doc-0.7.2-7.el10_0.noarch.rpm;name=aarch64_ghc-transformers-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-compat-doc}"
SRC_URI[aarch64_ghc-transformers-compat-doc.sha256sum] = "d627de83dfc0acbe6ac5252567adf689b89f12e301eb94e9ded933b0dfd1fb82"

URI_aarch64_ghc-transformers-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-transformers-compat-prof-0.7.2-7.el10_0.aarch64.rpm;name=aarch64_ghc-transformers-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-transformers-compat-prof}"
SRC_URI[aarch64_ghc-transformers-compat-prof.sha256sum] = "a20feed5a4ba4063b26ca7cb6081491ff28960b9025e82270d3028c1450cf2c4"

RDEPENDS:ghc-transformers-compat = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-transformers-compat-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-transformers-compat \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-transformers-compat-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-transformers-compat-prof = " \
 ghc-base-prof \
 ghc-transformers-compat-devel \
 ghc-transformers-prof \
 "
