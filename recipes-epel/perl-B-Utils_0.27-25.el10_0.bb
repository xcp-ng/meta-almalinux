# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-B-Utils"
PV = "0.27"
PR = "25.el10_0"
PACKAGES = " \
 perl-B-Utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-B-Utils-0.27-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b760d692e8ac2e434774b713b22b9bfc9e786e5325a373a3e8abf502afa9a23c"

URI_x86_64_v2_perl-B-Utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-B-Utils-0.27-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-B-Utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-B-Utils}"
SRC_URI[x86_64_v2_perl-B-Utils.sha256sum] = "9d7cbb113fa7e3c43c4990611694cba3320132f21cb70f197f5063bada9678b9"

URI_aarch64_perl-B-Utils = "${EPEL_MIRROR}/aarch64/Packages/p/perl-B-Utils-0.27-25.el10_0.aarch64.rpm;name=aarch64_perl-B-Utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-B-Utils}"
SRC_URI[aarch64_perl-B-Utils.sha256sum] = "61c246406ecb3ce810ef7a7d7496c485f24efb6bb90852e019e07813ac3af196"

RDEPENDS:perl-B-Utils = " \
 glibc \
 perl-B \
 perl-B-Utils \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 perl-subs \
 perl-vars \
 "
