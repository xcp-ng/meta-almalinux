# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_radius"
PV = "3.0.0"
PR = "2.el10_1"
PACKAGES = " \
 pam_radius \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_radius-3.0.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "563a3096accb009a468100edfdea6e30c204cb22f5be77a5b3e3e586df5fe682"

URI_x86_64_v2_pam_radius = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_radius-3.0.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_radius;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_radius}"
SRC_URI[x86_64_v2_pam_radius.sha256sum] = "5d3e15d202e97b974c6673d128e402241662d473eb698019a1fcf8032546623d"

URI_aarch64_pam_radius = "${EPEL_MIRROR}/aarch64/Packages/p/pam_radius-3.0.0-2.el10_1.aarch64.rpm;name=aarch64_pam_radius;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_radius}"
SRC_URI[aarch64_pam_radius.sha256sum] = "f3f2f93d56b8a684455c2f63f1a2056a6c3217663d181de6958c034034faf463"

RDEPENDS:pam_radius = " \
 bash \
 glibc \
 pam \
 pam-libs \
 "
