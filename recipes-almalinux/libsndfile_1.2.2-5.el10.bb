# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsndfile"
PV = "1.2.2"
PR = "5.el10"
PACKAGES = " \
 libsndfile \
 libsndfile-devel \
 libsndfile-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsndfile-1.2.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cce57c459f18fbb6371f590f7f96f1c0ddf7fe5339efe83294229099f98c4809"

URI_x86_64_v2_libsndfile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsndfile-1.2.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libsndfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsndfile}"
SRC_URI[x86_64_v2_libsndfile.sha256sum] = "75a596e2630a6c671e507d6461f44f294f2b3ed237c07a03c18ad69b685aa735"

URI_x86_64_v2_libsndfile-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsndfile-devel-1.2.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libsndfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsndfile-devel}"
SRC_URI[x86_64_v2_libsndfile-devel.sha256sum] = "bc1b5373e3196bd5ab32093a404056d708d20f47c5ddc6130bf08dfc7470f335"

URI_x86_64_v2_libsndfile-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsndfile-utils-1.2.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libsndfile-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsndfile-utils}"
SRC_URI[x86_64_v2_libsndfile-utils.sha256sum] = "dc3b4c0e5cae40a2dc36f7416013519960288268dd69d06b478b20416948f073"

URI_aarch64_libsndfile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsndfile-1.2.2-5.el10.aarch64.rpm;name=aarch64_libsndfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsndfile}"
SRC_URI[aarch64_libsndfile.sha256sum] = "4509f61db782182cd053db3bd85f9c1056c58c7b01b2e2d4aa09173268fc00e0"

URI_aarch64_libsndfile-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsndfile-devel-1.2.2-5.el10.aarch64.rpm;name=aarch64_libsndfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsndfile-devel}"
SRC_URI[aarch64_libsndfile-devel.sha256sum] = "4fb5e5f19b88a653bbe7ba7a9fb6a4a9267aa2ff3f5879987869d927eb3e502b"

URI_aarch64_libsndfile-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsndfile-utils-1.2.2-5.el10.aarch64.rpm;name=aarch64_libsndfile-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsndfile-utils}"
SRC_URI[aarch64_libsndfile-utils.sha256sum] = "deab710f343dca5374458947e6077e8e2cd00477b1c19ef2812cb198e532bf0c"

RDEPENDS:libsndfile = " \
 flac-libs \
 glibc \
 gsm \
 lame-libs \
 libogg \
 libvorbis \
 mpg123-libs \
 opus \
 "
RDEPENDS:libsndfile-devel = " \
 flac-devel \
 libogg-devel \
 libsndfile \
 libvorbis-devel \
 mpg123-devel \
 opus-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libsndfile-utils = " \
 alsa-lib \
 glibc \
 libsndfile \
 "
