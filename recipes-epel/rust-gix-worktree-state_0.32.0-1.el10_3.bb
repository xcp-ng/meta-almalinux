# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree-state"
PV = "0.32.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-worktree-state+default-devel \
 rust-gix-worktree-state+parallel-devel \
 rust-gix-worktree-state+sha1-devel \
 rust-gix-worktree-state+sha256-devel \
 rust-gix-worktree-state-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-state-0.32.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b0bc9c67acf043dc1f4e3a65c8fc8998be802996435a68f8a26f3940bd02b15"

URI_x86_64_v2_rust-gix-worktree-state+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state+default-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state+default-devel.sha256sum] = "ea8d5de1459e200dc5a8562641b9be70c37045cbcb3f8858d42e2ff8760078d5"

URI_x86_64_v2_rust-gix-worktree-state+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state+parallel-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state+parallel-devel.sha256sum] = "d55422fa95f649ec9c6593a4ee32d4142a128946d71cfc406a0169bd32be7d00"

URI_x86_64_v2_rust-gix-worktree-state+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state+sha1-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state+sha1-devel.sha256sum] = "fef8be592a8815a89604e06a743bba4d1988baaf1925348574c436bc89408748"

URI_x86_64_v2_rust-gix-worktree-state+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state+sha256-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state+sha256-devel.sha256sum] = "c57a0be0458484f8ace5e4b67155878e84487097929253b4da45b4084b35316f"

URI_x86_64_v2_rust-gix-worktree-state-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state-devel.sha256sum] = "48e893b36ab1bef7c11cdd84c882b233b2d5285b093435e51c4b1a1eb91e0c26"

URI_aarch64_rust-gix-worktree-state+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state+default-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree-state+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state+default-devel}"
SRC_URI[aarch64_rust-gix-worktree-state+default-devel.sha256sum] = "f1b00977c15636a742c117af98f59c3a081dfc8716c8761045d63ec6891cf936"

URI_aarch64_rust-gix-worktree-state+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state+parallel-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree-state+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state+parallel-devel}"
SRC_URI[aarch64_rust-gix-worktree-state+parallel-devel.sha256sum] = "49289a8e7248310a015a64a094543a2ef23679ee8315f8828c4ae4a2dcb85feb"

URI_aarch64_rust-gix-worktree-state+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state+sha1-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree-state+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state+sha1-devel}"
SRC_URI[aarch64_rust-gix-worktree-state+sha1-devel.sha256sum] = "f92241d8e8741689a84828b24870aa673bc69a774a0083d7f26a4e7b0d2f98a5"

URI_aarch64_rust-gix-worktree-state+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state+sha256-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree-state+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state+sha256-devel}"
SRC_URI[aarch64_rust-gix-worktree-state+sha256-devel.sha256sum] = "5f405953802ab4ea77599eb649d4a05251cc73ac6070c5f05703d982d567616c"

URI_aarch64_rust-gix-worktree-state-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-worktree-state-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state-devel}"
SRC_URI[aarch64_rust-gix-worktree-state-devel.sha256sum] = "929ffe358fa32924e6c47aeeac78cb6951feaa3e72174c519114e1aa728e2ae6"

RDEPENDS:rust-gix-worktree-state+default-devel = " \
 cargo \
 rust-gix-worktree-state-devel \
 "
RDEPENDS:rust-gix-worktree-state+parallel-devel = " \
 cargo \
 rust-gix-features+parallel-devel \
 rust-gix-worktree-state-devel \
 "
RDEPENDS:rust-gix-worktree-state+sha1-devel = " \
 cargo \
 rust-gix-index+sha1-devel \
 rust-gix-worktree-state-devel \
 "
RDEPENDS:rust-gix-worktree-state+sha256-devel = " \
 cargo \
 rust-gix-index+sha256-devel \
 rust-gix-worktree-state-devel \
 "
RDEPENDS:rust-gix-worktree-state-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-io-close+default-devel \
 rust-thiserror+default-devel \
 "
