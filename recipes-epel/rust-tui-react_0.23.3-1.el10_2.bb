# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tui-react"
PV = "0.23.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-tui-react+default-devel \
 rust-tui-react-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tui-react-0.23.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a03812ff73eb826f97d04cf72429b4c44ac76a35e6353c5fc28c8a4ef7f93ebb"

URI_x86_64_v2_rust-tui-react+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tui-react+default-devel-0.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tui-react+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tui-react+default-devel}"
SRC_URI[x86_64_v2_rust-tui-react+default-devel.sha256sum] = "209553295f17848da632f17fc8447e28bf05c31d0a2b05038c59be55b27dd070"

URI_x86_64_v2_rust-tui-react-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tui-react-devel-0.23.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tui-react-devel}"
SRC_URI[x86_64_v2_rust-tui-react-devel.sha256sum] = "4b8d411361743d258de89582b6c8b6e962ff1847eb40d6c010d7009ca22e2170"

URI_aarch64_rust-tui-react+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tui-react+default-devel-0.23.3-1.el10_2.noarch.rpm;name=aarch64_rust-tui-react+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tui-react+default-devel}"
SRC_URI[aarch64_rust-tui-react+default-devel.sha256sum] = "0a1df62d1ab87821aa19150054d9a463c066ea5dd0a4442668aa0eeca25dee40"

URI_aarch64_rust-tui-react-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tui-react-devel-0.23.3-1.el10_2.noarch.rpm;name=aarch64_rust-tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tui-react-devel}"
SRC_URI[aarch64_rust-tui-react-devel.sha256sum] = "45217da061fc6a9a925455f588f2a3cb2209d05a035c35e916922812647092f2"

RDEPENDS:rust-tui-react+default-devel = " \
 cargo \
 rust-tui-react-devel \
 "
RDEPENDS:rust-tui-react-devel = " \
 cargo \
 rust-log+default-devel \
 rust-ratatui0.26-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 "
