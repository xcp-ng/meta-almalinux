# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-vhacdx"
PV = "0.0.5"
PR = "1.el10_1"
PACKAGES = " \
 python3-vhacdx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-vhacdx-0.0.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c373f7b07356f367452589a27bacb641895b7eca5c2c2fa3b30bf4a7ac9e2da6"

URI_x86_64_v2_python3-vhacdx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vhacdx-0.0.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-vhacdx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vhacdx}"
SRC_URI[x86_64_v2_python3-vhacdx.sha256sum] = "9ef14575b584df702e093ec9561723818e9901a56b14256527a9a580f8a2921b"

URI_aarch64_python3-vhacdx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vhacdx-0.0.5-1.el10_1.aarch64.rpm;name=aarch64_python3-vhacdx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vhacdx}"
SRC_URI[aarch64_python3-vhacdx.sha256sum] = "3834464b8e92082b851756a5c9f40b6dc9cf57d7c9d4746d2d20dda617fbd545"

RDEPENDS:python3-vhacdx = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 "
