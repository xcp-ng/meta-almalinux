# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-disks"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-disks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-disks-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "353c01b40eae366e7d97fda82ee8cba21a7d25873620da5a85753a3b286508cf"

URI_x86_64_v2_plasma-disks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-disks-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-disks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-disks}"
SRC_URI[x86_64_v2_plasma-disks.sha256sum] = "cc71b2d0326ba4c10014480ab81d53748490b9fb477915c7449cda37c4a9829e"

URI_aarch64_plasma-disks = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-disks-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-disks;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-disks}"
SRC_URI[aarch64_plasma-disks.sha256sum] = "a204a8248b1ecd1554b9094a9ebf273e3a83a887a7ab915b2804cfa4388deea0"

RDEPENDS:plasma-disks = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kservice \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 smartmontools \
 "
