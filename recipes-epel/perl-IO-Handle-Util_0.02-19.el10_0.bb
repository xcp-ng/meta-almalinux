# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Handle-Util"
PV = "0.02"
PR = "19.el10_0"
PACKAGES = " \
 perl-IO-Handle-Util \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-Handle-Util-0.02-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4fa327251526ca8bb83b9f761dd0f29f24700c0f3c06e4d1b21051c77d16901"

URI_x86_64_v2_perl-IO-Handle-Util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-Handle-Util-0.02-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IO-Handle-Util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Handle-Util}"
SRC_URI[x86_64_v2_perl-IO-Handle-Util.sha256sum] = "74b321163fd1a658579d69842ff274a472229a4b69f9a601b8d40e492f61bd29"

URI_aarch64_perl-IO-Handle-Util = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-Handle-Util-0.02-19.el10_0.noarch.rpm;name=aarch64_perl-IO-Handle-Util;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Handle-Util}"
SRC_URI[aarch64_perl-IO-Handle-Util.sha256sum] = "eef5997270b80572224f3ccd4a1485bff562507d739bf2903c493e412929eda2"

RDEPENDS:perl-IO-Handle-Util = " \
 perl-Carp \
 perl-FileHandle \
 perl-IO \
 perl-IO-Handle-Util \
 perl-IO-String \
 perl-Scalar-List-Utils \
 perl-Sub-Exporter \
 perl-asa \
 perl-libs \
 perl-overload \
 perl-parent \
 "
