# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-vishvananda-netlink"
PV = "1.2.1~beta.2"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-vishvananda-netlink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-vishvananda-netlink-1.2.1~beta.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01f99f55e56faff597da3e0f9563389355e111bdf069ead2b0d6daca3b166bdc"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-vishvananda-netlink-devel: golang(github.com/vishvananda/netns)

URI_x86_64_v2_golang-github-vishvananda-netlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-vishvananda-netlink-devel-1.2.1~beta.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-vishvananda-netlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-vishvananda-netlink-devel}"
SRC_URI[x86_64_v2_golang-github-vishvananda-netlink-devel.sha256sum] = "b81750dd45887ac11326cea714d8ad8cdbec4b4635c9a9aaf355647148c931de"

URI_aarch64_golang-github-vishvananda-netlink-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-vishvananda-netlink-devel-1.2.1~beta.2-6.el10_0.noarch.rpm;name=aarch64_golang-github-vishvananda-netlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-vishvananda-netlink-devel}"
SRC_URI[aarch64_golang-github-vishvananda-netlink-devel.sha256sum] = "5b9c1bc0e5ebc555def2d1c39aba4717b0d5297483c25d9b3d3d37d48a2a5af4"

RDEPENDS:golang-github-vishvananda-netlink-devel:x86_64_v2 = " \
 go-filesystem \
 golang-x-sys-devel \
"
RDEPENDS:golang-github-vishvananda-netlink-devel:aarch64 = " \
 go-filesystem \
 golang-github-vishvananda-netns-devel \
 golang-x-sys-devel \
"
