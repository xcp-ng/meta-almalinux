# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdesdk-thumbnailers"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kdesdk-thumbnailers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdesdk-thumbnailers-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e00d326fe56be74e52dcdc80a25298f5947cb4b5df887bc5604e974b03d53091"

URI_x86_64_v2_kdesdk-thumbnailers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesdk-thumbnailers-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesdk-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesdk-thumbnailers}"
SRC_URI[x86_64_v2_kdesdk-thumbnailers.sha256sum] = "094b73d329d57d5a5b9624d47e2c883b6ab099f3a156948f92a559ed261c5f74"

URI_aarch64_kdesdk-thumbnailers = "${EPEL_MIRROR}/aarch64/Packages/k/kdesdk-thumbnailers-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kdesdk-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesdk-thumbnailers}"
SRC_URI[aarch64_kdesdk-thumbnailers.sha256sum] = "4262e7d786a575d0a118d517c3ccc984c0d3515f044bda2c7812e63f3412a753"

RDEPENDS:kdesdk-thumbnailers = " \
 gettext-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
