# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-mapping"
PV = "3.0.0"
PR = "28.el10_0"
PACKAGES = " \
 maven-mapping \
 maven-mapping-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/maven-mapping-3.0.0-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bba0bcd1f470b5e60998095d67770d997d8f8220a3aa44964558dfa0083a5bce"

URI_x86_64_v2_maven-mapping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maven-mapping-3.0.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_maven-mapping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-mapping}"
SRC_URI[x86_64_v2_maven-mapping.sha256sum] = "89fbafb5948ea17a24eb050f45a712986eefa402dbd88932765da5669fdbc4cc"

URI_x86_64_v2_maven-mapping-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maven-mapping-javadoc-3.0.0-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_maven-mapping-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-mapping-javadoc}"
SRC_URI[x86_64_v2_maven-mapping-javadoc.sha256sum] = "5910bf87ff69738177d435bb8a40173bb754757f9b702f4016634160b1708345"

URI_aarch64_maven-mapping = "${EPEL_MIRROR}/aarch64/Packages/m/maven-mapping-3.0.0-28.el10_0.noarch.rpm;name=aarch64_maven-mapping;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-mapping}"
SRC_URI[aarch64_maven-mapping.sha256sum] = "9170acf3400cd64b9444b035293e6a471a9100fbccd75bb9ff94333b69b85e30"

URI_aarch64_maven-mapping-javadoc = "${EPEL_MIRROR}/aarch64/Packages/m/maven-mapping-javadoc-3.0.0-28.el10_0.noarch.rpm;name=aarch64_maven-mapping-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-mapping-javadoc}"
SRC_URI[aarch64_maven-mapping-javadoc.sha256sum] = "1732a2fd492be7d0e492330faebfe0f6b7572ac63b7b1d761df2411a23eccdf6"

RDEPENDS:maven-mapping = " \
 javapackages-filesystem \
 maven-lib \
 plexus-interpolation \
 "
RDEPENDS:maven-mapping-javadoc = " \
 javapackages-filesystem \
 "
