# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xcb-util-errors"
PV = "1.0.1"
PR = "2.el10_0"
PACKAGES = " \
 xcb-util-errors \
 xcb-util-errors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xcb-util-errors-1.0.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9e8074b10133d7332fb0232f55fb47d226fbd21e0ceae5da080cd9bd57fd94b"

URI_x86_64_v2_xcb-util-errors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xcb-util-errors-1.0.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xcb-util-errors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-errors}"
SRC_URI[x86_64_v2_xcb-util-errors.sha256sum] = "d064a5e820665a6c3254ae26d69c52f320bb9f463477402aa5d0ca6f25cb1c2f"

URI_x86_64_v2_xcb-util-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xcb-util-errors-devel-1.0.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xcb-util-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-errors-devel}"
SRC_URI[x86_64_v2_xcb-util-errors-devel.sha256sum] = "2d1d88515eba1b54889a5aa4e06609855018d87e629944fe5cd4388899a848fa"

URI_aarch64_xcb-util-errors = "${EPEL_MIRROR}/aarch64/Packages/x/xcb-util-errors-1.0.1-2.el10_0.aarch64.rpm;name=aarch64_xcb-util-errors;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-errors}"
SRC_URI[aarch64_xcb-util-errors.sha256sum] = "f304997a7c4e9b39cf5ef105ed30c3ee951122a5df94ccdef9522a8d65eb6bbe"

URI_aarch64_xcb-util-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xcb-util-errors-devel-1.0.1-2.el10_0.aarch64.rpm;name=aarch64_xcb-util-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-errors-devel}"
SRC_URI[aarch64_xcb-util-errors-devel.sha256sum] = "5e2143ec1c846eb58eafb7a99283e0b40a60d5a077cd77ea95235afa98333e89"

RDEPENDS:xcb-util-errors = " \
 glibc \
 libxcb \
 "
RDEPENDS:xcb-util-errors-devel = " \
 libxcb-devel \
 pkgconf-pkg-config \
 xcb-util-errors \
 "
