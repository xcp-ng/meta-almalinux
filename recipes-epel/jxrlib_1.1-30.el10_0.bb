# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jxrlib"
PV = "1.1"
PR = "30.el10_0"
PACKAGES = " \
 jxrlib \
 jxrlib-devel \
 mingw32-jxrlib \
 mingw64-jxrlib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jxrlib-1.1-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24a5c9312425962a037a343d69a1130d05a256573ac6ee95beafc25460e9e425"

URI_x86_64_v2_jxrlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jxrlib-1.1-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jxrlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jxrlib}"
SRC_URI[x86_64_v2_jxrlib.sha256sum] = "52657db7ca87f43129e4499c82b1d71a38add499af65ba2529a3b7cd9c0668d5"

URI_x86_64_v2_jxrlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jxrlib-devel-1.1-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jxrlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jxrlib-devel}"
SRC_URI[x86_64_v2_jxrlib-devel.sha256sum] = "553bcb1b789829229067528416adde000e4192f983cdd512b65e107db8c26dfe"

URI_x86_64_v2_mingw32-jxrlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-jxrlib-1.1-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-jxrlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-jxrlib}"
SRC_URI[x86_64_v2_mingw32-jxrlib.sha256sum] = "fabccb4cf6f378222611ff853bbd80102ec341e8e46a630267d00f0db73e666f"

URI_x86_64_v2_mingw64-jxrlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-jxrlib-1.1-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-jxrlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-jxrlib}"
SRC_URI[x86_64_v2_mingw64-jxrlib.sha256sum] = "5ad4ba87beaaa2ed11c0dc74c8bf9dbcd79683bf3b7954d7e45cfe67ddb11ec0"

URI_aarch64_jxrlib = "${EPEL_MIRROR}/aarch64/Packages/j/jxrlib-1.1-30.el10_0.aarch64.rpm;name=aarch64_jxrlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_jxrlib}"
SRC_URI[aarch64_jxrlib.sha256sum] = "5a0abc8a8fcfd395f8b2bf2ea421b0278c34a5c065344f6a43f0ada0cdb2c0de"

URI_aarch64_jxrlib-devel = "${EPEL_MIRROR}/aarch64/Packages/j/jxrlib-devel-1.1-30.el10_0.aarch64.rpm;name=aarch64_jxrlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jxrlib-devel}"
SRC_URI[aarch64_jxrlib-devel.sha256sum] = "38e352b37d208a01366028968b88690e8ed5b766a75c710cf5b7387437e1b261"

URI_aarch64_mingw32-jxrlib = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-jxrlib-1.1-30.el10_0.noarch.rpm;name=aarch64_mingw32-jxrlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-jxrlib}"
SRC_URI[aarch64_mingw32-jxrlib.sha256sum] = "e07bf2d95c02a26d418073a1f87e908d085d0375e8288063cdfb9e8af7c297af"

URI_aarch64_mingw64-jxrlib = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-jxrlib-1.1-30.el10_0.noarch.rpm;name=aarch64_mingw64-jxrlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-jxrlib}"
SRC_URI[aarch64_mingw64-jxrlib.sha256sum] = "819a7d427167b0d310dab40a1a3d1ba90514f0f99fc2fdacb2008d146dd190bd"

RDEPENDS:jxrlib = " \
 glibc \
 "
RDEPENDS:jxrlib-devel = " \
 jxrlib \
 "
RDEPENDS:mingw32-jxrlib = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
 "
RDEPENDS:mingw64-jxrlib = " \
 mingw64-crt \
 mingw64-filesystem \
 "
