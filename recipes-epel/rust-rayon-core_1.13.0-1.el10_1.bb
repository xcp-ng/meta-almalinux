# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rayon-core"
PV = "1.13.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rayon-core+default-devel \
 rust-rayon-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rayon-core-1.13.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13bdec9b123346498bacabc2fe8112e05ccc87319430ed7cc731e7f2abe6fa42"

URI_x86_64_v2_rust-rayon-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rayon-core+default-devel-1.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rayon-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rayon-core+default-devel}"
SRC_URI[x86_64_v2_rust-rayon-core+default-devel.sha256sum] = "4ac34d2ec0604e292742351590703caf3152bddbec8c165174ed6969197121b2"

URI_x86_64_v2_rust-rayon-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rayon-core-devel-1.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rayon-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rayon-core-devel}"
SRC_URI[x86_64_v2_rust-rayon-core-devel.sha256sum] = "6602d93175ae5c28d5f8fc970c71df66eed35bfd05b2f0c4ff27347674761ed7"

URI_aarch64_rust-rayon-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rayon-core+default-devel-1.13.0-1.el10_1.noarch.rpm;name=aarch64_rust-rayon-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rayon-core+default-devel}"
SRC_URI[aarch64_rust-rayon-core+default-devel.sha256sum] = "72b5a7538835acfd33fa74b12e1777c2209b0a325fe823bef60657b9c6c240b4"

URI_aarch64_rust-rayon-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rayon-core-devel-1.13.0-1.el10_1.noarch.rpm;name=aarch64_rust-rayon-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rayon-core-devel}"
SRC_URI[aarch64_rust-rayon-core-devel.sha256sum] = "ffa37f3893f160cd0a5ae1c1ca64cd61d7943e7307ee4b677aa5b1c103e0f3d1"

RDEPENDS:rust-rayon-core+default-devel = " \
 cargo \
 rust-rayon-core-devel \
 "
RDEPENDS:rust-rayon-core-devel = " \
 cargo \
 rust \
 rust-crossbeam-deque+default-devel \
 rust-crossbeam-utils+default-devel \
 "
