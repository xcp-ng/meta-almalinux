# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nanoid"
PV = "0.4.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-nanoid+default-devel \
 rust-nanoid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nanoid-0.4.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "804d8cb03f7e9cfc4f6b8f70ac19f97246893b3424796358526ffb80fbc50701"

URI_x86_64_v2_rust-nanoid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanoid+default-devel-0.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanoid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanoid+default-devel}"
SRC_URI[x86_64_v2_rust-nanoid+default-devel.sha256sum] = "e62df46bf14ddaab88b91bf9c8d7dd156c9e7dce49b21241137d86b5bc1ea862"

URI_x86_64_v2_rust-nanoid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nanoid-devel-0.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nanoid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nanoid-devel}"
SRC_URI[x86_64_v2_rust-nanoid-devel.sha256sum] = "418a9cc2d388fd436da48f021f1bd49c536e6bc772036111388a1e4e4f168d8d"

URI_aarch64_rust-nanoid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanoid+default-devel-0.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-nanoid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanoid+default-devel}"
SRC_URI[aarch64_rust-nanoid+default-devel.sha256sum] = "287898aeb5054f0404e6b1cafc8bf49ffcdcccc42340e9b643bd0387f564d046"

URI_aarch64_rust-nanoid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nanoid-devel-0.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-nanoid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nanoid-devel}"
SRC_URI[aarch64_rust-nanoid-devel.sha256sum] = "c3d0746fd7d7401183bd0dbbb29fa91268bfa064ec65ab19a8df4bb9f129a362"

RDEPENDS:rust-nanoid+default-devel = " \
 cargo \
 rust-nanoid-devel \
 "
RDEPENDS:rust-nanoid-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 rust-rand0.8+small_rng-devel \
 "
