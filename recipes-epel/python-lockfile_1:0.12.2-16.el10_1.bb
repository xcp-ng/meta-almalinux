# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lockfile"
PE = "1"
PV = "0.12.2"
PR = "16.el10_1"
PACKAGES = " \
 python-lockfile-doc \
 python3-lockfile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-lockfile-0.12.2-16.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddcc183110ab3c1e8678fc72ca82ea2335da06b7c258e85ca33496c89b757d33"

URI_x86_64_v2_python-lockfile-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-lockfile-doc-0.12.2-16.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-lockfile-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-lockfile-doc}"
SRC_URI[x86_64_v2_python-lockfile-doc.sha256sum] = "39c5e1282880b659d20e1fac7c78ca0bf39b8ee3ae6f289163c4c5f6b085cd39"

URI_x86_64_v2_python3-lockfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lockfile-0.12.2-16.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-lockfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lockfile}"
SRC_URI[x86_64_v2_python3-lockfile.sha256sum] = "c15224826facb01e70f8c4806c3cebfc4b8c401da76f026d0761b77db8bd5ee1"

URI_aarch64_python-lockfile-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-lockfile-doc-0.12.2-16.el10_1.noarch.rpm;name=aarch64_python-lockfile-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-lockfile-doc}"
SRC_URI[aarch64_python-lockfile-doc.sha256sum] = "70ec30ecc166b974ab482dcf6e110b8378cd93940c247f306e1813ad3aaad181"

URI_aarch64_python3-lockfile = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lockfile-0.12.2-16.el10_1.noarch.rpm;name=aarch64_python3-lockfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lockfile}"
SRC_URI[aarch64_python3-lockfile.sha256sum] = "1e2578840a5dc314a74c38696c3e54f32172ba199368154a34c0ba41e6385e4d"

RDEPENDS:python-lockfile-doc = " \
 "
RDEPENDS:python3-lockfile = " \
 python3 \
 "
