# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-queue"
PV = "0.3.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue+default-devel \
 rust-crossbeam-queue+nightly-devel \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-queue-0.3.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2396ab8cbe798c93eb57d1c1f8ecbc680bc9db1862f851789bcf82f69493cd8"

URI_x86_64_v2_rust-crossbeam-queue+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+alloc-devel-0.3.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+alloc-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+alloc-devel.sha256sum] = "db76ef42f2fa1bc97bef10737a90bf111e11bcb87e13165c5ee7dcc8d7c0e5b7"

URI_x86_64_v2_rust-crossbeam-queue+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+default-devel-0.3.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+default-devel.sha256sum] = "00b16ac04f7ae360fb4e3a1a85b3eee4d311cff6cb2093d46fdf566abec33bd8"

URI_x86_64_v2_rust-crossbeam-queue+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+nightly-devel-0.3.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+nightly-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+nightly-devel.sha256sum] = "70147a8cfcc6d0eee754f80e7acf8ed1b1edd2193f1603d959433d2a9b898d60"

URI_x86_64_v2_rust-crossbeam-queue+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+std-devel-0.3.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+std-devel.sha256sum] = "fbe8b9c0ad11b2f24152ee3f88824f3fa3d70fcc4fb3d7150f0d05abae8a9094"

URI_x86_64_v2_rust-crossbeam-queue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue-devel-0.3.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue-devel.sha256sum] = "c47ff88afaa4d7fecb67f91ba695a537682d86d81cd3987cdbfe7ee4a50f56ff"

URI_aarch64_rust-crossbeam-queue+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+alloc-devel-0.3.12-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-queue+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+alloc-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+alloc-devel.sha256sum] = "58205de629a6bfd5fa48d3764178d320775edf023595046b5af7cdb296d254f3"

URI_aarch64_rust-crossbeam-queue+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+default-devel-0.3.12-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+default-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+default-devel.sha256sum] = "1a4321e929fdc9c694a7be69140c3bf2f9b9cac84bae2a1268616e95295ce7c0"

URI_aarch64_rust-crossbeam-queue+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+nightly-devel-0.3.12-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-queue+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+nightly-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+nightly-devel.sha256sum] = "1a6479655f850b1440832a6faaad6c89145a7464864ac922ebb9b6d90a69ebb2"

URI_aarch64_rust-crossbeam-queue+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+std-devel-0.3.12-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+std-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+std-devel.sha256sum] = "db227094bd17b4982d242ca928eb7db90937651bfdee30befa0726171f1b2c5e"

URI_aarch64_rust-crossbeam-queue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue-devel-0.3.12-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue-devel}"
SRC_URI[aarch64_rust-crossbeam-queue-devel.sha256sum] = "bb163cfbb5343323999f0bdfec62d6af3f11c8b07ca4435f08f887e28cf30c6b"

RDEPENDS:rust-crossbeam-queue+alloc-devel = " \
 cargo \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam-queue+default-devel = " \
 cargo \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam-queue+nightly-devel = " \
 cargo \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam-queue+std-devel = " \
 cargo \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-queue-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
