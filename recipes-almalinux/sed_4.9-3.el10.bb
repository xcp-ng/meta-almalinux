# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sed"
PV = "4.9"
PR = "3.el10"
PACKAGES = " \
 sed \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sed-4.9-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7c8a5e61a79ee0cec6f2f5c1d82b97127fd76b9c29dbc75844ae465e02488cf9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sed-4.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_sed;unpack=0"
SRC_URI[x86_64_v2_sed.sha256sum] = "44456b015140e03f094f48530d7d4432def05c5dfc30facb935d1384f9892b5e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sed-4.9-3.el10.aarch64.rpm;name=aarch64_sed;unpack=0"
SRC_URI[aarch64_sed.sha256sum] = "64a399c7072f19ba0024c660eb377a762914641552e7b9c71e1dcde572e94945"

RDEPENDS:sed = " \
 glibc \
 libacl \
 libselinux \
 "
