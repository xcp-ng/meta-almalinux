# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "duo_unix"
PV = "2.2.3"
PR = "1.el10_2"
PACKAGES = " \
 duo_unix \
 duo_unix-devel \
 duo_unix-doc \
 duo_unix-selinux \
 pam_duo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/duo_unix-2.2.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62cff58137f165a751124592e165d088da1cefa5abdd807994b8245b83aca736"

URI_x86_64_v2_duo_unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-2.2.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duo_unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix}"
SRC_URI[x86_64_v2_duo_unix.sha256sum] = "aa4c077e4c9bc097c9be569af16e569985bec79479d012fa77b1b179a101ff50"

URI_x86_64_v2_duo_unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-devel-2.2.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duo_unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix-devel}"
SRC_URI[x86_64_v2_duo_unix-devel.sha256sum] = "6d9bf20ea38136b9419e00300fc3f3be2538b4e9b813ee6f19dd3bcfa9036b49"

URI_x86_64_v2_duo_unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-doc-2.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_duo_unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix-doc}"
SRC_URI[x86_64_v2_duo_unix-doc.sha256sum] = "00d7482ea60b2cb0c01d50320cff1fc457d585de4118ea936d10fca246b606d3"

URI_x86_64_v2_duo_unix-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-selinux-2.2.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duo_unix-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix-selinux}"
SRC_URI[x86_64_v2_duo_unix-selinux.sha256sum] = "d7ef2ab55aa73fb883c931d0ab5324110ec7a1d5126d94cbe740602f395f28a7"

URI_x86_64_v2_pam_duo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_duo-2.2.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_duo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_duo}"
SRC_URI[x86_64_v2_pam_duo.sha256sum] = "e3286aa76bb2be0027586c43e082caf948f3d4d1526ed8ef2ba4845bd0336314"

URI_aarch64_duo_unix = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-2.2.3-1.el10_2.aarch64.rpm;name=aarch64_duo_unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix}"
SRC_URI[aarch64_duo_unix.sha256sum] = "d63439ea6be03f91ba4ae0035752f760db13f8891c1dbe1bdd3e14a4273125c5"

URI_aarch64_duo_unix-devel = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-devel-2.2.3-1.el10_2.aarch64.rpm;name=aarch64_duo_unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix-devel}"
SRC_URI[aarch64_duo_unix-devel.sha256sum] = "158b8e5465a845e80d8d447454531194a464e8ca384177056acc2f63f42301b0"

URI_aarch64_duo_unix-doc = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-doc-2.2.3-1.el10_2.noarch.rpm;name=aarch64_duo_unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix-doc}"
SRC_URI[aarch64_duo_unix-doc.sha256sum] = "e8304699fcce81d0b6f65c929cb3c11c10a34a53159a7ec078f5979ea0cce31e"

URI_aarch64_duo_unix-selinux = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-selinux-2.2.3-1.el10_2.aarch64.rpm;name=aarch64_duo_unix-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix-selinux}"
SRC_URI[aarch64_duo_unix-selinux.sha256sum] = "62334260405b6adecc860ecf425b59ee931455c77006266f9c0a0ea2e67524ef"

URI_aarch64_pam_duo = "${EPEL_MIRROR}/aarch64/Packages/p/pam_duo-2.2.3-1.el10_2.aarch64.rpm;name=aarch64_pam_duo;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_duo}"
SRC_URI[aarch64_pam_duo.sha256sum] = "a9265c4d40e30d855ebb56a5ce2a78f41ef65981b01f55644398da661f400b37"

RDEPENDS:duo_unix = " \
 bash \
 glibc \
 openssl-libs \
 "
RDEPENDS:duo_unix-devel = " \
 duo_unix \
 openssl-devel \
 pam_duo \
 pkgconf-pkg-config \
 "
RDEPENDS:duo_unix-doc = " \
 "
RDEPENDS:duo_unix-selinux = " \
 bash \
 libselinux-utils \
 pam_duo \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:pam_duo = " \
 duo_unix-selinux \
 glibc \
 openssl-libs \
 pam \
 pam-libs \
 "
