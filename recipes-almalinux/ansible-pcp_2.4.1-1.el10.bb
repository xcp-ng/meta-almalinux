# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-pcp"
PV = "2.4.1"
PR = "1.el10"
PACKAGES = " \
 ansible-pcp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-pcp-2.4.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed034e12e189ae577aa775dcd0c90a75f41d57c5941fa4b98ee0f30a9ab4d0da"

URI_x86_64_v2_ansible-pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-pcp-2.4.1-1.el10.noarch.rpm;name=x86_64_v2_ansible-pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-pcp}"
SRC_URI[x86_64_v2_ansible-pcp.sha256sum] = "9171925a35cb7e6efed2d65109286cb2f42a51d184e966f2e765a45a3e5a2f9e"

URI_aarch64_ansible-pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-pcp-2.4.1-1.el10.noarch.rpm;name=aarch64_ansible-pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-pcp}"
SRC_URI[aarch64_ansible-pcp.sha256sum] = "9171925a35cb7e6efed2d65109286cb2f42a51d184e966f2e765a45a3e5a2f9e"

RDEPENDS:ansible-pcp = " \
 ansible-core \
 bash \
 "
