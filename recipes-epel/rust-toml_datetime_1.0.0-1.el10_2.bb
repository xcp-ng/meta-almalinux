# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_datetime"
PV = "1.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-toml_datetime+alloc-devel \
 rust-toml_datetime+default-devel \
 rust-toml_datetime+serde-devel \
 rust-toml_datetime+std-devel \
 rust-toml_datetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_datetime-1.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0362711963aceb91187b47e4dd3f28653b1304593888908e63ae9aea04144ae"

URI_x86_64_v2_rust-toml_datetime+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+alloc-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+alloc-devel.sha256sum] = "8026c457b53639208fb56681a41fe7329f5eda00cbddb00ee7d8c0bcf69bcac0"

URI_x86_64_v2_rust-toml_datetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+default-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+default-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+default-devel.sha256sum] = "e79284ce4f605f4b99be2d5d1fb95d2962b3df853b1279d2eca4c9e4aa7074a8"

URI_x86_64_v2_rust-toml_datetime+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+serde-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+serde-devel.sha256sum] = "2f42a1fb570209de03b406609be0f71f83ded52d57dd282e9d44013440e458b7"

URI_x86_64_v2_rust-toml_datetime+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+std-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+std-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+std-devel.sha256sum] = "e1b5109d50400dfc2937e03c7e6b650c9a6c40d21ee92d180cf24d891c315e27"

URI_x86_64_v2_rust-toml_datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime-devel.sha256sum] = "70cc82b69a5563056c4351d9ebed5cca022a29977413b2f367c8dcb003818f60"

URI_aarch64_rust-toml_datetime+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+alloc-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-toml_datetime+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+alloc-devel}"
SRC_URI[aarch64_rust-toml_datetime+alloc-devel.sha256sum] = "998be6b9754df029a9174a0fc1b4df9996c7ff79f66bf012ecce71a7c76c1f2b"

URI_aarch64_rust-toml_datetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+default-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-toml_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+default-devel}"
SRC_URI[aarch64_rust-toml_datetime+default-devel.sha256sum] = "941f9a643aed8d69e35287c7363afae30aafef2a59cd77fe1fdedaaa9bbbe890"

URI_aarch64_rust-toml_datetime+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+serde-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-toml_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+serde-devel}"
SRC_URI[aarch64_rust-toml_datetime+serde-devel.sha256sum] = "0f1250ce316d882388fe0ddf64363aef136ecc06e311f185e5effcd9a4c55de3"

URI_aarch64_rust-toml_datetime+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+std-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-toml_datetime+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+std-devel}"
SRC_URI[aarch64_rust-toml_datetime+std-devel.sha256sum] = "8f1ab3e35a46fef5a2e98fd8c188d9fda63719ca5f0b756ee16acade671ad2d6"

URI_aarch64_rust-toml_datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-toml_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime-devel}"
SRC_URI[aarch64_rust-toml_datetime-devel.sha256sum] = "ee7f16f1455635d915adf7287e24744fb47a289163a3358d74f2b587d5ede128"

RDEPENDS:rust-toml_datetime+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime+default-devel = " \
 cargo \
 rust-toml_datetime+std-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime+std-devel = " \
 cargo \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-toml_datetime+alloc-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime-devel = " \
 cargo \
 rust \
 "
