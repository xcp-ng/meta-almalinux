# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossterm0.25"
PV = "0.25.0"
PR = "5.el10_1"
PACKAGES = " \
 rust-crossterm0.25+bracketed-paste-devel \
 rust-crossterm0.25+default-devel \
 rust-crossterm0.25+event-stream-devel \
 rust-crossterm0.25+futures-core-devel \
 rust-crossterm0.25+serde-devel \
 rust-crossterm0.25-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossterm0.25-0.25.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de9cb8e49143b015d108bb906c78d4277430021d4ed201df4817076435e8c220"

URI_x86_64_v2_rust-crossterm0.25+bracketed-paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25+bracketed-paste-devel-0.25.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25+bracketed-paste-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25+bracketed-paste-devel.sha256sum] = "0bfdd88d8c000d9baf790c9f3922e7aa3712c8a497c101c370f91254dc1f38f0"

URI_x86_64_v2_rust-crossterm0.25+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25+default-devel-0.25.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25+default-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25+default-devel.sha256sum] = "df6c55f63b202df49b2eb0e81e786e93cd20402a2e4e326febf40de6d3ae1a8b"

URI_x86_64_v2_rust-crossterm0.25+event-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25+event-stream-devel-0.25.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25+event-stream-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25+event-stream-devel.sha256sum] = "113d6aade835cd161486d777ac70b0d6eecbb91d8ae56786cadb14d99ef0443b"

URI_x86_64_v2_rust-crossterm0.25+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25+futures-core-devel-0.25.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25+futures-core-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25+futures-core-devel.sha256sum] = "6bb304dac3d91a09a8b91a74647ba643cbb333e263a21e679399267cc6c0a4a6"

URI_x86_64_v2_rust-crossterm0.25+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25+serde-devel-0.25.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25+serde-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25+serde-devel.sha256sum] = "fc072ca0e1a1ff10ea4c2b5ec489d8635da6aea39320da70ca325a0fa6144fc1"

URI_x86_64_v2_rust-crossterm0.25-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25-devel-0.25.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25-devel.sha256sum] = "e77978ab6c090c57c3c058dc00e57bd876ac57918694fe7663f5b41ad3548227"

URI_aarch64_rust-crossterm0.25+bracketed-paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25+bracketed-paste-devel-0.25.0-5.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.25+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25+bracketed-paste-devel}"
SRC_URI[aarch64_rust-crossterm0.25+bracketed-paste-devel.sha256sum] = "eab1465bca3c1a8e509a5b7b7d5fabde79e73d1ef66b6d3a901034d424ea8f17"

URI_aarch64_rust-crossterm0.25+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25+default-devel-0.25.0-5.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25+default-devel}"
SRC_URI[aarch64_rust-crossterm0.25+default-devel.sha256sum] = "68eda9d34e73a8a3a043def5a581056bdc4f5351d56d61fb8be100035da2c980"

URI_aarch64_rust-crossterm0.25+event-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25+event-stream-devel-0.25.0-5.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.25+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25+event-stream-devel}"
SRC_URI[aarch64_rust-crossterm0.25+event-stream-devel.sha256sum] = "aff62f29c4bada7bce29865586c6a7869f9d1ef699848fbdd3fb5c0095dd3f62"

URI_aarch64_rust-crossterm0.25+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25+futures-core-devel-0.25.0-5.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.25+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25+futures-core-devel}"
SRC_URI[aarch64_rust-crossterm0.25+futures-core-devel.sha256sum] = "0ad6f97105396d818d24508526d1bd0eb2d1e7862f87f3b432cbefb204bf3f30"

URI_aarch64_rust-crossterm0.25+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25+serde-devel-0.25.0-5.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.25+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25+serde-devel}"
SRC_URI[aarch64_rust-crossterm0.25+serde-devel.sha256sum] = "83bcfbfa031fec075855a3e05aff0d62a420c1fff36239fcba16963f71b6921f"

URI_aarch64_rust-crossterm0.25-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25-devel-0.25.0-5.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.25-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25-devel}"
SRC_URI[aarch64_rust-crossterm0.25-devel.sha256sum] = "529f9692e77b7f47894f8aaf9a418797c098e17cba8d5c904c251ac7827d7995"

RDEPENDS:rust-crossterm0.25+bracketed-paste-devel = " \
 cargo \
 rust-crossterm0.25-devel \
 "
RDEPENDS:rust-crossterm0.25+default-devel = " \
 cargo \
 rust-crossterm0.25+bracketed-paste-devel \
 rust-crossterm0.25-devel \
 "
RDEPENDS:rust-crossterm0.25+event-stream-devel = " \
 cargo \
 rust-crossterm0.25+futures-core-devel \
 rust-crossterm0.25-devel \
 "
RDEPENDS:rust-crossterm0.25+futures-core-devel = " \
 cargo \
 rust-crossterm0.25-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-crossterm0.25+serde-devel = " \
 cargo \
 rust-crossterm0.25-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-crossterm0.25-devel = " \
 cargo \
 rust-bitflags1+default-devel \
 rust-libc+default-devel \
 rust-mio0.8+default-devel \
 rust-mio0.8+os-poll-devel \
 rust-parking_lot+default-devel \
 rust-signal-hook-mio+default-devel \
 rust-signal-hook-mio+support-v0_8-devel \
 rust-signal-hook0.3+default-devel \
 "
