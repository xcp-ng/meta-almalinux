# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql18-postgis"
PV = "3.5.3"
PR = "1.el10_2.1"
PACKAGES = " \
 postgresql18-postgis \
 postgresql18-postgis-client \
 postgresql18-postgis-docs \
 postgresql18-postgis-upgrade \
 postgresql18-postgis-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql18-postgis-3.5.3-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3027d07ba05413376d80a5a347e8eebf4f95e655497696eb27984caf0c90684f"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - postgresql18-postgis-client: libgeos_c.so.1()(64bit)
# - postgresql18-postgis-upgrade: libgeos_c.so.1()(64bit)
# - postgresql18-postgis: libgeos_c.so.1()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-postgis-3.5.3-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_postgresql18-postgis;unpack=0"
SRC_URI[x86_64_v2_postgresql18-postgis.sha256sum] = "5c282b4ed1425c321358377303a38a64a77b1b55325f47b8a659658223a2ac32"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-postgis-client-3.5.3-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_postgresql18-postgis-client;unpack=0"
SRC_URI[x86_64_v2_postgresql18-postgis-client.sha256sum] = "890e57cb584a32fb5ca7fa27f7f55f350b21c79a0f425cc7e47a053f3f2f9fb0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-postgis-docs-3.5.3-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_postgresql18-postgis-docs;unpack=0"
SRC_URI[x86_64_v2_postgresql18-postgis-docs.sha256sum] = "25f0161a0b531d32eee806485e2b99fecda79f105ada3a1341a457bf9c984cf4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-postgis-upgrade-3.5.3-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_postgresql18-postgis-upgrade;unpack=0"
SRC_URI[x86_64_v2_postgresql18-postgis-upgrade.sha256sum] = "f606fb07b44eda3ce146fbdd7073e2cee1ddf9c6a82e1039c643e67f7bd8d6d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-postgis-utils-3.5.3-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_postgresql18-postgis-utils;unpack=0"
SRC_URI[x86_64_v2_postgresql18-postgis-utils.sha256sum] = "6f09d4a4cef0a5f27926d4f3e9d608f094605dc468306ae6370e7cbc989c17e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-postgis-3.5.3-1.el10_2.1.aarch64.rpm;name=aarch64_postgresql18-postgis;unpack=0"
SRC_URI[aarch64_postgresql18-postgis.sha256sum] = "b246d2170812b233bc59da17764dbf9df43b0023106b9324695ff2296d24ea62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-postgis-client-3.5.3-1.el10_2.1.aarch64.rpm;name=aarch64_postgresql18-postgis-client;unpack=0"
SRC_URI[aarch64_postgresql18-postgis-client.sha256sum] = "03256d1c44213b1d2a3d8614e53038c445eaac6f575c7d604a2d77b6bf68e7bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-postgis-docs-3.5.3-1.el10_2.1.aarch64.rpm;name=aarch64_postgresql18-postgis-docs;unpack=0"
SRC_URI[aarch64_postgresql18-postgis-docs.sha256sum] = "39a3396cbd1397eae9aeb251b3d54be1c14fa592c5d19244cc26af0e5311d8a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-postgis-upgrade-3.5.3-1.el10_2.1.aarch64.rpm;name=aarch64_postgresql18-postgis-upgrade;unpack=0"
SRC_URI[aarch64_postgresql18-postgis-upgrade.sha256sum] = "f156018d2e7fe3c80336eacb6eb112ff880af84fef371859663dbd5e4fc4d052"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-postgis-utils-3.5.3-1.el10_2.1.aarch64.rpm;name=aarch64_postgresql18-postgis-utils;unpack=0"
SRC_URI[aarch64_postgresql18-postgis-utils.sha256sum] = "2bd35c05cb98c76cf9c4632f1c3f5f5cf4ecd1bb32140427d1997e9c309e8bff"

RDEPENDS:postgresql18-postgis:x86_64_v2 = " \
 gdal-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 proj \
 protobuf-c \
"
RDEPENDS:postgresql18-postgis:aarch64 = " \
 gdal-libs \
 geos \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 proj \
 protobuf-c \
"
RDEPENDS:postgresql18-postgis-client:x86_64_v2 = " \
 bash \
 gdal-libs \
 glibc \
 perl-File-Basename \
 perl-interpreter \
 perl-libs \
 postgresql18-postgis \
 postgresql18-private-libs \
 proj \
"
RDEPENDS:postgresql18-postgis-client:aarch64 = " \
 bash \
 gdal-libs \
 geos \
 glibc \
 perl-File-Basename \
 perl-interpreter \
 perl-libs \
 postgresql18-postgis \
 postgresql18-private-libs \
 proj \
"
RDEPENDS:postgresql18-postgis-docs = " \
 "
RDEPENDS:postgresql18-postgis-upgrade:x86_64_v2 = " \
 gdal-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 postgresql-upgrade \
 postgresql18-postgis \
 proj \
 protobuf-c \
"
RDEPENDS:postgresql18-postgis-upgrade:aarch64 = " \
 gdal-libs \
 geos \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 postgresql-upgrade \
 postgresql18-postgis \
 proj \
 protobuf-c \
"
RDEPENDS:postgresql18-postgis-utils = " \
 perl-DBD-Pg \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 postgresql18-postgis \
 "
