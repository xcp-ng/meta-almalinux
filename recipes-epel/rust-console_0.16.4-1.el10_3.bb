# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-console"
PV = "0.16.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-console+alloc-devel \
 rust-console+ansi-parsing-devel \
 rust-console+default-devel \
 rust-console+std-devel \
 rust-console+unicode-width-devel \
 rust-console-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-console-0.16.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eeb09893c4c7e1528bf9b79a1970f67155dc74f33a13ad16579d0f07517c1a50"

URI_x86_64_v2_rust-console+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+alloc-devel-0.16.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+alloc-devel}"
SRC_URI[x86_64_v2_rust-console+alloc-devel.sha256sum] = "d3bf17d6ea16a30f908b69fff6f577d6297599a027120fca08172746272eae97"

URI_x86_64_v2_rust-console+ansi-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+ansi-parsing-devel-0.16.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+ansi-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+ansi-parsing-devel}"
SRC_URI[x86_64_v2_rust-console+ansi-parsing-devel.sha256sum] = "061503929ae344398d9decf7171251b8d8958dbe1a46bc9cefe2bb2b0c8e4b4f"

URI_x86_64_v2_rust-console+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+default-devel-0.16.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+default-devel}"
SRC_URI[x86_64_v2_rust-console+default-devel.sha256sum] = "619f23912a6356e4552d9401a34bd835b27371074582241679d57cd804b2c6d0"

URI_x86_64_v2_rust-console+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+std-devel-0.16.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+std-devel}"
SRC_URI[x86_64_v2_rust-console+std-devel.sha256sum] = "3e9b13e855f9635043d0552d277604c6a278a3bc7f6c2ec94115c7bd8d734415"

URI_x86_64_v2_rust-console+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console+unicode-width-devel-0.16.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-console+unicode-width-devel.sha256sum] = "cddfb27849b01cddaa89c047525561806fff6da4ab2f1f576945bf9d19b7d203"

URI_x86_64_v2_rust-console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-console-devel-0.16.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-console-devel}"
SRC_URI[x86_64_v2_rust-console-devel.sha256sum] = "829e31976b282f35933a27bcf1cac2650b55bb9a3471f958b57b423e4de33ae9"

URI_aarch64_rust-console+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+alloc-devel-0.16.4-1.el10_3.noarch.rpm;name=aarch64_rust-console+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+alloc-devel}"
SRC_URI[aarch64_rust-console+alloc-devel.sha256sum] = "7ce5c52b64da0bb8bc2c58cfb74deada92447c9467be563ee92a01e5dd1252a2"

URI_aarch64_rust-console+ansi-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+ansi-parsing-devel-0.16.4-1.el10_3.noarch.rpm;name=aarch64_rust-console+ansi-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+ansi-parsing-devel}"
SRC_URI[aarch64_rust-console+ansi-parsing-devel.sha256sum] = "328629aa37277f7832b5bc1d89fb17b5f179d4cf8bb6933b8659450003731e57"

URI_aarch64_rust-console+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+default-devel-0.16.4-1.el10_3.noarch.rpm;name=aarch64_rust-console+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+default-devel}"
SRC_URI[aarch64_rust-console+default-devel.sha256sum] = "7d3b66a44c0164340463218293ceeaa7a812654ecf0aece000197448176ba6be"

URI_aarch64_rust-console+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+std-devel-0.16.4-1.el10_3.noarch.rpm;name=aarch64_rust-console+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+std-devel}"
SRC_URI[aarch64_rust-console+std-devel.sha256sum] = "9edfcac0f833bc601aa11251e112298e070f4e16107d473b1c75372a2353c3be"

URI_aarch64_rust-console+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console+unicode-width-devel-0.16.4-1.el10_3.noarch.rpm;name=aarch64_rust-console+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console+unicode-width-devel}"
SRC_URI[aarch64_rust-console+unicode-width-devel.sha256sum] = "063a71d67058f0f14a9a743c37f5bf405533c1f8ec43ca19e388c988187bf41f"

URI_aarch64_rust-console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-console-devel-0.16.4-1.el10_3.noarch.rpm;name=aarch64_rust-console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-console-devel}"
SRC_URI[aarch64_rust-console-devel.sha256sum] = "0df1b01e96da7d66f37f9de46fe3e7448198e4e39fb1949e8208bfb7997326db"

RDEPENDS:rust-console+alloc-devel = " \
 cargo \
 rust-console-devel \
 "
RDEPENDS:rust-console+ansi-parsing-devel = " \
 cargo \
 rust-console-devel \
 "
RDEPENDS:rust-console+default-devel = " \
 cargo \
 rust-console+ansi-parsing-devel \
 rust-console+std-devel \
 rust-console+unicode-width-devel \
 rust-console-devel \
 "
RDEPENDS:rust-console+std-devel = " \
 cargo \
 rust-console+alloc-devel \
 rust-console-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-console+unicode-width-devel = " \
 cargo \
 rust-console-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-console-devel = " \
 cargo \
 rust \
 "
