# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxsmm"
PV = "1.17"
PR = "7.el10_1"
PACKAGES:x86_64_v2 = " \
 libxsmm \
 libxsmm-devel \
 libxsmm-doc \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/libxsmm-1.17-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "769af5e598c7da9ff2fa68b1acdc74fe2c1aee6206c5563e76d16bbc05ecf1ba"

URI_x86_64_v2_libxsmm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxsmm-1.17-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxsmm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxsmm}"
SRC_URI[x86_64_v2_libxsmm.sha256sum] = "8b4e9a89ef8b6cf20299f7dbf32ad9d069225998003e7edcd0c01dc93bb687df"

URI_x86_64_v2_libxsmm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxsmm-devel-1.17-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxsmm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxsmm-devel}"
SRC_URI[x86_64_v2_libxsmm-devel.sha256sum] = "e337b39923e32685795c964a6ad870b64827939a2455eb0adb63d401fb6895d2"

URI_x86_64_v2_libxsmm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxsmm-doc-1.17-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libxsmm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxsmm-doc}"
SRC_URI[x86_64_v2_libxsmm-doc.sha256sum] = "efb99b44f1d32c1ca0d0ae1d1d4864c842e7063c6b50ecc19cd90903d7ac0b05"

RDEPENDS:libxsmm = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:libxsmm-devel = " \
 glibc \
 libxsmm \
 libxsmm-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libxsmm-doc = " \
 virtual//usr/bin/env \
 "
