# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-remyoudompheng-bigfft"
PV = "0"
PR = "28.20200801giteec4a21.el10_0"
PACKAGES = " \
 golang-github-remyoudompheng-bigfft-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-remyoudompheng-bigfft-0-28.20200801giteec4a21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adae9b44df9b57dd4cc3b05f831e7ce8d1af29c311794f373ce93a54b9ae397b"

URI_aarch64_golang-github-remyoudompheng-bigfft-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-remyoudompheng-bigfft-devel-0-28.20200801giteec4a21.el10_0.noarch.rpm;name=aarch64_golang-github-remyoudompheng-bigfft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-remyoudompheng-bigfft-devel}"
SRC_URI[aarch64_golang-github-remyoudompheng-bigfft-devel.sha256sum] = "39da9c9abfaa3fe50f5dac1816d6abbbf7312bb15488efbeda36e7cc21beeea7"

RDEPENDS:golang-github-remyoudompheng-bigfft-devel = " \
 go-filesystem \
 "
