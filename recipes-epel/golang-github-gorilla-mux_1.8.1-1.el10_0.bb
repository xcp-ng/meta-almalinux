# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gorilla-mux"
PV = "1.8.1"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-gorilla-mux-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gorilla-mux-1.8.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28ae9ab5ebf4bdeb5a8d6888b2deda5db4beb28cfa4e50572a0901155352607f"

URI_x86_64_v2_golang-github-gorilla-mux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gorilla-mux-devel-1.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gorilla-mux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gorilla-mux-devel}"
SRC_URI[x86_64_v2_golang-github-gorilla-mux-devel.sha256sum] = "82eed628fae23b8e61e4d032aca395477f275a9fa798953e2f4566833fe833fb"

URI_aarch64_golang-github-gorilla-mux-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gorilla-mux-devel-1.8.1-1.el10_0.noarch.rpm;name=aarch64_golang-github-gorilla-mux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gorilla-mux-devel}"
SRC_URI[aarch64_golang-github-gorilla-mux-devel.sha256sum] = "e1b2beb391e38792e62173573a0d76ef4b1013546d37f3738abd2a47a2cf061d"

RDEPENDS:golang-github-gorilla-mux-devel = " \
 go-filesystem \
 "
