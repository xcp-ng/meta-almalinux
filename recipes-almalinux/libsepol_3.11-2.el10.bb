# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsepol"
PV = "3.11"
PR = "2.el10"
PACKAGES = " \
 libsepol \
 libsepol-devel \
 libsepol-static \
 libsepol-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsepol-3.11-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "242a5e25620dd4103243abac4e63c96bfaf80133950effd510c86ce55f774437"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsepol-3.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol;unpack=0"
SRC_URI[x86_64_v2_libsepol.sha256sum] = "8b6d89d1b54ee89ada8f991513da63ce1f8d65789f68c02cf307f3df5a98e8cb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsepol-devel-3.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-devel;unpack=0"
SRC_URI[x86_64_v2_libsepol-devel.sha256sum] = "311a3cda7e42b12f639539b15052012fc257e00a86dad5a19808ad613ceb5e40"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsepol-static-3.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-static;unpack=0"
SRC_URI[x86_64_v2_libsepol-static.sha256sum] = "25b0fe0a25ee878dac65640330a0a2027ae48f472da4875541b34f280fded42b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsepol-utils-3.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-utils;unpack=0"
SRC_URI[x86_64_v2_libsepol-utils.sha256sum] = "bfc52a29fc4842674c9dfd9ec4503144d5d5cb172bb11b6a49338b430325784c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsepol-3.11-2.el10.aarch64.rpm;name=aarch64_libsepol;unpack=0"
SRC_URI[aarch64_libsepol.sha256sum] = "158202c25fb5ea74578402314c6c8c2efa4191681a5ccd02529cb650e9fcb052"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsepol-devel-3.11-2.el10.aarch64.rpm;name=aarch64_libsepol-devel;unpack=0"
SRC_URI[aarch64_libsepol-devel.sha256sum] = "15fd925385f5b083da1fc4ea9e843aa963727c45707d731d1f66a22c3f0ad395"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsepol-static-3.11-2.el10.aarch64.rpm;name=aarch64_libsepol-static;unpack=0"
SRC_URI[aarch64_libsepol-static.sha256sum] = "f0f146c0fc187b59586b3e848067b654ea42be981114d269bf194d7d8a1c3698"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsepol-utils-3.11-2.el10.aarch64.rpm;name=aarch64_libsepol-utils;unpack=0"
SRC_URI[aarch64_libsepol-utils.sha256sum] = "aa02258b765ac84e1bd09b1f0eb5e1bfb7128881b819de3ec9fd047ba53db8d4"

RDEPENDS:libsepol = " \
 glibc \
 "
RDEPENDS:libsepol-devel = " \
 libsepol \
 pkgconf-pkg-config \
 "
RDEPENDS:libsepol-static = " \
 libsepol-devel \
 "
RDEPENDS:libsepol-utils = " \
 glibc \
 libsepol \
 "
