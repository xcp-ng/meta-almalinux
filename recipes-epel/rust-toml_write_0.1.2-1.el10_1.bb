# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_write"
PV = "0.1.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-toml_write+alloc-devel \
 rust-toml_write+default-devel \
 rust-toml_write+std-devel \
 rust-toml_write-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_write-0.1.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e5b74befe8c944ae1d0e1aabf6b9911dd02d6386a0060b792134e4fb6d1a417"

URI_x86_64_v2_rust-toml_write+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_write+alloc-devel-0.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_write+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_write+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_write+alloc-devel.sha256sum] = "9947132ecb43e1f41e070b90faa0021c482db6c306eb492c44de03a02e2357a2"

URI_x86_64_v2_rust-toml_write+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_write+default-devel-0.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_write+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_write+default-devel}"
SRC_URI[x86_64_v2_rust-toml_write+default-devel.sha256sum] = "7f923dd6ec40855ea3e5b0cd324918505f16794ce5b348c99e282ac67a6dd3a6"

URI_x86_64_v2_rust-toml_write+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_write+std-devel-0.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_write+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_write+std-devel}"
SRC_URI[x86_64_v2_rust-toml_write+std-devel.sha256sum] = "46778a1a2b4d2a3aa51ff306cdd98f3b2f67897fdd2668bc86ec879280a7e616"

URI_x86_64_v2_rust-toml_write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_write-devel-0.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_write-devel}"
SRC_URI[x86_64_v2_rust-toml_write-devel.sha256sum] = "e32d0709a819eb15ab3c97a445f3a8734d65c5aef43ce4f93bbc6ca8aaed5a8a"

URI_aarch64_rust-toml_write+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_write+alloc-devel-0.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-toml_write+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_write+alloc-devel}"
SRC_URI[aarch64_rust-toml_write+alloc-devel.sha256sum] = "a301ea5368975101195fe2aa6a7e08b035cf612c23faaf1a685cbfa5ff77b391"

URI_aarch64_rust-toml_write+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_write+default-devel-0.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-toml_write+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_write+default-devel}"
SRC_URI[aarch64_rust-toml_write+default-devel.sha256sum] = "4d0b6d3eea1629f7e41f2412b82389adc74b875d11f4008b921eb6f8b328d5af"

URI_aarch64_rust-toml_write+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_write+std-devel-0.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-toml_write+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_write+std-devel}"
SRC_URI[aarch64_rust-toml_write+std-devel.sha256sum] = "5d62e09d61af858599fd0eff67657311672c14960bfdd7cc054765b67d32e5ad"

URI_aarch64_rust-toml_write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_write-devel-0.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-toml_write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_write-devel}"
SRC_URI[aarch64_rust-toml_write-devel.sha256sum] = "ffa4f1e3d513d5b1bea24407682917920725699d7e317582c9724351ffc438bd"

RDEPENDS:rust-toml_write+alloc-devel = " \
 cargo \
 rust-toml_write-devel \
 "
RDEPENDS:rust-toml_write+default-devel = " \
 cargo \
 rust-toml_write+std-devel \
 rust-toml_write-devel \
 "
RDEPENDS:rust-toml_write+std-devel = " \
 cargo \
 rust-toml_write+alloc-devel \
 rust-toml_write-devel \
 "
RDEPENDS:rust-toml_write-devel = " \
 cargo \
 rust \
 "
