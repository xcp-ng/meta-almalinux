# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ndctl"
PV = "80"
PR = "3.el10"
PACKAGES = " \
 cxl-cli \
 cxl-devel \
 cxl-libs \
 daxctl \
 daxctl-devel \
 daxctl-libs \
 ndctl \
 ndctl-devel \
 ndctl-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ndctl-80-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c13a79530bcad70867ba0fed2b856cd241d930830513918b8340e1b26a8f5c8c"

URI_x86_64_v2_cxl-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cxl-cli-80-3.el10.x86_64_v2.rpm;name=x86_64_v2_cxl-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cxl-cli}"
SRC_URI[x86_64_v2_cxl-cli.sha256sum] = "8681927d73f1e328349872c7cba65c6373df68388c8d5f55061828dba76314b0"

URI_x86_64_v2_cxl-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cxl-devel-80-3.el10.x86_64_v2.rpm;name=x86_64_v2_cxl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cxl-devel}"
SRC_URI[x86_64_v2_cxl-devel.sha256sum] = "09d35a4b4a92a927d81ddc401feec1a65fcc21cac7ab9c916b068aaa1f9ecc90"

URI_x86_64_v2_cxl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cxl-libs-80-3.el10.x86_64_v2.rpm;name=x86_64_v2_cxl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cxl-libs}"
SRC_URI[x86_64_v2_cxl-libs.sha256sum] = "cd1e175a362877ed4862325d8897a5c53b5152efeacb55976a915d9538d0d1fc"

URI_x86_64_v2_daxctl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/daxctl-80-3.el10.x86_64_v2.rpm;name=x86_64_v2_daxctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daxctl}"
SRC_URI[x86_64_v2_daxctl.sha256sum] = "98e6585814332dd04560d00b32f74b77469ee1804dd1435c932d50f0802f9434"

URI_x86_64_v2_daxctl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/daxctl-devel-80-3.el10.x86_64_v2.rpm;name=x86_64_v2_daxctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daxctl-devel}"
SRC_URI[x86_64_v2_daxctl-devel.sha256sum] = "8c31465ac7a354dfb53a539553da14613761d12abbe6cbaec35e07ff5307d385"

URI_x86_64_v2_daxctl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/daxctl-libs-80-3.el10.x86_64_v2.rpm;name=x86_64_v2_daxctl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daxctl-libs}"
SRC_URI[x86_64_v2_daxctl-libs.sha256sum] = "c7cbd1a957a9fd8efc0d626d7d5c3808aea2e4119418c7d47149c9871deeb132"

URI_x86_64_v2_ndctl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ndctl-80-3.el10.x86_64_v2.rpm;name=x86_64_v2_ndctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ndctl}"
SRC_URI[x86_64_v2_ndctl.sha256sum] = "319f33433775c01b60e46a8e4ac38cd0de297b951f6429cfd497f82fe9750cca"

URI_x86_64_v2_ndctl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ndctl-devel-80-3.el10.x86_64_v2.rpm;name=x86_64_v2_ndctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ndctl-devel}"
SRC_URI[x86_64_v2_ndctl-devel.sha256sum] = "6e3aca034a52d590ee8ebf15c99991aa72514322043c73630a44e5c4d8accfba"

URI_x86_64_v2_ndctl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ndctl-libs-80-3.el10.x86_64_v2.rpm;name=x86_64_v2_ndctl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ndctl-libs}"
SRC_URI[x86_64_v2_ndctl-libs.sha256sum] = "0b8213191539360f0a078278c826718bd02f696cc65b599c15f0fc67aee533a0"

URI_aarch64_cxl-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cxl-cli-80-3.el10.aarch64.rpm;name=aarch64_cxl-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_cxl-cli}"
SRC_URI[aarch64_cxl-cli.sha256sum] = "215324beeb76927ee361fb155a24faad538a6f349bb809f2b06a1793696ce813"

URI_aarch64_cxl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cxl-devel-80-3.el10.aarch64.rpm;name=aarch64_cxl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cxl-devel}"
SRC_URI[aarch64_cxl-devel.sha256sum] = "98ed33fcfa7676fd99648a343c641deae6b854b9ee695cf97d602e19f9bc8e34"

URI_aarch64_cxl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cxl-libs-80-3.el10.aarch64.rpm;name=aarch64_cxl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cxl-libs}"
SRC_URI[aarch64_cxl-libs.sha256sum] = "dedda73802f50809adc977b477691e0597880a9e162a14487100b6e4b1c8fd62"

URI_aarch64_daxctl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/daxctl-80-3.el10.aarch64.rpm;name=aarch64_daxctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_daxctl}"
SRC_URI[aarch64_daxctl.sha256sum] = "843af54f53ee8d6a5c144590a88b4cf94ec8fd826798b406484ac66db80c619b"

URI_aarch64_daxctl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/daxctl-devel-80-3.el10.aarch64.rpm;name=aarch64_daxctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_daxctl-devel}"
SRC_URI[aarch64_daxctl-devel.sha256sum] = "33b4bab26a30fb957037877c91a88dddc2972ef3586b5db4f417476fdac8a4b8"

URI_aarch64_daxctl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/daxctl-libs-80-3.el10.aarch64.rpm;name=aarch64_daxctl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_daxctl-libs}"
SRC_URI[aarch64_daxctl-libs.sha256sum] = "ba3118bb82984e18f99d8dcd1d9d798e23716f2496769496ecf13961ade5029f"

URI_aarch64_ndctl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ndctl-80-3.el10.aarch64.rpm;name=aarch64_ndctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ndctl}"
SRC_URI[aarch64_ndctl.sha256sum] = "7b9d6c9f8d29172d00481eb71a351629f6a2815121fa574e010e650897315694"

URI_aarch64_ndctl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ndctl-devel-80-3.el10.aarch64.rpm;name=aarch64_ndctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ndctl-devel}"
SRC_URI[aarch64_ndctl-devel.sha256sum] = "18f9a67c74f9106f926b8b418f97fbe1a42d999578a1eec543ae32eff0d339a9"

URI_aarch64_ndctl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ndctl-libs-80-3.el10.aarch64.rpm;name=aarch64_ndctl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ndctl-libs}"
SRC_URI[aarch64_ndctl-libs.sha256sum] = "dc3a082d5a1c934edfbd7609dc8b675e66eab4129d8573dff074a8134922c768"

RDEPENDS:cxl-cli = " \
 cxl-libs \
 daxctl-libs \
 glibc \
 json-c \
 libtraceevent \
 libtracefs \
 libuuid \
 "
RDEPENDS:cxl-devel = " \
 cxl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:cxl-libs = " \
 daxctl-libs \
 glibc \
 kmod-libs \
 libuuid \
 systemd-libs \
 "
RDEPENDS:daxctl = " \
 daxctl-libs \
 glibc \
 iniparser \
 json-c \
 libuuid \
 ndctl-libs \
 "
RDEPENDS:daxctl-devel = " \
 daxctl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:daxctl-libs = " \
 glibc \
 kmod-libs \
 libuuid \
 "
RDEPENDS:ndctl = " \
 bash \
 cxl-libs \
 daxctl-libs \
 glibc \
 iniparser \
 json-c \
 keyutils-libs \
 libuuid \
 ndctl-libs \
 "
RDEPENDS:ndctl-devel = " \
 ndctl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ndctl-libs = " \
 daxctl-libs \
 glibc \
 kmod-libs \
 libuuid \
 systemd-libs \
 "
