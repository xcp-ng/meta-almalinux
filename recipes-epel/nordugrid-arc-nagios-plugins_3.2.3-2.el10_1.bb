# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nordugrid-arc-nagios-plugins"
PV = "3.2.3"
PR = "2.el10_1"
PACKAGES = " \
 nordugrid-arc-nagios-plugins \
 nordugrid-arc-nagios-plugins-doc \
 nordugrid-arc-nagios-plugins-egi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nordugrid-arc-nagios-plugins-3.2.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5b808b5cbcf77b7fdc8713e0ec5818202e781642be7a9a2cb3c293ec36d3109"

URI_x86_64_v2_nordugrid-arc-nagios-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc-nagios-plugins-3.2.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc-nagios-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc-nagios-plugins}"
SRC_URI[x86_64_v2_nordugrid-arc-nagios-plugins.sha256sum] = "9ef656a5d9ed7b9eb196db74e9dc9650a3bfd524c2cecb96b865d02bb83b93cc"

URI_x86_64_v2_nordugrid-arc-nagios-plugins-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc-nagios-plugins-doc-3.2.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc-nagios-plugins-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc-nagios-plugins-doc}"
SRC_URI[x86_64_v2_nordugrid-arc-nagios-plugins-doc.sha256sum] = "0d68732fc2f8d27ea7ba1d8fc4dc4ad126b11c25aaabea786bfa062cf14b0a17"

URI_x86_64_v2_nordugrid-arc-nagios-plugins-egi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc-nagios-plugins-egi-3.2.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc-nagios-plugins-egi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc-nagios-plugins-egi}"
SRC_URI[x86_64_v2_nordugrid-arc-nagios-plugins-egi.sha256sum] = "eb6302a345ba60f56e47b7fed9063b51055a77ce575ac1c794f1cf25bc1cff5b"

URI_aarch64_nordugrid-arc-nagios-plugins = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc-nagios-plugins-3.2.3-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc-nagios-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc-nagios-plugins}"
SRC_URI[aarch64_nordugrid-arc-nagios-plugins.sha256sum] = "5ed276b9a91f96f1c569267b4d9565908daa2ba85fa0353fd03bc346345e04d5"

URI_aarch64_nordugrid-arc-nagios-plugins-doc = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc-nagios-plugins-doc-3.2.3-2.el10_1.noarch.rpm;name=aarch64_nordugrid-arc-nagios-plugins-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc-nagios-plugins-doc}"
SRC_URI[aarch64_nordugrid-arc-nagios-plugins-doc.sha256sum] = "3e1c97a4964dcd625f0859942ac445f21ddc990e30cd44be5977346eba901718"

URI_aarch64_nordugrid-arc-nagios-plugins-egi = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc-nagios-plugins-egi-3.2.3-2.el10_1.noarch.rpm;name=aarch64_nordugrid-arc-nagios-plugins-egi;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc-nagios-plugins-egi}"
SRC_URI[aarch64_nordugrid-arc-nagios-plugins-egi.sha256sum] = "8fb905a672dedbdcec05b5c7503fcb23388d2a58ba6ed6f02af232da68fb27e6"

RDEPENDS:nordugrid-arc-nagios-plugins = " \
 nagios-common \
 nordugrid-arc7-client \
 nordugrid-arc7-plugins-needed \
 python3 \
 python3-cryptography \
 python3-jinja2 \
 python3-ldap \
 "
RDEPENDS:nordugrid-arc-nagios-plugins-doc = " \
 "
RDEPENDS:nordugrid-arc-nagios-plugins-egi = " \
 nordugrid-arc-nagios-plugins \
 nordugrid-arc7-plugins-gridftp \
 "
