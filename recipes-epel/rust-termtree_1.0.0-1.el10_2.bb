# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-termtree"
PV = "1.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-termtree+default-devel \
 rust-termtree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-termtree-1.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ddb2aebe6f7825165a79116f7839c5b0e3c78bf5ec486e89603fccd757da72f"

URI_x86_64_v2_rust-termtree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termtree+default-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termtree+default-devel}"
SRC_URI[x86_64_v2_rust-termtree+default-devel.sha256sum] = "c0fc360b7e60778d9994c9915ae1f7eba1dce0f10b0d3a40841d1727dca1fe03"

URI_x86_64_v2_rust-termtree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termtree-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termtree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termtree-devel}"
SRC_URI[x86_64_v2_rust-termtree-devel.sha256sum] = "658c1e7c47b85ee46d127c79d75ce21dc63646a50014f881c864ad5d7085ebc6"

URI_aarch64_rust-termtree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termtree+default-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-termtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termtree+default-devel}"
SRC_URI[aarch64_rust-termtree+default-devel.sha256sum] = "42b5fb0ec92278dd8e9d7f7e5a396a4d788aa54349f46b8e76bcf063006d37f3"

URI_aarch64_rust-termtree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termtree-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-termtree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termtree-devel}"
SRC_URI[aarch64_rust-termtree-devel.sha256sum] = "378e003f7a86a3d3cae06aedd87f0433209f8305d06724d248758ea8c235868a"

RDEPENDS:rust-termtree+default-devel = " \
 cargo \
 rust-termtree-devel \
 "
RDEPENDS:rust-termtree-devel = " \
 cargo \
 rust \
 "
