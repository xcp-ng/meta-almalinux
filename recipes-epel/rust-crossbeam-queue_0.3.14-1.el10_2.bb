# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-queue"
PV = "0.3.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue+default-devel \
 rust-crossbeam-queue+nightly-devel \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-queue-0.3.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d986c8d2e2052d8854a6d71ff124a37054f6e5f973ae971ad10c7d18c90eb7f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+alloc-devel-0.3.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-queue+alloc-devel.sha256sum] = "f12c335981ffae823ca1618abe6b184569e477cd8944b85a7f4bc53e0fcac89c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+default-devel-0.3.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-queue+default-devel.sha256sum] = "a9a22e1c152f0168de75db8b06760f474dfdc611c0c0f6571d8792f6f514b4a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+nightly-devel-0.3.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-queue+nightly-devel.sha256sum] = "28a44be0aadf1ac2ce9edc6a480d3fb1f1cd8c84ee44197755d2a51d9fa2e680"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+std-devel-0.3.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-queue+std-devel.sha256sum] = "a650e26d48fa5fe67fc431cb82e8887b67a511b8074f0876a8269cf4725ce901"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue-devel-0.3.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-queue-devel.sha256sum] = "6c0f4723390f9147ac114bc2319ff3dc30252f42fadf8112c76da47931fd6fe1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+alloc-devel-0.3.14-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-queue+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-queue+alloc-devel.sha256sum] = "1b8ce6779490794985ac93303d0fdef55c76b5f4a9101d1d0f2b5d18be5ba5fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+default-devel-0.3.14-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-queue+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-queue+default-devel.sha256sum] = "89ba670136d8b166811935ab354c9cf55a305853bdd8619e20995c10048734ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+nightly-devel-0.3.14-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-queue+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-queue+nightly-devel.sha256sum] = "7bc25c74923990716ffac86702ec7436f56c6f605487dde234b2b4eeb36891df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+std-devel-0.3.14-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-queue+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-queue+std-devel.sha256sum] = "4c79a2c160828ce21fc37a08a6b70d819600af6cfebd1d3ade0680a3a839f07c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue-devel-0.3.14-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-queue-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-queue-devel.sha256sum] = "8ca857e7440c244f563a3713bcd6c11dae3d51c6bdcc9bab54eb87ce6550cd98"

RDEPENDS:rust-crossbeam-queue+alloc-devel = " \
 cargo \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam-queue+default-devel = " \
 cargo \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam-queue+nightly-devel = " \
 cargo \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam-queue+std-devel = " \
 cargo \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-queue-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
