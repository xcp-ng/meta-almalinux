# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit"
PV = "356.2"
PR = "1.el10_2"
PACKAGES = " \
 cockpit \
 cockpit-bridge \
 cockpit-doc \
 cockpit-packagekit \
 cockpit-storaged \
 cockpit-system \
 cockpit-ws \
 cockpit-ws-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cockpit-356.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99569da7b7d02f246c259536c2224e28aa55e0caa1454eeb80343dc3214d5f71"

URI_x86_64_v2_cockpit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-356.2-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_cockpit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit}"
SRC_URI[x86_64_v2_cockpit.sha256sum] = "27ec8d8ba0e93e4fdbcabc9dbb7c2e87682c36536d129d8f863e0851d270945b"

URI_x86_64_v2_cockpit-bridge = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-bridge-356.2-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-bridge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-bridge}"
SRC_URI[x86_64_v2_cockpit-bridge.sha256sum] = "69809bd2b67896ae5625bdac03f99782c25446ce48e676fab21a2c56793e777e"

URI_x86_64_v2_cockpit-doc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-doc-356.2-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-doc}"
SRC_URI[x86_64_v2_cockpit-doc.sha256sum] = "d08c8b96ba98f9fe8baecf04c8836f93b6fcf0365213b8d39621d6b7d360b39d"

URI_x86_64_v2_cockpit-packagekit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-packagekit-356.2-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-packagekit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-packagekit}"
SRC_URI[x86_64_v2_cockpit-packagekit.sha256sum] = "29bea62d6da80ffe7185c0a5c07130c9f8bdd8cf3db5e6956ab11f4675ba353b"

URI_x86_64_v2_cockpit-storaged = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-storaged-356.2-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-storaged;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-storaged}"
SRC_URI[x86_64_v2_cockpit-storaged.sha256sum] = "db2a2a221c93a54b55c9d8c46acdea7e845e9d978c1572d583e9113742dd59f2"

URI_x86_64_v2_cockpit-system = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-system-356.2-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-system}"
SRC_URI[x86_64_v2_cockpit-system.sha256sum] = "f49a133e2eb12072f7769108e22882ba9074586d6a393ee0f9972bd2585b10a9"

URI_x86_64_v2_cockpit-ws = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-356.2-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-ws}"
SRC_URI[x86_64_v2_cockpit-ws.sha256sum] = "20a6f6bd64494940e5bf2d2b9b4c4491c40742d2c5af776248b4f60bdfe775d6"

URI_x86_64_v2_cockpit-ws-selinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-selinux-356.2-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-ws-selinux}"
SRC_URI[x86_64_v2_cockpit-ws-selinux.sha256sum] = "a643744ec887c32053793d8461b415db9e7c592beefd1978053b42965d5f9848"

URI_aarch64_cockpit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-356.2-1.el10_2.aarch64.rpm;name=aarch64_cockpit;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit}"
SRC_URI[aarch64_cockpit.sha256sum] = "621795ffce36477c396276df7c67ca8e946284d42c042bc18d9e793a578df449"

URI_aarch64_cockpit-bridge = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-bridge-356.2-1.el10_2.noarch.rpm;name=aarch64_cockpit-bridge;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-bridge}"
SRC_URI[aarch64_cockpit-bridge.sha256sum] = "69809bd2b67896ae5625bdac03f99782c25446ce48e676fab21a2c56793e777e"

URI_aarch64_cockpit-doc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-doc-356.2-1.el10_2.noarch.rpm;name=aarch64_cockpit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-doc}"
SRC_URI[aarch64_cockpit-doc.sha256sum] = "d08c8b96ba98f9fe8baecf04c8836f93b6fcf0365213b8d39621d6b7d360b39d"

URI_aarch64_cockpit-packagekit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-packagekit-356.2-1.el10_2.noarch.rpm;name=aarch64_cockpit-packagekit;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-packagekit}"
SRC_URI[aarch64_cockpit-packagekit.sha256sum] = "29bea62d6da80ffe7185c0a5c07130c9f8bdd8cf3db5e6956ab11f4675ba353b"

URI_aarch64_cockpit-storaged = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-storaged-356.2-1.el10_2.noarch.rpm;name=aarch64_cockpit-storaged;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-storaged}"
SRC_URI[aarch64_cockpit-storaged.sha256sum] = "db2a2a221c93a54b55c9d8c46acdea7e845e9d978c1572d583e9113742dd59f2"

URI_aarch64_cockpit-system = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-system-356.2-1.el10_2.noarch.rpm;name=aarch64_cockpit-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-system}"
SRC_URI[aarch64_cockpit-system.sha256sum] = "f49a133e2eb12072f7769108e22882ba9074586d6a393ee0f9972bd2585b10a9"

URI_aarch64_cockpit-ws = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-356.2-1.el10_2.aarch64.rpm;name=aarch64_cockpit-ws;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-ws}"
SRC_URI[aarch64_cockpit-ws.sha256sum] = "868e2d64e0706ee0dda8047a20991e2326fa914c1ffadb5e39e336723ff4a019"

URI_aarch64_cockpit-ws-selinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-selinux-356.2-1.el10_2.aarch64.rpm;name=aarch64_cockpit-ws-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-ws-selinux}"
SRC_URI[aarch64_cockpit-ws-selinux.sha256sum] = "dff992d03321617a7a13bc0999c143ee17103c8d74107f7a2911cf6c26285f48"

RDEPENDS:cockpit = " \
 cockpit-bridge \
 cockpit-system \
 cockpit-ws \
 "
RDEPENDS:cockpit-bridge = " \
 python3 \
 "
RDEPENDS:cockpit-doc = " \
 "
RDEPENDS:cockpit-packagekit = " \
 PackageKit \
 cockpit-bridge \
 polkit \
 "
RDEPENDS:cockpit-storaged = " \
 bash \
 cockpit-system \
 python3 \
 python3-dbus \
 udisks2 \
 "
RDEPENDS:cockpit-system = " \
 NetworkManager \
 cockpit-bridge \
 grep \
 libpwquality \
 shadow-utils \
 sos \
 sudo \
 virtual//usr/bin/date \
 "
RDEPENDS:cockpit-ws = " \
 bash \
 cockpit-ws-selinux \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 krb5-libs \
 libgcc \
 openssl \
 pam-libs \
 systemd-libs \
 "
RDEPENDS:cockpit-ws-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 selinux-policy-targeted \
 "
