# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBD-Cassandra"
PV = "0.57"
PR = "1.el10_2"
PACKAGES = " \
 perl-DBD-Cassandra \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DBD-Cassandra-0.57-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e097930aaa08e16903ad8d8389331a318584af6e3014f49d3218692eb582348"

URI_x86_64_v2_perl-DBD-Cassandra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DBD-Cassandra-0.57-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DBD-Cassandra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DBD-Cassandra}"
SRC_URI[x86_64_v2_perl-DBD-Cassandra.sha256sum] = "e7572199d4930118622a8fffe386cba20ebc7e877dc33c2c171a7da3eb2e45df"

URI_aarch64_perl-DBD-Cassandra = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DBD-Cassandra-0.57-1.el10_2.noarch.rpm;name=aarch64_perl-DBD-Cassandra;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DBD-Cassandra}"
SRC_URI[aarch64_perl-DBD-Cassandra.sha256sum] = "f662b81d2b394636a86c2dcd5e8338550ca018efbfc5069e9d1c752fd946d8db"

RDEPENDS:perl-DBD-Cassandra = " \
 perl-Cassandra-Client \
 perl-DBD-Cassandra \
 perl-DBI \
 perl-Devel-GlobalDestruction \
 perl-libs \
 "
