# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx"
PV = "1.0.197"
PR = "1.el10_2"
PACKAGES = " \
 rust-cxx+alloc-devel \
 rust-cxx+c++14-devel \
 rust-cxx+c++17-devel \
 rust-cxx+c++20-devel \
 rust-cxx+default-devel \
 rust-cxx+std-devel \
 rust-cxx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-1.0.197-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "776b6277436a6a844fcf68bbc3112d8cd39244808a379fa930507f0ed6872e71"

URI_x86_64_v2_rust-cxx+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+alloc-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+alloc-devel}"
SRC_URI[x86_64_v2_rust-cxx+alloc-devel.sha256sum] = "806c203d52d8426dcd291c36dde00ad93371a00141e9062365793c0097c675e3"

URI_x86_64_v2_rust-cxx+c++14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++14-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++14-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++14-devel.sha256sum] = "a21fbe4aba2b9634dc4842bcc3deb8751c3b56b50ecf33885b95b3c0f9df7977"

URI_x86_64_v2_rust-cxx+c++17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++17-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++17-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++17-devel.sha256sum] = "78319aee845b3ca40cd84408b0af07ddcfe6df411fadfced364e1f364b80e6e7"

URI_x86_64_v2_rust-cxx+c++20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+c++20-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+c++20-devel}"
SRC_URI[x86_64_v2_rust-cxx+c++20-devel.sha256sum] = "b4b175a39c9bf7c39e2cfc4a4bbe1aaf3a15f432f0b915c0365dd16bdb38b087"

URI_x86_64_v2_rust-cxx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+default-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+default-devel}"
SRC_URI[x86_64_v2_rust-cxx+default-devel.sha256sum] = "d94e8433ac9e7558f5fcf705efeaac9553b933d74ab05450ccf6f50a2912a8bb"

URI_x86_64_v2_rust-cxx+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx+std-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx+std-devel}"
SRC_URI[x86_64_v2_rust-cxx+std-devel.sha256sum] = "41ac719ddc5c3f5e0009a0f74346dcc1576b2529a1094f741407edbbd28b4f4a"

URI_x86_64_v2_rust-cxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-devel}"
SRC_URI[x86_64_v2_rust-cxx-devel.sha256sum] = "0c643abe82e0c7d634cf9a458f55793ed108dafe252f801d97a17b8709a71477"

URI_aarch64_rust-cxx+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+alloc-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+alloc-devel}"
SRC_URI[aarch64_rust-cxx+alloc-devel.sha256sum] = "bde2dff62d9283bbd2c3a86f477bb37f67540da20757065fbdac732e1fd67e26"

URI_aarch64_rust-cxx+c++14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++14-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++14-devel}"
SRC_URI[aarch64_rust-cxx+c++14-devel.sha256sum] = "9811fc5577ab95ec4779ee7df98d8e3218e6bc1a8b7deb06c5f0bc6dadc00bdf"

URI_aarch64_rust-cxx+c++17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++17-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++17-devel}"
SRC_URI[aarch64_rust-cxx+c++17-devel.sha256sum] = "9c468803116b8acd99db8a921d1024df85eeb8650310fa191a2f69a8214ababc"

URI_aarch64_rust-cxx+c++20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+c++20-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+c++20-devel}"
SRC_URI[aarch64_rust-cxx+c++20-devel.sha256sum] = "6a8cc592b58250627e10faaee76ed654e1c03df08f75c87c05ee3a8c43d42710"

URI_aarch64_rust-cxx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+default-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+default-devel}"
SRC_URI[aarch64_rust-cxx+default-devel.sha256sum] = "3a0cfa42fb904bffff89c0615ce554abd9cc12b23e9d7778a5b7b33e4143ed44"

URI_aarch64_rust-cxx+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx+std-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx+std-devel}"
SRC_URI[aarch64_rust-cxx+std-devel.sha256sum] = "198419c8a655cce612a46eaf0817420852e2c8440627c4a88f207cfb52331bd9"

URI_aarch64_rust-cxx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-devel}"
SRC_URI[aarch64_rust-cxx-devel.sha256sum] = "d2e49671ff6cba2edd9a1a3417793eb5e78529ba31bbaa7340652db1d2babbfb"

RDEPENDS:rust-cxx+alloc-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++14-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++17-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+c++20-devel = " \
 cargo \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+default-devel = " \
 cargo \
 rust-cxx+std-devel \
 rust-cxx-devel \
 "
RDEPENDS:rust-cxx+std-devel = " \
 cargo \
 rust-cxx+alloc-devel \
 rust-cxx-devel \
 rust-foldhash+std-devel \
 "
RDEPENDS:rust-cxx-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-cxxbridge-flags-devel \
 rust-cxxbridge-macro+default-devel \
 rust-foldhash-devel \
 rust-link-cplusplus+default-devel \
 "
