# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-simplejson"
PV = "3.20.2"
PR = "1.el10_3"
PACKAGES = " \
 python-simplejson-doc \
 python3-simplejson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-simplejson-3.20.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb136b1d61de97ef419e9e6c3342d126f43f26865914355795905a2a527f49cc"

URI_x86_64_v2_python-simplejson-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-simplejson-doc-3.20.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-simplejson-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-simplejson-doc}"
SRC_URI[x86_64_v2_python-simplejson-doc.sha256sum] = "42bd74f6f56c85e94531fca48b7fadeb6f299967ded0ca05662bdfb9f4d1205e"

URI_x86_64_v2_python3-simplejson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-simplejson-3.20.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-simplejson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-simplejson}"
SRC_URI[x86_64_v2_python3-simplejson.sha256sum] = "81015f73afb3c6597a830c06d36bb269758f9a825ca5205ee07a3272d03ea6d4"

URI_aarch64_python-simplejson-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-simplejson-doc-3.20.2-1.el10_3.aarch64.rpm;name=aarch64_python-simplejson-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-simplejson-doc}"
SRC_URI[aarch64_python-simplejson-doc.sha256sum] = "aef645cb9ac5c3082035138d4787dab8e3673c5de1e23be195358846cdf24330"

URI_aarch64_python3-simplejson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-simplejson-3.20.2-1.el10_3.aarch64.rpm;name=aarch64_python3-simplejson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-simplejson}"
SRC_URI[aarch64_python3-simplejson.sha256sum] = "68947a30a0d2ae2f5fdd3232cf798c9c4e8d96dbae682f8d3383ff42f75e3228"

RDEPENDS:python-simplejson-doc = " \
 "
RDEPENDS:python3-simplejson = " \
 glibc \
 python3 \
 "
