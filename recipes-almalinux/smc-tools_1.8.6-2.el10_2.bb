# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smc-tools"
PV = "1.8.6"
PR = "2.el10_2"
PACKAGES = " \
 smc-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/smc-tools-1.8.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9e5b1bedbb9e7c184444817085569805181aed7c7e122df2ed7a1becaa5f6ad7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/smc-tools-1.8.6-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_smc-tools;unpack=0"
SRC_URI[x86_64_v2_smc-tools.sha256sum] = "9d81b8f7eb50b16a6bb0c64fd835d278c05a09c2c8476ed95ef0fb0327d7b931"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/smc-tools-1.8.6-2.el10_2.aarch64.rpm;name=aarch64_smc-tools;unpack=0"
SRC_URI[aarch64_smc-tools.sha256sum] = "c29d789410f3f1e36777ab282e98a1c37032b6a26b2d72024e16413a04f30543"

RDEPENDS:smc-tools = " \
 bash \
 glibc \
 libnl3 \
 "
