# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-ostree"
PE = "1"
PV = "222"
PR = "1.el10"
PACKAGES = " \
 cockpit-ostree \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-ostree-222-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1442b23caf1b3fe1f498f72354a14f98c15edcdb24870c79089ed53dd68ec4d4"

URI_x86_64_v2_cockpit-ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-ostree-222-1.el10.noarch.rpm;name=x86_64_v2_cockpit-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-ostree}"
SRC_URI[x86_64_v2_cockpit-ostree.sha256sum] = "7090506e44fbfb03b028eaa7bf505ca1e006807290cc0b9caaa90550078fdac2"

URI_aarch64_cockpit-ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-ostree-222-1.el10.noarch.rpm;name=aarch64_cockpit-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-ostree}"
SRC_URI[aarch64_cockpit-ostree.sha256sum] = "7090506e44fbfb03b028eaa7bf505ca1e006807290cc0b9caaa90550078fdac2"

RDEPENDS:cockpit-ostree = " \
 cockpit-bridge \
 cockpit-system \
 rpm-ostree \
 "
