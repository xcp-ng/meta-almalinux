# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-attributes"
PV = "0.27.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+document-features-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-attributes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-attributes-0.27.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4ee560387c185f193dd85194a7e1267dee1312b3b3fe4dc00a9dc163c248c65"

URI_x86_64_v2_rust-gix-attributes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+default-devel-0.27.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+default-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+default-devel.sha256sum] = "4e66b6c1122fc5b158857e78cdba7fb5245e071aec36af94e98a214e66756004"

URI_x86_64_v2_rust-gix-attributes+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+document-features-devel-0.27.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+document-features-devel.sha256sum] = "586b3246bf10ff226d9b0f45e4fb5bf704f9c888a7386fad40080323cb639ced"

URI_x86_64_v2_rust-gix-attributes+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes+serde-devel-0.27.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes+serde-devel.sha256sum] = "bc239dc19dd8ed12cfd6698b19c6bd3b6682d839887505e6c2b0aa1e1aa19d93"

URI_x86_64_v2_rust-gix-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-attributes-devel-0.27.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-attributes-devel}"
SRC_URI[x86_64_v2_rust-gix-attributes-devel.sha256sum] = "d145f5cbc46fa99c8faff21cc8c98d64455f417e980e074cb26db76155bd3bec"

URI_aarch64_rust-gix-attributes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+default-devel-0.27.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+default-devel}"
SRC_URI[aarch64_rust-gix-attributes+default-devel.sha256sum] = "0eafd86ed1c71714cd4fefdb2ff954277021270acebf9ff06ac6e97156ed0132"

URI_aarch64_rust-gix-attributes+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+document-features-devel-0.27.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-attributes+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+document-features-devel}"
SRC_URI[aarch64_rust-gix-attributes+document-features-devel.sha256sum] = "da76576fdabc289ab5d49332287670a5e8c4a00efba859b53cea0ce5c71c82c2"

URI_aarch64_rust-gix-attributes+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes+serde-devel-0.27.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-attributes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes+serde-devel}"
SRC_URI[aarch64_rust-gix-attributes+serde-devel.sha256sum] = "2e3f9c68c16de4af9c4d0765157b1f05eac2f6776fb64fc7340b16776e396c6b"

URI_aarch64_rust-gix-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-attributes-devel-0.27.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-attributes-devel}"
SRC_URI[aarch64_rust-gix-attributes-devel.sha256sum] = "b48e680c49f20a92b70508f03fd835f8034f7f225acb8a4c72151d49c734249a"

RDEPENDS:rust-gix-attributes+default-devel = " \
 cargo \
 rust-gix-attributes-devel \
 "
RDEPENDS:rust-gix-attributes+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-attributes-devel \
 "
RDEPENDS:rust-gix-attributes+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-attributes-devel \
 rust-gix-glob+serde-devel \
 rust-kstring+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-attributes-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-trace+default-devel \
 rust-kstring+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-bom+default-devel \
 "
