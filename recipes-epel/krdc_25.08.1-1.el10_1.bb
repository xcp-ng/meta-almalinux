# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krdc"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 krdc \
 krdc-devel \
 krdc-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krdc-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33f5b480138b4ef99ada1ceb48715ef379b9e245315fe194c04d6c35755a1a11"

URI_x86_64_v2_krdc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc}"
SRC_URI[x86_64_v2_krdc.sha256sum] = "a600abb7c0352d757daff2ccfba134bbd9d56c2179961398c360386fcd931bc3"

URI_x86_64_v2_krdc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc-devel}"
SRC_URI[x86_64_v2_krdc-devel.sha256sum] = "8016b9ce8e27ae08863a935a741a3183c52e3ca4aaf078c63cbb571fb831a977"

URI_x86_64_v2_krdc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdc-libs}"
SRC_URI[x86_64_v2_krdc-libs.sha256sum] = "c6196f7e3b1bccaaacc650148bb4cd916f6bbf9a57c0ce8ff97c1d4ee97a7eb0"

URI_aarch64_krdc = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_krdc;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc}"
SRC_URI[aarch64_krdc.sha256sum] = "d1ae6ea2645e4ad943d20bd29be985616acee027dc63df08e93b48ec0c3b64fa"

URI_aarch64_krdc-devel = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_krdc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc-devel}"
SRC_URI[aarch64_krdc-devel.sha256sum] = "ba5cfa0fc1954cba4f396b8952bd91e682b997368c7486309acec9ef6d4ca5d5"

URI_aarch64_krdc-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krdc-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_krdc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdc-libs}"
SRC_URI[aarch64_krdc-libs.sha256sum] = "0eabc7c86f711676702386b894cc9dd7919e04687a2b09b5fe7e892f885e85bd"

RDEPENDS:krdc = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 krdc-libs \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:krdc-devel = " \
 krdc-libs \
 "
RDEPENDS:krdc-libs = " \
 freerdp-libs \
 glibc \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 krdc \
 libssh \
 libstdc++ \
 libvncserver \
 libwayland-client \
 libwinpr \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
