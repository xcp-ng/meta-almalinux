# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ima-evm-utils"
PV = "1.6.2"
PR = "3.el10"
PACKAGES = " \
 ima-evm-utils \
 ima-evm-utils-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ima-evm-utils-1.6.2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54bd1221e68d52346a7fccc4c6823fbf4ff74bb5a3a9b6726b9842bba9a6caed"

URI_x86_64_v2_ima-evm-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ima-evm-utils-1.6.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_ima-evm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ima-evm-utils}"
SRC_URI[x86_64_v2_ima-evm-utils.sha256sum] = "8bbe77beba64b05d86fcfefd51de13ebefcfc798e000e53fe17ee7a6ea0e30fb"

URI_x86_64_v2_ima-evm-utils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ima-evm-utils-devel-1.6.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_ima-evm-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ima-evm-utils-devel}"
SRC_URI[x86_64_v2_ima-evm-utils-devel.sha256sum] = "5a8fade93733cbabe0ec45cfa45924f7406c79e3088a9e96249cd0dbdd5463f2"

URI_aarch64_ima-evm-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ima-evm-utils-1.6.2-3.el10.aarch64.rpm;name=aarch64_ima-evm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_ima-evm-utils}"
SRC_URI[aarch64_ima-evm-utils.sha256sum] = "f0c9ca836b42403ae7728763580d4cbe953c16f79603b9ceef1a4da541439529"

URI_aarch64_ima-evm-utils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ima-evm-utils-devel-1.6.2-3.el10.aarch64.rpm;name=aarch64_ima-evm-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ima-evm-utils-devel}"
SRC_URI[aarch64_ima-evm-utils-devel.sha256sum] = "0f09e982e0c6e97a57de71c87f70c6d5979d53c0dc3fb62b138861faabc3eede"

RDEPENDS:ima-evm-utils = " \
 attr \
 bash \
 glibc \
 keyutils \
 keyutils-libs \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:ima-evm-utils-devel = " \
 ima-evm-utils \
 "
