# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yyjson"
PV = "0.10.0"
PR = "2.el10_0"
PACKAGES = " \
 yyjson \
 yyjson-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yyjson-0.10.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee59202f0e8bf03352e84f848418a311dfff78847583fd600378c84d78e5ee53"

URI_x86_64_v2_yyjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yyjson-0.10.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yyjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yyjson}"
SRC_URI[x86_64_v2_yyjson.sha256sum] = "3c27b14b5c42477bfe848397267f88cfecf46207d69a34795dde14a871eb04e0"

URI_x86_64_v2_yyjson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yyjson-devel-0.10.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yyjson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yyjson-devel}"
SRC_URI[x86_64_v2_yyjson-devel.sha256sum] = "dfcec8d3ff9bf9672f9183f3eec2b863654cf063c3cb993a2485f47d60e62349"

URI_aarch64_yyjson = "${EPEL_MIRROR}/aarch64/Packages/y/yyjson-0.10.0-2.el10_0.aarch64.rpm;name=aarch64_yyjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_yyjson}"
SRC_URI[aarch64_yyjson.sha256sum] = "a3186facb0f375b59bfde941de57084fcf69a4fc2bcfea1d090a9d207191d17f"

URI_aarch64_yyjson-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yyjson-devel-0.10.0-2.el10_0.aarch64.rpm;name=aarch64_yyjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yyjson-devel}"
SRC_URI[aarch64_yyjson-devel.sha256sum] = "caab2241ebb416232e42aeb6adff9d5874bee3993623a3f70410adbcc0a664e5"

RDEPENDS:yyjson = " \
 glibc \
 "
RDEPENDS:yyjson-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 yyjson \
 "
