# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13-packaging"
PV = "25.0"
PR = "1.el10_0"
PACKAGES = " \
 python3.13-packaging \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-packaging-25.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f7012e5457be87386d2171ac052f5f61075c3e39e710cf20e1a5cf42bada730"

URI_x86_64_v2_python3.13-packaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-packaging-25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-packaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-packaging}"
SRC_URI[x86_64_v2_python3.13-packaging.sha256sum] = "604ae739fad676c7d8223349f8db3360ae538ee1252a642480a2f91721169a05"

URI_aarch64_python3.13-packaging = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-packaging-25.0-1.el10_0.noarch.rpm;name=aarch64_python3.13-packaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-packaging}"
SRC_URI[aarch64_python3.13-packaging.sha256sum] = "f964fa39c47868ee06eb74667ce4be1dab1683730f5c33599b84e4aa0472fec2"

RDEPENDS:python3.13-packaging = " \
 python3.13 \
 "
