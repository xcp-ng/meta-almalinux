# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "re2"
PE = "2"
PV = "20251105"
PR = "1.el10_2"
PACKAGES = " \
 python3-google-re2 \
 re2 \
 re2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/re2-20251105-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0695d0f5608160ed20cefae0241211f1f404a54e8c971571fb090ac47e89a6f0"

URI_x86_64_v2_python3-google-re2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-re2-1.1.20251105-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-google-re2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-re2}"
SRC_URI[x86_64_v2_python3-google-re2.sha256sum] = "008216e61eae475535b2408a30f67b3ebd2f932aec14efea9e69bcf44f5a4d30"

URI_x86_64_v2_re2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/re2-20251105-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_re2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_re2}"
SRC_URI[x86_64_v2_re2.sha256sum] = "c7cf28e9a194f7b6e635681011ba4b48d9837899be58f8dbe12d9bc911fead7f"

URI_x86_64_v2_re2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/re2-devel-20251105-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_re2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_re2-devel}"
SRC_URI[x86_64_v2_re2-devel.sha256sum] = "f358d294cb76914c51a8a42b7241e7f6a823e5e1ab4ceb391d79ea1129e81433"

URI_aarch64_python3-google-re2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-re2-1.1.20251105-1.el10_2.aarch64.rpm;name=aarch64_python3-google-re2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-re2}"
SRC_URI[aarch64_python3-google-re2.sha256sum] = "b16d2266981ccf8c5b7654e4a7998e8e5f747914b5c562fa0bd63f7d5a4d2b57"

URI_aarch64_re2 = "${EPEL_MIRROR}/aarch64/Packages/r/re2-20251105-1.el10_2.aarch64.rpm;name=aarch64_re2;unpack=0"
SRC_URI:append = " ${URI_aarch64_re2}"
SRC_URI[aarch64_re2.sha256sum] = "c14c99e0324e211181312ea23108b1736e296e24ccfe68e86b971181dc31a8b8"

URI_aarch64_re2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/re2-devel-20251105-1.el10_2.aarch64.rpm;name=aarch64_re2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_re2-devel}"
SRC_URI[aarch64_re2-devel.sha256sum] = "ea8b121051a4a56c8c1ec13e214663ac5694f1ebefdea735ed696db6d21be8e1"

RDEPENDS:python3-google-re2 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 re2 \
 "
RDEPENDS:re2 = " \
 abseil-cpp \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:re2-devel = " \
 abseil-cpp-devel \
 cmake-filesystem \
 libicu-devel \
 pkgconf-pkg-config \
 re2 \
 "
