# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-bad-free"
PV = "1.24.11"
PR = "2.el10_0"
PACKAGES = " \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-bad-free-devel \
 gstreamer1-plugins-bad-free-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-bad-free-1.24.11-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d21f04258f5772483895e79a1ac542859374bfed755e9e300ec125750a10cb55"

URI_x86_64_v2_gstreamer1-plugins-bad-free = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-1.24.11-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free.sha256sum] = "2b1520ccb8b04914ab28a26e1fb2cd58179ad1cad61628d0f5bc1655c957e5ef"

URI_x86_64_v2_gstreamer1-plugins-bad-free-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-devel-1.24.11-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free-devel}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free-devel.sha256sum] = "44f166912884e21d554958be772fd54120a2c5fe042be1a34c05c67891a6b531"

URI_x86_64_v2_gstreamer1-plugins-bad-free-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-libs-1.24.11-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free-libs}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free-libs.sha256sum] = "64d956e158237037209fd0e2b28f048069bde1e49a59b3c3f5d279ff9593f4ba"

URI_aarch64_gstreamer1-plugins-bad-free = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-bad-free-1.24.11-2.el10_0.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free.sha256sum] = "be9d404bfe2fbc45ba5bc265d74ca99c31733479101f4c39bf9e6f265984db64"

URI_aarch64_gstreamer1-plugins-bad-free-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gstreamer1-plugins-bad-free-devel-1.24.11-2.el10_0.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free-devel}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free-devel.sha256sum] = "509fb586c740741b94e6d717a7d22a48cc068268363083753b32ad75e72bca9c"

URI_aarch64_gstreamer1-plugins-bad-free-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-bad-free-libs-1.24.11-2.el10_0.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free-libs}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free-libs.sha256sum] = "d2310f4cdc36c6eb16fd7a4ca64e8c099e49bd6a27f34dd42a9c15a439528ec0"

RDEPENDS:gstreamer1-plugins-bad-free = " \
 bzip2-libs \
 cairo \
 fdk-aac-free \
 glib2 \
 glibc \
 gsm \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk3 \
 json-glib \
 lcms2 \
 libdrm \
 libdvdnav \
 libdvdread \
 libgcc \
 libgudev \
 liblc3 \
 librsvg2 \
 libsndfile \
 libsrtp \
 libstdc++ \
 libusb1 \
 libva \
 libwayland-client \
 libwebp \
 libxml2 \
 openssl-libs \
 opus \
 orc \
 pango \
 soundtouch \
 vulkan-loader \
 webrtc-audio-processing \
 "
RDEPENDS:gstreamer1-plugins-bad-free-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-bad-free-devel \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base-devel \
 libdrm-devel \
 libva-devel \
 pkgconf-pkg-config \
 vulkan-loader-devel \
 wayland-devel \
 "
RDEPENDS:gstreamer1-plugins-bad-free-libs = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libdrm \
 libgcc \
 libstdc++ \
 libva \
 libwayland-client \
 vulkan-loader \
 "
