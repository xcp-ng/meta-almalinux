# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eventviews"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 eventviews \
 eventviews-devel \
 eventviews-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/eventviews-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74d60bc3084e34042775b94c72c650d7157e874ac82caf391a9e62ba8477954c"

URI_x86_64_v2_eventviews = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eventviews;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews}"
SRC_URI[x86_64_v2_eventviews.sha256sum] = "a70515ab94b8f07b2ce58946f26500734dc7386df8d03b286caf5fdcbbbd1089"

URI_x86_64_v2_eventviews-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eventviews-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews-devel}"
SRC_URI[x86_64_v2_eventviews-devel.sha256sum] = "6a09d1f04fb5fc24b59640e443da3a094bf60fcb6297ad4ef01e9d84b2266b32"

URI_x86_64_v2_eventviews-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_eventviews-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eventviews-doc}"
SRC_URI[x86_64_v2_eventviews-doc.sha256sum] = "a10c38fba7c28a8f906218acd229e14fec2d799545e02929694de82ad00ddfd3"

URI_aarch64_eventviews = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_eventviews;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews}"
SRC_URI[aarch64_eventviews.sha256sum] = "8949181afc694b04c281377f3e4d58c17facbd285aa7b3e19805ae996ee846f3"

URI_aarch64_eventviews-devel = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_eventviews-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews-devel}"
SRC_URI[aarch64_eventviews-devel.sha256sum] = "afefd98f0ec338882f2609fd2a9cee1c8e501dd7b4e778949305a0077fde3534"

URI_aarch64_eventviews-doc = "${EPEL_MIRROR}/aarch64/Packages/e/eventviews-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_eventviews-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_eventviews-doc}"
SRC_URI[aarch64_eventviews-doc.sha256sum] = "d59eb6635ce0d64721ec6aef7d97b131b163c3afbf563f15622157c2d045e757"

RDEPENDS:eventviews = " \
 akonadi-calendar \
 akonadi-server \
 calendarsupport \
 glibc \
 kcalutils \
 kdiagram \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 libgcc \
 libkdepim \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:eventviews-devel = " \
 akonadi-calendar-devel \
 akonadi-server-devel \
 calendarsupport-devel \
 cmake-filesystem \
 eventviews \
 kcalutils-devel \
 kf6-kcalendarcore-devel \
 "
RDEPENDS:eventviews-doc = " \
 "
