# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unscanny"
PV = "0.1.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-unscanny+default-devel \
 rust-unscanny-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unscanny-0.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "281753530dd6e49706a8327ef865d1be2488d456bd663db26a2049a607911e8b"

URI_x86_64_v2_rust-unscanny+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unscanny+default-devel-0.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unscanny+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unscanny+default-devel}"
SRC_URI[x86_64_v2_rust-unscanny+default-devel.sha256sum] = "546c9a8fa10c29d272e3c2b044016866b9854ce66fc5fa0ad2a1ff461d326736"

URI_x86_64_v2_rust-unscanny-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unscanny-devel-0.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unscanny-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unscanny-devel}"
SRC_URI[x86_64_v2_rust-unscanny-devel.sha256sum] = "620a6940060dabf071d82550119a879ad9939ce10337d64652a93831a46ecce6"

URI_aarch64_rust-unscanny+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unscanny+default-devel-0.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-unscanny+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unscanny+default-devel}"
SRC_URI[aarch64_rust-unscanny+default-devel.sha256sum] = "7e57165e3a85b68acddab3bc4ccc0721e33cd6ea66632fac36a898a74126ebdf"

URI_aarch64_rust-unscanny-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unscanny-devel-0.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-unscanny-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unscanny-devel}"
SRC_URI[aarch64_rust-unscanny-devel.sha256sum] = "97d7f9f6972b847cf14737e98859bea80e8d7554b5fb90c6106d7cc04e088213"

RDEPENDS:rust-unscanny+default-devel = " \
 cargo \
 rust-unscanny-devel \
 "
RDEPENDS:rust-unscanny-devel = " \
 cargo \
 "
