# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_decimal"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_decimal+alloc-devel \
 rust-icu_decimal+compiled_data-devel \
 rust-icu_decimal+datagen-devel \
 rust-icu_decimal+default-devel \
 rust-icu_decimal+ryu-devel \
 rust-icu_decimal+serde-devel \
 rust-icu_decimal+unstable-devel \
 rust-icu_decimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_decimal-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c8bca405364ebe79e178418c668298cffac4c70eea639fba0e0d9ac776e2384"

URI_x86_64_v2_rust-icu_decimal+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+alloc-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+alloc-devel.sha256sum] = "b2994861765941297730a50d7abe8579f6f7fb860927101f90d1a60b00a00e2b"

URI_x86_64_v2_rust-icu_decimal+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+compiled_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+compiled_data-devel.sha256sum] = "f48cee2f36552e6f2bdb7f4190b689707b98fc3c0843420d8e9332228155bbf9"

URI_x86_64_v2_rust-icu_decimal+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+datagen-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+datagen-devel.sha256sum] = "def232dbed9b1f62bab7dfb5c3858263385e311c20ca945d0e558009bcdb1c05"

URI_x86_64_v2_rust-icu_decimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+default-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+default-devel.sha256sum] = "ee75c0f4bcaa2e35fdc284c04de6d070a1c80612791be97b0edc965ff4b0bac1"

URI_x86_64_v2_rust-icu_decimal+ryu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+ryu-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+ryu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+ryu-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+ryu-devel.sha256sum] = "b499b8d5fe9a506e33e801fe2a176c50349308e7720212b670eadff99ed3a36b"

URI_x86_64_v2_rust-icu_decimal+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+serde-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+serde-devel.sha256sum] = "ae7512c71fcfd21e9e136b0805802182073a5c2acfad6bbafb1cbc0c09f635f4"

URI_x86_64_v2_rust-icu_decimal+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal+unstable-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal+unstable-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal+unstable-devel.sha256sum] = "adf2572bd9c87749ea691e2b03d7806c26741a0bb77e98bc2ae95e6358bf08e5"

URI_x86_64_v2_rust-icu_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal-devel.sha256sum] = "297a617a861715bac51698e0c999b2c7cbe9ebc7d11320e677c61ece7cacc824"

URI_aarch64_rust-icu_decimal+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+alloc-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_decimal+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+alloc-devel}"
SRC_URI[aarch64_rust-icu_decimal+alloc-devel.sha256sum] = "67937be9e4a03dbf59032b7fd35ce73aebcba1dc93b60b749d563e846bc486eb"

URI_aarch64_rust-icu_decimal+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+compiled_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_decimal+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_decimal+compiled_data-devel.sha256sum] = "cf443f4ec88815b46aeca6ce13115f85174da5d6c6fd6177999d4caa4350ad08"

URI_aarch64_rust-icu_decimal+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+datagen-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_decimal+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+datagen-devel}"
SRC_URI[aarch64_rust-icu_decimal+datagen-devel.sha256sum] = "9ad3af924de19cfb05e24f6f1d272c5e4a7cf7565b5e6a725caa8cf5069b3e6c"

URI_aarch64_rust-icu_decimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+default-devel}"
SRC_URI[aarch64_rust-icu_decimal+default-devel.sha256sum] = "83d70c145645ba9cac8c2755e14b4cf6bb3835580f326f89485c8b0e70c72777"

URI_aarch64_rust-icu_decimal+ryu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+ryu-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_decimal+ryu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+ryu-devel}"
SRC_URI[aarch64_rust-icu_decimal+ryu-devel.sha256sum] = "ac75f25ba6cd3d8f92b4765a1af9ff35aae95339f57964d9f57edd8cb2a52cff"

URI_aarch64_rust-icu_decimal+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+serde-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+serde-devel}"
SRC_URI[aarch64_rust-icu_decimal+serde-devel.sha256sum] = "449666a2da1c9e0501813a1d814a4a4ccc7418255a677ea0de6158ab6fbcbfdf"

URI_aarch64_rust-icu_decimal+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal+unstable-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_decimal+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal+unstable-devel}"
SRC_URI[aarch64_rust-icu_decimal+unstable-devel.sha256sum] = "bc7534e13930bee7709979354a1dbca023f4bbd4c9fdc4830e3f5afd39e8219d"

URI_aarch64_rust-icu_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal-devel}"
SRC_URI[aarch64_rust-icu_decimal-devel.sha256sum] = "0dde99c60d40f1f932390cc8c3bbc28f34cb6d54b1c6e1b095e64ab76541a9c6"

RDEPENDS:rust-icu_decimal+alloc-devel = " \
 cargo \
 rust-icu_decimal-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_decimal+compiled_data-devel = " \
 cargo \
 rust-icu_decimal-devel \
 rust-icu_decimal_data-devel \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_plurals+compiled_data-devel \
 rust-icu_plurals-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_decimal+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_decimal+alloc-devel \
 rust-icu_decimal+serde-devel \
 rust-icu_decimal-devel \
 rust-icu_plurals+datagen-devel \
 rust-icu_plurals-devel \
 rust-icu_provider+export-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_decimal+default-devel = " \
 cargo \
 rust-icu_decimal+compiled_data-devel \
 rust-icu_decimal-devel \
 "
RDEPENDS:rust-icu_decimal+ryu-devel = " \
 cargo \
 rust-fixed_decimal+ryu-devel \
 rust-icu_decimal-devel \
 "
RDEPENDS:rust-icu_decimal+serde-devel = " \
 cargo \
 rust-icu_decimal+alloc-devel \
 rust-icu_decimal-devel \
 rust-icu_pattern+serde-devel \
 rust-icu_pattern+zerovec-devel \
 rust-icu_pattern-devel \
 rust-icu_plurals+serde-devel \
 rust-icu_plurals-devel \
 rust-icu_provider+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_decimal+unstable-devel = " \
 cargo \
 rust-icu_decimal-devel \
 rust-icu_pattern+zerovec-devel \
 rust-icu_pattern-devel \
 rust-icu_plurals-devel \
 "
RDEPENDS:rust-icu_decimal-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-fixed_decimal-devel \
 rust-icu_locale_core-devel \
 rust-icu_provider-devel \
 rust-writeable-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
