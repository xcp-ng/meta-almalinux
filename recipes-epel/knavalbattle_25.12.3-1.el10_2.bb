# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knavalbattle"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 knavalbattle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knavalbattle-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1abfbb19b6bfe464dcbb62f2b3c526ea819acfc5f5f4d2f68c87f7f73e94a4db"

URI_x86_64_v2_knavalbattle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knavalbattle-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knavalbattle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knavalbattle}"
SRC_URI[x86_64_v2_knavalbattle.sha256sum] = "b0e1aee6562d9e39b0298876bf3b1e8fa042df295ce9516371371427c044fdd1"

URI_aarch64_knavalbattle = "${EPEL_MIRROR}/aarch64/Packages/k/knavalbattle-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_knavalbattle;unpack=0"
SRC_URI:append = " ${URI_aarch64_knavalbattle}"
SRC_URI[aarch64_knavalbattle.sha256sum] = "55d19172aa79ced0c9f65c40b02ce5de90bea7a966fe8f313c10c3d179bf67d0"

RDEPENDS:knavalbattle = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
