# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mimedefang"
PV = "3.6"
PR = "1.el10_0"
PACKAGES = " \
 mimedefang \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mimedefang-3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39909e7340de55aae357f66d7fc0a13882506d34b04116c518dd591e0631bdf3"

URI_x86_64_v2_mimedefang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimedefang-3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimedefang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimedefang}"
SRC_URI[x86_64_v2_mimedefang.sha256sum] = "cb5988bfe831edbf046de0c4d6eb3a6a53c2f74a8438e6af15d8371f13ca6131"

URI_aarch64_mimedefang = "${EPEL_MIRROR}/aarch64/Packages/m/mimedefang-3.6-1.el10_0.aarch64.rpm;name=aarch64_mimedefang;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimedefang}"
SRC_URI[aarch64_mimedefang.sha256sum] = "9fef611bb9198b30f6764318514a1158da0e089878aaf9b9a49b9261f67d3645"

RDEPENDS:mimedefang = " \
 bash \
 glibc \
 mimedefang \
 perl-Carp \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-Errno \
 perl-Exporter \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-Mail-SPF \
 perl-Net-DNS \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Socket \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 sendmail-milter \
 shadow-utils \
 systemd \
 "
