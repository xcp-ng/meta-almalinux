# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-influxdb-client"
PV = "1.49.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-influxdb-client \
 python3-influxdb-client+async \
 python3-influxdb-client+extra \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-influxdb-client-1.49.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60d4b842ec9c26c711e318bcd60f1f622a5724ad392f38490141c933ecce95a9"

URI_x86_64_v2_python3-influxdb-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-influxdb-client-1.49.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-influxdb-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-influxdb-client}"
SRC_URI[x86_64_v2_python3-influxdb-client.sha256sum] = "f1ea6bd848e71c1be08a3a3a4bc00b513593a35e282b9df069d4c7dd6a990be8"

URI_x86_64_v2_python3-influxdb-client+async = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-influxdb-client+async-1.49.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-influxdb-client+async;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-influxdb-client+async}"
SRC_URI[x86_64_v2_python3-influxdb-client+async.sha256sum] = "72bfe716f7c2fccf1789d02ec15ac3693cfa40fabd1b91cc8bc8eab1e1c3f1ae"

URI_x86_64_v2_python3-influxdb-client+extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-influxdb-client+extra-1.49.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-influxdb-client+extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-influxdb-client+extra}"
SRC_URI[x86_64_v2_python3-influxdb-client+extra.sha256sum] = "7df84821d0b6bd9f849618c062e99797b777e1a4bf963b5de002c82834ca1cfe"

URI_aarch64_python3-influxdb-client = "${EPEL_MIRROR}/aarch64/Packages/p/python3-influxdb-client-1.49.0-1.el10_1.noarch.rpm;name=aarch64_python3-influxdb-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-influxdb-client}"
SRC_URI[aarch64_python3-influxdb-client.sha256sum] = "1f4ca5cd946f889017d75d9140257ff228187cac7cefdfc7150229325e9c452b"

URI_aarch64_python3-influxdb-client+async = "${EPEL_MIRROR}/aarch64/Packages/p/python3-influxdb-client+async-1.49.0-1.el10_1.noarch.rpm;name=aarch64_python3-influxdb-client+async;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-influxdb-client+async}"
SRC_URI[aarch64_python3-influxdb-client+async.sha256sum] = "e1aa07366eb3893434c1483dcb689644c913cd173d3a9f964fd8d58d259f3b77"

URI_aarch64_python3-influxdb-client+extra = "${EPEL_MIRROR}/aarch64/Packages/p/python3-influxdb-client+extra-1.49.0-1.el10_1.noarch.rpm;name=aarch64_python3-influxdb-client+extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-influxdb-client+extra}"
SRC_URI[aarch64_python3-influxdb-client+extra.sha256sum] = "e4650de42ae8f3efdad8ed5aa6a6febd4505bd72c6fa37e50ea8019baedf212d"

RDEPENDS:python3-influxdb-client = " \
 python3 \
 python3-certifi \
 python3-dateutil \
 python3-reactivex \
 python3-setuptools \
 python3-urllib3 \
 "
RDEPENDS:python3-influxdb-client+async = " \
 python3 \
 python3-aiohttp \
 python3-influxdb-client \
 "
RDEPENDS:python3-influxdb-client+extra = " \
 python3 \
 python3-influxdb-client \
 python3-numpy \
 python3-pandas \
 "
