# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arc-swap"
PV = "1.9.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-arc-swap+default-devel \
 rust-arc-swap+experimental-strategies-devel \
 rust-arc-swap+experimental-thread-local-devel \
 rust-arc-swap+internal-test-strategies-devel \
 rust-arc-swap+serde-devel \
 rust-arc-swap+weak-devel \
 rust-arc-swap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arc-swap-1.9.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33eae28341fabd76459e299687aa3b3b23089f7a3c9adda5948bb47168bfc021"

URI_x86_64_v2_rust-arc-swap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+default-devel-1.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+default-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+default-devel.sha256sum] = "eae6537c0c0ed4392b53916295100a41edc609159dbf3691b5c89dde624e22bb"

URI_x86_64_v2_rust-arc-swap+experimental-strategies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+experimental-strategies-devel-1.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+experimental-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+experimental-strategies-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+experimental-strategies-devel.sha256sum] = "39cc89c68344384583d25807cb4940c586d8603f764d3fc8a131bdc827388647"

URI_x86_64_v2_rust-arc-swap+experimental-thread-local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+experimental-thread-local-devel-1.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+experimental-thread-local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+experimental-thread-local-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+experimental-thread-local-devel.sha256sum] = "bae0e3ec2163a0dda8a205e6f48e0cdfab990b29bb051c38d0835e2931ab1e13"

URI_x86_64_v2_rust-arc-swap+internal-test-strategies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+internal-test-strategies-devel-1.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+internal-test-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+internal-test-strategies-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+internal-test-strategies-devel.sha256sum] = "29f9ed4a8e007b49a8548e1a996286602e1dd2edac113ba3f3fc709962e5cf89"

URI_x86_64_v2_rust-arc-swap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+serde-devel-1.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+serde-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+serde-devel.sha256sum] = "2bf0de99295b54086e7d7cb563e30a18b74d25fd1a282349bc77c564734c188f"

URI_x86_64_v2_rust-arc-swap+weak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+weak-devel-1.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+weak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+weak-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+weak-devel.sha256sum] = "8c165cceb2ebcfb97392899040ae1842f0ce9c93f3e45a589ee5895711ad3628"

URI_x86_64_v2_rust-arc-swap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap-devel-1.9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap-devel}"
SRC_URI[x86_64_v2_rust-arc-swap-devel.sha256sum] = "cd3e78302c0b3fb4a982322ee2bf9268219702812ab5fa6872a3c1e1552f5385"

URI_aarch64_rust-arc-swap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+default-devel-1.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-arc-swap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+default-devel}"
SRC_URI[aarch64_rust-arc-swap+default-devel.sha256sum] = "bb98fd7cf12403dda48fe9ccc8fa913ca725cd4bf772779f352e65f76c35a134"

URI_aarch64_rust-arc-swap+experimental-strategies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+experimental-strategies-devel-1.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-arc-swap+experimental-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+experimental-strategies-devel}"
SRC_URI[aarch64_rust-arc-swap+experimental-strategies-devel.sha256sum] = "c2a8486dc252ac17ea9a4c196f55b9cfe95f383b40ba79d44aa5a71287c1f8f2"

URI_aarch64_rust-arc-swap+experimental-thread-local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+experimental-thread-local-devel-1.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-arc-swap+experimental-thread-local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+experimental-thread-local-devel}"
SRC_URI[aarch64_rust-arc-swap+experimental-thread-local-devel.sha256sum] = "1b62f66f04826ad553de452e5ec34bafc17d630c2581f8bd43dd9f7ae61abc6e"

URI_aarch64_rust-arc-swap+internal-test-strategies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+internal-test-strategies-devel-1.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-arc-swap+internal-test-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+internal-test-strategies-devel}"
SRC_URI[aarch64_rust-arc-swap+internal-test-strategies-devel.sha256sum] = "b3a8e3ae765ece3f048d19a0a8bf0b72c806403ed74301489d6a8157c08eb29c"

URI_aarch64_rust-arc-swap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+serde-devel-1.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-arc-swap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+serde-devel}"
SRC_URI[aarch64_rust-arc-swap+serde-devel.sha256sum] = "71274152894fd9eed87eedd5ffed731cdf81738211787a41f3b05e2d9be81c86"

URI_aarch64_rust-arc-swap+weak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+weak-devel-1.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-arc-swap+weak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+weak-devel}"
SRC_URI[aarch64_rust-arc-swap+weak-devel.sha256sum] = "bb4708d1fe9cddeea2527558d5077567dd6a21a3c69bba454b667b10a885297b"

URI_aarch64_rust-arc-swap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap-devel-1.9.2-1.el10_3.noarch.rpm;name=aarch64_rust-arc-swap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap-devel}"
SRC_URI[aarch64_rust-arc-swap-devel.sha256sum] = "6e5ab8b97fd34fa8c90acb9743386a95fb10a15b1b54f41c72a6c6a0a6612471"

RDEPENDS:rust-arc-swap+default-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+experimental-strategies-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+experimental-thread-local-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+internal-test-strategies-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+serde-devel = " \
 cargo \
 rust-arc-swap-devel \
 rust-serde+default-devel \
 rust-serde+rc-devel \
 "
RDEPENDS:rust-arc-swap+weak-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap-devel = " \
 bash \
 cargo \
 rust-rustversion+default-devel \
 "
