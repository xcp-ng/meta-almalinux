# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "container-tools"
PV = "1"
PR = "17.el10"
PACKAGES = " \
 container-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/container-tools-1-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bc935e049853fcf9ab16fcf84de565fed013ad24e5280b6c84c01c8338e1bdf"

URI_x86_64_v2_container-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/container-tools-1-17.el10.noarch.rpm;name=x86_64_v2_container-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_container-tools}"
SRC_URI[x86_64_v2_container-tools.sha256sum] = "1d79222c1d3d26268766915f2c4876bc49693d02dcec0db7b64009fafc75a085"

URI_aarch64_container-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/container-tools-1-17.el10.noarch.rpm;name=aarch64_container-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_container-tools}"
SRC_URI[aarch64_container-tools.sha256sum] = "1d79222c1d3d26268766915f2c4876bc49693d02dcec0db7b64009fafc75a085"

RDEPENDS:container-tools = " \
 aardvark-dns \
 buildah \
 cockpit-podman \
 conmon \
 container-selinux \
 containers-common \
 crun \
 fuse-overlayfs \
 netavark \
 podman \
 podman-docker \
 python3-podman \
 skopeo \
 slirp4netns \
 toolbox \
 udica \
 virtual/oci-runtime \
 "
