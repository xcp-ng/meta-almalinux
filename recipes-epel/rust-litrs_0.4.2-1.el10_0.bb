# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-litrs"
PV = "0.4.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-litrs+check_suffix-devel \
 rust-litrs+default-devel \
 rust-litrs+proc-macro2-devel \
 rust-litrs+unicode-xid-devel \
 rust-litrs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-litrs-0.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a3362d32c89008b478cf855b6db370cb91e175d84c84a8a6527a53bcda89cdc"

URI_x86_64_v2_rust-litrs+check_suffix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+check_suffix-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+check_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+check_suffix-devel}"
SRC_URI[x86_64_v2_rust-litrs+check_suffix-devel.sha256sum] = "a333f6c27fb5ca65bed0fb31b7d054cb9b28e6fa7e6b15704a8bc4bf60a5e0f9"

URI_x86_64_v2_rust-litrs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+default-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+default-devel}"
SRC_URI[x86_64_v2_rust-litrs+default-devel.sha256sum] = "2601f97d417471b0a0bdc3a084dae5e45cb55c9767b7c4ca2061c62902f3e68c"

URI_x86_64_v2_rust-litrs+proc-macro2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+proc-macro2-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+proc-macro2-devel}"
SRC_URI[x86_64_v2_rust-litrs+proc-macro2-devel.sha256sum] = "e0f9fbc2d4deece7bd5c99e54804b61312bd571ac390dffa8d8cacc6a90e7dc0"

URI_x86_64_v2_rust-litrs+unicode-xid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs+unicode-xid-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs+unicode-xid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs+unicode-xid-devel}"
SRC_URI[x86_64_v2_rust-litrs+unicode-xid-devel.sha256sum] = "2c188784998a400b3b526db94b756dd7e1e69435d8f5572f32d8cfa78719c1c9"

URI_x86_64_v2_rust-litrs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litrs-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litrs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litrs-devel}"
SRC_URI[x86_64_v2_rust-litrs-devel.sha256sum] = "1a76250ecdd294ce49c9b228b81ba45593ba4a39e043575fcf935c897b304fc7"

URI_aarch64_rust-litrs+check_suffix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+check_suffix-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-litrs+check_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+check_suffix-devel}"
SRC_URI[aarch64_rust-litrs+check_suffix-devel.sha256sum] = "54bdf9760cce4af210f22516b2fc088b104a74c3353314f71129950c4681e3eb"

URI_aarch64_rust-litrs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+default-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-litrs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+default-devel}"
SRC_URI[aarch64_rust-litrs+default-devel.sha256sum] = "ef6fec9c5b69abbccaa41f8fc9d746b4afd075a9b4b9d3f68db6c7ed2941d37e"

URI_aarch64_rust-litrs+proc-macro2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+proc-macro2-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-litrs+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+proc-macro2-devel}"
SRC_URI[aarch64_rust-litrs+proc-macro2-devel.sha256sum] = "f3267e157aab8cbea5e88b3be740d1816937fff6fba2cee7d51f49ccb772bd89"

URI_aarch64_rust-litrs+unicode-xid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs+unicode-xid-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-litrs+unicode-xid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs+unicode-xid-devel}"
SRC_URI[aarch64_rust-litrs+unicode-xid-devel.sha256sum] = "49a81a16e1234905ba25d253b75243b6656405dfd49923141a2f971a87f828c7"

URI_aarch64_rust-litrs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litrs-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-litrs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litrs-devel}"
SRC_URI[aarch64_rust-litrs-devel.sha256sum] = "52a4d2f4b61e2cda4e0dd558ed20595dc602d7635c4c9adb166bb824c57ee556"

RDEPENDS:rust-litrs+check_suffix-devel = " \
 cargo \
 rust-litrs+unicode-xid-devel \
 rust-litrs-devel \
 "
RDEPENDS:rust-litrs+default-devel = " \
 cargo \
 rust-litrs+proc-macro2-devel \
 rust-litrs-devel \
 "
RDEPENDS:rust-litrs+proc-macro2-devel = " \
 cargo \
 rust-litrs-devel \
 rust-proc-macro2+default-devel \
 "
RDEPENDS:rust-litrs+unicode-xid-devel = " \
 cargo \
 rust-litrs-devel \
 rust-unicode-xid+default-devel \
 "
RDEPENDS:rust-litrs-devel = " \
 cargo \
 rust \
 "
