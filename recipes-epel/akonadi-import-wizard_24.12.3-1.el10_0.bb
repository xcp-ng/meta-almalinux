# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-import-wizard"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 akonadi-import-wizard \
 akonadi-import-wizard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-import-wizard-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c6abc8c8f006f0ae6e9c1374cb452b37a649c0845e5175a55f647bc7fc2c579"

URI_x86_64_v2_akonadi-import-wizard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-import-wizard-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-import-wizard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-import-wizard}"
SRC_URI[x86_64_v2_akonadi-import-wizard.sha256sum] = "37a1fe1795ef483d24749d7a64647f8b11273aaa716e51cfb8f46dc75c6c69b5"

URI_x86_64_v2_akonadi-import-wizard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-import-wizard-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-import-wizard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-import-wizard-devel}"
SRC_URI[x86_64_v2_akonadi-import-wizard-devel.sha256sum] = "12c17dc589763cfa3f6252d852166773eb6278c052ba76cbbc3bb5295983c2f6"

URI_aarch64_akonadi-import-wizard = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-import-wizard-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-import-wizard;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-import-wizard}"
SRC_URI[aarch64_akonadi-import-wizard.sha256sum] = "b034cc05a3797715066455fd734737abd9943557dbed603a48b623d5c72e0432"

URI_aarch64_akonadi-import-wizard-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-import-wizard-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-import-wizard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-import-wizard-devel}"
SRC_URI[aarch64_akonadi-import-wizard-devel.sha256sum] = "651385528d823b0430d8c45bd8ff119111103045e07cf71e15128c2ac6ccd032"

RDEPENDS:akonadi-import-wizard = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 libgcc \
 libstdc++ \
 mailcommon \
 mailimporter \
 mailimporter-akonadi \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:akonadi-import-wizard-devel = " \
 akonadi-import-wizard \
 cmake-filesystem \
 kmailtransport-devel \
 "
