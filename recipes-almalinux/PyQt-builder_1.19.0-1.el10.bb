# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "PyQt-builder"
PV = "1.19.0"
PR = "1.el10"
PACKAGES = " \
 PyQt-builder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/PyQt-builder-1.19.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf536059eac11ef651c9e2149667f66fd9e4c6bf465bf4940856471408365b1a"

URI_x86_64_v2_PyQt-builder = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/PyQt-builder-1.19.0-1.el10.noarch.rpm;name=x86_64_v2_PyQt-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PyQt-builder}"
SRC_URI[x86_64_v2_PyQt-builder.sha256sum] = "43b7f3b5264cc0bf075d1cb549fd34af89b392d0324741b2747b2b9b6fda41aa"

URI_aarch64_PyQt-builder = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/PyQt-builder-1.19.0-1.el10.noarch.rpm;name=aarch64_PyQt-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_PyQt-builder}"
SRC_URI[aarch64_PyQt-builder.sha256sum] = "43b7f3b5264cc0bf075d1cb549fd34af89b392d0324741b2747b2b9b6fda41aa"

RDEPENDS:PyQt-builder = " \
 python3 \
 python3-packaging \
 sip6 \
 "
