# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Which"
PV = "1.27"
PR = "14.el10"
PACKAGES = " \
 perl-File-Which \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-File-Which-1.27-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e91963e0f6ad731ae1e7a18c1598bb9f82f06cc0d17dc995022bc032cef9f0a6"

URI_x86_64_v2_perl-File-Which = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Which-1.27-14.el10.noarch.rpm;name=x86_64_v2_perl-File-Which;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Which}"
SRC_URI[x86_64_v2_perl-File-Which.sha256sum] = "0da102b77913fa5a2ab14160ea1df00cf4edefc16602543eefe3ceac1077f61d"

URI_aarch64_perl-File-Which = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Which-1.27-14.el10.noarch.rpm;name=aarch64_perl-File-Which;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Which}"
SRC_URI[aarch64_perl-File-Which.sha256sum] = "0da102b77913fa5a2ab14160ea1df00cf4edefc16602543eefe3ceac1077f61d"

RDEPENDS:perl-File-Which = " \
 perl-Exporter \
 perl-PathTools \
 perl-base \
 perl-constant \
 perl-libs \
 "
