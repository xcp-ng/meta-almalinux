# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dcap"
PV = "2.47.14"
PR = "7.el10_0"
PACKAGES = " \
 dcap \
 dcap-devel \
 dcap-libs \
 dcap-tunnel-gsi \
 dcap-tunnel-krb \
 dcap-tunnel-ssl \
 dcap-tunnel-telnet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dcap-2.47.14-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f5a0f59e779c23fb29ce61bf5b8f4e708c58e2ab47cd75f7ac5a8b03fbff42e"

URI_x86_64_v2_dcap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcap-2.47.14-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dcap}"
SRC_URI[x86_64_v2_dcap.sha256sum] = "856fe8b8d7f053d97e19b898feca82edc3989d41cc25df5d3f891fc11c096c40"

URI_x86_64_v2_dcap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcap-devel-2.47.14-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dcap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dcap-devel}"
SRC_URI[x86_64_v2_dcap-devel.sha256sum] = "66e7b5b91c6c434bcf187013dc7e27e06ff48d9891207d4cc56f659621c3b0b6"

URI_x86_64_v2_dcap-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcap-libs-2.47.14-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dcap-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dcap-libs}"
SRC_URI[x86_64_v2_dcap-libs.sha256sum] = "54d03d89efb3e81dc3516563276a2915595115fefb6c1cb15586b2c67c0b18f2"

URI_x86_64_v2_dcap-tunnel-gsi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcap-tunnel-gsi-2.47.14-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dcap-tunnel-gsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dcap-tunnel-gsi}"
SRC_URI[x86_64_v2_dcap-tunnel-gsi.sha256sum] = "c27b7f9d190535b4f110baa20d01c3f352e9e068d67df38d6a195aa57cf8daa1"

URI_x86_64_v2_dcap-tunnel-krb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcap-tunnel-krb-2.47.14-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dcap-tunnel-krb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dcap-tunnel-krb}"
SRC_URI[x86_64_v2_dcap-tunnel-krb.sha256sum] = "6d0bbd6a32e7a0c19156eeb0a781658da0f54942c462a9c0f04b65b9cb6cd727"

URI_x86_64_v2_dcap-tunnel-ssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcap-tunnel-ssl-2.47.14-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dcap-tunnel-ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dcap-tunnel-ssl}"
SRC_URI[x86_64_v2_dcap-tunnel-ssl.sha256sum] = "cc9bd9da7ddfc7368c5eb523d30002adbb5eb293509c1bd162146db163eedd74"

URI_x86_64_v2_dcap-tunnel-telnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcap-tunnel-telnet-2.47.14-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dcap-tunnel-telnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dcap-tunnel-telnet}"
SRC_URI[x86_64_v2_dcap-tunnel-telnet.sha256sum] = "3565a65f6a7b8c9d886cf59de36e5a965e8090290bf486ea087cf700735d703c"

URI_aarch64_dcap = "${EPEL_MIRROR}/aarch64/Packages/d/dcap-2.47.14-7.el10_0.aarch64.rpm;name=aarch64_dcap;unpack=0"
SRC_URI:append = " ${URI_aarch64_dcap}"
SRC_URI[aarch64_dcap.sha256sum] = "e7fc6d81ddfdd44d2cff40a8f46da129e91b2c0593522188d156dfe105258d15"

URI_aarch64_dcap-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dcap-devel-2.47.14-7.el10_0.aarch64.rpm;name=aarch64_dcap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dcap-devel}"
SRC_URI[aarch64_dcap-devel.sha256sum] = "f61a6559f3b438472e2e719cb20d5a88ceaf516a71ea4ade63714c96848ca7f2"

URI_aarch64_dcap-libs = "${EPEL_MIRROR}/aarch64/Packages/d/dcap-libs-2.47.14-7.el10_0.aarch64.rpm;name=aarch64_dcap-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_dcap-libs}"
SRC_URI[aarch64_dcap-libs.sha256sum] = "b74aba9904afd1ccc2e3872605bd3b14551bd968bb2859a6370bbe537c15dcb9"

URI_aarch64_dcap-tunnel-gsi = "${EPEL_MIRROR}/aarch64/Packages/d/dcap-tunnel-gsi-2.47.14-7.el10_0.aarch64.rpm;name=aarch64_dcap-tunnel-gsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_dcap-tunnel-gsi}"
SRC_URI[aarch64_dcap-tunnel-gsi.sha256sum] = "5ba16fbdc1411314095845a465d04424cb7b59faba49efb7148e805e3f60696d"

URI_aarch64_dcap-tunnel-krb = "${EPEL_MIRROR}/aarch64/Packages/d/dcap-tunnel-krb-2.47.14-7.el10_0.aarch64.rpm;name=aarch64_dcap-tunnel-krb;unpack=0"
SRC_URI:append = " ${URI_aarch64_dcap-tunnel-krb}"
SRC_URI[aarch64_dcap-tunnel-krb.sha256sum] = "0c31ba6d268f520ad4654b0ef5ecd520496301e4262405432a56a3f3862ef67d"

URI_aarch64_dcap-tunnel-ssl = "${EPEL_MIRROR}/aarch64/Packages/d/dcap-tunnel-ssl-2.47.14-7.el10_0.aarch64.rpm;name=aarch64_dcap-tunnel-ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_dcap-tunnel-ssl}"
SRC_URI[aarch64_dcap-tunnel-ssl.sha256sum] = "6cabd9286dbc4a9080fdf312697789853b21f9280954612449e9e48b9ab9a648"

URI_aarch64_dcap-tunnel-telnet = "${EPEL_MIRROR}/aarch64/Packages/d/dcap-tunnel-telnet-2.47.14-7.el10_0.aarch64.rpm;name=aarch64_dcap-tunnel-telnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_dcap-tunnel-telnet}"
SRC_URI[aarch64_dcap-tunnel-telnet.sha256sum] = "ad1d672e916e48dc83340e33a65dcd7b8645512de94ec8e4fc03a5687f55c1dd"

RDEPENDS:dcap = " \
 dcap-libs \
 glibc \
 "
RDEPENDS:dcap-devel = " \
 dcap-libs \
 "
RDEPENDS:dcap-libs = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:dcap-tunnel-gsi = " \
 dcap-libs \
 glibc \
 globus-gssapi-gsi \
 "
RDEPENDS:dcap-tunnel-krb = " \
 dcap-libs \
 glibc \
 krb5-libs \
 "
RDEPENDS:dcap-tunnel-ssl = " \
 dcap-libs \
 glibc \
 openssl-libs \
 "
RDEPENDS:dcap-tunnel-telnet = " \
 dcap-libs \
 glibc \
 libxcrypt \
 "
