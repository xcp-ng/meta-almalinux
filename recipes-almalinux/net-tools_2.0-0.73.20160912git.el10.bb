# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "net-tools"
PV = "2.0"
PR = "0.73.20160912git.el10"
PACKAGES = " \
 net-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/net-tools-2.0-0.73.20160912git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91da6eb23ffc2ca2d10d6b9b31fa825883cefc5c6c3cd51bbb63ed7fa777d038"

URI_x86_64_v2_net-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/net-tools-2.0-0.73.20160912git.el10.x86_64_v2.rpm;name=x86_64_v2_net-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-tools}"
SRC_URI[x86_64_v2_net-tools.sha256sum] = "253dfde89d6977ca1e5ebfb7169270aff1d2bd573165d2462589916fe1a6184d"

URI_aarch64_net-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/net-tools-2.0-0.73.20160912git.el10.aarch64.rpm;name=aarch64_net-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-tools}"
SRC_URI[aarch64_net-tools.sha256sum] = "0a2dece5a9d0637bc49fb5ef0d817847e8ec3b7f3f338bc8fd4f72d29298af3d"

RDEPENDS:net-tools = " \
 bash \
 glibc \
 libselinux \
 systemd \
 "
