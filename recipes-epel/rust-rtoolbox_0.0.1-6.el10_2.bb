# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rtoolbox"
PV = "0.0.1"
PR = "6.el10_2"
PACKAGES = " \
 rust-rtoolbox+default-devel \
 rust-rtoolbox+serde-devel \
 rust-rtoolbox-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rtoolbox-0.0.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1979a8c16bc6ef550ee1bf0402bccad33a8a6a343551915e1ca99db824597dc9"

URI_x86_64_v2_rust-rtoolbox+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rtoolbox+default-devel-0.0.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rtoolbox+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rtoolbox+default-devel}"
SRC_URI[x86_64_v2_rust-rtoolbox+default-devel.sha256sum] = "8d12df18d9392944ba4fe7d22dfb153e6e727eae013425fd7cd91e037ba9a246"

URI_x86_64_v2_rust-rtoolbox+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rtoolbox+serde-devel-0.0.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rtoolbox+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rtoolbox+serde-devel}"
SRC_URI[x86_64_v2_rust-rtoolbox+serde-devel.sha256sum] = "df6e5451611d176a21d4fd8ed6187430931e9b4cb02a73e720eec0fb4ef411a6"

URI_x86_64_v2_rust-rtoolbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rtoolbox-devel-0.0.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rtoolbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rtoolbox-devel}"
SRC_URI[x86_64_v2_rust-rtoolbox-devel.sha256sum] = "00e021a0d20f03c490170f9bc5c5bbcdfd4c59aa62f0e8841ad987499b087b11"

URI_aarch64_rust-rtoolbox+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rtoolbox+default-devel-0.0.1-6.el10_2.noarch.rpm;name=aarch64_rust-rtoolbox+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rtoolbox+default-devel}"
SRC_URI[aarch64_rust-rtoolbox+default-devel.sha256sum] = "7c1fdfc7be8ab925d04d6c5f311ecf0be6c64e3e3ab82605c4d250fc32ea14e3"

URI_aarch64_rust-rtoolbox+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rtoolbox+serde-devel-0.0.1-6.el10_2.noarch.rpm;name=aarch64_rust-rtoolbox+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rtoolbox+serde-devel}"
SRC_URI[aarch64_rust-rtoolbox+serde-devel.sha256sum] = "d61e4a202811b14951b0e0f4876f97aa195578143fef53efe2019a4974f293a5"

URI_aarch64_rust-rtoolbox-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rtoolbox-devel-0.0.1-6.el10_2.noarch.rpm;name=aarch64_rust-rtoolbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rtoolbox-devel}"
SRC_URI[aarch64_rust-rtoolbox-devel.sha256sum] = "958dde5e09f9f8d6e7b6b67525c9cd5e22c2d884b7d768463462912dc3dc8feb"

RDEPENDS:rust-rtoolbox+default-devel = " \
 cargo \
 rust-rtoolbox-devel \
 "
RDEPENDS:rust-rtoolbox+serde-devel = " \
 cargo \
 rust-rtoolbox-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rtoolbox-devel = " \
 cargo \
 rust-libc+default-devel \
 "
