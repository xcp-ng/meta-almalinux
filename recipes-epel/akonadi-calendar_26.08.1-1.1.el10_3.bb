# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-calendar"
PV = "26.08.1"
PR = "1.1.el10_3"
PACKAGES = " \
 akonadi-calendar \
 akonadi-calendar-devel \
 akonadi-calendar-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/akonadi-calendar-26.08.1-1.1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a02f76befedbe255afb65b939d8a49a5ef2595093353661e11aae109b8998a1a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-26.08.1-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar;unpack=0"
SRC_URI[x86_64_v2_akonadi-calendar.sha256sum] = "926f6b36ce93b6279ca77c8b0273be7a909f23cb2218c074996e18b3e57482bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-devel-26.08.1-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar-devel;unpack=0"
SRC_URI[x86_64_v2_akonadi-calendar-devel.sha256sum] = "1de6495580d503c225a4fe1fd7cf6f9ed3d9b2e22ad38941c8c97bf1a53129cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-doc-26.08.1-1.1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-calendar-doc;unpack=0"
SRC_URI[x86_64_v2_akonadi-calendar-doc.sha256sum] = "fc550d1d7d45222c9aa696a322fe4e04dc552744e207d57597afabb256998595"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-26.08.1-1.1.el10_3.aarch64.rpm;name=aarch64_akonadi-calendar;unpack=0"
SRC_URI[aarch64_akonadi-calendar.sha256sum] = "59a8e25157c8e6da93151ed8f3e7bfea29c6e7577f16c11809fd24c1a2dfada8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-devel-26.08.1-1.1.el10_3.aarch64.rpm;name=aarch64_akonadi-calendar-devel;unpack=0"
SRC_URI[aarch64_akonadi-calendar-devel.sha256sum] = "084ccaa6fe4cf8739695962be4efafc31952b7e96af39d84e1f0940fe475f7af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-doc-26.08.1-1.1.el10_3.noarch.rpm;name=aarch64_akonadi-calendar-doc;unpack=0"
SRC_URI[aarch64_akonadi-calendar-doc.sha256sum] = "89016670180f47bcf8a3f73f580da168fdd56b61180ecc5bf9bd45b690f44429"

RDEPENDS:akonadi-calendar = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgme2pp \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kitemmodels \
 kf6-kmime \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 libgcc \
 libkleo \
 libstdc++ \
 messagelib \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-calendar-devel = " \
 akonadi-calendar \
 akonadi-contacts-devel \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kidentitymanagement-devel \
 "
RDEPENDS:akonadi-calendar-doc = " \
 "
