# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcr"
PV = "4.3.0"
PR = "1.el10"
PACKAGES = " \
 gcr \
 gcr-devel \
 gcr-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcr-4.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1426abd9f86a710af6ad426d585377bca33d3519b825d9366f2bf7c4daad90c"

URI_x86_64_v2_gcr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcr-4.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_gcr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcr}"
SRC_URI[x86_64_v2_gcr.sha256sum] = "05c2aa5afaeb967f3105f42ee866ab3784172e850866e61230217b6ebde2f943"

URI_x86_64_v2_gcr-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcr-devel-4.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_gcr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcr-devel}"
SRC_URI[x86_64_v2_gcr-devel.sha256sum] = "9d8c58a8e6e76f2dfc2594c5a8fab3ad33bddfb2cf6a4acf67d3430aa1dedf48"

URI_x86_64_v2_gcr-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcr-libs-4.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_gcr-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcr-libs}"
SRC_URI[x86_64_v2_gcr-libs.sha256sum] = "0f3caf7930806943b01c5a7475c5a65090555225a4175a3f59edd51567997cf8"

URI_aarch64_gcr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcr-4.3.0-1.el10.aarch64.rpm;name=aarch64_gcr;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcr}"
SRC_URI[aarch64_gcr.sha256sum] = "31ba4e4209e9ca0509266dc93120d8ef07f3fec199d2002b7e346672fe9f26d9"

URI_aarch64_gcr-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcr-devel-4.3.0-1.el10.aarch64.rpm;name=aarch64_gcr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcr-devel}"
SRC_URI[aarch64_gcr-devel.sha256sum] = "5648c5dc34aba9e79124aeca24dc1d10cbb5a8182fab6e096364a5ac6ecf0a5c"

URI_aarch64_gcr-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcr-libs-4.3.0-1.el10.aarch64.rpm;name=aarch64_gcr-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcr-libs}"
SRC_URI[aarch64_gcr-libs.sha256sum] = "ef27db9c896c710c911fa0eaeadf361c17b3aeeb8fb5e04bed342f6ccdbc24d8"

RDEPENDS:gcr = " \
 bash \
 gcr-libs \
 glib2 \
 glibc \
 gnupg2 \
 gtk4 \
 libsecret \
 openssh-clients \
 pango \
 systemd-libs \
 "
RDEPENDS:gcr-devel = " \
 gcr-devel \
 gcr-libs \
 glib2-devel \
 p11-kit-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gcr-libs = " \
 glib2 \
 glibc \
 gnutls \
 p11-kit \
 "
