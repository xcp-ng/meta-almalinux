# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xclip"
PV = "0.13"
PR = "24.git11cba61.el10_1"
PACKAGES = " \
 xclip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xclip-0.13-24.git11cba61.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c1fe7b1fe6c34944d3dc67bfd339334fb4f6eaf07ace6eb5e1289fa975a47b9"

URI_x86_64_v2_xclip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xclip-0.13-24.git11cba61.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xclip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xclip}"
SRC_URI[x86_64_v2_xclip.sha256sum] = "c85ef9d61dcfcd54344e6d3f62efff1cf1cc2931f8661f355dcf59f9c2432686"

URI_aarch64_xclip = "${EPEL_MIRROR}/aarch64/Packages/x/xclip-0.13-24.git11cba61.el10_1.aarch64.rpm;name=aarch64_xclip;unpack=0"
SRC_URI:append = " ${URI_aarch64_xclip}"
SRC_URI[aarch64_xclip.sha256sum] = "3ea3e5624356d0ed44a1e7cd35024fccb1aaca860e537091f1171129a948cdb3"

RDEPENDS:xclip = " \
 bash \
 glibc \
 libX11 \
 libXmu \
 "
