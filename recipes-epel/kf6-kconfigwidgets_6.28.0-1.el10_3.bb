# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kconfigwidgets"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kconfigwidgets \
 kf6-kconfigwidgets-devel \
 kf6-kconfigwidgets-doc \
 kf6-kconfigwidgets-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kconfigwidgets-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a2868bbe4581f99fb39e477e78373b5eee82724fb5814a1b17127705d27fb01"

URI_x86_64_v2_kf6-kconfigwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfigwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets.sha256sum] = "4be3b912fe45f2c9175a234c7ba4abcd5e2e5666a4f24c135e33a480021f8a07"

URI_x86_64_v2_kf6-kconfigwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfigwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-devel}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-devel.sha256sum] = "d4b0d634ebcf05e17737296cd9aaf8a56a84156d30d32891f4ee7768d12c5aea"

URI_x86_64_v2_kf6-kconfigwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfigwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-doc}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-doc.sha256sum] = "bbb2c25cdde75ccfaad72d1e998826d00a91e4c0e2d49ee85a501fda6310a523"

URI_x86_64_v2_kf6-kconfigwidgets-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfigwidgets-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-html}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-html.sha256sum] = "dc8e0074d04eddc0b064f211964522981f575d94681bcd48afe053f9c9a3accd"

URI_aarch64_kf6-kconfigwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kconfigwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets}"
SRC_URI[aarch64_kf6-kconfigwidgets.sha256sum] = "7bf1de77c36a6db9a530e8e13cf242c995816ef7771c15917073db52ccf848d8"

URI_aarch64_kf6-kconfigwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kconfigwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-devel}"
SRC_URI[aarch64_kf6-kconfigwidgets-devel.sha256sum] = "5dedb9ec5d3196eb990a4759ed77f7df537e32e49822ec2c0f0b341f670e6318"

URI_aarch64_kf6-kconfigwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kconfigwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-doc}"
SRC_URI[aarch64_kf6-kconfigwidgets-doc.sha256sum] = "7e08afa765cb9b471cc08b2a2c6f5c8bdb927a8c3f8127955f31986cf2d22f05"

URI_aarch64_kf6-kconfigwidgets-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kconfigwidgets-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-html}"
SRC_URI[aarch64_kf6-kconfigwidgets-html.sha256sum] = "a53a296ab18bc4ab63aab31cfedc838ca6d74f2c0f9d91f081a36def01d0d596"

RDEPENDS:kf6-kconfigwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kconfigwidgets-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kauth-devel \
 kf6-kcodecs-devel \
 kf6-kcolorscheme-devel \
 kf6-kconfig-devel \
 kf6-kconfigwidgets \
 kf6-kwidgetsaddons-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kconfigwidgets-doc = " \
 "
RDEPENDS:kf6-kconfigwidgets-html = " \
 "
