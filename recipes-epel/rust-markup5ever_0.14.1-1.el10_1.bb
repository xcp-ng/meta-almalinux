# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-markup5ever"
PV = "0.14.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-markup5ever+default-devel \
 rust-markup5ever-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-markup5ever-0.14.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b41f8897cd185fe70f59e21204d5e28e79c9c16844e990f58bc05ebee5910b2"

URI_x86_64_v2_rust-markup5ever+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever+default-devel-0.14.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever+default-devel}"
SRC_URI[x86_64_v2_rust-markup5ever+default-devel.sha256sum] = "1f6fa932fe207d67cf0e090b0f015510381261187c30844557b8245b345f5bcf"

URI_x86_64_v2_rust-markup5ever-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever-devel-0.14.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever-devel}"
SRC_URI[x86_64_v2_rust-markup5ever-devel.sha256sum] = "780d63d89aff30d853dd014db6cec734ce33ee3fbd8b86fa404485bf5fe2de64"

URI_aarch64_rust-markup5ever+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever+default-devel-0.14.1-1.el10_1.noarch.rpm;name=aarch64_rust-markup5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever+default-devel}"
SRC_URI[aarch64_rust-markup5ever+default-devel.sha256sum] = "a5fc51016d0f9ff5263ae3f22dc0d6ed1da9f406d83bb6a06bfd9a0fb32f1256"

URI_aarch64_rust-markup5ever-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever-devel-0.14.1-1.el10_1.noarch.rpm;name=aarch64_rust-markup5ever-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever-devel}"
SRC_URI[aarch64_rust-markup5ever-devel.sha256sum] = "5a28dba0ed0241fda3ca0da5f0d7f3e27a8148be5842b07cd775faf42d7ed94c"

RDEPENDS:rust-markup5ever+default-devel = " \
 cargo \
 rust-markup5ever-devel \
 "
RDEPENDS:rust-markup5ever-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-phf+default-devel \
 rust-phf_codegen+default-devel \
 rust-string_cache+default-devel \
 rust-string_cache_codegen+default-devel \
 rust-tendril+default-devel \
 "
