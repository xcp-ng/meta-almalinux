# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-ftp-client"
PV = "9.8"
PR = "8.el10_0"
PACKAGES = " \
 globus-ftp-client \
 globus-ftp-client-devel \
 globus-ftp-client-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-ftp-client-9.8-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f785fa0ddd1f53b5150983355d2ae2b8a67eedaa9d59fc59d32661b028680b7"

URI_x86_64_v2_globus-ftp-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-client-9.8-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-ftp-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-client}"
SRC_URI[x86_64_v2_globus-ftp-client.sha256sum] = "b2c8c81c41fa04a9d7de50f68cc278cf31237561768f9ebc03e5565a318c5565"

URI_x86_64_v2_globus-ftp-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-client-devel-9.8-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-ftp-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-client-devel}"
SRC_URI[x86_64_v2_globus-ftp-client-devel.sha256sum] = "6265580aee92153f6ecfafd336c2b9034a01494b1acff9f879b5d333c2c26fba"

URI_x86_64_v2_globus-ftp-client-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-client-doc-9.8-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-ftp-client-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-client-doc}"
SRC_URI[x86_64_v2_globus-ftp-client-doc.sha256sum] = "7f908229e1e08f2852952eef5d1cea6cb8cb34c08c091ce3bdbaaa51f5f093bc"

URI_aarch64_globus-ftp-client = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-client-9.8-8.el10_0.aarch64.rpm;name=aarch64_globus-ftp-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-client}"
SRC_URI[aarch64_globus-ftp-client.sha256sum] = "a50b3b4c577d0b095a1e9189806897076738e7062cc462276c2e2dee11b8e067"

URI_aarch64_globus-ftp-client-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-client-devel-9.8-8.el10_0.aarch64.rpm;name=aarch64_globus-ftp-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-client-devel}"
SRC_URI[aarch64_globus-ftp-client-devel.sha256sum] = "dc49939ede52c1e4f0e3d639981414fd619fa59808f5e3bda0a5f9e0b370ef50"

URI_aarch64_globus-ftp-client-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-client-doc-9.8-8.el10_0.noarch.rpm;name=aarch64_globus-ftp-client-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-client-doc}"
SRC_URI[aarch64_globus-ftp-client-doc.sha256sum] = "30258acae4181912157ca5737eb0926f102eaf33ade218c911b318c64143a69f"

RDEPENDS:globus-ftp-client = " \
 bash \
 glibc \
 globus-common \
 globus-ftp-control \
 globus-gsi-callback \
 globus-gsi-credential \
 globus-gsi-sysconfig \
 globus-gssapi-gsi \
 globus-xio \
 globus-xio-popen-driver \
 openssl-libs \
 "
RDEPENDS:globus-ftp-client-devel = " \
 globus-common-devel \
 globus-ftp-client \
 globus-ftp-control-devel \
 globus-gsi-callback-devel \
 globus-gsi-credential-devel \
 globus-gsi-sysconfig-devel \
 globus-gssapi-gsi-devel \
 globus-xio-devel \
 globus-xio-popen-driver-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-ftp-client-doc = " \
 "
