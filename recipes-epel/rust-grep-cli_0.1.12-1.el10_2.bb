# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-cli"
PV = "0.1.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-grep-cli+default-devel \
 rust-grep-cli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-cli-0.1.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f26da24763163170d8b2407f455117e38e495507033a17834317204064a5aad"

URI_x86_64_v2_rust-grep-cli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-cli+default-devel-0.1.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-cli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-cli+default-devel}"
SRC_URI[x86_64_v2_rust-grep-cli+default-devel.sha256sum] = "6f9298975fd8314ea173a6d5367e5ae7e6b0fae543ec5b849087328a1d327c9c"

URI_x86_64_v2_rust-grep-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-cli-devel-0.1.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-cli-devel}"
SRC_URI[x86_64_v2_rust-grep-cli-devel.sha256sum] = "fac4025ab6971ca523df26ffe22012fb25e2785d2be0c03d2d2bd30782ba3b70"

URI_aarch64_rust-grep-cli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-cli+default-devel-0.1.12-1.el10_2.noarch.rpm;name=aarch64_rust-grep-cli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-cli+default-devel}"
SRC_URI[aarch64_rust-grep-cli+default-devel.sha256sum] = "b4707db293994ec383f25c150386cade1e339c3bc0ba6d59c0ce9690dec4c4bc"

URI_aarch64_rust-grep-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-cli-devel-0.1.12-1.el10_2.noarch.rpm;name=aarch64_rust-grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-cli-devel}"
SRC_URI[aarch64_rust-grep-cli-devel.sha256sum] = "58101c5f196303d7cfcca315c22999da1741459fe9283941163d478cb6ee81d5"

RDEPENDS:rust-grep-cli+default-devel = " \
 cargo \
 rust-grep-cli-devel \
 "
RDEPENDS:rust-grep-cli-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-bstr+std-devel \
 rust-globset+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-termcolor+default-devel \
 "
