# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kidentitymanagement"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kidentitymanagement \
 kidentitymanagement-devel \
 kidentitymanagement-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kidentitymanagement-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea7fb6ff92f7c0766b593a3c76ab3fc0d9487d4bb47bb356e2bf5f2eef25f4a9"

URI_x86_64_v2_kidentitymanagement = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kidentitymanagement;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kidentitymanagement}"
SRC_URI[x86_64_v2_kidentitymanagement.sha256sum] = "5adb7271585637ec185aac46f60c395869ee7892b8716b4cea43927f4f9afab5"

URI_x86_64_v2_kidentitymanagement-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kidentitymanagement-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kidentitymanagement-devel}"
SRC_URI[x86_64_v2_kidentitymanagement-devel.sha256sum] = "0745a56fc6f994d39371ae92f786e53031b0a3bed413bcdad6e5eca461e6730d"

URI_x86_64_v2_kidentitymanagement-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kidentitymanagement-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kidentitymanagement-doc}"
SRC_URI[x86_64_v2_kidentitymanagement-doc.sha256sum] = "f8622790372ce9cb312b80179c2b3bb8101f13d1a356ba2e4ed7c366a95fcc6e"

URI_aarch64_kidentitymanagement = "${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kidentitymanagement;unpack=0"
SRC_URI:append = " ${URI_aarch64_kidentitymanagement}"
SRC_URI[aarch64_kidentitymanagement.sha256sum] = "19692070763ecd44a975e999b563ff0f2c393d39817148d6ef5fb93d83b62d54"

URI_aarch64_kidentitymanagement-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kidentitymanagement-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kidentitymanagement-devel}"
SRC_URI[aarch64_kidentitymanagement-devel.sha256sum] = "12d0edcf047b61ca9d266ae443320a451b54de2804e450df7997e322ab5f87d8"

URI_aarch64_kidentitymanagement-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kidentitymanagement-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kidentitymanagement-doc}"
SRC_URI[aarch64_kidentitymanagement-doc.sha256sum] = "d061d263b0c96721b7092c8e21b69f0d33a7565990a4acf4c739e17f171708a2"

RDEPENDS:kidentitymanagement = " \
 glibc \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kpimtextedit \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kidentitymanagement-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kidentitymanagement \
 kpimtextedit-devel \
 "
RDEPENDS:kidentitymanagement-doc = " \
 "
