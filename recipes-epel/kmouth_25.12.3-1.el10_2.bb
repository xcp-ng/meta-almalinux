# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmouth"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmouth \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmouth-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c401257d470bcab673c2e7a353efe608a928d5d12ad1bfff70476e72fc36af6"

URI_x86_64_v2_kmouth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmouth-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmouth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmouth}"
SRC_URI[x86_64_v2_kmouth.sha256sum] = "79e5e89f83538fefe5006d2d4a5710d54bd01cd06691fd3480097f5f4b59853e"

URI_aarch64_kmouth = "${EPEL_MIRROR}/aarch64/Packages/k/kmouth-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmouth;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmouth}"
SRC_URI[aarch64_kmouth.sha256sum] = "250a1cc03c2d9f5bdc7a919507373ee2081a6fb19c0aac3fba5975f1b143157c"

RDEPENDS:kmouth = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
