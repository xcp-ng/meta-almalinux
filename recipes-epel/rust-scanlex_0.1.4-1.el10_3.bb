# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scanlex"
PV = "0.1.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-scanlex+default-devel \
 rust-scanlex-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-scanlex-0.1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f19f7eca2210d2545bf254b05258eb098ecb0f1a7a05989ac34484d50fc0df69"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scanlex+default-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scanlex+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-scanlex+default-devel.sha256sum] = "8578c4d94a556232d6b2b719834eb1e1000f1df05458133fafbf880dd91b9139"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scanlex-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scanlex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-scanlex-devel.sha256sum] = "c305b8d4fd6443e3e1cfe8afa5ade38bad4b2fa3e7630c782c59da4980d8b27a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-scanlex+default-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-scanlex+default-devel;unpack=0"
SRC_URI[aarch64_rust-scanlex+default-devel.sha256sum] = "bfe5de0f023be882fb7c04214021957e7d1efe97007617f8dce970bffeed300d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-scanlex-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-scanlex-devel;unpack=0"
SRC_URI[aarch64_rust-scanlex-devel.sha256sum] = "bff233df07c2d2a47a10681ceba9cfcfb00b8e62800d32b31424467ecd2d97f3"

RDEPENDS:rust-scanlex+default-devel = " \
 cargo \
 rust-scanlex-devel \
 "
RDEPENDS:rust-scanlex-devel = " \
 cargo \
 "
