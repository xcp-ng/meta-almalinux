# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "runc"
PE = "2"
PV = "1.4.1"
PR = "1.el10_2"
PACKAGES = " \
 runc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/runc-1.4.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c3463fc9f061d1ccc8924cf8bbf0ebb4ffc3fb2872539fbfdf82d6aa4f6cc38"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/runc-1.4.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_runc;unpack=0"
SRC_URI[x86_64_v2_runc.sha256sum] = "3b2b26259349ce0d2874234f8a769b3e2ba217436e2c76bb5b776e7e65c28209"
RPROVIDES:runc:append:x86_64_v2 = " virtual/oci-runtime"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/runc-1.4.1-1.el10_2.aarch64.rpm;name=aarch64_runc;unpack=0"
SRC_URI[aarch64_runc.sha256sum] = "68dd2e3fe756519cc12369279406cae732ad3a5f0f73dd98e75c617f75a2d804"
RPROVIDES:runc:append:aarch64 = " virtual/oci-runtime"

RDEPENDS:runc = " \
 glibc \
 libseccomp \
 "
