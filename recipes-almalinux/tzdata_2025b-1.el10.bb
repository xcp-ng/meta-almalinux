# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tzdata"
PV = "2025b"
PR = "1.el10"
PACKAGES = " \
 tzdata \
 tzdata-java \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tzdata-2025b-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "add1048114cdc7245e96143576e7bf5dfc9788ab825b3ecfb111bc5b82814e46"

URI_x86_64_v2_tzdata = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tzdata-2025b-1.el10.noarch.rpm;name=x86_64_v2_tzdata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tzdata}"
SRC_URI[x86_64_v2_tzdata.sha256sum] = "a1d9fa359dbd922237680eac553ac44749a40e1cc545a9384afcaafe66500779"

URI_x86_64_v2_tzdata-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tzdata-java-2025b-1.el10.noarch.rpm;name=x86_64_v2_tzdata-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tzdata-java}"
SRC_URI[x86_64_v2_tzdata-java.sha256sum] = "4e442e51e89d98b998d85d867741f12598219cc68fb08b53254d7a6982c5e791"

URI_aarch64_tzdata = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tzdata-2025b-1.el10.noarch.rpm;name=aarch64_tzdata;unpack=0"
SRC_URI:append = " ${URI_aarch64_tzdata}"
SRC_URI[aarch64_tzdata.sha256sum] = "a1d9fa359dbd922237680eac553ac44749a40e1cc545a9384afcaafe66500779"

URI_aarch64_tzdata-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tzdata-java-2025b-1.el10.noarch.rpm;name=aarch64_tzdata-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_tzdata-java}"
SRC_URI[aarch64_tzdata-java.sha256sum] = "4e442e51e89d98b998d85d867741f12598219cc68fb08b53254d7a6982c5e791"

RDEPENDS:tzdata = " \
 "
RDEPENDS:tzdata-java = " \
 "
