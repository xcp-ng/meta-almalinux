# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gkrellm"
PV = "2.4.0"
PR = "5.el10_1"
PACKAGES = " \
 gkrellm \
 gkrellm-daemon \
 gkrellm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gkrellm-2.4.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a8ffb5998953c425661527e2c55b3c2e53f2a0384e70e1528a090581864e159"

URI_x86_64_v2_gkrellm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gkrellm-2.4.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gkrellm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gkrellm}"
SRC_URI[x86_64_v2_gkrellm.sha256sum] = "d9e624c229c87b78adb5cea1f2ff54278ca4465c5dc83ef33e5302c2ea7acd76"

URI_x86_64_v2_gkrellm-daemon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gkrellm-daemon-2.4.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gkrellm-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gkrellm-daemon}"
SRC_URI[x86_64_v2_gkrellm-daemon.sha256sum] = "0444fc78da0a90abd39583353ca238464f396979355e6b57c06ff1e1811051fa"

URI_x86_64_v2_gkrellm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gkrellm-devel-2.4.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gkrellm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gkrellm-devel}"
SRC_URI[x86_64_v2_gkrellm-devel.sha256sum] = "6c1077bdec9df50981459ec65a1e83c0f680259a9c19655dc1187b0ea52214ca"

URI_aarch64_gkrellm = "${EPEL_MIRROR}/aarch64/Packages/g/gkrellm-2.4.0-5.el10_1.aarch64.rpm;name=aarch64_gkrellm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gkrellm}"
SRC_URI[aarch64_gkrellm.sha256sum] = "fd0b8ad36a691340d73bf9f3fa23bb6cbf1b0a6eb13eadd0241f4d3ca59b784d"

URI_aarch64_gkrellm-daemon = "${EPEL_MIRROR}/aarch64/Packages/g/gkrellm-daemon-2.4.0-5.el10_1.aarch64.rpm;name=aarch64_gkrellm-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_gkrellm-daemon}"
SRC_URI[aarch64_gkrellm-daemon.sha256sum] = "d7ef2775fd201bca8a31c925cad1a501a6dfe0d079973b5c84e69bc56f0d5125"

URI_aarch64_gkrellm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gkrellm-devel-2.4.0-5.el10_1.aarch64.rpm;name=aarch64_gkrellm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gkrellm-devel}"
SRC_URI[aarch64_gkrellm-devel.sha256sum] = "9ebb9d5fb8af5e1a2622a82914c898d643abcb6d88992eb4aec3539116bb5050"

RDEPENDS:gkrellm = " \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules-extra \
 glib2 \
 glibc \
 gtk2 \
 libICE \
 libSM \
 libX11 \
 libntlm \
 lm_sensors-libs \
 openssl-libs \
 pango \
 "
RDEPENDS:gkrellm-daemon = " \
 bash \
 glib2 \
 glibc \
 lm_sensors-libs \
 systemd \
 "
RDEPENDS:gkrellm-devel = " \
 gtk2-devel \
 pkgconf-pkg-config \
 "
