# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnma"
PV = "1.10.6"
PR = "9.el10"
PACKAGES = " \
 libnma \
 libnma-devel \
 libnma-gtk4 \
 libnma-gtk4-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnma-1.10.6-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b715f29d9aff3eeae84394c09c850c19ee46cc57bd7e8aa8720b5f82fdb4bae4"

URI_x86_64_v2_libnma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnma-1.10.6-9.el10.x86_64_v2.rpm;name=x86_64_v2_libnma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnma}"
SRC_URI[x86_64_v2_libnma.sha256sum] = "7fb8984a155773cbf26243b1ff61c9169f993f3e10c294099b85e27ebb2e75dd"

URI_x86_64_v2_libnma-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnma-devel-1.10.6-9.el10.x86_64_v2.rpm;name=x86_64_v2_libnma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnma-devel}"
SRC_URI[x86_64_v2_libnma-devel.sha256sum] = "a589b61be8df140fea1cdc58709b9bda2a160893243ef5a3f7756893ab087061"

URI_x86_64_v2_libnma-gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnma-gtk4-1.10.6-9.el10.x86_64_v2.rpm;name=x86_64_v2_libnma-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnma-gtk4}"
SRC_URI[x86_64_v2_libnma-gtk4.sha256sum] = "6d1a23d584ddfc8b347d5140be4afb7f5c761a8dcf2f161b46e1095134057f67"

URI_x86_64_v2_libnma-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnma-gtk4-devel-1.10.6-9.el10.x86_64_v2.rpm;name=x86_64_v2_libnma-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnma-gtk4-devel}"
SRC_URI[x86_64_v2_libnma-gtk4-devel.sha256sum] = "500dbdf6c3cf3e83902c36f4002fadd7d14949a06f8e1da101e13ed5747183af"

URI_aarch64_libnma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnma-1.10.6-9.el10.aarch64.rpm;name=aarch64_libnma;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnma}"
SRC_URI[aarch64_libnma.sha256sum] = "bf11ed9d45fc9b73fab36e03cae1d21fe9de425c062fd84d4dd72df5119928b1"

URI_aarch64_libnma-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnma-devel-1.10.6-9.el10.aarch64.rpm;name=aarch64_libnma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnma-devel}"
SRC_URI[aarch64_libnma-devel.sha256sum] = "0610f04711449ac69fd6e039ae0c5bfec06dc77bd2b0e9f3bd277f525f8c4f01"

URI_aarch64_libnma-gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnma-gtk4-1.10.6-9.el10.aarch64.rpm;name=aarch64_libnma-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnma-gtk4}"
SRC_URI[aarch64_libnma-gtk4.sha256sum] = "76a33b3bc54a795e828f0f3a9431d96085020f10f6cf1dc01a46925bc7006d27"

URI_aarch64_libnma-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnma-gtk4-devel-1.10.6-9.el10.aarch64.rpm;name=aarch64_libnma-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnma-gtk4-devel}"
SRC_URI[aarch64_libnma-gtk4-devel.sha256sum] = "8d70791bd5246f4fcbfa1064c9ee460b89709f90b69e9aa37d2e953e8147e309"

RDEPENDS:libnma = " \
 NetworkManager-libnm \
 cairo \
 gcr-libs \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 mobile-broadband-provider-info \
 "
RDEPENDS:libnma-devel = " \
 NetworkManager-libnm-devel \
 gtk3-devel \
 libnma \
 pkgconf-pkg-config \
 "
RDEPENDS:libnma-gtk4 = " \
 NetworkManager-libnm \
 cairo \
 gcr-libs \
 glib2 \
 glibc \
 gtk4 \
 libgcc \
 mobile-broadband-provider-info \
 "
RDEPENDS:libnma-gtk4-devel = " \
 NetworkManager-libnm-devel \
 gtk4-devel \
 libnma-gtk4 \
 pkgconf-pkg-config \
 "
