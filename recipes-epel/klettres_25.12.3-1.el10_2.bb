# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klettres"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 klettres \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klettres-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08f64acbf0f3b052218b0410b430e6ca3a7e987c904644915600752dbbc8a645"

URI_x86_64_v2_klettres = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klettres-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klettres;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klettres}"
SRC_URI[x86_64_v2_klettres.sha256sum] = "d32a018a8a4b7d3954aad3b38324139079594917ae0d1e4508004feef643779d"

URI_aarch64_klettres = "${EPEL_MIRROR}/aarch64/Packages/k/klettres-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_klettres;unpack=0"
SRC_URI:append = " ${URI_aarch64_klettres}"
SRC_URI[aarch64_klettres.sha256sum] = "0afac29fad8c05f4d72de4c17a65d2f331cf7f524370b9361ced695e17421819"

RDEPENDS:klettres = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
