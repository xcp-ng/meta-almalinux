# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_datetime_data"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_datetime_data+default-devel \
 rust-icu_datetime_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_datetime_data-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21f5a8d328a0a9938994914730ce3e92b8bad3b8fa45fad693a30c6af9176b76"

URI_x86_64_v2_rust-icu_datetime_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime_data+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime_data+default-devel.sha256sum] = "24116a0898e758d51f6a97a4d4f899696065935ff78527c4b702d620888cd03c"

URI_x86_64_v2_rust-icu_datetime_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime_data-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime_data-devel.sha256sum] = "ce8e594d9c83049ecfedf976e36e9381f0572baa26cde44e8a0d1cec888164ad"

URI_aarch64_rust-icu_datetime_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime_data+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime_data+default-devel}"
SRC_URI[aarch64_rust-icu_datetime_data+default-devel.sha256sum] = "931e104808dc3a72bfadb33e24869b600765474e1377361b30cc42b191157e44"

URI_aarch64_rust-icu_datetime_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime_data-devel}"
SRC_URI[aarch64_rust-icu_datetime_data-devel.sha256sum] = "dcd0e7bebdab6519c98b8ce18aeeb7aee62c7260a52c5ec20ee33bad12c9c10c"

RDEPENDS:rust-icu_datetime_data+default-devel = " \
 cargo \
 rust-icu_datetime_data-devel \
 "
RDEPENDS:rust-icu_datetime_data-devel = " \
 cargo \
 rust \
 "
