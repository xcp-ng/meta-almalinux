# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Implementation"
PV = "0.09"
PR = "36.el10_0"
PACKAGES = " \
 perl-Module-Implementation \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Implementation-0.09-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "876bbcbcc12279c66f4711dafdc130f9e90162abd81baebb433c1783ae09033b"

URI_x86_64_v2_perl-Module-Implementation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Implementation-0.09-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Implementation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Implementation}"
SRC_URI[x86_64_v2_perl-Module-Implementation.sha256sum] = "0bf846c6c0fe19abea1deb6b231a58c653e1b9855496840e39b1e0fc7cd78306"

URI_aarch64_perl-Module-Implementation = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Implementation-0.09-36.el10_0.noarch.rpm;name=aarch64_perl-Module-Implementation;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Implementation}"
SRC_URI[aarch64_perl-Module-Implementation.sha256sum] = "13bf2d45bb767bf97cb3992a5ab74f134f483021384f2b1a7f650d187d93dd5a"

RDEPENDS:perl-Module-Implementation = " \
 perl-Carp \
 perl-Module-Runtime \
 perl-Try-Tiny \
 perl-libs \
 "
