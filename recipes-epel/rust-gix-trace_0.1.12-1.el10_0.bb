# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-trace"
PV = "0.1.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-trace+default-devel \
 rust-gix-trace+document-features-devel \
 rust-gix-trace+tracing-detail-devel \
 rust-gix-trace+tracing-devel \
 rust-gix-trace-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-trace-0.1.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75767ef68aee0119ea9fedd76a8ca57803963159c43b8ed466a5411fe2e9fe46"

URI_x86_64_v2_rust-gix-trace+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+default-devel-0.1.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+default-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+default-devel.sha256sum] = "80cc0cbcbdadd6467a7fbd8039ab9f3263f08563933c0064d31e1be4a661ab81"

URI_x86_64_v2_rust-gix-trace+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+document-features-devel-0.1.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+document-features-devel.sha256sum] = "605e0b1e97a8fda50e6c4c5ec91187ac8bb6d159ceac39067d0be08b5379b106"

URI_x86_64_v2_rust-gix-trace+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+tracing-detail-devel-0.1.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+tracing-detail-devel.sha256sum] = "22c4a9e18adb3d21f72dcb63b0bdccaaafb071c46d83ca743163c95bbf42ea85"

URI_x86_64_v2_rust-gix-trace+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+tracing-devel-0.1.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+tracing-devel.sha256sum] = "58be67be2ace121e8352558ac8e31c293f67b34573aa82881a5b2983eeaa5e92"

URI_x86_64_v2_rust-gix-trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace-devel-0.1.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace-devel}"
SRC_URI[x86_64_v2_rust-gix-trace-devel.sha256sum] = "ab0934a89a7fd5ea2847a10c7074507eef9bac37372a4105d53025fe1213da9c"

URI_aarch64_rust-gix-trace+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+default-devel-0.1.12-1.el10_0.noarch.rpm;name=aarch64_rust-gix-trace+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+default-devel}"
SRC_URI[aarch64_rust-gix-trace+default-devel.sha256sum] = "d51476761c14ecbe30333c08d422397a7e2566d6dd572fdd8afbc5c97d664836"

URI_aarch64_rust-gix-trace+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+document-features-devel-0.1.12-1.el10_0.noarch.rpm;name=aarch64_rust-gix-trace+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+document-features-devel}"
SRC_URI[aarch64_rust-gix-trace+document-features-devel.sha256sum] = "ecb3e38e6b6f43735a8c8f8fa0bba8a517d852052aaf6262f101ccc671ab113e"

URI_aarch64_rust-gix-trace+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+tracing-detail-devel-0.1.12-1.el10_0.noarch.rpm;name=aarch64_rust-gix-trace+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix-trace+tracing-detail-devel.sha256sum] = "ec15486ca54c6ced6f43ca8e175a76041653ee46ff1fa2a15d03952682d8f976"

URI_aarch64_rust-gix-trace+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+tracing-devel-0.1.12-1.el10_0.noarch.rpm;name=aarch64_rust-gix-trace+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+tracing-devel}"
SRC_URI[aarch64_rust-gix-trace+tracing-devel.sha256sum] = "76a47e07d767e9597853b574fc220e8b923d43509d1496814ede6ba4bdc8a340"

URI_aarch64_rust-gix-trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace-devel-0.1.12-1.el10_0.noarch.rpm;name=aarch64_rust-gix-trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace-devel}"
SRC_URI[aarch64_rust-gix-trace-devel.sha256sum] = "d7645f1ccdd037f18c7dc91519014382f081527ec954a52caba2d2e1cd4264e8"

RDEPENDS:rust-gix-trace+default-devel = " \
 cargo \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+tracing-detail-devel = " \
 cargo \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+tracing-devel = " \
 cargo \
 rust-gix-trace-devel \
 rust-tracing-core+default-devel \
 "
RDEPENDS:rust-gix-trace-devel = " \
 cargo \
 rust \
 "
