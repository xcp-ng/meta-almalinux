# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chrono"
PV = "0.4.44"
PR = "1.el10_1"
PACKAGES = " \
 rust-chrono+alloc-devel \
 rust-chrono+arbitrary-devel \
 rust-chrono+clock-devel \
 rust-chrono+core-error-devel \
 rust-chrono+default-devel \
 rust-chrono+iana-time-zone-devel \
 rust-chrono+libc-devel \
 rust-chrono+now-devel \
 rust-chrono+oldtime-devel \
 rust-chrono+pure-rust-locales-devel \
 rust-chrono+rkyv-16-devel \
 rust-chrono+rkyv-32-devel \
 rust-chrono+rkyv-64-devel \
 rust-chrono+rkyv-devel \
 rust-chrono+rkyv-validation-devel \
 rust-chrono+serde-devel \
 rust-chrono+std-devel \
 rust-chrono+unstable-locales-devel \
 rust-chrono-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-chrono-0.4.44-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a1b464556a6782da36fa83c5b2570ca7227120eba74f0e8a2f0af92b3a132dda"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+alloc-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+alloc-devel.sha256sum] = "89cbac7aa12ef22b3174afaff1718641871c8c4d77522416582603fecaac18ad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+arbitrary-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+arbitrary-devel.sha256sum] = "b998d49530b9806e8b53d1d3713ce2ed135474a081b6e95cf27d5fd9910f530d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+clock-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+clock-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+clock-devel.sha256sum] = "1e0ec53334aabbc5336ee698dd35aa956f1664881f8288af1aeb743ae7baebb6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+core-error-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+core-error-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+core-error-devel.sha256sum] = "f6ef9de96b18ff41a4794bcb76dea7c4f415cc3fc1b450c2e0357d6174997109"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+default-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+default-devel.sha256sum] = "d92e672088a7794f47bb66a52d66505c7eea6e1a8cb256b975d2fc0f0c429f89"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+iana-time-zone-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+iana-time-zone-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+iana-time-zone-devel.sha256sum] = "a4e485eb0d7b065366b504cbb95b7fedc6b823716cb8ca255443c789d34b82fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+libc-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+libc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+libc-devel.sha256sum] = "25a9bb1cbf988b8c7a99c57ec7913386ee8cab365bea0ddab41a8b8d8f22edb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+now-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+now-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+now-devel.sha256sum] = "bc68ae5c9b031e893d22fb3d28e18683b20bde6eafb55f9b2edd419359965eb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+oldtime-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+oldtime-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+oldtime-devel.sha256sum] = "0095cdbdf7b59194a45022a3f2ab83735e24d2640d3a7f5a6fc8e6b996eabfe0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+pure-rust-locales-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+pure-rust-locales-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+pure-rust-locales-devel.sha256sum] = "d99617c30e56f0408ee5800b9077a17f785c09d93db7816f6edc4be10b08b133"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-16-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-16-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+rkyv-16-devel.sha256sum] = "3d7ecad7f499b881c014825739d9038ab5a3f401cedf333871f242d31b19cc75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-32-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-32-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+rkyv-32-devel.sha256sum] = "25aa7890928b6b6f81471b14e6a2b599ec2db8f63bcbe7deee8347505fbdc9bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-64-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-64-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+rkyv-64-devel.sha256sum] = "1679870484c214972bb10061a4a061e0dce8514419a05a91416adeff00d0c6db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+rkyv-devel.sha256sum] = "843b05d8b82f61b850634f0c167f4eec5472c3b084df5854ca18b813c359504c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-validation-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-validation-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+rkyv-validation-devel.sha256sum] = "bf522c908f159670525c969b1cb684acf5fe48c0bb4fa1cba34904cd57e3786f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+serde-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+serde-devel.sha256sum] = "d50090db178d98505a5517c253c20ee4c9af5dd269228dae128d245003d9ecb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+std-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+std-devel.sha256sum] = "dafff968db61c8b86dc3d607a75462b34248054da4d91c28de35952035942b13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+unstable-locales-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+unstable-locales-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono+unstable-locales-devel.sha256sum] = "38ab7dc0986dd4f9e305b07631b273c91c0c4e2e0d5c7c83318c9220a2caefb1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-devel-0.4.44-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-devel;unpack=0"
SRC_URI[x86_64_v2_rust-chrono-devel.sha256sum] = "d8c7cfdef71491ff4d7a2f3697028be88ba6536e6b0916403dd66dc56d74f2a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+alloc-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+alloc-devel.sha256sum] = "0ea61e62c3bb48687134bb033cf0e9c38a00444ab1e18906581b0c84cfd21c56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+arbitrary-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+arbitrary-devel.sha256sum] = "d1ad8dc376dc40dba813a6f8befc15700e75b3c524281494913a97746b159d73"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+clock-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+clock-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+clock-devel.sha256sum] = "56b5c8ea917c2adabf996c9fa3d5df1d3c77bd6d92d41026f7675469d230b0fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+core-error-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+core-error-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+core-error-devel.sha256sum] = "edf35833d0bd9fd6a12e9475891012addc888f6a789de629b6124b7a2ac74d37"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+default-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+default-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+default-devel.sha256sum] = "5342be03e3958457051d272912ca7d9a263f9eeb11468e787c285b31d3621894"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+iana-time-zone-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+iana-time-zone-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+iana-time-zone-devel.sha256sum] = "ac0ad5eadb07cf0ad60d41a6ecd449b04c2124d27a63c6ff60570dbe4cfd16db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+libc-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+libc-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+libc-devel.sha256sum] = "7a399748f8dcb9b67b573bcdc257bbc3ed8aa9e37eedcfe2ad59406d1c5502f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+now-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+now-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+now-devel.sha256sum] = "8151737fd698e7e778324cc8f417c9224916f0fa7d9a7f811fbd017a8a8eb623"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+oldtime-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+oldtime-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+oldtime-devel.sha256sum] = "b10146b98137f81182a0160ee90c39a16929e10cbbbe1982f1b97859f0fcafae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+pure-rust-locales-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+pure-rust-locales-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+pure-rust-locales-devel.sha256sum] = "64c0c3b8c6326d7db2fc22a3a13f67850293821ab005f80993427ab81adfb5b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-16-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+rkyv-16-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+rkyv-16-devel.sha256sum] = "00f42a11fd63c10eb571d49deebeead6f0177ef54095bf89df9764b1a012fc46"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-32-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+rkyv-32-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+rkyv-32-devel.sha256sum] = "9650a7763d909045bbd9ca7e68215d2a247ec6ad708d188b60adde1bf3783f74"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-64-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+rkyv-64-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+rkyv-64-devel.sha256sum] = "f484efa54c0938d3a65d452094562c42a045fc116bc2992d820918026b98c8eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+rkyv-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+rkyv-devel.sha256sum] = "fa63ca39f125ed2c9f1fee66e07de9faca62ee7409f4dcc1e78b60f8b7b2bb84"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-validation-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+rkyv-validation-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+rkyv-validation-devel.sha256sum] = "f36f0159b6f121bd74a3b232ad26525b512532b1b2b25a659f580029d693c511"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+serde-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+serde-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+serde-devel.sha256sum] = "20057d7f3ae9fca2af111685eab1c20430aa88d54694ab0f5ce2bd0867618dd4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+std-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+std-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+std-devel.sha256sum] = "9e5aa17c2d61c3d57eb38a0a732542e991b8efb8b62c1f4023a8a637aa17f62a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+unstable-locales-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono+unstable-locales-devel;unpack=0"
SRC_URI[aarch64_rust-chrono+unstable-locales-devel.sha256sum] = "5e027e37605955797d1f425a9768b79805e573091c0d12db692ed5a29848d10b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-devel-0.4.44-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-devel;unpack=0"
SRC_URI[aarch64_rust-chrono-devel.sha256sum] = "a0bcc981d938c8c8fa3c0fdf4701fe866509b3092983d1dd07dfd7518327255d"

RDEPENDS:rust-chrono+alloc-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+clock-devel = " \
 cargo \
 rust-chrono+iana-time-zone-devel \
 rust-chrono+now-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+core-error-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+default-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+oldtime-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+iana-time-zone-devel = " \
 cargo \
 rust-chrono-devel \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 "
RDEPENDS:rust-chrono+libc-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+now-devel = " \
 cargo \
 rust-chrono+std-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+oldtime-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+pure-rust-locales-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pure-rust-locales+default-devel \
 "
RDEPENDS:rust-chrono+rkyv-16-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_16-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-32-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-64-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_64-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-validation-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+serde-devel = " \
 cargo \
 rust-chrono-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-chrono+std-devel = " \
 cargo \
 rust-chrono+alloc-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+unstable-locales-devel = " \
 cargo \
 rust-chrono+pure-rust-locales-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
