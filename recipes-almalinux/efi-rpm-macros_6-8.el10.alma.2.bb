# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "efi-rpm-macros"
PV = "6"
PR = "8.el10.alma.2"
PACKAGES = " \
 efi-filesystem \
 efi-srpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/efi-rpm-macros-6-8.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad3e153736326406aa82a604af46982bfa9c32efe21fa0dda36b1e2ad2b6995b"

URI_x86_64_v2_efi-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/efi-filesystem-6-8.el10.alma.2.noarch.rpm;name=x86_64_v2_efi-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_efi-filesystem}"
SRC_URI[x86_64_v2_efi-filesystem.sha256sum] = "2f7f138ae201ccaeb52b6256258b795a6a5c3603cc2a2a4be7e83751d8fc2eab"

URI_x86_64_v2_efi-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/efi-srpm-macros-6-8.el10.alma.2.noarch.rpm;name=x86_64_v2_efi-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_efi-srpm-macros}"
SRC_URI[x86_64_v2_efi-srpm-macros.sha256sum] = "44f77359441b0245d57ff0483fc03912c9d2c279ddb074f2eb3b929ad7f20809"

URI_aarch64_efi-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/efi-filesystem-6-8.el10.alma.2.noarch.rpm;name=aarch64_efi-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_efi-filesystem}"
SRC_URI[aarch64_efi-filesystem.sha256sum] = "2f7f138ae201ccaeb52b6256258b795a6a5c3603cc2a2a4be7e83751d8fc2eab"

URI_aarch64_efi-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/efi-srpm-macros-6-8.el10.alma.2.noarch.rpm;name=aarch64_efi-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_efi-srpm-macros}"
SRC_URI[aarch64_efi-srpm-macros.sha256sum] = "44f77359441b0245d57ff0483fc03912c9d2c279ddb074f2eb3b929ad7f20809"

RDEPENDS:efi-filesystem = " \
 filesystem \
 "
RDEPENDS:efi-srpm-macros = " \
 bash \
 rpm \
 "
