# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-universal-hash"
PV = "0.5.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-universal-hash+default-devel \
 rust-universal-hash+std-devel \
 rust-universal-hash-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-universal-hash-0.5.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e87da8935e8509b0fd55753e55b29fb11c718235c6b0c75e85b35161eb270929"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-universal-hash+default-devel-0.5.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-universal-hash+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-universal-hash+default-devel.sha256sum] = "e6d11d61f6d4e96157ba6cfc417574e75f4b42d30a783f9915a1aa6040928e24"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-universal-hash+std-devel-0.5.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-universal-hash+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-universal-hash+std-devel.sha256sum] = "7d936e876769fdaa59a3fc226bc94a2f83d1ce61f3d4437153d0b7a4f1a65c4a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-universal-hash-devel-0.5.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-universal-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-universal-hash-devel.sha256sum] = "c80d10ce5e13a716bad5c51d6e0e89298e26eaae8f398e72eb919c89637c0a4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-universal-hash+default-devel-0.5.1-4.el10_0.noarch.rpm;name=aarch64_rust-universal-hash+default-devel;unpack=0"
SRC_URI[aarch64_rust-universal-hash+default-devel.sha256sum] = "47d22c36c7dd3259d84b4c75b017d1679af2b4f3e08253542893c5d9d1db36d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-universal-hash+std-devel-0.5.1-4.el10_0.noarch.rpm;name=aarch64_rust-universal-hash+std-devel;unpack=0"
SRC_URI[aarch64_rust-universal-hash+std-devel.sha256sum] = "db9f14bc695c902019d89485f3b9b1ee6867fb35a3236c5f5fd393ab0aaaa596"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-universal-hash-devel-0.5.1-4.el10_0.noarch.rpm;name=aarch64_rust-universal-hash-devel;unpack=0"
SRC_URI[aarch64_rust-universal-hash-devel.sha256sum] = "14ca328dd7ab0220c000eaea5d7eb7668c824152a38e77102823a005b1caf474"

RDEPENDS:rust-universal-hash+default-devel = " \
 cargo \
 rust-universal-hash-devel \
 "
RDEPENDS:rust-universal-hash+std-devel = " \
 cargo \
 rust-crypto-common0.1+std-devel \
 rust-universal-hash-devel \
 "
RDEPENDS:rust-universal-hash-devel = " \
 cargo \
 rust \
 rust-crypto-common0.1+default-devel \
 rust-subtle-devel \
 "
