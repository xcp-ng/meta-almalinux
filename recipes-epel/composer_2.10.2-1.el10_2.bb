# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "composer"
PV = "2.10.2"
PR = "1.el10_2"
PACKAGES = " \
 composer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/composer-2.10.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a78757650cc06cd6f9cbb2ef302ed927bf5a12c54a5c3d1a2b07d9c3e711c0b9"

URI_x86_64_v2_composer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/composer-2.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_composer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_composer}"
SRC_URI[x86_64_v2_composer.sha256sum] = "4854a44aff14be8b2eff5f61b588430a2a79a7df877aa60d7ae87518daa8aadb"

URI_aarch64_composer = "${EPEL_MIRROR}/aarch64/Packages/c/composer-2.10.2-1.el10_2.noarch.rpm;name=aarch64_composer;unpack=0"
SRC_URI:append = " ${URI_aarch64_composer}"
SRC_URI[aarch64_composer.sha256sum] = "cda205154eaf3877737140d21e073686fdc7d959a507fff223d2ddf548b49e53"

RDEPENDS:composer = " \
 bash \
 ca-certificates \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-date \
 virtual/php-dom \
 virtual/php-filter \
 virtual/php-hash \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-openssl \
 virtual/php-pcntl \
 virtual/php-pcre \
 virtual/php-phar \
 virtual/php-posix \
 virtual/php-reflection \
 virtual/php-spl \
 virtual/php-tokenizer \
 virtual/php-xsl \
 virtual/php-zip \
 virtual/php-zlib \
 virtual/php_language__ge_7.2.5 \
 "
