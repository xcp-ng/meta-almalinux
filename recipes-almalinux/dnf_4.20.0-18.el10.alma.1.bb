# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf"
PV = "4.20.0"
PR = "18.el10.alma.1"
PACKAGES = " \
 dnf \
 dnf-automatic \
 dnf-bootc \
 dnf-data \
 python3-dnf \
 yum \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dnf-4.20.0-18.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b4a04a78410c7ea7cae9466e07b4e99909b3826ef975151fff6f3529f0a1991"

URI_x86_64_v2_dnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-4.20.0-18.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf}"
SRC_URI[x86_64_v2_dnf.sha256sum] = "b521b5dec27f152226feb197a27109744d7e8c573b0528bc2c344f987d5e6b7b"

URI_x86_64_v2_dnf-automatic = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-automatic-4.20.0-18.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf-automatic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-automatic}"
SRC_URI[x86_64_v2_dnf-automatic.sha256sum] = "7f720df0e559aca9196c10cca958cbea0354934636850615bc534587db230dd8"

URI_x86_64_v2_dnf-bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnf-bootc-4.20.0-18.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf-bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-bootc}"
SRC_URI[x86_64_v2_dnf-bootc.sha256sum] = "4f7c7ae4df3517ddcc94a799eec43e2117b1db1c68249fcd0d2567e7b2ed3bac"

URI_x86_64_v2_dnf-data = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dnf-data-4.20.0-18.el10.alma.1.noarch.rpm;name=x86_64_v2_dnf-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-data}"
SRC_URI[x86_64_v2_dnf-data.sha256sum] = "7a6ebe78124bdcdc175d88b5cdeca89626c057ac2eb02d9abba39a9bcbbe9060"

URI_x86_64_v2_python3-dnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dnf-4.20.0-18.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf}"
SRC_URI[x86_64_v2_python3-dnf.sha256sum] = "7dc59033bf9fb77be18fc96b50514d3227a1e1fcf6064b22015b56fa0aef9cbb"

URI_x86_64_v2_yum = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/yum-4.20.0-18.el10.alma.1.noarch.rpm;name=x86_64_v2_yum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yum}"
SRC_URI[x86_64_v2_yum.sha256sum] = "51b18ca55fd8785176f7504b358b45ee5195041c3b3a2558a824314bde13411f"

URI_aarch64_dnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-4.20.0-18.el10.alma.1.noarch.rpm;name=aarch64_dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf}"
SRC_URI[aarch64_dnf.sha256sum] = "b521b5dec27f152226feb197a27109744d7e8c573b0528bc2c344f987d5e6b7b"

URI_aarch64_dnf-automatic = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-automatic-4.20.0-18.el10.alma.1.noarch.rpm;name=aarch64_dnf-automatic;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-automatic}"
SRC_URI[aarch64_dnf-automatic.sha256sum] = "7f720df0e559aca9196c10cca958cbea0354934636850615bc534587db230dd8"

URI_aarch64_dnf-bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnf-bootc-4.20.0-18.el10.alma.1.noarch.rpm;name=aarch64_dnf-bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-bootc}"
SRC_URI[aarch64_dnf-bootc.sha256sum] = "4f7c7ae4df3517ddcc94a799eec43e2117b1db1c68249fcd0d2567e7b2ed3bac"

URI_aarch64_dnf-data = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dnf-data-4.20.0-18.el10.alma.1.noarch.rpm;name=aarch64_dnf-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-data}"
SRC_URI[aarch64_dnf-data.sha256sum] = "7a6ebe78124bdcdc175d88b5cdeca89626c057ac2eb02d9abba39a9bcbbe9060"

URI_aarch64_python3-dnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dnf-4.20.0-18.el10.alma.1.noarch.rpm;name=aarch64_python3-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf}"
SRC_URI[aarch64_python3-dnf.sha256sum] = "7dc59033bf9fb77be18fc96b50514d3227a1e1fcf6064b22015b56fa0aef9cbb"

URI_aarch64_yum = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/yum-4.20.0-18.el10.alma.1.noarch.rpm;name=aarch64_yum;unpack=0"
SRC_URI:append = " ${URI_aarch64_yum}"
SRC_URI[aarch64_yum.sha256sum] = "51b18ca55fd8785176f7504b358b45ee5195041c3b3a2558a824314bde13411f"

RDEPENDS:dnf = " \
 bash \
 python3-dnf \
 virtual/coreutils \
 "
RDEPENDS:dnf-automatic = " \
 bash \
 python3 \
 python3-dnf \
 systemd \
 "
RDEPENDS:dnf-bootc = " \
 ostree \
 ostree-libs \
 python3-dnf \
 python3-gobject-base \
 util-linux-core \
 "
RDEPENDS:dnf-data = " \
 "
RDEPENDS:python3-dnf = " \
 dnf-data \
 libmodulemd \
 python3 \
 python3-hawkey \
 python3-libcomps \
 python3-libdnf \
 python3-rpm \
 "
RDEPENDS:yum = " \
 dnf \
 "
