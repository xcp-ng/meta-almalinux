# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax-templates-rhel"
PV = "10.0"
PR = "56.el10_0"
PACKAGES = " \
 lorax-templates-rhel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-templates-rhel-10.0-56.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74e6c7675027f23a79d142413a4325b4a1b7b078c28485b830a5fc37c8d02ada"

URI_x86_64_v2_lorax-templates-rhel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-rhel-10.0-56.el10_0.noarch.rpm;name=x86_64_v2_lorax-templates-rhel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-rhel}"
SRC_URI[x86_64_v2_lorax-templates-rhel.sha256sum] = "a99291f3a50987d5f8751098d40865a99a442a9c682ecb17630ae12a58e071c0"
RPROVIDES:lorax-templates-rhel:x86_64_v2 = "virtual/lorax-templates"

URI_aarch64_lorax-templates-rhel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-rhel-10.0-56.el10_0.noarch.rpm;name=aarch64_lorax-templates-rhel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-rhel}"
SRC_URI[aarch64_lorax-templates-rhel.sha256sum] = "a99291f3a50987d5f8751098d40865a99a442a9c682ecb17630ae12a58e071c0"
RPROVIDES:lorax-templates-rhel:aarch64 = "virtual/lorax-templates"

RDEPENDS:lorax-templates-rhel = " \
 lorax \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/lorax-templates"

PROVIDES:append:aarch64 = " rpm/virtual/lorax-templates"
