# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_parser"
PV = "1.0.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser+default-devel \
 rust-toml_parser+simd-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser+unsafe-devel \
 rust-toml_parser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_parser-1.0.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39a4edcf9ca04a9e17f87cc9333137cac126a5213e4ca8b8f2dfc9438bc4adab"

URI_x86_64_v2_rust-toml_parser+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+alloc-devel-1.0.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+alloc-devel.sha256sum] = "4f0e147f3995ebe1a32a0c2af9ffc9d32c340414a5ffb298e125addc48b0d78e"

URI_x86_64_v2_rust-toml_parser+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+debug-devel-1.0.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+debug-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+debug-devel.sha256sum] = "a4735b261b2f95051e798ad8a55c1ebaf2f248220fb32927911fd524a6e88154"

URI_x86_64_v2_rust-toml_parser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+default-devel-1.0.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+default-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+default-devel.sha256sum] = "fd04acd171fc85c538781c4576a5f7d6d2abc5f0ab8f1d964f6b2130f2996ed8"

URI_x86_64_v2_rust-toml_parser+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+simd-devel-1.0.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+simd-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+simd-devel.sha256sum] = "e44c532f3ada9543963267a16b2f7dad990cbfb8239897053d1e5bac6a28ee9e"

URI_x86_64_v2_rust-toml_parser+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+std-devel-1.0.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+std-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+std-devel.sha256sum] = "03bcbd27e57ad41138ee2ad33761500227f8017dde3e5ff970e494f839649a07"

URI_x86_64_v2_rust-toml_parser+unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+unsafe-devel-1.0.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+unsafe-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+unsafe-devel.sha256sum] = "2f4f6878f7bad49fd63044ade90f1a5f824d0015c430c33d514fcd5c325dd0b6"

URI_x86_64_v2_rust-toml_parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser-devel-1.0.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser-devel}"
SRC_URI[x86_64_v2_rust-toml_parser-devel.sha256sum] = "f07084af263e06031c19c99670fc669b4ae561156ed2afa29acbf8f1be644d48"

URI_aarch64_rust-toml_parser+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+alloc-devel-1.0.9-1.el10_2.noarch.rpm;name=aarch64_rust-toml_parser+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+alloc-devel}"
SRC_URI[aarch64_rust-toml_parser+alloc-devel.sha256sum] = "9467cb32d1fdce2ddfd61176895274a15c41ac5a241f3cd27361b1752d2d5acd"

URI_aarch64_rust-toml_parser+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+debug-devel-1.0.9-1.el10_2.noarch.rpm;name=aarch64_rust-toml_parser+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+debug-devel}"
SRC_URI[aarch64_rust-toml_parser+debug-devel.sha256sum] = "5683bcbd9b0758d48b1f9c2f84485c4472c97e1c49d658ec5bac46a0b7bcd1b2"

URI_aarch64_rust-toml_parser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+default-devel-1.0.9-1.el10_2.noarch.rpm;name=aarch64_rust-toml_parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+default-devel}"
SRC_URI[aarch64_rust-toml_parser+default-devel.sha256sum] = "4e7bda9ff54b9add78dfc3aa0b85607ed500d78a8b6d28d3840135b572474898"

URI_aarch64_rust-toml_parser+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+simd-devel-1.0.9-1.el10_2.noarch.rpm;name=aarch64_rust-toml_parser+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+simd-devel}"
SRC_URI[aarch64_rust-toml_parser+simd-devel.sha256sum] = "5d72391938104323463e7a7dd0def8cfd2ec45e574890af5073eb30fc214f7e9"

URI_aarch64_rust-toml_parser+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+std-devel-1.0.9-1.el10_2.noarch.rpm;name=aarch64_rust-toml_parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+std-devel}"
SRC_URI[aarch64_rust-toml_parser+std-devel.sha256sum] = "1e2354f1af67e606e061fa6a7a51c21d25b20f51d6c011bacd6619248145d37f"

URI_aarch64_rust-toml_parser+unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+unsafe-devel-1.0.9-1.el10_2.noarch.rpm;name=aarch64_rust-toml_parser+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+unsafe-devel}"
SRC_URI[aarch64_rust-toml_parser+unsafe-devel.sha256sum] = "a2ce3360fee39c97a1acda444d25c1abf1bacd9e499b661676ba615a58b6d1b6"

URI_aarch64_rust-toml_parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser-devel-1.0.9-1.el10_2.noarch.rpm;name=aarch64_rust-toml_parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser-devel}"
SRC_URI[aarch64_rust-toml_parser-devel.sha256sum] = "d31edb114d1a568d2147e61ad523c1a4593212ba91e7ab58456a09fb7a485a27"

RDEPENDS:rust-toml_parser+alloc-devel = " \
 cargo \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+debug-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+default-devel = " \
 cargo \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+simd-devel = " \
 cargo \
 rust-toml_parser-devel \
 rust-winnow+simd-devel \
 "
RDEPENDS:rust-toml_parser+std-devel = " \
 cargo \
 rust-toml_parser+alloc-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+unsafe-devel = " \
 cargo \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser-devel = " \
 cargo \
 rust \
 rust-winnow-devel \
 "
