# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet8.0"
PV = "8.0.121"
PR = "1.el10_0"
PACKAGES = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-runtime-dbg-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-hostfxr-8.0 \
 dotnet-runtime-8.0 \
 dotnet-runtime-dbg-8.0 \
 dotnet-sdk-8.0 \
 dotnet-sdk-8.0-source-built-artifacts \
 dotnet-sdk-dbg-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet8.0-8.0.121-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f03e1694a4f957465b16936437647dadf069c6a88c7543fc21d722f98a0cde45"

URI_x86_64_v2_aspnetcore-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-8.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-8.0.sha256sum] = "86c4a3bcdb5d7c1110acf33b8fb9a7bcac249af1071b0f6d72b380b402740394"

URI_x86_64_v2_aspnetcore-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-8.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-8.0.sha256sum] = "4c7eeff6bc5da42889120d908aec50096380affebf6e454037240fd16ed1aedf"

URI_x86_64_v2_aspnetcore-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-8.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-8.0.sha256sum] = "731b3101b013373022d544d8aa4f72029dd060de3104db4ee4f5f9513cdf2f37"

URI_x86_64_v2_dotnet-apphost-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-8.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-8.0.sha256sum] = "5a8199baa999b8130df6c3afdd64a5379cf08fc2259e61a9a8b0021c2fc5236a"

URI_x86_64_v2_dotnet-hostfxr-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-8.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-8.0.sha256sum] = "4ad367311e59b9ab95658b5d814d942d6bacfe1d56e99989d99c47a9b1611326"

URI_x86_64_v2_dotnet-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-8.0}"
SRC_URI[x86_64_v2_dotnet-runtime-8.0.sha256sum] = "0a73b9b7ca193800b58cea2df7df70714f2014590161f1dcccbb08fc15d8a83d"

URI_x86_64_v2_dotnet-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-8.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-8.0.sha256sum] = "31a48ede0784436eb9733cab5abf459bd54c380fc6cffe010426fd41297f602a"

URI_x86_64_v2_dotnet-sdk-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-8.0-8.0.121-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-8.0}"
SRC_URI[x86_64_v2_dotnet-sdk-8.0.sha256sum] = "14efdd98f913146e97bb7851c75152cd69f529dfe0a66b3b76527ef7049031fa"

URI_x86_64_v2_dotnet-sdk-8.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.121-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-8.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "49cf99c68d57c1c48d0e527c1007ab0bc9814a936330204000dd0b5b41eb9327"

URI_x86_64_v2_dotnet-sdk-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-8.0-8.0.121-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-8.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-8.0.sha256sum] = "8816a5b20ae8d1a2f9aa9b769eb2420db942c4470301fa2f2e621cfeb85c7411"

URI_x86_64_v2_dotnet-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-8.0-8.0.21-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-8.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-8.0.sha256sum] = "76b7b1cdd3569a9147a8f9c5c8e9846ba10f4db8539a3fe00de724d9533c08a6"

URI_x86_64_v2_dotnet-templates-8.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-8.0-8.0.121-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-8.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-8.0}"
SRC_URI[x86_64_v2_dotnet-templates-8.0.sha256sum] = "b6558e935df5b29cc3d15ba475ed933d8281644641c0edff6a1826c39b1871d2"

URI_aarch64_aspnetcore-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-8.0-8.0.21-1.el10_0.aarch64.rpm;name=aarch64_aspnetcore-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-8.0}"
SRC_URI[aarch64_aspnetcore-runtime-8.0.sha256sum] = "46e4da4b75ecab3707d9c639337f382a4f5929356575e5dc2dc6bb0327a0d151"

URI_aarch64_aspnetcore-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.21-1.el10_0.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-8.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-8.0.sha256sum] = "7ea7fe3b64f2e95fad16521a292b3d863f66490bba4471fa087397181a0fad7f"

URI_aarch64_aspnetcore-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-8.0-8.0.21-1.el10_0.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-8.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-8.0.sha256sum] = "e84fa2dd12356783e42ee80e2a4aa627c3c8db1a3e251b3a1c03de97a08ae5c8"

URI_aarch64_dotnet-apphost-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-8.0-8.0.21-1.el10_0.aarch64.rpm;name=aarch64_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-8.0}"
SRC_URI[aarch64_dotnet-apphost-pack-8.0.sha256sum] = "2333d948c38575baf400b6cbf033a3f3fed2addc9249e7917011885b3d79957e"

URI_aarch64_dotnet-hostfxr-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-8.0-8.0.21-1.el10_0.aarch64.rpm;name=aarch64_dotnet-hostfxr-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-8.0}"
SRC_URI[aarch64_dotnet-hostfxr-8.0.sha256sum] = "a7d88404ae4f00f41957780b6317066e79f21f6133fa8570f6d1dcedaff3792c"

URI_aarch64_dotnet-runtime-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-8.0-8.0.21-1.el10_0.aarch64.rpm;name=aarch64_dotnet-runtime-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-8.0}"
SRC_URI[aarch64_dotnet-runtime-8.0.sha256sum] = "ca713967d2b078aa1320e8bdff36588eac30ac4a12e5bde5b42f776849a54f65"

URI_aarch64_dotnet-runtime-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-8.0-8.0.21-1.el10_0.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-8.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-8.0.sha256sum] = "a9ca2c5d1e8fec4fe5c452f0fe69170063c30b819d51eb0d91feb35e052d81f0"

URI_aarch64_dotnet-sdk-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-8.0-8.0.121-1.el10_0.aarch64.rpm;name=aarch64_dotnet-sdk-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-8.0}"
SRC_URI[aarch64_dotnet-sdk-8.0.sha256sum] = "3ac83315689d3c40099d27073c2ad4ab096f35cdf4bff124a81c4d1c88ea251c"

URI_aarch64_dotnet-sdk-8.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.121-1.el10_0.aarch64.rpm;name=aarch64_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-8.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "66d62eb26aba7884f3a96ca34e0aab5052592640eefff399aac891264dcb3f8c"

URI_aarch64_dotnet-sdk-dbg-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-8.0-8.0.121-1.el10_0.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-8.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-8.0.sha256sum] = "c80209373f4828e3b789afb296d1c94d5a883f0c7b33ff895bd73351c12f33e6"

URI_aarch64_dotnet-targeting-pack-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-8.0-8.0.21-1.el10_0.aarch64.rpm;name=aarch64_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-8.0}"
SRC_URI[aarch64_dotnet-targeting-pack-8.0.sha256sum] = "7bef7dfdeabcd87456db017b065acbea3a68b1c862960bcf70a4b091d7b2f4a1"

URI_aarch64_dotnet-templates-8.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-8.0-8.0.121-1.el10_0.aarch64.rpm;name=aarch64_dotnet-templates-8.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-8.0}"
SRC_URI[aarch64_dotnet-templates-8.0.sha256sum] = "5393e992ee9ed232b40e449583363be2ad9f5842f2d633703c1cc32abe8fde8c"

RDEPENDS:aspnetcore-runtime-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-8.0 = " \
 aspnetcore-runtime-8.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-8.0 = " \
 dotnet-hostfxr-8.0 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:dotnet-sdk-8.0 = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-runtime-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-8.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-dbg-8.0 = " \
 dotnet-sdk-8.0 \
 "
RDEPENDS:dotnet-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-8.0 = " \
 dotnet-host \
 "
