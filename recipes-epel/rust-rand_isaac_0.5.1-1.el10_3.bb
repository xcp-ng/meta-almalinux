# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_isaac"
PV = "0.5.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-rand_isaac+default-devel \
 rust-rand_isaac-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rand_isaac-0.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "530a4d84d1726a00de21ae4788213998c38c63668f05db4bc70b3f503675c9e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac+default-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand_isaac+default-devel.sha256sum] = "81e773b51cbb4987a3af926e4c462be6166669a0f97fc89d7ce3ec1fa16f1e31"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand_isaac-devel.sha256sum] = "21e3463c31cfdfe0dcf6a2c5a62a86c1934f0052b5c0fbf2a019996556d488b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac+default-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rand_isaac+default-devel;unpack=0"
SRC_URI[aarch64_rust-rand_isaac+default-devel.sha256sum] = "5e2ba27d64bdca93efffb5fe24be25224c815d1a28f3e9029f3431b15ea56d3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rand_isaac-devel;unpack=0"
SRC_URI[aarch64_rust-rand_isaac-devel.sha256sum] = "47d0b856951131cfdaf60ded2e5eb11726fc53d794b0a6ba26c2a94a48cd5c0e"

RDEPENDS:rust-rand_isaac+default-devel = " \
 cargo \
 rust-rand_isaac-devel \
 "
RDEPENDS:rust-rand_isaac-devel = " \
 cargo \
 rust \
 rust-rand_core+default-devel \
 "
