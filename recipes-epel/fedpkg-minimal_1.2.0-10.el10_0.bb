# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedpkg-minimal"
PV = "1.2.0"
PR = "10.el10_0"
PACKAGES = " \
 fedpkg-minimal \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fedpkg-minimal-1.2.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f773677c76d71c508152a5547cfe6d95cdfaee78b325366ed7be31a6ebd2ebc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedpkg-minimal-1.2.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fedpkg-minimal;unpack=0"
SRC_URI[x86_64_v2_fedpkg-minimal.sha256sum] = "9f17a69b2c1176eca67f6c5dc1525131d5c3df3c920ed09a67c0046770f74a74"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fedpkg-minimal-1.2.0-10.el10_0.noarch.rpm;name=aarch64_fedpkg-minimal;unpack=0"
SRC_URI[aarch64_fedpkg-minimal.sha256sum] = "46a6612c6b3820889cde34e9d430170191919f5eae675ebb424ff2287e9a72c2"

RDEPENDS:fedpkg-minimal = " \
 bash \
 curl \
 "
