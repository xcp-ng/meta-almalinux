# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-karchive"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-karchive \
 kf6-karchive-devel \
 kf6-karchive-doc \
 kf6-karchive-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-karchive-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1395973f34d20723ee61eec0a5b9a09079a18dc331e689633a301918babca2d0"

URI_x86_64_v2_kf6-karchive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-karchive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive}"
SRC_URI[x86_64_v2_kf6-karchive.sha256sum] = "4af4b394ed50490b12c27fd0e30e99650dec06c436a01980bd1ef39f973efe1f"

URI_x86_64_v2_kf6-karchive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-karchive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-devel}"
SRC_URI[x86_64_v2_kf6-karchive-devel.sha256sum] = "6689cb63c8935a2fe65aa60c07d7cba0e94e44fb958b69540719bf499d900930"

URI_x86_64_v2_kf6-karchive-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-karchive-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-doc}"
SRC_URI[x86_64_v2_kf6-karchive-doc.sha256sum] = "b8e982c49feb27d5e2c5a7218af8cd7d65b59007a562ec3de4f691aa0121e602"

URI_x86_64_v2_kf6-karchive-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-karchive-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-html}"
SRC_URI[x86_64_v2_kf6-karchive-html.sha256sum] = "2b8374d7ac8c869d85bb2411dfd10f0b680b854f7086562cf893b04e35e43726"

URI_aarch64_kf6-karchive = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-karchive;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive}"
SRC_URI[aarch64_kf6-karchive.sha256sum] = "995e7aeccb6d6914c9f5c571f6716f1b7964a8416ddbed5875b4bfec4f6edb7f"

URI_aarch64_kf6-karchive-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-karchive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-devel}"
SRC_URI[aarch64_kf6-karchive-devel.sha256sum] = "ce5c09dbf4a5cd96caa93ab68570f5ab0e43cd947bc4b944deab2bae26fdf7fd"

URI_aarch64_kf6-karchive-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-karchive-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-doc}"
SRC_URI[aarch64_kf6-karchive-doc.sha256sum] = "17b7a0c04e0c40389d83019faf50a29befb13aeb0352953f9f8e613503c09fa1"

URI_aarch64_kf6-karchive-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-karchive-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-html}"
SRC_URI[aarch64_kf6-karchive-html.sha256sum] = "92278f1c2599656630fb4252744a133aa2e2763330e4e502d80d8f7fe6c4903d"

RDEPENDS:kf6-karchive = " \
 bzip2-libs \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libzstd \
 openssl-libs \
 qt6-qtbase \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:kf6-karchive-devel = " \
 cmake-filesystem \
 kf6-karchive \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-karchive-doc = " \
 "
RDEPENDS:kf6-karchive-html = " \
 "
