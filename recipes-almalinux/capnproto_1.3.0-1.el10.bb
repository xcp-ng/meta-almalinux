# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "capnproto"
PV = "1.3.0"
PR = "1.el10"
PACKAGES = " \
 capnproto \
 capnproto-devel \
 capnproto-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/capnproto-1.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b272b7fc1e751b1586212ab0f58318bb7ea6a04d8118207a28c4f53ccb91a485"

URI_x86_64_v2_capnproto = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/capnproto-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_capnproto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capnproto}"
SRC_URI[x86_64_v2_capnproto.sha256sum] = "b0a7f2fcba5a2c6fffe02c972ae4d8edd75839e898e176d1a6c66a0806ed243e"

URI_x86_64_v2_capnproto-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/capnproto-devel-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_capnproto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capnproto-devel}"
SRC_URI[x86_64_v2_capnproto-devel.sha256sum] = "a3440b9b3747b43056b46de68cfb044e39304087c6fed7dae76b064024d492b7"

URI_x86_64_v2_capnproto-libs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/capnproto-libs-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_capnproto-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capnproto-libs}"
SRC_URI[x86_64_v2_capnproto-libs.sha256sum] = "ded06c7116c17cab6c291405e8d19e428431a36eee4426720d0dcd7deddf525b"

URI_aarch64_capnproto = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/capnproto-1.3.0-1.el10.aarch64.rpm;name=aarch64_capnproto;unpack=0"
SRC_URI:append = " ${URI_aarch64_capnproto}"
SRC_URI[aarch64_capnproto.sha256sum] = "ad47ffe591095fad95fce99a3090ca555dfed2e87a59992b0f902b8335e5d15f"

URI_aarch64_capnproto-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/capnproto-devel-1.3.0-1.el10.aarch64.rpm;name=aarch64_capnproto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_capnproto-devel}"
SRC_URI[aarch64_capnproto-devel.sha256sum] = "3c1ac88daf021a20a60202d10bd55451d01a3d0ccf6eafe0c6c3d74f2473c5fe"

URI_aarch64_capnproto-libs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/capnproto-libs-1.3.0-1.el10.aarch64.rpm;name=aarch64_capnproto-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_capnproto-libs}"
SRC_URI[aarch64_capnproto-libs.sha256sum] = "401819db310760a76829a6c722b9d2900970cfc9bd80212b831d41e5e557a35a"

RDEPENDS:capnproto = " \
 capnproto-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:capnproto-devel = " \
 capnproto-libs \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:capnproto-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 "
