# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-pemfile"
PV = "2.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustls-pemfile+default-devel \
 rust-rustls-pemfile+std-devel \
 rust-rustls-pemfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-pemfile-2.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80c9667a2ee31b4b8fcba58a7aeafc314d56d867cb03ded2af687d75bd1dabc4"

URI_x86_64_v2_rust-rustls-pemfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pemfile+default-devel-2.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pemfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pemfile+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-pemfile+default-devel.sha256sum] = "463f680d41b5ce0744bb422fd683e33320069960ccbab3135abd66e8a4f6e499"

URI_x86_64_v2_rust-rustls-pemfile+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pemfile+std-devel-2.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pemfile+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pemfile+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-pemfile+std-devel.sha256sum] = "96374653c79eb2f73a295c42654252b0f566a73b823647f958732628b810b0b7"

URI_x86_64_v2_rust-rustls-pemfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pemfile-devel-2.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pemfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pemfile-devel}"
SRC_URI[x86_64_v2_rust-rustls-pemfile-devel.sha256sum] = "8e0d2ac881825e32f946dad3eebafe1bcad1cc7c337ddcae91d433040e6adab7"

URI_aarch64_rust-rustls-pemfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pemfile+default-devel-2.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-pemfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pemfile+default-devel}"
SRC_URI[aarch64_rust-rustls-pemfile+default-devel.sha256sum] = "3dcd5e5d7ee90ef0e3053f255714fb16ec094742c4bf0af47ec3d5500defb09d"

URI_aarch64_rust-rustls-pemfile+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pemfile+std-devel-2.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-pemfile+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pemfile+std-devel}"
SRC_URI[aarch64_rust-rustls-pemfile+std-devel.sha256sum] = "811297aae2b8a0a86209dc32af17ab6372b9ff5a7f2e2a0e626caccee1101ac8"

URI_aarch64_rust-rustls-pemfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pemfile-devel-2.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-pemfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pemfile-devel}"
SRC_URI[aarch64_rust-rustls-pemfile-devel.sha256sum] = "a451338cd0da0b59382fea9bb5de4d51a9590434c37ab6f719eefb536c613d2e"

RDEPENDS:rust-rustls-pemfile+default-devel = " \
 cargo \
 rust-rustls-pemfile+std-devel \
 rust-rustls-pemfile-devel \
 "
RDEPENDS:rust-rustls-pemfile+std-devel = " \
 cargo \
 rust-rustls-pemfile-devel \
 rust-rustls-pki-types+std-devel \
 "
RDEPENDS:rust-rustls-pemfile-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 "
