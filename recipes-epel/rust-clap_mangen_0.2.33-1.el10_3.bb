# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_mangen"
PV = "0.2.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap_mangen+debug-devel \
 rust-clap_mangen+default-devel \
 rust-clap_mangen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_mangen-0.2.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8350cdbe360b925e1db668e093745e7016a3e471f546778cdf1a5e3b54f4153"

URI_x86_64_v2_rust-clap_mangen+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen+debug-devel-0.2.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen+debug-devel.sha256sum] = "ebd5795dcfb2a64f70094053c591baf22e94d8822096c787f53b7f519dd514d8"

URI_x86_64_v2_rust-clap_mangen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen+default-devel-0.2.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen+default-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen+default-devel.sha256sum] = "e6a617587818a3f94fadc5364000c7609b38915cf31c94aa30484fa62518694a"

URI_x86_64_v2_rust-clap_mangen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen-devel-0.2.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen-devel.sha256sum] = "fb76fc7cfac05fccc7ba174f14db426b831326b9bfd581fb83725c767e40b1bc"

URI_aarch64_rust-clap_mangen+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen+debug-devel-0.2.33-1.el10_3.noarch.rpm;name=aarch64_rust-clap_mangen+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen+debug-devel}"
SRC_URI[aarch64_rust-clap_mangen+debug-devel.sha256sum] = "5975968549b63c3e92923820c26c7ececda48e0f4c90bd1efe46dd8483db0230"

URI_aarch64_rust-clap_mangen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen+default-devel-0.2.33-1.el10_3.noarch.rpm;name=aarch64_rust-clap_mangen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen+default-devel}"
SRC_URI[aarch64_rust-clap_mangen+default-devel.sha256sum] = "26ac670bff54e319cd66b8b0eed689c5a057954103ce4151ddaedaac1537d924"

URI_aarch64_rust-clap_mangen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen-devel-0.2.33-1.el10_3.noarch.rpm;name=aarch64_rust-clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen-devel}"
SRC_URI[aarch64_rust-clap_mangen-devel.sha256sum] = "f2f0d8164000ef75198d1f78e4b9f56061152d9126ca8a57ae73ec008a593a88"

RDEPENDS:rust-clap_mangen+debug-devel = " \
 cargo \
 rust-clap+debug-devel \
 rust-clap_mangen-devel \
 "
RDEPENDS:rust-clap_mangen+default-devel = " \
 cargo \
 rust-clap_mangen-devel \
 "
RDEPENDS:rust-clap_mangen-devel = " \
 cargo \
 rust \
 rust-clap+env-devel \
 rust-clap+std-devel \
 rust-clap-devel \
 rust-roff+default-devel \
 "
