# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocsolver"
PV = "6.4.2"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
 rocsolver \
 rocsolver-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocsolver-6.4.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40c89c688b302a9ed7dd540e5ea00343ad4847aaed2c199938a20d6a0dbdd132"

URI_x86_64_v2_rocsolver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocsolver-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocsolver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocsolver}"
SRC_URI[x86_64_v2_rocsolver.sha256sum] = "1acce57c167229cb358587b4bf38dcdfaef77bd6c1f2eafdb06c9eb44757664b"

URI_x86_64_v2_rocsolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocsolver-devel-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocsolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocsolver-devel}"
SRC_URI[x86_64_v2_rocsolver-devel.sha256sum] = "c0535b051423faa700a7a659cf8d42d19590e0bcb868974b01d1cce60aac8c06"

RDEPENDS:rocsolver = " \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocm-hip \
 "
RDEPENDS:rocsolver-devel = " \
 cmake-filesystem \
 rocsolver \
 "
