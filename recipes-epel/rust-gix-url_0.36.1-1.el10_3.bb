# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-url"
PV = "0.36.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-url+default-devel \
 rust-gix-url+document-features-devel \
 rust-gix-url+serde-devel \
 rust-gix-url-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-url-0.36.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94b3901a61cee68e37ed383c5eef32c1a72b273d52a10fd051ea3965813f6bbd"

URI_x86_64_v2_rust-gix-url+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+default-devel-0.36.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+default-devel}"
SRC_URI[x86_64_v2_rust-gix-url+default-devel.sha256sum] = "ccbecfd05b6389caacf0f6281aaa6de991e1610beff54fa6fcfe496f810a0e36"

URI_x86_64_v2_rust-gix-url+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+document-features-devel-0.36.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-url+document-features-devel.sha256sum] = "74a66dc8f703ba7a84c7e636a271203e524bda7e89fb0c2c0ed50dabd7268c1c"

URI_x86_64_v2_rust-gix-url+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+serde-devel-0.36.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-url+serde-devel.sha256sum] = "557c54bccc57fddb06dcd95d082b110b8e04dffb4884b3f7cd972484a76ce4b2"

URI_x86_64_v2_rust-gix-url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url-devel-0.36.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url-devel}"
SRC_URI[x86_64_v2_rust-gix-url-devel.sha256sum] = "360868336097b99aa3dbf22c3cc38e292786092f9d193937350f485097c498a8"

URI_aarch64_rust-gix-url+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+default-devel-0.36.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+default-devel}"
SRC_URI[aarch64_rust-gix-url+default-devel.sha256sum] = "932576627f072c52abf9f00a82cad861c0190ac04c76f4d7e5d472812f300713"

URI_aarch64_rust-gix-url+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+document-features-devel-0.36.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-url+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+document-features-devel}"
SRC_URI[aarch64_rust-gix-url+document-features-devel.sha256sum] = "ccab194340c85828d1b5cbd8e5291f2e1b8d45f6318d9586208bf60f323444aa"

URI_aarch64_rust-gix-url+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+serde-devel-0.36.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+serde-devel}"
SRC_URI[aarch64_rust-gix-url+serde-devel.sha256sum] = "e93ac258890ea421e13c16a2bb8cdd758fd526f097cae36d1269678aff091f0e"

URI_aarch64_rust-gix-url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url-devel-0.36.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url-devel}"
SRC_URI[aarch64_rust-gix-url-devel.sha256sum] = "5b35ab2688d81035c153ae6da873a2ae9c650fec55cabc9309f2c47e96dd90ea"

RDEPENDS:rust-gix-url+default-devel = " \
 cargo \
 rust-gix-url-devel \
 "
RDEPENDS:rust-gix-url+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-url-devel \
 "
RDEPENDS:rust-gix-url+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-url-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-url-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-path+default-devel \
 rust-percent-encoding+default-devel \
 rust-thiserror+default-devel \
 "
