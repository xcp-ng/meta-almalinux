# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Judy"
PV = "1.0.5"
PR = "38.el10"
PACKAGES = " \
 Judy \
 Judy-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/Judy-1.0.5-38.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7819a0532ca6fe4d23e5397c8cb0880f2c14c3d05a83643743dbd9bbbc115cc"

URI_x86_64_v2_Judy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/Judy-1.0.5-38.el10.x86_64_v2.rpm;name=x86_64_v2_Judy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Judy}"
SRC_URI[x86_64_v2_Judy.sha256sum] = "860fe7c6a748b945c37038454ff7fab7812c95306679e89a9b60b304c3bfe2dd"

URI_x86_64_v2_Judy-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/Judy-devel-1.0.5-38.el10.x86_64_v2.rpm;name=x86_64_v2_Judy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Judy-devel}"
SRC_URI[x86_64_v2_Judy-devel.sha256sum] = "7f01548f4e70e571256d54898649fa63a3dc843094c0008fd3af762874b0e4b3"

URI_aarch64_Judy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/Judy-1.0.5-38.el10.aarch64.rpm;name=aarch64_Judy;unpack=0"
SRC_URI:append = " ${URI_aarch64_Judy}"
SRC_URI[aarch64_Judy.sha256sum] = "aaba368c2e1709126ea60eb672dfcdd15ba9f57ad49567f53eb2144df9d19488"

URI_aarch64_Judy-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/Judy-devel-1.0.5-38.el10.aarch64.rpm;name=aarch64_Judy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_Judy-devel}"
SRC_URI[aarch64_Judy-devel.sha256sum] = "ff584930e04be66d25a805e73e44f7d3bc795ba07fd142ec417c0628770cec7f"

RDEPENDS:Judy = " \
 glibc \
 "
RDEPENDS:Judy-devel = " \
 Judy \
 "
