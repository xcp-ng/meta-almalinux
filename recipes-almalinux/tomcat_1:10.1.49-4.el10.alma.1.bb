# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat"
PE = "1"
PV = "10.1.49"
PR = "4.el10.alma.1"
PACKAGES = " \
 tomcat \
 tomcat-admin-webapps \
 tomcat-docs-webapp \
 tomcat-el-5.0-api \
 tomcat-jsp-3.1-api \
 tomcat-lib \
 tomcat-servlet-6.0-api \
 tomcat-webapps \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tomcat-10.1.49-4.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df44fcf015e224257e5f175d99927abf7762209c94f94bdae0ecbb9a0bd274fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-10.1.49-4.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat;unpack=0"
SRC_URI[x86_64_v2_tomcat.sha256sum] = "0c21db25e8f0718804e566c14b992fd0c23b064e95417e27f52bca42059f7840"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-admin-webapps-10.1.49-4.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat-admin-webapps;unpack=0"
SRC_URI[x86_64_v2_tomcat-admin-webapps.sha256sum] = "22862f9edd817f6ea74723d6395e00390e60c2e6d1c6f9050ffc875630eabb4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-docs-webapp-10.1.49-4.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat-docs-webapp;unpack=0"
SRC_URI[x86_64_v2_tomcat-docs-webapp.sha256sum] = "6c8b08b167e233a80b65eb888e57dd8c40ae2bc5ef4fb4a8620b55aad9c26730"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-el-5.0-api-10.1.49-4.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat-el-5.0-api;unpack=0"
SRC_URI[x86_64_v2_tomcat-el-5.0-api.sha256sum] = "0f7b14e6ce6e5290b982cb0fb9cee66cf62f57277336ec96e0a504668ee5d30f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-jsp-3.1-api-10.1.49-4.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat-jsp-3.1-api;unpack=0"
SRC_URI[x86_64_v2_tomcat-jsp-3.1-api.sha256sum] = "65a0021632082bd4b0cfa4069eb912be6f4f34a455c1848ccef9c86954046197"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-lib-10.1.49-4.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat-lib;unpack=0"
SRC_URI[x86_64_v2_tomcat-lib.sha256sum] = "0d45226b0d9d774564e310f05e635cb009a422f911616c8926c670d8e27ed930"
RPROVIDES:tomcat-lib:append:x86_64_v2 = " virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-juli_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-servlet-6.0-api-10.1.49-4.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat-servlet-6.0-api;unpack=0"
SRC_URI[x86_64_v2_tomcat-servlet-6.0-api.sha256sum] = "aadbbfbb600350139865fd78df308d3129fdb84cb957a8d23940eee446ce8683"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-webapps-10.1.49-4.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat-webapps;unpack=0"
SRC_URI[x86_64_v2_tomcat-webapps.sha256sum] = "36b6c372c5cd773ed8265fe3e3106da34675e6016f68f0235860bb38914f1f67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-10.1.49-4.el10.alma.1.noarch.rpm;name=aarch64_tomcat;unpack=0"
SRC_URI[aarch64_tomcat.sha256sum] = "0c21db25e8f0718804e566c14b992fd0c23b064e95417e27f52bca42059f7840"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-admin-webapps-10.1.49-4.el10.alma.1.noarch.rpm;name=aarch64_tomcat-admin-webapps;unpack=0"
SRC_URI[aarch64_tomcat-admin-webapps.sha256sum] = "22862f9edd817f6ea74723d6395e00390e60c2e6d1c6f9050ffc875630eabb4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-docs-webapp-10.1.49-4.el10.alma.1.noarch.rpm;name=aarch64_tomcat-docs-webapp;unpack=0"
SRC_URI[aarch64_tomcat-docs-webapp.sha256sum] = "6c8b08b167e233a80b65eb888e57dd8c40ae2bc5ef4fb4a8620b55aad9c26730"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-el-5.0-api-10.1.49-4.el10.alma.1.noarch.rpm;name=aarch64_tomcat-el-5.0-api;unpack=0"
SRC_URI[aarch64_tomcat-el-5.0-api.sha256sum] = "0f7b14e6ce6e5290b982cb0fb9cee66cf62f57277336ec96e0a504668ee5d30f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-jsp-3.1-api-10.1.49-4.el10.alma.1.noarch.rpm;name=aarch64_tomcat-jsp-3.1-api;unpack=0"
SRC_URI[aarch64_tomcat-jsp-3.1-api.sha256sum] = "65a0021632082bd4b0cfa4069eb912be6f4f34a455c1848ccef9c86954046197"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-lib-10.1.49-4.el10.alma.1.noarch.rpm;name=aarch64_tomcat-lib;unpack=0"
SRC_URI[aarch64_tomcat-lib.sha256sum] = "0d45226b0d9d774564e310f05e635cb009a422f911616c8926c670d8e27ed930"
RPROVIDES:tomcat-lib:append:aarch64 = " virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-juli_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-servlet-6.0-api-10.1.49-4.el10.alma.1.noarch.rpm;name=aarch64_tomcat-servlet-6.0-api;unpack=0"
SRC_URI[aarch64_tomcat-servlet-6.0-api.sha256sum] = "aadbbfbb600350139865fd78df308d3129fdb84cb957a8d23940eee446ce8683"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-webapps-10.1.49-4.el10.alma.1.noarch.rpm;name=aarch64_tomcat-webapps;unpack=0"
SRC_URI[aarch64_tomcat-webapps.sha256sum] = "36b6c372c5cd773ed8265fe3e3106da34675e6016f68f0235860bb38914f1f67"

RDEPENDS:tomcat = " \
 bash \
 javapackages-tools \
 shadow-utils \
 systemd \
 tomcat-lib \
 virtual/java-headless_or_java-25-headless \
 "
RDEPENDS:tomcat-admin-webapps = " \
 tomcat \
 "
RDEPENDS:tomcat-docs-webapp = " \
 tomcat \
 "
RDEPENDS:tomcat-el-5.0-api = " \
 javapackages-filesystem \
 "
RDEPENDS:tomcat-jsp-3.1-api = " \
 javapackages-filesystem \
 tomcat-el-5.0-api \
 tomcat-servlet-6.0-api \
 "
RDEPENDS:tomcat-lib = " \
 ecj \
 javapackages-filesystem \
 tomcat-el-5.0-api \
 tomcat-jsp-3.1-api \
 tomcat-servlet-6.0-api \
 virtual/coreutils \
 "
RDEPENDS:tomcat-servlet-6.0-api = " \
 javapackages-filesystem \
 "
RDEPENDS:tomcat-webapps = " \
 tomcat \
 "
