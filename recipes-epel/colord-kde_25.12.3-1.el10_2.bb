# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colord-kde"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 colord-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/colord-kde-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f4b00de5fc957f80bc0fb56f49ef83b92c23df1c69a489b17dc65ef4a333157"

URI_x86_64_v2_colord-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/colord-kde-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_colord-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord-kde}"
SRC_URI[x86_64_v2_colord-kde.sha256sum] = "58b4ad274dcfa6f9d9dc6fbd559c46884fb5e69e4dd5df87575f1bd4661dd055"

URI_aarch64_colord-kde = "${EPEL_MIRROR}/aarch64/Packages/c/colord-kde-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_colord-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord-kde}"
SRC_URI[aarch64_colord-kde.sha256sum] = "b52942797b8c192165d3b6ba3f5c3fb4bf628185a672937a963f0eeaf891cf8d"

RDEPENDS:colord-kde = " \
 colord \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami-addons \
 kf6-kwidgetsaddons \
 lcms2 \
 libX11 \
 libXrandr \
 libstdc++ \
 plasma-systemsettings \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
