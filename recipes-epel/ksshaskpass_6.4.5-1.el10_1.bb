# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksshaskpass"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 ksshaskpass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksshaskpass-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34bd30c3cd7d1c700fb9d5db248fe5d6a7229714e1e8fe201a742de63de91390"

URI_x86_64_v2_ksshaskpass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksshaskpass-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksshaskpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksshaskpass}"
SRC_URI[x86_64_v2_ksshaskpass.sha256sum] = "75a96d57f9932da592ccc8c695fff804bfb1c8f99c72cfb29123a54e501bfc90"

URI_aarch64_ksshaskpass = "${EPEL_MIRROR}/aarch64/Packages/k/ksshaskpass-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_ksshaskpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksshaskpass}"
SRC_URI[aarch64_ksshaskpass.sha256sum] = "237a4b965510a59319b49a09d2c3dd148cb5307f268123a3f6fd719ae8ac20b7"

RDEPENDS:ksshaskpass = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
