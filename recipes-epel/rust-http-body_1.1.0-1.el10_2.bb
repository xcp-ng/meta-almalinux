# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-body"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-http-body+default-devel \
 rust-http-body-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-body-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d33fe1df537450564cb75967afeecbafd47d70b93f240cbd549fc94e9eea0b04"

URI_x86_64_v2_rust-http-body+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body+default-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body+default-devel}"
SRC_URI[x86_64_v2_rust-http-body+default-devel.sha256sum] = "1130fccbf1a31f9a8c6eb3615715f784a237767fe00cad53d345e948b4b3f8f1"

URI_x86_64_v2_rust-http-body-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-body-devel}"
SRC_URI[x86_64_v2_rust-http-body-devel.sha256sum] = "3c8c032bed4bf12b5752945a6ee1c75f0d337f5aa6e48e0cb67377614406e71a"

URI_aarch64_rust-http-body+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body+default-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-http-body+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body+default-devel}"
SRC_URI[aarch64_rust-http-body+default-devel.sha256sum] = "f7de1e8df9cd2c4a40d1e3f5ebdfb4d5b6a50bc131b6986c4184164ebaaf9038"

URI_aarch64_rust-http-body-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-http-body-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-body-devel}"
SRC_URI[aarch64_rust-http-body-devel.sha256sum] = "eb6b5ccb2b8b1a8a1803e815109dd272a0d589eadc5da16f22c08c1ce847f56c"

RDEPENDS:rust-http-body+default-devel = " \
 cargo \
 rust-http-body-devel \
 "
RDEPENDS:rust-http-body-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 "
