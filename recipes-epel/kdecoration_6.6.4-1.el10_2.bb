# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdecoration"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kdecoration \
 kdecoration-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdecoration-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "242aca94babae76e5595c2b3d01c3c12e62940f6c7c025df9752d1d0307397c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdecoration-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdecoration;unpack=0"
SRC_URI[x86_64_v2_kdecoration.sha256sum] = "0f94029ef3d45789b797db974e113bf55da7b280cc802c8c4d85e0198253db6a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdecoration-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdecoration-devel;unpack=0"
SRC_URI[x86_64_v2_kdecoration-devel.sha256sum] = "f857dce97caa96309801d316446cd1eec8cc04f79d98202bd004a5e5536e5d61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdecoration-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kdecoration;unpack=0"
SRC_URI[aarch64_kdecoration.sha256sum] = "8ba7036b03830e630bc5e89a86a2d7de10c47e553a7737ce7509e124dd5b230a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdecoration-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kdecoration-devel;unpack=0"
SRC_URI[aarch64_kdecoration-devel.sha256sum] = "766aaad3be7136b06e5661a17fc006e8cc518d2ca0a44bb2e077281650d2d8b3"

RDEPENDS:kdecoration = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kdecoration-devel = " \
 cmake-filesystem \
 kdecoration \
 "
