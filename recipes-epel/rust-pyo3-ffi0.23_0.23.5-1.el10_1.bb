# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi0.23"
PV = "0.23.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-ffi0.23+abi3-devel \
 rust-pyo3-ffi0.23+abi3-py310-devel \
 rust-pyo3-ffi0.23+abi3-py311-devel \
 rust-pyo3-ffi0.23+abi3-py312-devel \
 rust-pyo3-ffi0.23+abi3-py37-devel \
 rust-pyo3-ffi0.23+abi3-py38-devel \
 rust-pyo3-ffi0.23+abi3-py39-devel \
 rust-pyo3-ffi0.23+default-devel \
 rust-pyo3-ffi0.23+extension-module-devel \
 rust-pyo3-ffi0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi0.23-0.23.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95b2c3cd8f1746cd82a362151abaeae9bc87371efd1ad130875ade1cae6060cc"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-devel.sha256sum] = "4641f6526f06cbecab8950ef647ed3d762b4529ec5850b3c7ea723a6d0b808aa"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py310-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py310-devel.sha256sum] = "d72f86eebb22f67d5eb295f9757e2169acdc81dc8ab6248bb2e98b2f36103f19"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py311-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py311-devel.sha256sum] = "b5251597b73d2bd2cb57a750eddd0bec7482fbf5835e3e1436a51d18e6e0b86c"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py312-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py312-devel.sha256sum] = "14e9d7f3a69bbb9472b652ac818e58835375a175ee797c2e6588ba16499ac273"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py37-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py37-devel.sha256sum] = "8bd35def3a614211982fc371fde4f87d7cf1af58800f39e20c763da14956c7a1"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py38-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py38-devel.sha256sum] = "7e1e5f1d4ceb1b93f5371725417196427686231e144288f51220d3985404ef4a"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py39-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py39-devel.sha256sum] = "d632c0af43531d1c5fea8fa019708db421167a0e6b992d330d9bf23db8e5625e"

URI_x86_64_v2_rust-pyo3-ffi0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+default-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+default-devel.sha256sum] = "16d4c4c7f4c0b099015d45b4aa0caef41d488b3b61968e9c0d3608d1c414cdd7"

URI_x86_64_v2_rust-pyo3-ffi0.23+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+extension-module-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+extension-module-devel.sha256sum] = "69c2530cd9213882ac51e838b76f96019a6f014082794a5a1e8b7c7ed1f3091b"

URI_x86_64_v2_rust-pyo3-ffi0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23-devel.sha256sum] = "c9d4c5fc5081164c2466c82006a2c721e4880fde850ffe045b58f82894e7a1d8"

URI_aarch64_rust-pyo3-ffi0.23+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-devel.sha256sum] = "8c1031b3455effa621b474b2c0924bc3dcb7fd4bdc3acd88d9cc657e04575d73"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py310-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py310-devel.sha256sum] = "e559723d38f79fe0cfafe8696bd0658dd163d25561d9b98c7f597ae0c0544231"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py311-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py311-devel.sha256sum] = "418c5d48313f37d018fcac80cef97ec39862ad52a4ee70b1ffaaaac7056b78a9"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py312-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py312-devel.sha256sum] = "afbe03e6d4eae2eabbf03e4b6f8f9e8e8ee6e281491bcc2e0cca7427e72df441"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py37-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py37-devel.sha256sum] = "748513c503bbcee9ba34acd2ce79448ec07d957449367a1183bdedb39b440d9d"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py38-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py38-devel.sha256sum] = "10031ace678430773385106ea18131db8bc334190ff57f06a94d1274a9cadfdb"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py39-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py39-devel.sha256sum] = "60428f757070240443486105fd9a8718cd5c3b6f95eab740727c18292edbad5a"

URI_aarch64_rust-pyo3-ffi0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+default-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+default-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+default-devel.sha256sum] = "0a070a65668a60aee6ca9e2f73f19b74f826ef8ed33f4029fc1212cc1e85b843"

URI_aarch64_rust-pyo3-ffi0.23+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+extension-module-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+extension-module-devel.sha256sum] = "0005a15e94c65ff5dd34dd0b1be7c2677fceb36fd22d33cf27f0760f2b97a83c"

URI_aarch64_rust-pyo3-ffi0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23-devel.sha256sum] = "ab08444ad37d756f9390eba25303ddf4228a4ec475a637608a21fe715bc9bc5e"

RDEPENDS:rust-pyo3-ffi0.23+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py311-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py312-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py38-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py39-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py310-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+default-devel = " \
 cargo \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23-devel = " \
 cargo \
 python3-devel \
 rust \
 rust-libc+default-devel \
 rust-pyo3-build-config0.23+default-devel \
 rust-pyo3-build-config0.23+resolve-config-devel \
 "
