# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ascii"
PV = "3.32"
PR = "1.el10_3"
PACKAGES = " \
 ascii \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ascii-3.32-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05b7d90cfa4ca20842604cfa92affe2f7a3b26999d4c4f88d2a985af32844a94"

URI_x86_64_v2_ascii = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ascii-3.32-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ascii;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ascii}"
SRC_URI[x86_64_v2_ascii.sha256sum] = "6139137bbfa2368f3acae77c3830726bd951b99bdc906c688a5980888bd271bb"

URI_aarch64_ascii = "${EPEL_MIRROR}/aarch64/Packages/a/ascii-3.32-1.el10_3.aarch64.rpm;name=aarch64_ascii;unpack=0"
SRC_URI:append = " ${URI_aarch64_ascii}"
SRC_URI[aarch64_ascii.sha256sum] = "bbc2286d3995bba253f713b07e2e217ddbfd13d33f6894931e2a8c357bcfdc04"

RDEPENDS:ascii = " \
 glibc \
 "
