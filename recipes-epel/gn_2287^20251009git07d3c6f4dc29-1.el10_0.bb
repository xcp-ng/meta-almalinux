# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gn"
PV = "2287^20251009git07d3c6f4dc29"
PR = "1.el10_0"
PACKAGES = " \
 gn \
 gn-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gn-2287^20251009git07d3c6f4dc29-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a91da07988653848240535f37c61d6ca8200c9dd177c7160ce55066ebc797b4"

URI_x86_64_v2_gn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-2287^20251009git07d3c6f4dc29-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gn}"
SRC_URI[x86_64_v2_gn.sha256sum] = "f0a73c13ff0594a2733fcaae8d690d20722a9a4bec190af544e58d44c58cc9d2"

URI_x86_64_v2_gn-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-doc-2287^20251009git07d3c6f4dc29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gn-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gn-doc}"
SRC_URI[x86_64_v2_gn-doc.sha256sum] = "bd578edff13a20d36dc2582bfe936888d374e267129a82953dcead461c9ee07e"

URI_aarch64_gn = "${EPEL_MIRROR}/aarch64/Packages/g/gn-2287^20251009git07d3c6f4dc29-1.el10_0.aarch64.rpm;name=aarch64_gn;unpack=0"
SRC_URI:append = " ${URI_aarch64_gn}"
SRC_URI[aarch64_gn.sha256sum] = "fdc34c85dc3cddd4a60b8f43716c391c247d7ea8643d6fcb00265e1721503857"

URI_aarch64_gn-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gn-doc-2287^20251009git07d3c6f4dc29-1.el10_0.noarch.rpm;name=aarch64_gn-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gn-doc}"
SRC_URI[aarch64_gn-doc.sha256sum] = "38111b6fb3a1de8687551926f526c83b20408af18379219e1fc0aa88dfef7362"

RDEPENDS:gn = " \
 emacs-filesystem \
 glibc \
 libstdc++ \
 python3 \
 vim-filesystem \
 "
RDEPENDS:gn-doc = " \
 "
