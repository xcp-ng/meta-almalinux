# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "serd"
PV = "0.32.4"
PR = "1.el10_0"
PACKAGES = " \
 serd \
 serd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/serd-0.32.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "935e98e88214112144900d257fb3a0ef79ccbc7e2b04e093c76381d351b1dfbc"

URI_x86_64_v2_serd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/serd-0.32.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_serd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_serd}"
SRC_URI[x86_64_v2_serd.sha256sum] = "0288a01457f5086fe789f1dd876c15b7d8e87a56d10593a21b539fa29c95af76"

URI_x86_64_v2_serd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/serd-devel-0.32.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_serd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_serd-devel}"
SRC_URI[x86_64_v2_serd-devel.sha256sum] = "3bbb7a13d9a7e0373c2de64f40b95d415c865419e7a574fce42d92b6acd07473"

URI_aarch64_serd = "${EPEL_MIRROR}/aarch64/Packages/s/serd-0.32.4-1.el10_0.aarch64.rpm;name=aarch64_serd;unpack=0"
SRC_URI:append = " ${URI_aarch64_serd}"
SRC_URI[aarch64_serd.sha256sum] = "e920a52328585b63f52ac62c5eb3a13290cae185869602db16491a0fc5cb0cf6"

URI_aarch64_serd-devel = "${EPEL_MIRROR}/aarch64/Packages/s/serd-devel-0.32.4-1.el10_0.aarch64.rpm;name=aarch64_serd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_serd-devel}"
SRC_URI[aarch64_serd-devel.sha256sum] = "d6be9cd872c6a16484a18aff3548744478e8505ade8d568a73431aa3352ea070"

RDEPENDS:serd = " \
 glibc \
 "
RDEPENDS:serd-devel = " \
 pkgconf-pkg-config \
 serd \
 "
