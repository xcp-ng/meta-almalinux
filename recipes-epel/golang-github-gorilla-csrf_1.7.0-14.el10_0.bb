# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gorilla-csrf"
PV = "1.7.0"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-gorilla-csrf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gorilla-csrf-1.7.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92201cceda90e61f9fd91af5d1372a130c32cb255407f7f308c7741460ee3e70"

URI_x86_64_v2_golang-github-gorilla-csrf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gorilla-csrf-devel-1.7.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gorilla-csrf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gorilla-csrf-devel}"
SRC_URI[x86_64_v2_golang-github-gorilla-csrf-devel.sha256sum] = "55a53b986e36ec5c0840c7e4d7440e9ba9bd4cb3f5e2f087c7c5fe918f5ba947"

URI_aarch64_golang-github-gorilla-csrf-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gorilla-csrf-devel-1.7.0-14.el10_0.noarch.rpm;name=aarch64_golang-github-gorilla-csrf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gorilla-csrf-devel}"
SRC_URI[aarch64_golang-github-gorilla-csrf-devel.sha256sum] = "aae449211eb55743f6f4cc04f3559f7b61e157861aa2beb54528bad6871f3559"

RDEPENDS:golang-github-gorilla-csrf-devel = " \
 go-filesystem \
 golang-github-gorilla-securecookie-devel \
 golang-github-pkg-errors-devel \
 "
