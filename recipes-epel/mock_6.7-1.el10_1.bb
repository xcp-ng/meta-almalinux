# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mock"
PV = "6.7"
PR = "1.el10_1"
PACKAGES = " \
 mock \
 mock-filesystem \
 mock-lvm \
 mock-rpmautospec \
 mock-scm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mock-6.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14cf775e91f4ca6cca2bd68022108a8f7f33025e73a7c7d0aed52644645e74ae"

URI_x86_64_v2_mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-6.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock}"
SRC_URI[x86_64_v2_mock.sha256sum] = "918ab44b942e913ec553e3517a481de644e1d312fb7443805f314036799a866e"

URI_x86_64_v2_mock-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-filesystem-6.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mock-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-filesystem}"
SRC_URI[x86_64_v2_mock-filesystem.sha256sum] = "45e97e15d70484ca6670b3340d2261bcf84ac8809da8429dbaf537c603b4e0bf"

URI_x86_64_v2_mock-lvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-lvm-6.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mock-lvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-lvm}"
SRC_URI[x86_64_v2_mock-lvm.sha256sum] = "7e95b9b0672998e70f2c7c6a9064ca7dd733c2fc481c11877afcb913a3d69932"

URI_x86_64_v2_mock-rpmautospec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-rpmautospec-6.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mock-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-rpmautospec}"
SRC_URI[x86_64_v2_mock-rpmautospec.sha256sum] = "b32c05dd159a7fbbe2f46de6348de369c1c4a2a8890d05658571804ed90e76ca"

URI_x86_64_v2_mock-scm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-scm-6.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mock-scm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-scm}"
SRC_URI[x86_64_v2_mock-scm.sha256sum] = "a00c36d674e8fec950adabfa334077df691b2d602939de7dcb0541d43a7d9479"

URI_aarch64_mock = "${EPEL_MIRROR}/aarch64/Packages/m/mock-6.7-1.el10_1.noarch.rpm;name=aarch64_mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock}"
SRC_URI[aarch64_mock.sha256sum] = "7edcff7a9ff3eca87caf1a9f481134adee3d81eb61916e3091326886c6cf3512"

URI_aarch64_mock-filesystem = "${EPEL_MIRROR}/aarch64/Packages/m/mock-filesystem-6.7-1.el10_1.noarch.rpm;name=aarch64_mock-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-filesystem}"
SRC_URI[aarch64_mock-filesystem.sha256sum] = "dcfc84aa2a6d3e3c5fa41c1d258673d6168e0a08013dc742abb6bc063e58835e"

URI_aarch64_mock-lvm = "${EPEL_MIRROR}/aarch64/Packages/m/mock-lvm-6.7-1.el10_1.noarch.rpm;name=aarch64_mock-lvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-lvm}"
SRC_URI[aarch64_mock-lvm.sha256sum] = "9e0ab95715be7d44f1c2225b7c54ee2a0e3846a8ddb02706fe5c67f820010aec"

URI_aarch64_mock-rpmautospec = "${EPEL_MIRROR}/aarch64/Packages/m/mock-rpmautospec-6.7-1.el10_1.noarch.rpm;name=aarch64_mock-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-rpmautospec}"
SRC_URI[aarch64_mock-rpmautospec.sha256sum] = "796063cdf1255590f6633eeb26f2a6b8453ab7b3c25efc417d9e36a5ac6e42d0"

URI_aarch64_mock-scm = "${EPEL_MIRROR}/aarch64/Packages/m/mock-scm-6.7-1.el10_1.noarch.rpm;name=aarch64_mock-scm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-scm}"
SRC_URI[aarch64_mock-scm.sha256sum] = "6b45a16c0041dce643ab374857fdc0f2d0d0a6b7f5577f28b39abbf5f9783fa9"

RDEPENDS:mock = " \
 bash \
 createrepo_c \
 mock-core-configs \
 mock-filesystem \
 pigz \
 procps-ng \
 python3 \
 python3-backoff \
 python3-distro \
 python3-jinja2 \
 python3-pyroute2 \
 python3-requests \
 python3-rpm \
 python3-templated-dictionary \
 shadow-utils \
 systemd \
 systemd-container \
 tar \
 usermode \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:mock-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:mock-lvm = " \
 lvm2 \
 mock \
 python3 \
 "
RDEPENDS:mock-rpmautospec = " \
 mock \
 python3 \
 python3-rpmautospec-core \
 "
RDEPENDS:mock-scm = " \
 mock \
 python3 \
 "
