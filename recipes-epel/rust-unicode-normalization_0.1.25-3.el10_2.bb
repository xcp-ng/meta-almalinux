# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-normalization"
PV = "0.1.25"
PR = "3.el10_2"
PACKAGES = " \
 rust-unicode-normalization+default-devel \
 rust-unicode-normalization+std-devel \
 rust-unicode-normalization-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-normalization-0.1.25-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69d47974f8f72696ff54d727dfed51a52046ca4d4ae56c38314c2a4b60778609"

URI_x86_64_v2_rust-unicode-normalization+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-normalization+default-devel-0.1.25-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-normalization+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-normalization+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-normalization+default-devel.sha256sum] = "cbaade7ef89aa9e8ed68c5e4507e2e55c09dff37867dc95c2e9fc02c6df9f217"

URI_x86_64_v2_rust-unicode-normalization+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-normalization+std-devel-0.1.25-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-normalization+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-normalization+std-devel}"
SRC_URI[x86_64_v2_rust-unicode-normalization+std-devel.sha256sum] = "762eeeb115ff279e4e394c1cfe1d64c939089dff6c23aa4dbf38bbb39fa274b7"

URI_x86_64_v2_rust-unicode-normalization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-normalization-devel-0.1.25-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-normalization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-normalization-devel}"
SRC_URI[x86_64_v2_rust-unicode-normalization-devel.sha256sum] = "e59b55f4cf41af7c4dcb47b20113c42446692357980b3b8ec8989f89cfc7b79d"

URI_aarch64_rust-unicode-normalization+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-normalization+default-devel-0.1.25-3.el10_2.noarch.rpm;name=aarch64_rust-unicode-normalization+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-normalization+default-devel}"
SRC_URI[aarch64_rust-unicode-normalization+default-devel.sha256sum] = "1e59f72c542ff647af32758aec41a07975b827fdac06a642f1e3232fd8fe61bb"

URI_aarch64_rust-unicode-normalization+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-normalization+std-devel-0.1.25-3.el10_2.noarch.rpm;name=aarch64_rust-unicode-normalization+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-normalization+std-devel}"
SRC_URI[aarch64_rust-unicode-normalization+std-devel.sha256sum] = "872469eae336a5600bd47c93043576c8996f611c2eedb90d9ff02c165cd19663"

URI_aarch64_rust-unicode-normalization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-normalization-devel-0.1.25-3.el10_2.noarch.rpm;name=aarch64_rust-unicode-normalization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-normalization-devel}"
SRC_URI[aarch64_rust-unicode-normalization-devel.sha256sum] = "92764b1608c67c58ad53402aa7301d8d42e74377f21081d17b22ea76fe6e625e"

RDEPENDS:rust-unicode-normalization+default-devel = " \
 cargo \
 rust-unicode-normalization+std-devel \
 rust-unicode-normalization-devel \
 "
RDEPENDS:rust-unicode-normalization+std-devel = " \
 cargo \
 rust-unicode-normalization-devel \
 "
RDEPENDS:rust-unicode-normalization-devel = " \
 cargo \
 rust \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 "
