# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "proftpd"
PV = "1.3.9c"
PR = "4.el10_3"
PACKAGES = " \
 proftpd \
 proftpd-devel \
 proftpd-ldap \
 proftpd-mysql \
 proftpd-postgresql \
 proftpd-proxy \
 proftpd-sqlite \
 proftpd-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/proftpd-1.3.9c-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f20bb24292de2d4f300302e3272a2076c12db672e7f83d496aed94c29c6ce1f4"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - proftpd-devel: libcap-devel
# - proftpd: libcap.so.2()(64bit)

URI_x86_64_v2_proftpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-1.3.9c-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd}"
SRC_URI[x86_64_v2_proftpd.sha256sum] = "f03a503889d5823f300adc380c0f0d5645d222c7d82f199ff7e329cc03532c00"

URI_x86_64_v2_proftpd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-devel-1.3.9c-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-devel}"
SRC_URI[x86_64_v2_proftpd-devel.sha256sum] = "93c88c64d5e1e7560baca3b8f144271f9dae5531d25ae271bb4e751b12e0274c"

URI_x86_64_v2_proftpd-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-ldap-1.3.9c-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-ldap}"
SRC_URI[x86_64_v2_proftpd-ldap.sha256sum] = "d52e77bfd06e85c6a82fbe83cf55796dc063b6261e350866f3708cc6b2b517bc"

URI_x86_64_v2_proftpd-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-mysql-1.3.9c-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-mysql}"
SRC_URI[x86_64_v2_proftpd-mysql.sha256sum] = "1651dba869e50383ac0c3bab89e4f9c2927e323a6780cb39681b0133ac2d560a"

URI_x86_64_v2_proftpd-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-postgresql-1.3.9c-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-postgresql}"
SRC_URI[x86_64_v2_proftpd-postgresql.sha256sum] = "68879216092fc030411be64fb52e2958c0585977874153fa81e18b875d22e412"

URI_x86_64_v2_proftpd-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-proxy-1.3.9c-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-proxy}"
SRC_URI[x86_64_v2_proftpd-proxy.sha256sum] = "e96f5d665fda362f022f6b771cfb04f9a3de88d13c508a899f20a5e7f23d469d"

URI_x86_64_v2_proftpd-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-sqlite-1.3.9c-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-sqlite}"
SRC_URI[x86_64_v2_proftpd-sqlite.sha256sum] = "4d8f961d75c91eca74ada8b08a6422fa649234cd8279029b5678f04fd5dbc60c"

URI_x86_64_v2_proftpd-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-utils-1.3.9c-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-utils}"
SRC_URI[x86_64_v2_proftpd-utils.sha256sum] = "dbdebe6388a16bdeed72e6840ac19520e7dade4a7f0828af910c8deae3830325"

URI_aarch64_proftpd = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-1.3.9c-4.el10_3.aarch64.rpm;name=aarch64_proftpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd}"
SRC_URI[aarch64_proftpd.sha256sum] = "39f2c2df343daccce05186c2801254e418b94cd59fdfaf7a130abfe0fbe98ab4"

URI_aarch64_proftpd-devel = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-devel-1.3.9c-4.el10_3.aarch64.rpm;name=aarch64_proftpd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-devel}"
SRC_URI[aarch64_proftpd-devel.sha256sum] = "04eca4bbe7a192cb7845969404c57a6ddbd3ba67a0d77395f66698a8e03e8064"

URI_aarch64_proftpd-ldap = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-ldap-1.3.9c-4.el10_3.aarch64.rpm;name=aarch64_proftpd-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-ldap}"
SRC_URI[aarch64_proftpd-ldap.sha256sum] = "2b411305456a4fc443d8a36efd0129b059aa9275cb7703329c023289ad009274"

URI_aarch64_proftpd-mysql = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-mysql-1.3.9c-4.el10_3.aarch64.rpm;name=aarch64_proftpd-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-mysql}"
SRC_URI[aarch64_proftpd-mysql.sha256sum] = "bfa85d38521e87b535fc9c375b29664f278144de0f2897d25dae149f9a9a70f7"

URI_aarch64_proftpd-postgresql = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-postgresql-1.3.9c-4.el10_3.aarch64.rpm;name=aarch64_proftpd-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-postgresql}"
SRC_URI[aarch64_proftpd-postgresql.sha256sum] = "a65f4f872c3c99679d75d3769feac4dd2a26c2d4c37b13c6ca6f60e062235549"

URI_aarch64_proftpd-proxy = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-proxy-1.3.9c-4.el10_3.aarch64.rpm;name=aarch64_proftpd-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-proxy}"
SRC_URI[aarch64_proftpd-proxy.sha256sum] = "88da917b41c032673b694838dfd51d2029530ed9eccd8aee22d72ca34a07c7a0"

URI_aarch64_proftpd-sqlite = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-sqlite-1.3.9c-4.el10_3.aarch64.rpm;name=aarch64_proftpd-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-sqlite}"
SRC_URI[aarch64_proftpd-sqlite.sha256sum] = "3e06888b5b31cea57567cbd7abc59cba60c5822f5c288bf8a860d655ecc65002"

URI_aarch64_proftpd-utils = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-utils-1.3.9c-4.el10_3.aarch64.rpm;name=aarch64_proftpd-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-utils}"
SRC_URI[aarch64_proftpd-utils.sha256sum] = "743826397e7f6ae345fb096edf906dbbccf9a05e34cd1caaca8abf2ece217ff1"

RDEPENDS:proftpd:x86_64_v2 = " \
 bash \
 findutils \
 glibc \
 libacl \
 libcap \
 libidn2 \
 libmemcached-awesome \
 libsodium \
 libxcrypt \
 logrotate \
 openssl-libs \
 pam-libs \
 pcre2 \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:proftpd:aarch64 = " \
 bash \
 findutils \
 glibc \
 libacl \
 libidn2 \
 libmemcached-awesome \
 libsodium \
 libxcrypt \
 logrotate \
 openssl-libs \
 pam-libs \
 pcre2 \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:proftpd-devel:x86_64_v2 = " \
 gcc \
 libacl-devel \
 libcap-devel \
 libmemcached-awesome-devel \
 libpq-devel \
 libsodium-devel \
 mariadb-connector-c-devel \
 ncurses-devel \
 openldap-devel \
 openssl-devel \
 pam-devel \
 pcre2-devel \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 proftpd \
 sqlite-devel \
 zlib-ng-compat-devel \
"
RDEPENDS:proftpd-devel:aarch64 = " \
 gcc \
 libacl-devel \
 libmemcached-awesome-devel \
 libpq-devel \
 libsodium-devel \
 mariadb-connector-c-devel \
 ncurses-devel \
 openldap-devel \
 openssl-devel \
 pam-devel \
 pcre2-devel \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 proftpd \
 sqlite-devel \
 zlib-ng-compat-devel \
"
RDEPENDS:proftpd-ldap = " \
 glibc \
 libidn2 \
 libsodium \
 openldap \
 proftpd \
 "
RDEPENDS:proftpd-mysql = " \
 glibc \
 libidn2 \
 libsodium \
 mariadb-connector-c \
 proftpd \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-postgresql = " \
 glibc \
 libidn2 \
 libpq \
 libsodium \
 proftpd \
 "
RDEPENDS:proftpd-proxy = " \
 glibc \
 libidn2 \
 libsodium \
 openssl-libs \
 proftpd \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-sqlite = " \
 glibc \
 libidn2 \
 libsodium \
 proftpd \
 sqlite-libs \
 "
RDEPENDS:proftpd-utils = " \
 glibc \
 ncurses-libs \
 perl-Crypt-Cracklib \
 perl-Fcntl \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-MIME-Base64 \
 perl-Mail-Sendmail \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 proftpd \
 "
