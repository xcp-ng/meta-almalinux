# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-oxipng"
PV = "9.1.5"
PR = "1.el10_1"
PACKAGES = " \
 oxipng \
 rust-oxipng+binary-devel \
 rust-oxipng+default-devel \
 rust-oxipng+filetime-devel \
 rust-oxipng+freestanding-devel \
 rust-oxipng+parallel-devel \
 rust-oxipng+sanity-checks-devel \
 rust-oxipng+system-libdeflate-devel \
 rust-oxipng+zopfli-devel \
 rust-oxipng-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-oxipng-9.1.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b47e7ae59b03196022780271efb276258b9c8cd55b957b0e8e83ebd3724b2eb"

URI_x86_64_v2_oxipng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxipng-9.1.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oxipng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxipng}"
SRC_URI[x86_64_v2_oxipng.sha256sum] = "c7ecfa807d7692c950c6e0ed1aebf3c0f57cd3136325935ff2374d8df1c0fd82"

URI_x86_64_v2_rust-oxipng+binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+binary-devel-9.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+binary-devel}"
SRC_URI[x86_64_v2_rust-oxipng+binary-devel.sha256sum] = "dcb9a6437f70ffa2ae71c2561399e331c395ba15ccae750404c789854066be56"

URI_x86_64_v2_rust-oxipng+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+default-devel-9.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+default-devel}"
SRC_URI[x86_64_v2_rust-oxipng+default-devel.sha256sum] = "e36bd51a1e39766b4dca9b2c9318efb02d8e0c8f593822775a5ce4bd63a81b22"

URI_x86_64_v2_rust-oxipng+filetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+filetime-devel-9.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+filetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+filetime-devel}"
SRC_URI[x86_64_v2_rust-oxipng+filetime-devel.sha256sum] = "733df67aa80b2f22d19d6cf2684739028b3bdd4449f20413a1125379a2c07bb0"

URI_x86_64_v2_rust-oxipng+freestanding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+freestanding-devel-9.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+freestanding-devel}"
SRC_URI[x86_64_v2_rust-oxipng+freestanding-devel.sha256sum] = "801ed28239230c2846e5d6af9208fbd0d928c981f5be96c470eed89fa146af64"

URI_x86_64_v2_rust-oxipng+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+parallel-devel-9.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+parallel-devel}"
SRC_URI[x86_64_v2_rust-oxipng+parallel-devel.sha256sum] = "2e06f119bfa369ed644b2b137918f13461be1c115369f7283ea6c07017fb1727"

URI_x86_64_v2_rust-oxipng+sanity-checks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+sanity-checks-devel-9.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+sanity-checks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+sanity-checks-devel}"
SRC_URI[x86_64_v2_rust-oxipng+sanity-checks-devel.sha256sum] = "17b3c784d83b7d242d09107d43c7e97d4afb502d14fb6c655446694135b77fa8"

URI_x86_64_v2_rust-oxipng+system-libdeflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+system-libdeflate-devel-9.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+system-libdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+system-libdeflate-devel}"
SRC_URI[x86_64_v2_rust-oxipng+system-libdeflate-devel.sha256sum] = "15cecc9783f489acd06f0332e7fba78d0da731669a20f7b59ddf691e1082b387"

URI_x86_64_v2_rust-oxipng+zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng+zopfli-devel-9.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng+zopfli-devel}"
SRC_URI[x86_64_v2_rust-oxipng+zopfli-devel.sha256sum] = "8d7520595019c0b6f8bbea28816b9d46c71cb27355dea6b64598209b41ca6b22"

URI_x86_64_v2_rust-oxipng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oxipng-devel-9.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oxipng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oxipng-devel}"
SRC_URI[x86_64_v2_rust-oxipng-devel.sha256sum] = "4c4bb750b030e8b66468e53bcd28ca2bd7d2dcb78451761950cd3dc4c5fad11a"

URI_aarch64_oxipng = "${EPEL_MIRROR}/aarch64/Packages/o/oxipng-9.1.5-1.el10_1.aarch64.rpm;name=aarch64_oxipng;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxipng}"
SRC_URI[aarch64_oxipng.sha256sum] = "55918ad297ee1f8212824064fa7393d0dd697983049767f71bc439fd479fd7ad"

URI_aarch64_rust-oxipng+binary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+binary-devel-9.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-oxipng+binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+binary-devel}"
SRC_URI[aarch64_rust-oxipng+binary-devel.sha256sum] = "c47f579310cf0a4e53a75903dda1a8c5b92c595ed5272b977c6926c4dbe9631d"

URI_aarch64_rust-oxipng+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+default-devel-9.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-oxipng+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+default-devel}"
SRC_URI[aarch64_rust-oxipng+default-devel.sha256sum] = "31cc39dd3d3b83f4595dc14bf33a9f2fb5dc8f5237777539ec2daebdafd35766"

URI_aarch64_rust-oxipng+filetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+filetime-devel-9.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-oxipng+filetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+filetime-devel}"
SRC_URI[aarch64_rust-oxipng+filetime-devel.sha256sum] = "97b61c82b6c899c6eb107d40afcf8a4f4246803377ae89645fc2e4faf2907186"

URI_aarch64_rust-oxipng+freestanding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+freestanding-devel-9.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-oxipng+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+freestanding-devel}"
SRC_URI[aarch64_rust-oxipng+freestanding-devel.sha256sum] = "66f6b89369f4a06c036dd4425e513fd6ca17a45b09fe71ed972c9083f0230a2c"

URI_aarch64_rust-oxipng+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+parallel-devel-9.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-oxipng+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+parallel-devel}"
SRC_URI[aarch64_rust-oxipng+parallel-devel.sha256sum] = "ca3f3fdfdc5494da13a0dd8f7c5215092ab9f91d038979568be339e60f8d3181"

URI_aarch64_rust-oxipng+sanity-checks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+sanity-checks-devel-9.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-oxipng+sanity-checks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+sanity-checks-devel}"
SRC_URI[aarch64_rust-oxipng+sanity-checks-devel.sha256sum] = "428c2a01eac15872aec26d296443a21c4d97b57e44e90af5aefe5ba90eddcaff"

URI_aarch64_rust-oxipng+system-libdeflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+system-libdeflate-devel-9.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-oxipng+system-libdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+system-libdeflate-devel}"
SRC_URI[aarch64_rust-oxipng+system-libdeflate-devel.sha256sum] = "b5513f3ff102387b07750f0f5f2d1eab1f3eea6ce4ee1358f7d9b796de0fa5e9"

URI_aarch64_rust-oxipng+zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng+zopfli-devel-9.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-oxipng+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng+zopfli-devel}"
SRC_URI[aarch64_rust-oxipng+zopfli-devel.sha256sum] = "3f06b0b511451170e248e14d8a7f369fb0f54112a1252eaddfb73ff850ac036b"

URI_aarch64_rust-oxipng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oxipng-devel-9.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-oxipng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oxipng-devel}"
SRC_URI[aarch64_rust-oxipng-devel.sha256sum] = "a294c69a2e62477e661326dd0d2bcaf0bc6bb52687588d347c36c1bbc5e9e102"

RDEPENDS:oxipng = " \
 glibc \
 libdeflate \
 libgcc \
 "
RDEPENDS:rust-oxipng+binary-devel = " \
 cargo \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-env_logger+auto-color-devel \
 rust-env_logger-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+default-devel = " \
 cargo \
 rust-oxipng+binary-devel \
 rust-oxipng+filetime-devel \
 rust-oxipng+parallel-devel \
 rust-oxipng+zopfli-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+filetime-devel = " \
 cargo \
 rust-filetime+default-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+freestanding-devel = " \
 cargo \
 rust-libdeflater+freestanding-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+parallel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-indexmap+rayon-devel \
 rust-oxipng-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-oxipng+sanity-checks-devel = " \
 cargo \
 rust-image+png-devel \
 rust-image-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+system-libdeflate-devel = " \
 cargo \
 rust-libdeflater+dynamic-devel \
 rust-oxipng-devel \
 "
RDEPENDS:rust-oxipng+zopfli-devel = " \
 cargo \
 rust-oxipng-devel \
 rust-zopfli+std-devel \
 rust-zopfli+zlib-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-oxipng-devel = " \
 cargo \
 rust \
 rust-bitvec+default-devel \
 rust-indexmap+default-devel \
 rust-libdeflater+default-devel \
 rust-log+default-devel \
 rust-rgb+default-devel \
 rust-rustc-hash+default-devel \
 "
