# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "figlet"
PV = "2.2.5"
PR = "38.el10_2"
PACKAGES = " \
 figlet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/figlet-2.2.5-38.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f8a6c21ed166ea46619c5fb5f27339e363132020bea3c65c5e016c2b5803796"

URI_x86_64_v2_figlet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/figlet-2.2.5-38.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_figlet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_figlet}"
SRC_URI[x86_64_v2_figlet.sha256sum] = "8d4e358496688f0f3620e96795405d363ad0f4803d972731e83f4b04557611ca"

URI_aarch64_figlet = "${EPEL_MIRROR}/aarch64/Packages/f/figlet-2.2.5-38.el10_2.aarch64.rpm;name=aarch64_figlet;unpack=0"
SRC_URI:append = " ${URI_aarch64_figlet}"
SRC_URI[aarch64_figlet.sha256sum] = "d759615d0ee897ff72903f77bfb130883732f826a66b8a05f354f5f2f359c6d2"

RDEPENDS:figlet = " \
 bash \
 glibc \
 "
