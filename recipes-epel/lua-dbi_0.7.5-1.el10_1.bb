# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-dbi"
PV = "0.7.5"
PR = "1.el10_1"
PACKAGES = " \
 lua-dbi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-dbi-0.7.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d16224561395e1a28af0ed58a802e27d902babfe20610c3b9c402ec4b22cedfd"

URI_x86_64_v2_lua-dbi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-dbi-0.7.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-dbi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-dbi}"
SRC_URI[x86_64_v2_lua-dbi.sha256sum] = "6a0bcbd38f5bd5bc8642bb2327ed83d46981732fd3d4a4214c2e66232c043578"

URI_aarch64_lua-dbi = "${EPEL_MIRROR}/aarch64/Packages/l/lua-dbi-0.7.5-1.el10_1.aarch64.rpm;name=aarch64_lua-dbi;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-dbi}"
SRC_URI[aarch64_lua-dbi.sha256sum] = "9029137eca723ceec8c1975abbbf61e62c4f3cc0353179f499f340045eca2524"

RDEPENDS:lua-dbi = " \
 glibc \
 libpq \
 lua-libs \
 mariadb-connector-c \
 sqlite-libs \
 "
