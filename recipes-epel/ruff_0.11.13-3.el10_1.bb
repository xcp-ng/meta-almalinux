# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruff"
PV = "0.11.13"
PR = "3.el10_1"
PACKAGES = " \
 python3-ruff \
 ruff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ruff-0.11.13-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "623d726543c37e8d34ea5cd28ed52f4e54992242a1433c8560f1ff9bd7dd5525"

URI_x86_64_v2_python3-ruff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ruff-0.11.13-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ruff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ruff}"
SRC_URI[x86_64_v2_python3-ruff.sha256sum] = "dcd26ad854c82ff3bd80ad905ac5898a5056dd2bdac942f9bfb7976b988c0dc2"

URI_x86_64_v2_ruff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruff-0.11.13-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ruff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruff}"
SRC_URI[x86_64_v2_ruff.sha256sum] = "62391c79efc0833222ed21df590310ce18c3745e96433bf209596359465d5702"

URI_aarch64_python3-ruff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ruff-0.11.13-3.el10_1.noarch.rpm;name=aarch64_python3-ruff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ruff}"
SRC_URI[aarch64_python3-ruff.sha256sum] = "2fb8ad508058bfd71ea53d9f857785c8de22a0d75a84e198f0482c89d3863724"

URI_aarch64_ruff = "${EPEL_MIRROR}/aarch64/Packages/r/ruff-0.11.13-3.el10_1.aarch64.rpm;name=aarch64_ruff;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruff}"
SRC_URI[aarch64_ruff.sha256sum] = "ad587cbd2ae612f66fdcb5c09769ac7377135aaae3e2e6e78e770c80a097ea79"

RDEPENDS:python3-ruff = " \
 python3 \
 ruff \
 "
RDEPENDS:ruff = " \
 glibc \
 jemalloc \
 libgcc \
 "
