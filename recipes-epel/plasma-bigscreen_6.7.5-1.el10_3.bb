# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-bigscreen"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-bigscreen \
 plasma-bigscreen-wayland \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-bigscreen-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "408f7c8781ba692d9fc86311c42b7c377bd2152ea983129fc787f3ef6f5ee139"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-bigscreen-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-bigscreen;unpack=0"
SRC_URI[x86_64_v2_plasma-bigscreen.sha256sum] = "c5cfc11cf50be7df0e6c74be3bc2cd603db4d7f246ba79dbf042171dc008311a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-bigscreen-wayland-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-bigscreen-wayland;unpack=0"
SRC_URI[x86_64_v2_plasma-bigscreen-wayland.sha256sum] = "3061569d5eb6aed74c3097a9dad8460f2d03e7cda6a6b3cfc63df6a8464ededc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-bigscreen-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-bigscreen;unpack=0"
SRC_URI[aarch64_plasma-bigscreen.sha256sum] = "a3c39b4c11f33a721a8e043e2e35f227e5df011af8160abd7f1327c22bbdc319"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-bigscreen-wayland-6.7.5-1.el10_3.noarch.rpm;name=aarch64_plasma-bigscreen-wayland;unpack=0"
SRC_URI[aarch64_plasma-bigscreen-wayland.sha256sum] = "98f84362140ad6fbf39b00003d33ffbf8e7e73b1af0e4fd9292ca03c2ad6b6c0"

RDEPENDS:plasma-bigscreen = " \
 SDL3 \
 bash \
 glibc \
 kf6-bluez-qt \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-solid \
 libcec \
 libgcc \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 plasma-activities \
 plasma-bigscreen-wayland \
 plasma-nano \
 plasma-workspace-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
RDEPENDS:plasma-bigscreen-wayland = " \
 bash \
 plasma-bigscreen \
 plasma-workspace \
 "
