# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdap"
PV = "3.21.0.27"
PR = "1.el10_0"
PACKAGES = " \
 libdap \
 libdap-devel \
 libdap-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdap-3.21.0.27-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9994ff194bcd8545424867ca831c21274a2d2807e50a7b2579de7eb9a2ebbc1b"

URI_x86_64_v2_libdap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdap-3.21.0.27-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdap}"
SRC_URI[x86_64_v2_libdap.sha256sum] = "50214edb280c6b454b763a9d56131d9989bc22fc816e3baae3462f2abe1bb284"

URI_x86_64_v2_libdap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdap-devel-3.21.0.27-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdap-devel}"
SRC_URI[x86_64_v2_libdap-devel.sha256sum] = "88941229d4f456050634ccce8e38c206b1ba3d72b48fbe0697e74f8d31c37dc7"

URI_x86_64_v2_libdap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdap-doc-3.21.0.27-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdap-doc}"
SRC_URI[x86_64_v2_libdap-doc.sha256sum] = "fd90cf46b03dc98ee3661bad7df98c7a09537499ce932a202e64d1f5f5de2649"

URI_aarch64_libdap = "${EPEL_MIRROR}/aarch64/Packages/l/libdap-3.21.0.27-1.el10_0.aarch64.rpm;name=aarch64_libdap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdap}"
SRC_URI[aarch64_libdap.sha256sum] = "ec10cf5be905e283dc00dfb0c60cc7f9af725f4962dd2135ddb4acb5b2527611"

URI_aarch64_libdap-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdap-devel-3.21.0.27-1.el10_0.aarch64.rpm;name=aarch64_libdap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdap-devel}"
SRC_URI[aarch64_libdap-devel.sha256sum] = "ae81f6ab3e466a1a7130a46bb2acb5f9b28abe7c9cf018eff9818fd40051da70"

URI_aarch64_libdap-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libdap-doc-3.21.0.27-1.el10_0.aarch64.rpm;name=aarch64_libdap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdap-doc}"
SRC_URI[aarch64_libdap-doc.sha256sum] = "a2b0130df975e0ba19cde59a3856575f814d822b0f3ca4b1a7b9967054eaab5d"

RDEPENDS:libdap = " \
 glibc \
 libgcc \
 libstdc++ \
 libtirpc \
 libuuid \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libdap-devel = " \
 automake \
 bash \
 libcurl-devel \
 libdap \
 libdap-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libdap-doc = " \
 "
