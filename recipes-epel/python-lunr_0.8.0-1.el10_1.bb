# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lunr"
PV = "0.8.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-lunr \
 python3-lunr+languages \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-lunr-0.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "990048b3e50383a6bd9ca5a634a405ecf16616dafce01fcc2e87c05dd1800053"

URI_x86_64_v2_python3-lunr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lunr-0.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-lunr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lunr}"
SRC_URI[x86_64_v2_python3-lunr.sha256sum] = "0366fa2180aa5843b89b701c033846d41e0eeb23f53f4bd36627629869ac886c"

URI_x86_64_v2_python3-lunr+languages = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lunr+languages-0.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-lunr+languages;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lunr+languages}"
SRC_URI[x86_64_v2_python3-lunr+languages.sha256sum] = "e1dfbd8c7c396a00d3b7eac2d107da43396e6a7292716b825b5875acb4f56130"

URI_aarch64_python3-lunr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lunr-0.8.0-1.el10_1.noarch.rpm;name=aarch64_python3-lunr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lunr}"
SRC_URI[aarch64_python3-lunr.sha256sum] = "3fe5c0d19b04c0e5b4d8d2e6a5ac6b366ce1a2ddbb73946979d8f6152c0bd0c9"

URI_aarch64_python3-lunr+languages = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lunr+languages-0.8.0-1.el10_1.noarch.rpm;name=aarch64_python3-lunr+languages;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lunr+languages}"
SRC_URI[aarch64_python3-lunr+languages.sha256sum] = "3d5200036192b4dde294851366878976b0ad832a4a5c26dfc74d4d1fa009d12f"

RDEPENDS:python3-lunr = " \
 python3 \
 "
RDEPENDS:python3-lunr+languages = " \
 python3 \
 python3-lunr \
 python3-nltk \
 "
