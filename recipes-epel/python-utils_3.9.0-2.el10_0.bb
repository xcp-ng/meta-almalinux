# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-utils"
PV = "3.9.0"
PR = "2.el10_0"
PACKAGES = " \
 python-utils-docs \
 python3-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-utils-3.9.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "719efd22273812bc73587fcb852b9ccfcce35178e4b667b104988aab1845d758"

URI_x86_64_v2_python-utils-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-utils-docs-3.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-utils-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-utils-docs}"
SRC_URI[x86_64_v2_python-utils-docs.sha256sum] = "67580d68d1d5e0dcbc2eb3067347bbb6646cedb6327142938562353fa020cc20"

URI_x86_64_v2_python3-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-utils-3.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-utils}"
SRC_URI[x86_64_v2_python3-utils.sha256sum] = "502ef550425a9ab993784f175a1bc126341ecfd7d676164962b5099e894c397a"

URI_aarch64_python-utils-docs = "${EPEL_MIRROR}/aarch64/Packages/p/python-utils-docs-3.9.0-2.el10_0.noarch.rpm;name=aarch64_python-utils-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-utils-docs}"
SRC_URI[aarch64_python-utils-docs.sha256sum] = "b76fa1b4aa5512fd7cac966a063f7e8de017e239a2ac70f47e2b622fa00daa8f"

URI_aarch64_python3-utils = "${EPEL_MIRROR}/aarch64/Packages/p/python3-utils-3.9.0-2.el10_0.noarch.rpm;name=aarch64_python3-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-utils}"
SRC_URI[aarch64_python3-utils.sha256sum] = "f955426ae5814e0015e848409e4ea739e66394bbca9d4454ebe599a1c9ada82d"

RDEPENDS:python-utils-docs = " \
 "
RDEPENDS:python3-utils = " \
 python3 \
 python3-typing-extensions \
 "
