# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "giflib"
PV = "5.2.1"
PR = "25.el10_2"
PACKAGES = " \
 giflib \
 giflib-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/giflib-5.2.1-25.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ba196f5e05c7c00dcead77623582bb21b4297ea8fa7bc4cd02b6a592ec28500"

URI_x86_64_v2_giflib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/giflib-5.2.1-25.el10_2.x86_64_v2.rpm;name=x86_64_v2_giflib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_giflib}"
SRC_URI[x86_64_v2_giflib.sha256sum] = "105331590cc4914340b453820476b102cb584e054f312be2100fe9b538461922"

URI_x86_64_v2_giflib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/giflib-devel-5.2.1-25.el10_2.x86_64_v2.rpm;name=x86_64_v2_giflib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_giflib-devel}"
SRC_URI[x86_64_v2_giflib-devel.sha256sum] = "38d008be67aafd94716a031e861671b84a179a6cba3dbd90852fb4559ffe2f3b"

URI_aarch64_giflib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/giflib-5.2.1-25.el10_2.aarch64.rpm;name=aarch64_giflib;unpack=0"
SRC_URI:append = " ${URI_aarch64_giflib}"
SRC_URI[aarch64_giflib.sha256sum] = "20603f6ab27f20010640d1c20f688f635f564071b2378f0ceda83a9a6d33f7a0"

URI_aarch64_giflib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/giflib-devel-5.2.1-25.el10_2.aarch64.rpm;name=aarch64_giflib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_giflib-devel}"
SRC_URI[aarch64_giflib-devel.sha256sum] = "e1e115b2d866978afb239a5e2ea30f5caba4f01eebe6473af1004b598ba98dcb"

RDEPENDS:giflib = " \
 glibc \
 "
RDEPENDS:giflib-devel = " \
 giflib \
 "
