# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rx"
PV = "4.1.0"
PR = "6.el10_3"
PACKAGES = " \
 python3-rx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rx-4.1.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a9dc4631f0235a8ac4b4250c9b3df68d1bec5745c2899d8dc3378e6ec81a82f"

URI_x86_64_v2_python3-rx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rx-4.1.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rx}"
SRC_URI[x86_64_v2_python3-rx.sha256sum] = "270848bc67298e6d6425c9dcc46992a3fd755d065ecccb979f93ce840b0fe768"

URI_aarch64_python3-rx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rx-4.1.0-6.el10_3.noarch.rpm;name=aarch64_python3-rx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rx}"
SRC_URI[aarch64_python3-rx.sha256sum] = "fa277c9e11d27d41b0ea8cc3ebd6c8bb252242b5c0698585774b2db82dfbcaf0"

RDEPENDS:python3-rx = " \
 python3 \
 python3-typing-extensions \
 "
