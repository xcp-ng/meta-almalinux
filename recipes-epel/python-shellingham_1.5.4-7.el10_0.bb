# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-shellingham"
PV = "1.5.4"
PR = "7.el10_0"
PACKAGES = " \
 python3-shellingham \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-shellingham-1.5.4-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "967655f966fbaa8c3835d3d857fb5b2125cea8bec90a1992c6d260129faba9d4"

URI_x86_64_v2_python3-shellingham = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-shellingham-1.5.4-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-shellingham;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-shellingham}"
SRC_URI[x86_64_v2_python3-shellingham.sha256sum] = "a504419330b02b7aa24f243eecc625144ae78d4a52e8e81e4e8079123bfee1c0"

URI_aarch64_python3-shellingham = "${EPEL_MIRROR}/aarch64/Packages/p/python3-shellingham-1.5.4-7.el10_0.noarch.rpm;name=aarch64_python3-shellingham;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-shellingham}"
SRC_URI[aarch64_python3-shellingham.sha256sum] = "b1f10cd6e7a9f4a0f767f46cd168571ee985ba3a0f49f8931c461e94916ae5fb"

RDEPENDS:python3-shellingham = " \
 python3 \
 "
