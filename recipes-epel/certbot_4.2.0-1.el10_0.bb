# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "certbot"
PV = "4.2.0"
PR = "1.el10_0"
PACKAGES = " \
 certbot \
 python3-acme \
 python3-certbot \
 python3-certbot-apache \
 python3-certbot-dns-cloudflare \
 python3-certbot-dns-digitalocean \
 python3-certbot-dns-dnsimple \
 python3-certbot-dns-dnsmadeeasy \
 python3-certbot-dns-gehirn \
 python3-certbot-dns-linode \
 python3-certbot-dns-luadns \
 python3-certbot-dns-nsone \
 python3-certbot-dns-ovh \
 python3-certbot-dns-rfc2136 \
 python3-certbot-dns-route53 \
 python3-certbot-dns-sakuracloud \
 python3-certbot-nginx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/certbot-4.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "433b54bd1acb15f667320ca965ac0ea9c862fc90f6e5b87b856e53eacda06857"

URI_x86_64_v2_certbot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/certbot-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_certbot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_certbot}"
SRC_URI[x86_64_v2_certbot.sha256sum] = "8fd75cdbaf12e42460112b7ea767844b9bd33ac52583e2933cc1e8f85cbac377"

URI_x86_64_v2_python3-acme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-acme-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-acme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-acme}"
SRC_URI[x86_64_v2_python3-acme.sha256sum] = "0f6ffde64acdf066b5702c6eb24c90d0cd60133961ce4be54ec6fcbd9ac63c11"

URI_x86_64_v2_python3-certbot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot}"
SRC_URI[x86_64_v2_python3-certbot.sha256sum] = "a53a363019887ae676fe0b54f3f6e409553b3ad4906ba8f9d364e627a35c6218"

URI_x86_64_v2_python3-certbot-apache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-apache-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-apache}"
SRC_URI[x86_64_v2_python3-certbot-apache.sha256sum] = "8ce6d1569ba92d8c31c3dec1db0c47a3211fdeefc5e313394525c47deb8a384f"

URI_x86_64_v2_python3-certbot-dns-cloudflare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-cloudflare-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-cloudflare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-cloudflare}"
SRC_URI[x86_64_v2_python3-certbot-dns-cloudflare.sha256sum] = "a7b7bdd7add2511c62f150190b389fcec092bbb1442513568ff05101a80140fa"

URI_x86_64_v2_python3-certbot-dns-digitalocean = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-digitalocean-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-digitalocean;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-digitalocean}"
SRC_URI[x86_64_v2_python3-certbot-dns-digitalocean.sha256sum] = "7e51061f70976d325583ef5279147ff77c1e84861ea78bbfca90f7199079549f"

URI_x86_64_v2_python3-certbot-dns-dnsimple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-dnsimple-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-dnsimple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-dnsimple}"
SRC_URI[x86_64_v2_python3-certbot-dns-dnsimple.sha256sum] = "26ab70e06abdf93b9cb6e334b282c0298a7f1b028d64929d15315a5c45ddae2d"

URI_x86_64_v2_python3-certbot-dns-dnsmadeeasy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-dnsmadeeasy-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-dnsmadeeasy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-dnsmadeeasy}"
SRC_URI[x86_64_v2_python3-certbot-dns-dnsmadeeasy.sha256sum] = "43dad263e1b92ce7298ef7ef4e272bc1cd57bea4667cee5c9cbbdb88ad239581"

URI_x86_64_v2_python3-certbot-dns-gehirn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-gehirn-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-gehirn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-gehirn}"
SRC_URI[x86_64_v2_python3-certbot-dns-gehirn.sha256sum] = "2516c518822dc39af0364d91400fd71d8f48d224aaefb6e8f1579d625fd6ffaf"

URI_x86_64_v2_python3-certbot-dns-linode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-linode-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-linode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-linode}"
SRC_URI[x86_64_v2_python3-certbot-dns-linode.sha256sum] = "758f0f80ff81eab5cec44a555def6e0f3d7148d238b1dc95c1f1cf1af356b121"

URI_x86_64_v2_python3-certbot-dns-luadns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-luadns-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-luadns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-luadns}"
SRC_URI[x86_64_v2_python3-certbot-dns-luadns.sha256sum] = "2bbf72178c90aa6e5b2c7558e31736884e9ed4b4e7f23745bf700ea0f3c5596a"

URI_x86_64_v2_python3-certbot-dns-nsone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-nsone-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-nsone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-nsone}"
SRC_URI[x86_64_v2_python3-certbot-dns-nsone.sha256sum] = "fef12e0d0fdea40e15a99a924716f434896fd9386cd376f78f5786bb41173140"

URI_x86_64_v2_python3-certbot-dns-ovh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-ovh-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-ovh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-ovh}"
SRC_URI[x86_64_v2_python3-certbot-dns-ovh.sha256sum] = "c6af9840ba3134d94aa1a414b3b17f3c3df8733af7a82ad1a697279fa97ca790"

URI_x86_64_v2_python3-certbot-dns-rfc2136 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-rfc2136-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-rfc2136;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-rfc2136}"
SRC_URI[x86_64_v2_python3-certbot-dns-rfc2136.sha256sum] = "ab7d8bec9f0fd47313e47ad324a5ecfed77f44d9f4240d2c34d1f00cc4e8c29b"

URI_x86_64_v2_python3-certbot-dns-route53 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-route53-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-route53;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-route53}"
SRC_URI[x86_64_v2_python3-certbot-dns-route53.sha256sum] = "252945cbb19a98468b0f8026d52818d14064b789d3803fbb5f2d27ffb306a45a"

URI_x86_64_v2_python3-certbot-dns-sakuracloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-sakuracloud-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-sakuracloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-sakuracloud}"
SRC_URI[x86_64_v2_python3-certbot-dns-sakuracloud.sha256sum] = "cea0a15428f36470d9681ed909434cb8dc1229b5f5fdeb8d07810d4ec40aa69b"

URI_x86_64_v2_python3-certbot-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-nginx-4.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-nginx}"
SRC_URI[x86_64_v2_python3-certbot-nginx.sha256sum] = "7dd37295c472350cd1a34108bb8219042dad9d8b0132919447fad0fcc8cf369b"

URI_aarch64_certbot = "${EPEL_MIRROR}/aarch64/Packages/c/certbot-4.2.0-1.el10_0.noarch.rpm;name=aarch64_certbot;unpack=0"
SRC_URI:append = " ${URI_aarch64_certbot}"
SRC_URI[aarch64_certbot.sha256sum] = "c514c9b2883b581ebbd2bfa381172d79ecd97913d0dca5eeaddd722331bc590a"

URI_aarch64_python3-acme = "${EPEL_MIRROR}/aarch64/Packages/p/python3-acme-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-acme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-acme}"
SRC_URI[aarch64_python3-acme.sha256sum] = "a214faf472c395c8a9b4a6018bb021ed8d7aae64f898cc2592f9e79acf1e1c0a"

URI_aarch64_python3-certbot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot}"
SRC_URI[aarch64_python3-certbot.sha256sum] = "6008d47f90f0cd4fabc3b674a77b117ac6d6082f377d4fb1725dc94d1bd5675a"

URI_aarch64_python3-certbot-apache = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-apache-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-apache}"
SRC_URI[aarch64_python3-certbot-apache.sha256sum] = "d226f18dad823e641172f955ae5f723b62a842da7111e587d4643bd453f71cd4"

URI_aarch64_python3-certbot-dns-cloudflare = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-cloudflare-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-cloudflare;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-cloudflare}"
SRC_URI[aarch64_python3-certbot-dns-cloudflare.sha256sum] = "c2921adb4b4bb0d0d5b89f7411edf5efbd24824a5bbaecdcdd1a491dbaaf21d4"

URI_aarch64_python3-certbot-dns-digitalocean = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-digitalocean-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-digitalocean;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-digitalocean}"
SRC_URI[aarch64_python3-certbot-dns-digitalocean.sha256sum] = "fce4fa11f0ee4a1a33770dd9aa4d06f47b291c694e3ec4d4614c9684ac8a417b"

URI_aarch64_python3-certbot-dns-dnsimple = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-dnsimple-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-dnsimple;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-dnsimple}"
SRC_URI[aarch64_python3-certbot-dns-dnsimple.sha256sum] = "461cd5ea92abf7e97f89d0d2d50de4d100903d774cad0a14669f664506bcdc1d"

URI_aarch64_python3-certbot-dns-dnsmadeeasy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-dnsmadeeasy-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-dnsmadeeasy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-dnsmadeeasy}"
SRC_URI[aarch64_python3-certbot-dns-dnsmadeeasy.sha256sum] = "fd93fe5ca3ddb23da507d363cf1200654fc2ba0c3bd07e6d09d6f47f5fdb0ac7"

URI_aarch64_python3-certbot-dns-gehirn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-gehirn-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-gehirn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-gehirn}"
SRC_URI[aarch64_python3-certbot-dns-gehirn.sha256sum] = "a8d24bcb7ad9d04cd59f68a0af99be744e5dc4fce84716bc1a995f6b0c3d0a3d"

URI_aarch64_python3-certbot-dns-linode = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-linode-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-linode;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-linode}"
SRC_URI[aarch64_python3-certbot-dns-linode.sha256sum] = "2e4723d433aa72c4ffe9ee2116fd9a4a22603a682d59d9a44b6b3470395c715d"

URI_aarch64_python3-certbot-dns-luadns = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-luadns-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-luadns;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-luadns}"
SRC_URI[aarch64_python3-certbot-dns-luadns.sha256sum] = "dc2945363ee35c7d2ab58746c29e45738fbc3ff69360bb1465830d798ce37633"

URI_aarch64_python3-certbot-dns-nsone = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-nsone-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-nsone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-nsone}"
SRC_URI[aarch64_python3-certbot-dns-nsone.sha256sum] = "054a3a7c5cb0d9bf46872b10c88ecccdfa87a6c90d7233a9f4477b442105c99d"

URI_aarch64_python3-certbot-dns-ovh = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-ovh-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-ovh;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-ovh}"
SRC_URI[aarch64_python3-certbot-dns-ovh.sha256sum] = "69e420efe27f627918ca1fdc60ce32334d6441868692fab6c7a3e734a4bc71db"

URI_aarch64_python3-certbot-dns-rfc2136 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-rfc2136-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-rfc2136;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-rfc2136}"
SRC_URI[aarch64_python3-certbot-dns-rfc2136.sha256sum] = "1c7df1344eca4ed23ab2987d883678cc3b9aac6a19b96a416369b9e034c9a02e"

URI_aarch64_python3-certbot-dns-route53 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-route53-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-route53;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-route53}"
SRC_URI[aarch64_python3-certbot-dns-route53.sha256sum] = "41affd3ebd4e0ae81e129e22b89303774243df9260f50bd8973b44dca8493299"

URI_aarch64_python3-certbot-dns-sakuracloud = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-sakuracloud-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-dns-sakuracloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-sakuracloud}"
SRC_URI[aarch64_python3-certbot-dns-sakuracloud.sha256sum] = "dcdd44d9c49238e350c1472b78ddc10c5efeafd140f9b0a90dd90a32c73f23b8"

URI_aarch64_python3-certbot-nginx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-nginx-4.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-certbot-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-nginx}"
SRC_URI[aarch64_python3-certbot-nginx.sha256sum] = "07095aae5801650931221820bb62640a1c728dff2dc1725a1882686a822cd70e"

RDEPENDS:certbot = " \
 bash \
 fontawesome4-fonts \
 policycoreutils \
 python3-certbot \
 systemd \
 "
RDEPENDS:python3-acme = " \
 python3 \
 python3-cryptography \
 python3-josepy \
 python3-pyOpenSSL \
 python3-pyrfc3339 \
 python3-requests \
 "
RDEPENDS:python3-certbot = " \
 python3 \
 python3-acme \
 python3-configargparse \
 python3-configobj \
 python3-cryptography \
 python3-distro \
 python3-josepy \
 python3-parsedatetime \
 python3-pyrfc3339 \
 "
RDEPENDS:python3-certbot-apache = " \
 mod_ssl \
 python3 \
 python3-acme \
 python3-augeas \
 python3-certbot \
 "
RDEPENDS:python3-certbot-dns-cloudflare = " \
 python3 \
 python3-cloudflare \
 "
RDEPENDS:python3-certbot-dns-digitalocean = " \
 python3 \
 python3-digitalocean \
 "
RDEPENDS:python3-certbot-dns-dnsimple = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-dnsmadeeasy = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-gehirn = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-linode = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-luadns = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-nsone = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-ovh = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-rfc2136 = " \
 python3 \
 python3-dns \
 "
RDEPENDS:python3-certbot-dns-route53 = " \
 python3 \
 python3-boto3 \
 "
RDEPENDS:python3-certbot-dns-sakuracloud = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-nginx = " \
 python3 \
 python3-acme \
 python3-certbot \
 python3-pyOpenSSL \
 python3-pyparsing \
 "
