# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-glob"
PV = "0.18.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-glob+default-devel \
 rust-gix-glob+document-features-devel \
 rust-gix-glob+serde-devel \
 rust-gix-glob-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-glob-0.18.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdf511bf4c93ffd25b4f20cf2b3c1af23a162a80ee565ec4cb0f6c29e81e86b6"

URI_x86_64_v2_rust-gix-glob+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+default-devel-0.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob+default-devel}"
SRC_URI[x86_64_v2_rust-gix-glob+default-devel.sha256sum] = "87ad423f40f89de609bfe0768397a3ebd6e4d6ef9b4a25e15b3bb184af5d12ba"

URI_x86_64_v2_rust-gix-glob+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+document-features-devel-0.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-glob+document-features-devel.sha256sum] = "fec885f6b96844b3e6c6590026b55495e1ca1c04bcd0ba5e55edf5cc935e8a75"

URI_x86_64_v2_rust-gix-glob+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+serde-devel-0.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-glob+serde-devel.sha256sum] = "696ea217016f4d704255ed609011948e6ed594771956bb6837e025e25a07e5a8"

URI_x86_64_v2_rust-gix-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob-devel-0.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob-devel}"
SRC_URI[x86_64_v2_rust-gix-glob-devel.sha256sum] = "3bca698f78ece2d2adfb55e1d931abae86287bd9140faf89f09292ffd3d66389"

URI_aarch64_rust-gix-glob+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+default-devel-0.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob+default-devel}"
SRC_URI[aarch64_rust-gix-glob+default-devel.sha256sum] = "d199f6a4c417d82e2a5c34f9b1de3cab71749190bceac047e22ca0920b8a9fd9"

URI_aarch64_rust-gix-glob+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+document-features-devel-0.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-glob+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob+document-features-devel}"
SRC_URI[aarch64_rust-gix-glob+document-features-devel.sha256sum] = "1197e7e98015e75b6d599a8288abb3f0431df13e6c5f89637d6a28df1edc7c7e"

URI_aarch64_rust-gix-glob+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+serde-devel-0.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-glob+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob+serde-devel}"
SRC_URI[aarch64_rust-gix-glob+serde-devel.sha256sum] = "fa47b4ff789c72c9a734007f0e08eabad846255e33a2094432148f8df6881ce5"

URI_aarch64_rust-gix-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob-devel-0.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob-devel}"
SRC_URI[aarch64_rust-gix-glob-devel.sha256sum] = "2d010bd57455623034db020f865c0f7e39feb7f57b1ca90d75f406c8985bcd85"

RDEPENDS:rust-gix-glob+default-devel = " \
 cargo \
 rust-gix-glob-devel \
 "
RDEPENDS:rust-gix-glob+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-glob-devel \
 "
RDEPENDS:rust-gix-glob+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-bstr+serde-devel \
 rust-gix-glob-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-glob-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-path+default-devel \
 "
