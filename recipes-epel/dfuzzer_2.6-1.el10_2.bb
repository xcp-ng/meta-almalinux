# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dfuzzer"
PV = "2.6"
PR = "1.el10_2"
PACKAGES = " \
 dfuzzer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dfuzzer-2.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a641b72a5dae075db8e96dba2bad6363b725dfc55a96b7242a4222033f4849a"

URI_x86_64_v2_dfuzzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dfuzzer-2.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dfuzzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dfuzzer}"
SRC_URI[x86_64_v2_dfuzzer.sha256sum] = "a0db504331145c935f8f27d60cd306432a571d122da535eb3b5edbf798ab32af"

URI_aarch64_dfuzzer = "${EPEL_MIRROR}/aarch64/Packages/d/dfuzzer-2.6-1.el10_2.aarch64.rpm;name=aarch64_dfuzzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_dfuzzer}"
SRC_URI[aarch64_dfuzzer.sha256sum] = "887dcf6582bb62eba252112e53f714b30d2821dcf9e55bf4858db276ba3cf9f2"

RDEPENDS:dfuzzer = " \
 glib2 \
 glibc \
 libgcc \
 "
