# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cli11"
PV = "2.5.0"
PR = "1.el10_1"
PACKAGES = " \
 cli11-devel \
 cli11-docs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cli11-2.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "01ea9dfc9847a4b79c01072d5d430fde384eb6620d9844000ccec21024dd8285"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cli11-devel-2.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cli11-devel;unpack=0"
SRC_URI[x86_64_v2_cli11-devel.sha256sum] = "b328586a54c45a034662044bec4a3a0408424e80af21ffd28f010b275f9aeddd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cli11-docs-2.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cli11-docs;unpack=0"
SRC_URI[x86_64_v2_cli11-docs.sha256sum] = "572cbd564d1db4dfb3a23259dc72c1f75af2e34f433064bb60663bf31e1f2ddc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cli11-devel-2.5.0-1.el10_1.noarch.rpm;name=aarch64_cli11-devel;unpack=0"
SRC_URI[aarch64_cli11-devel.sha256sum] = "fdd6dac54fe21dce593e38d663807265c7acedbd6be56b39bb95c6254d3fa7c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cli11-docs-2.5.0-1.el10_1.noarch.rpm;name=aarch64_cli11-docs;unpack=0"
SRC_URI[aarch64_cli11-docs.sha256sum] = "57303a0309a4e6faf38aa9dd4dad182c91b473f243927586e989bcd30723d669"

RDEPENDS:cli11-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:cli11-docs = " \
 "
