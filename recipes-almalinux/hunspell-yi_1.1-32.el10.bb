# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-yi"
PV = "1.1"
PR = "32.el10"
PACKAGES = " \
 hunspell-yi \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-yi-1.1-32.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fe7ac36489b723d526bbea066b7f6a3ade51dbb4fae045f841be4e02aa1c3f1c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-yi-1.1-32.el10.noarch.rpm;name=x86_64_v2_hunspell-yi;unpack=0"
SRC_URI[x86_64_v2_hunspell-yi.sha256sum] = "7ed8d3d532c13f640512109a5e8da2fd6966aaf6d0494ab29d77b4854ad5ca94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-yi-1.1-32.el10.noarch.rpm;name=aarch64_hunspell-yi;unpack=0"
SRC_URI[aarch64_hunspell-yi.sha256sum] = "7ed8d3d532c13f640512109a5e8da2fd6966aaf6d0494ab29d77b4854ad5ca94"

RDEPENDS:hunspell-yi = " \
 hunspell-filesystem \
 "
