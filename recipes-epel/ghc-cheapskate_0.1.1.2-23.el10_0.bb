# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cheapskate"
PV = "0.1.1.2"
PR = "23.el10_0"
PACKAGES = " \
 ghc-cheapskate \
 ghc-cheapskate-devel \
 ghc-cheapskate-doc \
 ghc-cheapskate-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cheapskate-0.1.1.2-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd3e30d9c8a5a257036d5ac2b50fc2af70f5d7e2633ba9b80b86b25c90a85572"

URI_x86_64_v2_ghc-cheapskate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cheapskate-0.1.1.2-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cheapskate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cheapskate}"
SRC_URI[x86_64_v2_ghc-cheapskate.sha256sum] = "b3e11c232cca236006089f821c368f69a54342c1ef413d99f3dc4e58c3bfbe99"

URI_x86_64_v2_ghc-cheapskate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cheapskate-devel-0.1.1.2-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cheapskate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cheapskate-devel}"
SRC_URI[x86_64_v2_ghc-cheapskate-devel.sha256sum] = "375ff18be61e9470ee7289901ea2159b435a73214efd840b87fcd6d468b4a499"

URI_x86_64_v2_ghc-cheapskate-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cheapskate-doc-0.1.1.2-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cheapskate-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cheapskate-doc}"
SRC_URI[x86_64_v2_ghc-cheapskate-doc.sha256sum] = "abe1f33a7847ba0d38b264a672b3b043ee6d923fc41cc3d07a9cf23e25eca5c9"

URI_x86_64_v2_ghc-cheapskate-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cheapskate-prof-0.1.1.2-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cheapskate-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cheapskate-prof}"
SRC_URI[x86_64_v2_ghc-cheapskate-prof.sha256sum] = "bb3e5bc215b113193ed66b847cdbf6fe81bc2dc0d47fe15fc2b608494f04980f"

URI_aarch64_ghc-cheapskate = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cheapskate-0.1.1.2-23.el10_0.aarch64.rpm;name=aarch64_ghc-cheapskate;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cheapskate}"
SRC_URI[aarch64_ghc-cheapskate.sha256sum] = "6b8d7066bee8ebc02dafd4ccc384974ea59d073637f65b5f1ba329ab0749c6af"

URI_aarch64_ghc-cheapskate-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cheapskate-devel-0.1.1.2-23.el10_0.aarch64.rpm;name=aarch64_ghc-cheapskate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cheapskate-devel}"
SRC_URI[aarch64_ghc-cheapskate-devel.sha256sum] = "3d6a220d658254c7948b55058faeae02c8d5a37bebded5e6302e88bc131b5cc0"

URI_aarch64_ghc-cheapskate-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cheapskate-doc-0.1.1.2-23.el10_0.noarch.rpm;name=aarch64_ghc-cheapskate-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cheapskate-doc}"
SRC_URI[aarch64_ghc-cheapskate-doc.sha256sum] = "c5acaabb4b9958e613efca0c9f62b6f5fea300187487606e97d9da496191bd65"

URI_aarch64_ghc-cheapskate-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cheapskate-prof-0.1.1.2-23.el10_0.aarch64.rpm;name=aarch64_ghc-cheapskate-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cheapskate-prof}"
SRC_URI[aarch64_ghc-cheapskate-prof.sha256sum] = "d73a980f3816e5aadfc90a7c83634b9da8af2310699d8fcd240aecf864c008c7"

RDEPENDS:ghc-cheapskate = " \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-containers \
 ghc-css-text \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-deepseq \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-network-uri \
 ghc-old-locale \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-syb \
 ghc-tagsoup \
 ghc-template-haskell \
 ghc-text \
 ghc-th-compat \
 ghc-transformers \
 ghc-uniplate \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-xss-sanitize \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cheapskate-devel = " \
 ghc-base-devel \
 ghc-blaze-html-devel \
 ghc-cheapskate \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-default-devel \
 ghc-deepseq-devel \
 ghc-mtl-devel \
 ghc-syb-devel \
 ghc-text-devel \
 ghc-uniplate-devel \
 ghc-xss-sanitize-devel \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-cheapskate-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cheapskate-prof = " \
 ghc-base-prof \
 ghc-blaze-html-prof \
 ghc-cheapskate-devel \
 ghc-containers-prof \
 ghc-data-default-prof \
 ghc-deepseq-prof \
 ghc-mtl-prof \
 ghc-syb-prof \
 ghc-text-prof \
 ghc-uniplate-prof \
 ghc-xss-sanitize-prof \
 "
