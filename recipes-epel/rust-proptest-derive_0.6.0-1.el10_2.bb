# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proptest-derive"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-proptest-derive+boxed_union-devel \
 rust-proptest-derive+default-devel \
 rust-proptest-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proptest-derive-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f90d51961f519ed6d47fd90535547ba715fa547e9b6ffba77a487e1a4a0d35a"

URI_x86_64_v2_rust-proptest-derive+boxed_union-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-derive+boxed_union-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-derive+boxed_union-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-derive+boxed_union-devel}"
SRC_URI[x86_64_v2_rust-proptest-derive+boxed_union-devel.sha256sum] = "83c31fc76a24c33f00f684373544d449fd7d420ed56bcd2b143ac6fdbfd0e430"

URI_x86_64_v2_rust-proptest-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-derive+default-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-derive+default-devel}"
SRC_URI[x86_64_v2_rust-proptest-derive+default-devel.sha256sum] = "abe8223a5edc1380098b0beeef2cdc38dd629344f8b0dcbb7054767fe4440e90"

URI_x86_64_v2_rust-proptest-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-derive-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-derive-devel}"
SRC_URI[x86_64_v2_rust-proptest-derive-devel.sha256sum] = "452783fc24b71355543080fb9f0e27c593045904c2fcef82c4d8b7fc0a006cad"

URI_aarch64_rust-proptest-derive+boxed_union-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-derive+boxed_union-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest-derive+boxed_union-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-derive+boxed_union-devel}"
SRC_URI[aarch64_rust-proptest-derive+boxed_union-devel.sha256sum] = "2da81a09f8daf80d3c52a995c17e67efbea388eee918dcc4fe691d14ad4150a9"

URI_aarch64_rust-proptest-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-derive+default-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-derive+default-devel}"
SRC_URI[aarch64_rust-proptest-derive+default-devel.sha256sum] = "fd81dd05a52e78caa7403fe1e2821b7485b7db2f8034d062ea97efe472079b59"

URI_aarch64_rust-proptest-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-derive-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-proptest-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-derive-devel}"
SRC_URI[aarch64_rust-proptest-derive-devel.sha256sum] = "40b03c00ec2a938c72183c7dc970cc9e5ed8c47756ef4ef50eec089360077436"

RDEPENDS:rust-proptest-derive+boxed_union-devel = " \
 cargo \
 rust-proptest-derive-devel \
 "
RDEPENDS:rust-proptest-derive+default-devel = " \
 cargo \
 rust-proptest-derive-devel \
 "
RDEPENDS:rust-proptest-derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-devel \
 "
