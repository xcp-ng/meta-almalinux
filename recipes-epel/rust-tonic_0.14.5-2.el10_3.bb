# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tonic"
PV = "0.14.5"
PR = "2.el10_3"
PACKAGES = " \
 rust-tonic+_tls-any-devel \
 rust-tonic+channel-devel \
 rust-tonic+codegen-devel \
 rust-tonic+default-devel \
 rust-tonic+deflate-devel \
 rust-tonic+gzip-devel \
 rust-tonic+router-devel \
 rust-tonic+server-devel \
 rust-tonic+tls-connect-info-devel \
 rust-tonic+tls-native-roots-devel \
 rust-tonic+tls-ring-devel \
 rust-tonic+tls-webpki-roots-devel \
 rust-tonic+transport-devel \
 rust-tonic+zstd-devel \
 rust-tonic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tonic-0.14.5-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f688f1a881ba5ab531120f5bcbb4854729d84d5a6978b294db80ec51896fa10"

URI_x86_64_v2_rust-tonic+_tls-any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+_tls-any-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+_tls-any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+_tls-any-devel}"
SRC_URI[x86_64_v2_rust-tonic+_tls-any-devel.sha256sum] = "e963dbd26ad6f4804b105ee1d042a31b4e4e58adc8d6f60812c81cf041270762"

URI_x86_64_v2_rust-tonic+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+channel-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+channel-devel}"
SRC_URI[x86_64_v2_rust-tonic+channel-devel.sha256sum] = "5ffdb80beabfbe284808441be2e70322d663e92f3a95fe1d84fc34d9d2fa07c3"

URI_x86_64_v2_rust-tonic+codegen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+codegen-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+codegen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+codegen-devel}"
SRC_URI[x86_64_v2_rust-tonic+codegen-devel.sha256sum] = "40d7afa96b877956456bbac5e4abd4b67b32f6fdb670b3897e0f28318f9eb5e9"

URI_x86_64_v2_rust-tonic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+default-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+default-devel}"
SRC_URI[x86_64_v2_rust-tonic+default-devel.sha256sum] = "28b6d668e1b3b081074a293cb7a23bde9a9f490cf95c6b36d4e32f3517c57f3b"

URI_x86_64_v2_rust-tonic+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+deflate-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+deflate-devel}"
SRC_URI[x86_64_v2_rust-tonic+deflate-devel.sha256sum] = "862946200a526c7dd345eb74b1de787f64017b8303f8c12c6f84d53c75393840"

URI_x86_64_v2_rust-tonic+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+gzip-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+gzip-devel}"
SRC_URI[x86_64_v2_rust-tonic+gzip-devel.sha256sum] = "cf6a91c8a22b906c3045970276d1e931962d71a0433f4f75afb215ee4d018ff5"

URI_x86_64_v2_rust-tonic+router-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+router-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+router-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+router-devel}"
SRC_URI[x86_64_v2_rust-tonic+router-devel.sha256sum] = "dd6fd730fb8a45f2c14f775369e2bb49e6d28188393f2e19839d5eb8cfb1060c"

URI_x86_64_v2_rust-tonic+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+server-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+server-devel}"
SRC_URI[x86_64_v2_rust-tonic+server-devel.sha256sum] = "64a34806801cee4f41e8cf79f2eebfe1a829214bbf4ace6f21d06fd1bd6e71de"

URI_x86_64_v2_rust-tonic+tls-connect-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+tls-connect-info-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+tls-connect-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+tls-connect-info-devel}"
SRC_URI[x86_64_v2_rust-tonic+tls-connect-info-devel.sha256sum] = "f93f5874063aafbee49c1bb82e495c352b3ad49a18db7d54bf5cdcd053afd670"

URI_x86_64_v2_rust-tonic+tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+tls-native-roots-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tonic+tls-native-roots-devel.sha256sum] = "beec2b8662d1cc065ed8baef35b45e226756e7d3a7c537284aa9b89a9746af5e"

URI_x86_64_v2_rust-tonic+tls-ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+tls-ring-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+tls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+tls-ring-devel}"
SRC_URI[x86_64_v2_rust-tonic+tls-ring-devel.sha256sum] = "a3f21eef4b1c05ae78c47db30b455bce4e4640a00dc09a7cd55c096c413b1844"

URI_x86_64_v2_rust-tonic+tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+tls-webpki-roots-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tonic+tls-webpki-roots-devel.sha256sum] = "5a1a5ced2e2b5fa4f21dc02159d8481f317643ce2e383ffeb9ae46dbd2a3fbfc"

URI_x86_64_v2_rust-tonic+transport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+transport-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+transport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+transport-devel}"
SRC_URI[x86_64_v2_rust-tonic+transport-devel.sha256sum] = "1a253ee49b11bca26db076a50745c7c51a6d12d1f3ec13e3a172f7e4b5dbf3d5"

URI_x86_64_v2_rust-tonic+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic+zstd-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic+zstd-devel}"
SRC_URI[x86_64_v2_rust-tonic+zstd-devel.sha256sum] = "8e6dd00a6499d448695f8b3de9ee36e5f935dda79d3ce7fb106cf18fe6f429a8"

URI_x86_64_v2_rust-tonic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic-devel}"
SRC_URI[x86_64_v2_rust-tonic-devel.sha256sum] = "dce76c604d6b2416e699731bad0b073d9b7fc356aa0319224bb9e033ba0e699a"

URI_aarch64_rust-tonic+_tls-any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+_tls-any-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+_tls-any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+_tls-any-devel}"
SRC_URI[aarch64_rust-tonic+_tls-any-devel.sha256sum] = "11de10323c7a43fd4f7688d875c10e515fa114b2bb252b5b0dcbddf77fa5eaea"

URI_aarch64_rust-tonic+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+channel-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+channel-devel}"
SRC_URI[aarch64_rust-tonic+channel-devel.sha256sum] = "f5d49b43b341fc670613a9f95fcd069a2c7459d943a0d9d127e2f1dcaa1f0e2b"

URI_aarch64_rust-tonic+codegen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+codegen-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+codegen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+codegen-devel}"
SRC_URI[aarch64_rust-tonic+codegen-devel.sha256sum] = "d230bb63aec0c66474ae711ffa785e4af37e30d34bc1b6f8c3b95890ea43e055"

URI_aarch64_rust-tonic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+default-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+default-devel}"
SRC_URI[aarch64_rust-tonic+default-devel.sha256sum] = "914804221f2651defe0d593756d87ea2b1b620c3671f4ee11b05777b58c7452e"

URI_aarch64_rust-tonic+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+deflate-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+deflate-devel}"
SRC_URI[aarch64_rust-tonic+deflate-devel.sha256sum] = "f2ce326cac2618cfffd686c1bd8be329ec7bb7789568d7e8dba6284a28105ccd"

URI_aarch64_rust-tonic+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+gzip-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+gzip-devel}"
SRC_URI[aarch64_rust-tonic+gzip-devel.sha256sum] = "1f97db446d25687891bd5e905b01fdee4fd3e1af51211509305f13cdff65d497"

URI_aarch64_rust-tonic+router-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+router-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+router-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+router-devel}"
SRC_URI[aarch64_rust-tonic+router-devel.sha256sum] = "b8e792f96a4434adc7e5b2e0779ab84dd799a98846e9b683bdbdbc4fdd69eeab"

URI_aarch64_rust-tonic+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+server-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+server-devel}"
SRC_URI[aarch64_rust-tonic+server-devel.sha256sum] = "1f37736685c6b25503eb97445b0b73fa2d5b9084b0d37bdddc97c0ea5d6b1c1f"

URI_aarch64_rust-tonic+tls-connect-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+tls-connect-info-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+tls-connect-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+tls-connect-info-devel}"
SRC_URI[aarch64_rust-tonic+tls-connect-info-devel.sha256sum] = "1b2093f208eba54f33898526eca187e005bbb740725f82c99d781414caecf870"

URI_aarch64_rust-tonic+tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+tls-native-roots-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+tls-native-roots-devel}"
SRC_URI[aarch64_rust-tonic+tls-native-roots-devel.sha256sum] = "b577559fe00875f43daa16bb302be068fbbfd5390afae1cdb13696b337b62aa2"

URI_aarch64_rust-tonic+tls-ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+tls-ring-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+tls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+tls-ring-devel}"
SRC_URI[aarch64_rust-tonic+tls-ring-devel.sha256sum] = "e31c8a601574b4da80b0340f97a0db59854ce8d136ca3a458ad9a57b28b3010f"

URI_aarch64_rust-tonic+tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+tls-webpki-roots-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tonic+tls-webpki-roots-devel.sha256sum] = "1e0656087a52aa6158d492bad5f09df9639fa03e1c8661194295669b7b5f011b"

URI_aarch64_rust-tonic+transport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+transport-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+transport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+transport-devel}"
SRC_URI[aarch64_rust-tonic+transport-devel.sha256sum] = "2f03913f29f976375a165d987b1b6d076b5c1a8debdee50d5253d93f52be4108"

URI_aarch64_rust-tonic+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic+zstd-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic+zstd-devel}"
SRC_URI[aarch64_rust-tonic+zstd-devel.sha256sum] = "cb397fad27b72538d70c68b4e2b6e2c4b15048530d88c0d25c269862ee04dfc1"

URI_aarch64_rust-tonic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic-devel}"
SRC_URI[aarch64_rust-tonic-devel.sha256sum] = "d4bcbf5c9b935f1ed1e150127b0c4b6d27e23dd5ce5779dc1dad9da3d7aee9ae"

RDEPENDS:rust-tonic+_tls-any-devel = " \
 cargo \
 rust-tokio+macros-devel \
 rust-tokio+rt-devel \
 rust-tokio-devel \
 rust-tonic+tls-connect-info-devel \
 rust-tonic-devel \
 "
RDEPENDS:rust-tonic+channel-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper-timeout+default-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+tokio-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tonic-devel \
 rust-tower+balance-devel \
 rust-tower+buffer-devel \
 rust-tower+discover-devel \
 rust-tower+limit-devel \
 rust-tower+load-shed-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tonic+codegen-devel = " \
 cargo \
 rust-async-trait+default-devel \
 rust-tonic-devel \
 "
RDEPENDS:rust-tonic+default-devel = " \
 cargo \
 rust-tonic+codegen-devel \
 rust-tonic+router-devel \
 rust-tonic+transport-devel \
 rust-tonic-devel \
 "
RDEPENDS:rust-tonic+deflate-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-tonic-devel \
 "
RDEPENDS:rust-tonic+gzip-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-tonic-devel \
 "
RDEPENDS:rust-tonic+router-devel = " \
 cargo \
 rust-axum-devel \
 rust-tonic-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tonic+server-devel = " \
 cargo \
 rust-h2+default-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tokio-stream+net-devel \
 rust-tonic-devel \
 rust-tower+limit-devel \
 rust-tower+load-shed-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tonic+tls-connect-info-devel = " \
 cargo \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 rust-tonic-devel \
 "
RDEPENDS:rust-tonic+tls-native-roots-devel = " \
 cargo \
 rust-rustls-native-certs+default-devel \
 rust-tonic+_tls-any-devel \
 rust-tonic+channel-devel \
 rust-tonic-devel \
 "
RDEPENDS:rust-tonic+tls-ring-devel = " \
 cargo \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 rust-tonic+_tls-any-devel \
 rust-tonic-devel \
 "
RDEPENDS:rust-tonic+tls-webpki-roots-devel = " \
 cargo \
 rust-tonic+_tls-any-devel \
 rust-tonic+channel-devel \
 rust-tonic-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-tonic+transport-devel = " \
 cargo \
 rust-tonic+channel-devel \
 rust-tonic+server-devel \
 rust-tonic-devel \
 "
RDEPENDS:rust-tonic+zstd-devel = " \
 cargo \
 rust-tonic-devel \
 rust-zstd+default-devel \
 "
RDEPENDS:rust-tonic-devel = " \
 cargo \
 rust \
 rust-base64_0.22+default-devel \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project+default-devel \
 rust-sync_wrapper+default-devel \
 rust-tokio-stream-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 rust-tracing+default-devel \
 "
