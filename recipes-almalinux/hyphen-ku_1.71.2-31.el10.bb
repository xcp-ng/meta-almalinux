# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-ku"
PV = "1.71.2"
PR = "31.el10"
PACKAGES = " \
 hyphen-ku \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-ku-1.71.2-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1ade04c8f78233871a8e946bf545ede32a1fa71932c48f00bdbba33874dd981"

URI_x86_64_v2_hyphen-ku = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-ku-1.71.2-31.el10.noarch.rpm;name=x86_64_v2_hyphen-ku;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-ku}"
SRC_URI[x86_64_v2_hyphen-ku.sha256sum] = "9ca2c72b15dc0aaef0c2c15f3c98ab135e3de070a5769434627633e4c06e352a"

URI_aarch64_hyphen-ku = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-ku-1.71.2-31.el10.noarch.rpm;name=aarch64_hyphen-ku;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-ku}"
SRC_URI[aarch64_hyphen-ku.sha256sum] = "9ca2c72b15dc0aaef0c2c15f3c98ab135e3de070a5769434627633e4c06e352a"

RDEPENDS:hyphen-ku = " \
 hyphen \
 "
