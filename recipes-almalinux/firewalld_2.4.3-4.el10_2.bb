# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firewalld"
PV = "2.4.3"
PR = "4.el10_2"
PACKAGES = " \
 firewall-applet \
 firewall-config \
 firewalld \
 firewalld-filesystem \
 python3-firewall \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/firewalld-2.4.3-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c737efc4d193efd71bb8c03d55083da591b6afdde4465821b4dc4d187992535"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firewall-applet-2.4.3-4.el10_2.noarch.rpm;name=x86_64_v2_firewall-applet;unpack=0"
SRC_URI[x86_64_v2_firewall-applet.sha256sum] = "80e1e41a3f4e7948e4f29b1bb7dad8e2fc5db51ff7db13b68422639a3c958072"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firewall-config-2.4.3-4.el10_2.noarch.rpm;name=x86_64_v2_firewall-config;unpack=0"
SRC_URI[x86_64_v2_firewall-config.sha256sum] = "1deac5c4dc7f57697194121903a22e3c12c3e0b084e57cec25c265245089ecb4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/firewalld-2.4.3-4.el10_2.noarch.rpm;name=x86_64_v2_firewalld;unpack=0"
SRC_URI[x86_64_v2_firewalld.sha256sum] = "f5f4a3dde4648d63c0788338b29d659529a82ad20b6b847a4d2435f0936d52d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/firewalld-filesystem-2.4.3-4.el10_2.noarch.rpm;name=x86_64_v2_firewalld-filesystem;unpack=0"
SRC_URI[x86_64_v2_firewalld-filesystem.sha256sum] = "e06163c486be0d18b840a03a604ca734b588e22687a876bf7c906423da1266c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-firewall-2.4.3-4.el10_2.noarch.rpm;name=x86_64_v2_python3-firewall;unpack=0"
SRC_URI[x86_64_v2_python3-firewall.sha256sum] = "c008b6b62ec34fbcbae74fdd41f8a8e6deb2b742f38670141c120adf18ed290b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firewall-applet-2.4.3-4.el10_2.noarch.rpm;name=aarch64_firewall-applet;unpack=0"
SRC_URI[aarch64_firewall-applet.sha256sum] = "80e1e41a3f4e7948e4f29b1bb7dad8e2fc5db51ff7db13b68422639a3c958072"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firewall-config-2.4.3-4.el10_2.noarch.rpm;name=aarch64_firewall-config;unpack=0"
SRC_URI[aarch64_firewall-config.sha256sum] = "1deac5c4dc7f57697194121903a22e3c12c3e0b084e57cec25c265245089ecb4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/firewalld-2.4.3-4.el10_2.noarch.rpm;name=aarch64_firewalld;unpack=0"
SRC_URI[aarch64_firewalld.sha256sum] = "f5f4a3dde4648d63c0788338b29d659529a82ad20b6b847a4d2435f0936d52d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/firewalld-filesystem-2.4.3-4.el10_2.noarch.rpm;name=aarch64_firewalld-filesystem;unpack=0"
SRC_URI[aarch64_firewalld-filesystem.sha256sum] = "e06163c486be0d18b840a03a604ca734b588e22687a876bf7c906423da1266c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-firewall-2.4.3-4.el10_2.noarch.rpm;name=aarch64_python3-firewall;unpack=0"
SRC_URI[aarch64_python3-firewall.sha256sum] = "c008b6b62ec34fbcbae74fdd41f8a8e6deb2b742f38670141c120adf18ed290b"

RDEPENDS:firewall-applet = " \
 NetworkManager-libnm \
 dbus-x11 \
 firewall-config \
 firewalld \
 hicolor-icon-theme \
 libnotify \
 python3 \
 python3-firewall \
 python3-gobject \
 python3-pyqt6-base \
 "
RDEPENDS:firewall-config = " \
 NetworkManager-libnm \
 dbus-x11 \
 firewalld \
 gtk3 \
 hicolor-icon-theme \
 python3 \
 python3-firewall \
 python3-gobject \
 "
RDEPENDS:firewalld = " \
 bash \
 firewalld-filesystem \
 python3 \
 python3-firewall \
 systemd \
 "
RDEPENDS:firewalld-filesystem = " \
 "
RDEPENDS:python3-firewall = " \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-nftables \
 "
