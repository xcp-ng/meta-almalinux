# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "VK_hdr_layer"
PV = "0~git20250416.3b276e6"
PR = "1.el10_1"
PACKAGES = " \
 VK_hdr_layer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/VK_hdr_layer-0~git20250416.3b276e6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f5e56740aa91104fb8f0b4dc240913fac44f82a756f9ed300e0c3027c8149b5"

URI_x86_64_v2_VK_hdr_layer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/VK_hdr_layer-0~git20250416.3b276e6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_VK_hdr_layer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_VK_hdr_layer}"
SRC_URI[x86_64_v2_VK_hdr_layer.sha256sum] = "37f49e830f507d62e1f847ece8511147fd0b0083c6db7163de627dcc73c7eb70"

URI_aarch64_VK_hdr_layer = "${EPEL_MIRROR}/aarch64/Packages/v/VK_hdr_layer-0~git20250416.3b276e6-1.el10_1.aarch64.rpm;name=aarch64_VK_hdr_layer;unpack=0"
SRC_URI:append = " ${URI_aarch64_VK_hdr_layer}"
SRC_URI[aarch64_VK_hdr_layer.sha256sum] = "809e17146e71a4a0615c79f8ab77f899f662ff8a49bd074aa3f5d41f133e5126"

RDEPENDS:VK_hdr_layer = " \
 glibc \
 libgcc \
 libstdc++ \
 libwayland-client \
 "
