# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cobbler3.3"
PV = "3.3.7"
PR = "1.el10_1"
PACKAGES = " \
 cobbler3.3 \
 cobbler3.3-selinux \
 cobbler3.3-tests \
 cobbler3.3-tests-containers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cobbler3.3-3.3.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86d548c1b56f5bc4e5ff5fc3c129a560ce60a94ac5e3edb560df1c1846c151af"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - cobbler3.3: (syslinux if (filesystem.x86_64 or filesystem.i686))

URI_x86_64_v2_cobbler3.3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-3.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cobbler3.3}"
SRC_URI[x86_64_v2_cobbler3.3.sha256sum] = "15494fd8867c9b0f14a5ea2ea70945c5cfac085a18f30647a7722529779f1801"

URI_x86_64_v2_cobbler3.3-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-selinux-3.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cobbler3.3-selinux}"
SRC_URI[x86_64_v2_cobbler3.3-selinux.sha256sum] = "f2278d73df47a0a7af339ab8b177b640107a300c40631eefcbf51fbd0e1c52d9"

URI_x86_64_v2_cobbler3.3-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-tests-3.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cobbler3.3-tests}"
SRC_URI[x86_64_v2_cobbler3.3-tests.sha256sum] = "bbf5b19ba526cd3ef83dc7b259a3e8d9d354fee886db29714746bc171a80b14b"

URI_x86_64_v2_cobbler3.3-tests-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cobbler3.3-tests-containers-3.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cobbler3.3-tests-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cobbler3.3-tests-containers}"
SRC_URI[x86_64_v2_cobbler3.3-tests-containers.sha256sum] = "bdb7997a3b1c42f5c757740820434b2f9648f35a8d643d9347020b10966fe24c"

URI_aarch64_cobbler3.3 = "${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-3.3.7-1.el10_1.noarch.rpm;name=aarch64_cobbler3.3;unpack=0"
SRC_URI:append = " ${URI_aarch64_cobbler3.3}"
SRC_URI[aarch64_cobbler3.3.sha256sum] = "4711a06c5074a6555771c80886d222b6070e702aac1f3e68c481a163bc1eb91c"

URI_aarch64_cobbler3.3-selinux = "${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-selinux-3.3.7-1.el10_1.noarch.rpm;name=aarch64_cobbler3.3-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_cobbler3.3-selinux}"
SRC_URI[aarch64_cobbler3.3-selinux.sha256sum] = "fb8ae8b79170d848e480d2b2fa913dbe147f44c20a8e046c18df2a965e968a1e"

URI_aarch64_cobbler3.3-tests = "${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-tests-3.3.7-1.el10_1.noarch.rpm;name=aarch64_cobbler3.3-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_cobbler3.3-tests}"
SRC_URI[aarch64_cobbler3.3-tests.sha256sum] = "9390410c5627499ab6c1019a2cc8d36536898bb8bdfac770435ff51f737b70b1"

URI_aarch64_cobbler3.3-tests-containers = "${EPEL_MIRROR}/aarch64/Packages/c/cobbler3.3-tests-containers-3.3.7-1.el10_1.noarch.rpm;name=aarch64_cobbler3.3-tests-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_cobbler3.3-tests-containers}"
SRC_URI[aarch64_cobbler3.3-tests-containers.sha256sum] = "36a9e6d0553525c3b6d967cdf356ea20a285d9554fa808c309aa82a4e62fb113"

RDEPENDS:cobbler3.3:x86_64_v2 = " \
 bash \
 cobbler3.3-selinux \
 createrepo_c \
 dnf-plugins-core \
 dosfstools \
 genisoimage \
 httpd \
 python3 \
 python3-cheetah \
 python3-distro \
 python3-dns \
 python3-file-magic \
 python3-ldap \
 python3-mod_wsgi \
 python3-netaddr \
 python3-pymongo \
 python3-pyyaml \
 python3-requests \
 python3-schema \
 rsync \
 syslinux \
 systemd \
 tftp-server \
 xorriso \
"
RDEPENDS:cobbler3.3:aarch64 = " \
 bash \
 cobbler3.3-selinux \
 createrepo_c \
 dnf-plugins-core \
 dosfstools \
 genisoimage \
 httpd \
 python3 \
 python3-cheetah \
 python3-distro \
 python3-dns \
 python3-file-magic \
 python3-ldap \
 python3-mod_wsgi \
 python3-netaddr \
 python3-pymongo \
 python3-pyyaml \
 python3-requests \
 python3-schema \
 rsync \
 systemd \
 tftp-server \
 xorriso \
"
RDEPENDS:cobbler3.3-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:cobbler3.3-tests = " \
 cobbler3.3 \
 "
RDEPENDS:cobbler3.3-tests-containers = " \
 bash \
 cobbler3.3 \
 "
