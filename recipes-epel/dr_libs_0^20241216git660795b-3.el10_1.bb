# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dr_libs"
PV = "0^20241216git660795b"
PR = "3.el10_1"
PACKAGES = " \
 dr_flac-devel \
 dr_libs-devel \
 dr_libs-doc \
 dr_mp3-devel \
 dr_wav-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dr_libs-0^20241216git660795b-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6b468aec1e7128a24bb2056323e1f1d12b6dd340cd233fe6a48f8bd462280d2"

URI_x86_64_v2_dr_flac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_flac-devel-0.12.43^20241216git660795b-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dr_flac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_flac-devel}"
SRC_URI[x86_64_v2_dr_flac-devel.sha256sum] = "4916d20d1941b76a38256ae2fbc6c645a7f0c6dc8cc524c5a03332fe3c09a490"

URI_x86_64_v2_dr_libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_libs-devel-0^20241216git660795b-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dr_libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_libs-devel}"
SRC_URI[x86_64_v2_dr_libs-devel.sha256sum] = "2ee1803769958dd97148122a2e7a32681017d950865bcc7eb4632d86c99ba0cb"

URI_x86_64_v2_dr_libs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_libs-doc-0^20241216git660795b-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dr_libs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_libs-doc}"
SRC_URI[x86_64_v2_dr_libs-doc.sha256sum] = "9e4ef438009cf6c511094fa970d1fcf2942b6321343cbe581b8d96af40a11e0b"

URI_x86_64_v2_dr_mp3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_mp3-devel-0.6.40^20241216git660795b-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dr_mp3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_mp3-devel}"
SRC_URI[x86_64_v2_dr_mp3-devel.sha256sum] = "c6e633ab4c716f31a6797dd52eaf981258bfa74f387539c58ac71238014605fc"

URI_x86_64_v2_dr_wav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_wav-devel-0.13.17^20241216git660795b-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dr_wav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_wav-devel}"
SRC_URI[x86_64_v2_dr_wav-devel.sha256sum] = "c1b47f9a47b1067d3f54be5d80b4ace3363c2cfb52bf6fd035fa565dccfd3817"

URI_aarch64_dr_flac-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_flac-devel-0.12.43^20241216git660795b-3.el10_1.noarch.rpm;name=aarch64_dr_flac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_flac-devel}"
SRC_URI[aarch64_dr_flac-devel.sha256sum] = "5987e3c1f344e4e2004d6c34edb0cc39b8e3ca2cfb6e9f576f01459de89fe982"

URI_aarch64_dr_libs-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_libs-devel-0^20241216git660795b-3.el10_1.noarch.rpm;name=aarch64_dr_libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_libs-devel}"
SRC_URI[aarch64_dr_libs-devel.sha256sum] = "25164a074f26e29e89e5f380900a9b84119425176d799e567327937449d59fa8"

URI_aarch64_dr_libs-doc = "${EPEL_MIRROR}/aarch64/Packages/d/dr_libs-doc-0^20241216git660795b-3.el10_1.noarch.rpm;name=aarch64_dr_libs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_libs-doc}"
SRC_URI[aarch64_dr_libs-doc.sha256sum] = "749b221026f5f85ec40bbdf3e9cf781328ab74ee91ec8e1e235ae707e39ea764"

URI_aarch64_dr_mp3-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_mp3-devel-0.6.40^20241216git660795b-3.el10_1.noarch.rpm;name=aarch64_dr_mp3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_mp3-devel}"
SRC_URI[aarch64_dr_mp3-devel.sha256sum] = "68b08fca121cabda85730593a1eb03ad7df15fff11ca068bed3e2118e434b40e"

URI_aarch64_dr_wav-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_wav-devel-0.13.17^20241216git660795b-3.el10_1.noarch.rpm;name=aarch64_dr_wav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_wav-devel}"
SRC_URI[aarch64_dr_wav-devel.sha256sum] = "5859dabfe6bfc783172064b75839dc1d78b2c86b3afd3ef2e15bcb5f97869104"

RDEPENDS:dr_flac-devel = " \
 "
RDEPENDS:dr_libs-devel = " \
 dr_flac-devel \
 dr_mp3-devel \
 dr_wav-devel \
 "
RDEPENDS:dr_libs-doc = " \
 "
RDEPENDS:dr_mp3-devel = " \
 "
RDEPENDS:dr_wav-devel = " \
 "
