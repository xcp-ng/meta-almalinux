# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "reposurgeon"
PV = "5.11"
PR = "1.el10_3"
PACKAGES = " \
 reposurgeon \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/reposurgeon-5.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ad811e297391598d0e3c70ca88ddcfa18230925b0678291fd5d99ffddc65ef36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/reposurgeon-5.11-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_reposurgeon;unpack=0"
SRC_URI[x86_64_v2_reposurgeon.sha256sum] = "671bc60d6a8898d75865d9495ef9db1e8454e8a53ef1e432e4dedcf893602b36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/reposurgeon-5.11-1.el10_3.aarch64.rpm;name=aarch64_reposurgeon;unpack=0"
SRC_URI[aarch64_reposurgeon.sha256sum] = "a47df4c0968c56bf6cc46ebcdfc64a5abd7875b86631f9cf510ef6807044bda0"

RDEPENDS:reposurgeon = " \
 emacs-filesystem \
 glibc \
 "
