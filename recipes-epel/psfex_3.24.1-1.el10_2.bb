# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "psfex"
PV = "3.24.1"
PR = "1.el10_2"
PACKAGES = " \
 psfex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/psfex-3.24.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f27f2d589317643c2a0888d88ddcf2e95861f7e6d11591bc94dc3e341966a7ce"

URI_x86_64_v2_psfex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psfex-3.24.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_psfex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psfex}"
SRC_URI[x86_64_v2_psfex.sha256sum] = "01a862079bbe95f99c071b8a808e029e1498ce1b2c20cc50a56b8955f54e9f07"

URI_aarch64_psfex = "${EPEL_MIRROR}/aarch64/Packages/p/psfex-3.24.1-1.el10_2.aarch64.rpm;name=aarch64_psfex;unpack=0"
SRC_URI:append = " ${URI_aarch64_psfex}"
SRC_URI[aarch64_psfex.sha256sum] = "72f59fa576fa0d4b8e7075203f816aa414a1700969476cd9c0d5ec2d56523ffb"

RDEPENDS:psfex = " \
 fftw-libs-single \
 glibc \
 openblas-threads \
 "
