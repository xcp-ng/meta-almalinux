# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-feedparser"
PV = "6.0.11"
PR = "5.el10_1"
PACKAGES = " \
 python-feedparser-doc \
 python3-feedparser \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-feedparser-6.0.11-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d010cc35d5f4b8a39a4b57d92b1e5109f08c5fe7d581c3686ee2513c8eda729"

URI_x86_64_v2_python-feedparser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-feedparser-doc-6.0.11-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-feedparser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-feedparser-doc}"
SRC_URI[x86_64_v2_python-feedparser-doc.sha256sum] = "e0f761f58d4fe797fc1c9502c01f4da7ed876f89dc8ff1834aa0f05f8c086e27"

URI_x86_64_v2_python3-feedparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-feedparser-6.0.11-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-feedparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-feedparser}"
SRC_URI[x86_64_v2_python3-feedparser.sha256sum] = "a50671ea3a8310019e6d734202a7192faaf7be710dbd5c57824d93b1090204bc"

URI_aarch64_python-feedparser-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-feedparser-doc-6.0.11-5.el10_1.noarch.rpm;name=aarch64_python-feedparser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-feedparser-doc}"
SRC_URI[aarch64_python-feedparser-doc.sha256sum] = "828888ddfa49f039f689db6efd30adc239adf709030e9581d45848e299882f87"

URI_aarch64_python3-feedparser = "${EPEL_MIRROR}/aarch64/Packages/p/python3-feedparser-6.0.11-5.el10_1.noarch.rpm;name=aarch64_python3-feedparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-feedparser}"
SRC_URI[aarch64_python3-feedparser.sha256sum] = "7545b63f629d7a6b93ca69411779ce32e29d7d23391dea19e8ad90b2c3e5ee2a"

RDEPENDS:python-feedparser-doc = " \
 "
RDEPENDS:python3-feedparser = " \
 python3 \
 python3-sgmllib3k \
 "
