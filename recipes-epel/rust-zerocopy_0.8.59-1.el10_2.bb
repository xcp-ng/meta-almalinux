# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy"
PV = "0.8.59"
PR = "1.el10_2"
PACKAGES = " \
 rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+float-nightly-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+simd-nightly-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-0.8.59-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "30dcaaab1bd42542ef711ad428dba60375e4aec548fde936021fda06cdf2502e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "107f43b092255f08131e3c7a22dc4e2e35e2596e236877a33468f0b91cf707f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+alloc-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+alloc-devel.sha256sum] = "986fd47f31f3a35659cbecb72c4e6cea3cef9acac1444f2d7e291af8e61a1190"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+default-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+default-devel.sha256sum] = "c12daf07fc5f16190642da29138b6fc56107b4dd7a934b6feb113565718be4d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+derive-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+derive-devel.sha256sum] = "8b2d8d4bdd07d5e1c30c9a5af9c12320daf9aa8ba044ff76eff99d5eccb033b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+float-nightly-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+float-nightly-devel.sha256sum] = "e78fd723dfcc5eaf08d7616cf816162b683bde2b53e8a6a47c91350efe3037b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+simd-devel.sha256sum] = "4c07bbb992273294d4fd57efdbdce60fc46bc2097a76cace9c7c04a268a432aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+simd-nightly-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+simd-nightly-devel.sha256sum] = "ca8b2371c71029d83bf588ce61b6953a785706cfcf190455f7a944b0e48bea5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+std-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+std-devel.sha256sum] = "6758a70f05b58fb87d11e9ae691c75b7af5ffade71569feb08cbf715126ad28e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy+zerocopy-derive-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "66516b22b8b38b2ffde2d38042cb3b85f5601a19daa1e0a6745c883ff8473a9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-devel-0.8.59-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy-devel.sha256sum] = "0fb87636445142294c8777eb9f2b3fdba7876c2142e104d79a698f99ec2d3493"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel.sha256sum] = "5e4e13a70ffbfd3d13dfbf80364f7f2947bf6db87946a536144e5f60a9e51827"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+alloc-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+alloc-devel.sha256sum] = "a3902d6dd880df514fb19fcdb60b16755b365e548384e2792278c58dc49c784a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+default-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+default-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+default-devel.sha256sum] = "95302d619bbc0f7c0712cb934cc6ebf3d591f84308be6970aae6eee5a7c758ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+derive-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+derive-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+derive-devel.sha256sum] = "c941238f7752f92d93ee3067acfa77979d3dbb6cbadb4768be880ca820feaeb6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+float-nightly-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+float-nightly-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+float-nightly-devel.sha256sum] = "e8c7471c22062cd73ff4e38fa5f5ccc4d18aaaff15c9a32ab52cabbb09cadb9a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+simd-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+simd-devel.sha256sum] = "613e23fc5ed2cdd9d6e9a073cb26d75284021a0efe6d058a63585bf2718b0ffb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+simd-nightly-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+simd-nightly-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+simd-nightly-devel.sha256sum] = "3b4377491b7f7365671e916d2a73d324308f69efebd64c9e769f70742eeff41a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+std-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+std-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+std-devel.sha256sum] = "e785f7ee0272a93e4b11ed09024ee13b8783b5a064b2289957de8cab88b521ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy+zerocopy-derive-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy+zerocopy-derive-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy+zerocopy-derive-devel.sha256sum] = "a3dfcca5b4248489e930e258f9ed6e84802a7cbdd8db5c8137a6d5df25db62bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-devel-0.8.59-1.el10_2.noarch.rpm;name=aarch64_rust-zerocopy-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy-devel.sha256sum] = "e2399ea807d936d99b5a484ddba8d6b1d0cfa436bacb18707dc6af576278933f"

RDEPENDS:rust-zerocopy+__internal_use_only_features_that_work_on_stable-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy+std-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+alloc-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+default-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+derive-devel = " \
 cargo \
 rust-zerocopy+zerocopy-derive-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+float-nightly-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-devel = " \
 cargo \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+simd-nightly-devel = " \
 cargo \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+std-devel = " \
 cargo \
 rust-zerocopy+alloc-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy+zerocopy-derive-devel = " \
 cargo \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-zerocopy-devel = " \
 cargo \
 rust \
 rust-zerocopy-derive+default-devel \
 "
