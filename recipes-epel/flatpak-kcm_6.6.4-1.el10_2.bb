# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-kcm"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 flatpak-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flatpak-kcm-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff172b97f7e471880bb3c031e304cb33a3bb0318d02fb004b7e2e2bad0ae4943"

URI_x86_64_v2_flatpak-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatpak-kcm-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flatpak-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-kcm}"
SRC_URI[x86_64_v2_flatpak-kcm.sha256sum] = "40ccc8d9e01aef01b0ba2bb10335218fa672ae4c245615f95fd85522fab2e47f"

URI_aarch64_flatpak-kcm = "${EPEL_MIRROR}/aarch64/Packages/f/flatpak-kcm-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_flatpak-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-kcm}"
SRC_URI[aarch64_flatpak-kcm.sha256sum] = "7996864f571990e3ed8b4e7ba0686911fe41576a87774866b4927720f9311c1b"

RDEPENDS:flatpak-kcm = " \
 flatpak-libs \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
