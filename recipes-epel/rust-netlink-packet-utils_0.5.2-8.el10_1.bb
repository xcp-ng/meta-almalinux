# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-netlink-packet-utils"
PV = "0.5.2"
PR = "8.el10_1"
PACKAGES = " \
 rust-netlink-packet-utils+default-devel \
 rust-netlink-packet-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-netlink-packet-utils-0.5.2-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18c34634e7693dc17e72e4a8aabc7a006fbf2a6084ef6cace38f2da1d6afc990"

URI_x86_64_v2_rust-netlink-packet-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-utils+default-devel-0.5.2-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-utils+default-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-utils+default-devel.sha256sum] = "a6284a7aec2410af7d7074a6c81f2a4bbe0f7b1f7902c64aea1868062a134b07"

URI_x86_64_v2_rust-netlink-packet-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netlink-packet-utils-devel-0.5.2-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netlink-packet-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netlink-packet-utils-devel}"
SRC_URI[x86_64_v2_rust-netlink-packet-utils-devel.sha256sum] = "48019779989416580f22f20b361d439380dbd0851d5610713b5b534437a8bb5d"

URI_aarch64_rust-netlink-packet-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-utils+default-devel-0.5.2-8.el10_1.noarch.rpm;name=aarch64_rust-netlink-packet-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-utils+default-devel}"
SRC_URI[aarch64_rust-netlink-packet-utils+default-devel.sha256sum] = "d103ff9553df61aefd4cd6b8fe1825cc02dd1b6f5c208e3ef8e590b498a5e905"

URI_aarch64_rust-netlink-packet-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netlink-packet-utils-devel-0.5.2-8.el10_1.noarch.rpm;name=aarch64_rust-netlink-packet-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netlink-packet-utils-devel}"
SRC_URI[aarch64_rust-netlink-packet-utils-devel.sha256sum] = "beb5fa8ad12929ced7c85fa88d3923e1dd64d30ffbfb8d3ee1cd28d586319393"

RDEPENDS:rust-netlink-packet-utils+default-devel = " \
 cargo \
 rust-netlink-packet-utils-devel \
 "
RDEPENDS:rust-netlink-packet-utils-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-byteorder+default-devel \
 rust-paste+default-devel \
 rust-thiserror1+default-devel \
 "
