# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-core"
PV = "1.0.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-lexical-core+compact-devel \
 rust-lexical-core+default-devel \
 rust-lexical-core+f128-devel \
 rust-lexical-core+f16-devel \
 rust-lexical-core+floats-devel \
 rust-lexical-core+format-devel \
 rust-lexical-core+integers-devel \
 rust-lexical-core+lexical-parse-float-devel \
 rust-lexical-core+lexical-parse-integer-devel \
 rust-lexical-core+lexical-write-float-devel \
 rust-lexical-core+lexical-write-integer-devel \
 rust-lexical-core+lint-devel \
 rust-lexical-core+parse-devel \
 rust-lexical-core+parse-floats-devel \
 rust-lexical-core+parse-integers-devel \
 rust-lexical-core+power-of-two-devel \
 rust-lexical-core+radix-devel \
 rust-lexical-core+std-devel \
 rust-lexical-core+write-devel \
 rust-lexical-core+write-floats-devel \
 rust-lexical-core+write-integers-devel \
 rust-lexical-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-core-1.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2de4c998e1d52807048feb6ae590071cd7dde38abff8169b66cf2d5911f134ff"

URI_x86_64_v2_rust-lexical-core+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+compact-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+compact-devel.sha256sum] = "6d4fe3b2683012c0ba587d3f3919e8f558f30e4354e3e01def4bc4e55555d100"

URI_x86_64_v2_rust-lexical-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+default-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+default-devel.sha256sum] = "89d04148d6e6a736d8e0fbf33c76c44f20064faf343f0f21fcc3a41ca4f07313"

URI_x86_64_v2_rust-lexical-core+f128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+f128-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+f128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+f128-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+f128-devel.sha256sum] = "74d6e7fd1c4e066e8c350518ec00776dbf5534ee6d9d88337d86495ac568a104"

URI_x86_64_v2_rust-lexical-core+f16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+f16-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+f16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+f16-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+f16-devel.sha256sum] = "7c937570fcd4f94dccb95dac01b1e13e37cdbd61289a489f3a9706c64cf193a5"

URI_x86_64_v2_rust-lexical-core+floats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+floats-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+floats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+floats-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+floats-devel.sha256sum] = "764378f5fe2627c102329bbce7cf46ad112c799e602df30156bd8bce4b86b644"

URI_x86_64_v2_rust-lexical-core+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+format-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+format-devel.sha256sum] = "10539dd0852c9544dddcba479744e8b6b43192ae75c3427ee79596a15bc00c68"

URI_x86_64_v2_rust-lexical-core+integers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+integers-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+integers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+integers-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+integers-devel.sha256sum] = "20e06868ef9a83bb7726a15162c3820f24d7186deea9b6303fd23173da4c75f4"

URI_x86_64_v2_rust-lexical-core+lexical-parse-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+lexical-parse-float-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+lexical-parse-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+lexical-parse-float-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+lexical-parse-float-devel.sha256sum] = "5bbc74140efdae4964a3b62ce8c7270676c309943506503485297dd80cf1159c"

URI_x86_64_v2_rust-lexical-core+lexical-parse-integer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+lexical-parse-integer-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+lexical-parse-integer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+lexical-parse-integer-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+lexical-parse-integer-devel.sha256sum] = "9dec3cdaf8c79eacd2f87848a5562129a7da080608cec65fdec2e90871919115"

URI_x86_64_v2_rust-lexical-core+lexical-write-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+lexical-write-float-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+lexical-write-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+lexical-write-float-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+lexical-write-float-devel.sha256sum] = "66c1e1c6fce3733626f99fc8e150e66ea44eb9152fbacb3a424698ddc01c1ca8"

URI_x86_64_v2_rust-lexical-core+lexical-write-integer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+lexical-write-integer-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+lexical-write-integer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+lexical-write-integer-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+lexical-write-integer-devel.sha256sum] = "06df3c922f363413e808dca5369b0c9ab797f7e604013a689808f57b29a39b77"

URI_x86_64_v2_rust-lexical-core+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+lint-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+lint-devel.sha256sum] = "89fd114c2c686a979d92822ec8136ec8266c1160e7a7d94c9d1b66f64b792ba2"

URI_x86_64_v2_rust-lexical-core+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+parse-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+parse-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+parse-devel.sha256sum] = "0762ebbc984bb0b2a3d42675a20649c6a0d49f2ca93c21f8bbe73413f1af117d"

URI_x86_64_v2_rust-lexical-core+parse-floats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+parse-floats-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+parse-floats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+parse-floats-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+parse-floats-devel.sha256sum] = "cf274d7bb8e8cf89ee7baab97ea7ac57fb32bc6b391291d38309a6e92070d5c2"

URI_x86_64_v2_rust-lexical-core+parse-integers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+parse-integers-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+parse-integers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+parse-integers-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+parse-integers-devel.sha256sum] = "384ff7a6720d7095bfe6b9e3526b312c5d8c5182538169cc87032550da3a91cf"

URI_x86_64_v2_rust-lexical-core+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+power-of-two-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+power-of-two-devel.sha256sum] = "a132286578c76f977baf513049435154b3016429c0fa873b5727e823fc2440b1"

URI_x86_64_v2_rust-lexical-core+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+radix-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+radix-devel.sha256sum] = "8cafe897f4d0d0fd559314fd7d76b2330e4e542c7cb83062ed77663240a5c3a1"

URI_x86_64_v2_rust-lexical-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+std-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+std-devel.sha256sum] = "88df8655d12ad1c41cad642a6637fd787556cf7be8f767d26dac472590e25514"

URI_x86_64_v2_rust-lexical-core+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+write-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+write-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+write-devel.sha256sum] = "270ae206fd1792a4983bec976994a8e82d78b530bea926d77e989deb58b7335f"

URI_x86_64_v2_rust-lexical-core+write-floats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+write-floats-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+write-floats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+write-floats-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+write-floats-devel.sha256sum] = "87770fe1508d27415114b72779607b1e5a04dd7e048ad749591323f9177b395d"

URI_x86_64_v2_rust-lexical-core+write-integers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core+write-integers-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core+write-integers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core+write-integers-devel}"
SRC_URI[x86_64_v2_rust-lexical-core+write-integers-devel.sha256sum] = "1df875e5bbe5b9ba591a4a7d5bd6e8f277574bd3eae32db4a0666168cd894061"

URI_x86_64_v2_rust-lexical-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-core-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-core-devel}"
SRC_URI[x86_64_v2_rust-lexical-core-devel.sha256sum] = "fe9643849187741004141fc1d6d35c31390a5477df4407d8b33c98f12681adcf"

URI_aarch64_rust-lexical-core+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+compact-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+compact-devel}"
SRC_URI[aarch64_rust-lexical-core+compact-devel.sha256sum] = "987be5a92daeb54e531e9eaa1098f09c8be0dfd6dddfdd5a8fafb1637bb7fcdd"

URI_aarch64_rust-lexical-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+default-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+default-devel}"
SRC_URI[aarch64_rust-lexical-core+default-devel.sha256sum] = "bbda9070d58063833f884395bed10c109215d25aba53856bb99ca294b83cb68b"

URI_aarch64_rust-lexical-core+f128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+f128-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+f128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+f128-devel}"
SRC_URI[aarch64_rust-lexical-core+f128-devel.sha256sum] = "2dd1663549692aa4b452219eed9909034432b2a2a703d4313edcdd99005588ce"

URI_aarch64_rust-lexical-core+f16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+f16-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+f16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+f16-devel}"
SRC_URI[aarch64_rust-lexical-core+f16-devel.sha256sum] = "941a7f1890e806bd45452b23a9fd11e901e67e5ae518b109a8c70e0710201db6"

URI_aarch64_rust-lexical-core+floats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+floats-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+floats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+floats-devel}"
SRC_URI[aarch64_rust-lexical-core+floats-devel.sha256sum] = "52feb0ee6763c07c5d28e5ec0cf37339b12867fadade3fdb3f7367c5a6f011eb"

URI_aarch64_rust-lexical-core+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+format-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+format-devel}"
SRC_URI[aarch64_rust-lexical-core+format-devel.sha256sum] = "39935d31b4c66905796afa1adb8b52192803d49f0476124da82f98aaac1ab8c4"

URI_aarch64_rust-lexical-core+integers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+integers-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+integers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+integers-devel}"
SRC_URI[aarch64_rust-lexical-core+integers-devel.sha256sum] = "b09e3a8c990a57c0f0b7e46d30228bc23e161057eaa510220faee4f8469b23a6"

URI_aarch64_rust-lexical-core+lexical-parse-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+lexical-parse-float-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+lexical-parse-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+lexical-parse-float-devel}"
SRC_URI[aarch64_rust-lexical-core+lexical-parse-float-devel.sha256sum] = "354725f419d6bff445a05832e582c3bed5d56963bd7fd7f37ad2b227ddd1bdc8"

URI_aarch64_rust-lexical-core+lexical-parse-integer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+lexical-parse-integer-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+lexical-parse-integer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+lexical-parse-integer-devel}"
SRC_URI[aarch64_rust-lexical-core+lexical-parse-integer-devel.sha256sum] = "2d8f859d0a5d6ea4b36c9593265c24762e151cced3a85603511e8cd9c3297c1d"

URI_aarch64_rust-lexical-core+lexical-write-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+lexical-write-float-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+lexical-write-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+lexical-write-float-devel}"
SRC_URI[aarch64_rust-lexical-core+lexical-write-float-devel.sha256sum] = "f9ef520ec55a5357d5eec7be8c019fb5721fad39f6e0725f82d8e2d9bafc93b9"

URI_aarch64_rust-lexical-core+lexical-write-integer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+lexical-write-integer-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+lexical-write-integer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+lexical-write-integer-devel}"
SRC_URI[aarch64_rust-lexical-core+lexical-write-integer-devel.sha256sum] = "ffaa364e8f09bb1dd7fde2ed8b27b2a53fe5b63af71a7042dd6754ccc8c321cf"

URI_aarch64_rust-lexical-core+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+lint-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+lint-devel}"
SRC_URI[aarch64_rust-lexical-core+lint-devel.sha256sum] = "e5539830ce7685be8c919ff7d6bd3a2485f23d99bcce4ae3a84ca38237662473"

URI_aarch64_rust-lexical-core+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+parse-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+parse-devel}"
SRC_URI[aarch64_rust-lexical-core+parse-devel.sha256sum] = "851d1f0da0c246cce8491b641a0a7f499fe74d86a890a9d33e867437cb7c3238"

URI_aarch64_rust-lexical-core+parse-floats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+parse-floats-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+parse-floats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+parse-floats-devel}"
SRC_URI[aarch64_rust-lexical-core+parse-floats-devel.sha256sum] = "bc69685746f49ec2903825cd5eee90f9fc2ab7ab9861154703714e2c796d3105"

URI_aarch64_rust-lexical-core+parse-integers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+parse-integers-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+parse-integers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+parse-integers-devel}"
SRC_URI[aarch64_rust-lexical-core+parse-integers-devel.sha256sum] = "e50a053b590a6b5d3313254674863b173aa172d16c2df67d0c0de84d78fac588"

URI_aarch64_rust-lexical-core+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+power-of-two-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-core+power-of-two-devel.sha256sum] = "824f1d4050ed42f7723c2fbaeca5f8bafe9e3cdc9d9c638820bc62277eac9519"

URI_aarch64_rust-lexical-core+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+radix-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+radix-devel}"
SRC_URI[aarch64_rust-lexical-core+radix-devel.sha256sum] = "0d6b7d74a44e306e52e320c302a69023ba9efd7157658a00f194d16510650f68"

URI_aarch64_rust-lexical-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+std-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+std-devel}"
SRC_URI[aarch64_rust-lexical-core+std-devel.sha256sum] = "2ce9e84648f96d2d7b489648cfca2698839aac73651d7ea2df112deaca9c0ac1"

URI_aarch64_rust-lexical-core+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+write-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+write-devel}"
SRC_URI[aarch64_rust-lexical-core+write-devel.sha256sum] = "832d0f6a818d75e2338c69c778b50edfe846c7e6861cf4db8d094ca704a48610"

URI_aarch64_rust-lexical-core+write-floats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+write-floats-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+write-floats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+write-floats-devel}"
SRC_URI[aarch64_rust-lexical-core+write-floats-devel.sha256sum] = "0c4de0e8890b093b30febb4f8907fb35a7e2b06e179d89a3235230f35e273711"

URI_aarch64_rust-lexical-core+write-integers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core+write-integers-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core+write-integers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core+write-integers-devel}"
SRC_URI[aarch64_rust-lexical-core+write-integers-devel.sha256sum] = "bfb64d18cf6f0d082ffd1098eb269f80acba04b9d16ac19490350d2bdf0ab652"

URI_aarch64_rust-lexical-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-core-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-lexical-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-core-devel}"
SRC_URI[aarch64_rust-lexical-core-devel.sha256sum] = "5b420b81a036838f81c0e830298fd52b66f0303fe8e5c86cb2631e3b8107d9a6"

RDEPENDS:rust-lexical-core+compact-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-parse-float+compact-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+compact-devel \
 rust-lexical-parse-integer-devel \
 rust-lexical-write-float+compact-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+compact-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-core+default-devel = " \
 cargo \
 rust-lexical-core+parse-floats-devel \
 rust-lexical-core+parse-integers-devel \
 rust-lexical-core+std-devel \
 rust-lexical-core+write-floats-devel \
 rust-lexical-core+write-integers-devel \
 rust-lexical-core-devel \
 "
RDEPENDS:rust-lexical-core+f128-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-parse-float+f128-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-util+f128-devel \
 rust-lexical-write-float+f128-devel \
 rust-lexical-write-float-devel \
 "
RDEPENDS:rust-lexical-core+f16-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-parse-float+f16-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-util+f16-devel \
 rust-lexical-write-float+f16-devel \
 rust-lexical-write-float-devel \
 "
RDEPENDS:rust-lexical-core+floats-devel = " \
 cargo \
 rust-lexical-core+parse-floats-devel \
 rust-lexical-core+write-floats-devel \
 rust-lexical-core-devel \
 "
RDEPENDS:rust-lexical-core+format-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-parse-float+format-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+format-devel \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+format-devel \
 rust-lexical-write-float+format-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+format-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-core+integers-devel = " \
 cargo \
 rust-lexical-core+parse-integers-devel \
 rust-lexical-core+write-integers-devel \
 rust-lexical-core-devel \
 "
RDEPENDS:rust-lexical-core+lexical-parse-float-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-parse-float-devel \
 "
RDEPENDS:rust-lexical-core+lexical-parse-integer-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-parse-integer-devel \
 "
RDEPENDS:rust-lexical-core+lexical-write-float-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-write-float-devel \
 "
RDEPENDS:rust-lexical-core+lexical-write-integer-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-core+lint-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-parse-float+lint-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+lint-devel \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+lint-devel \
 rust-lexical-write-float+lint-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+lint-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-core+parse-devel = " \
 cargo \
 rust-lexical-core+parse-floats-devel \
 rust-lexical-core+parse-integers-devel \
 rust-lexical-core-devel \
 "
RDEPENDS:rust-lexical-core+parse-floats-devel = " \
 cargo \
 rust-lexical-core+lexical-parse-float-devel \
 rust-lexical-core-devel \
 "
RDEPENDS:rust-lexical-core+parse-integers-devel = " \
 cargo \
 rust-lexical-core+lexical-parse-integer-devel \
 rust-lexical-core-devel \
 "
RDEPENDS:rust-lexical-core+power-of-two-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-parse-float+power-of-two-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+power-of-two-devel \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+power-of-two-devel \
 rust-lexical-write-float+power-of-two-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+power-of-two-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-core+radix-devel = " \
 cargo \
 rust-lexical-core+power-of-two-devel \
 rust-lexical-core-devel \
 rust-lexical-parse-float+radix-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+radix-devel \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+radix-devel \
 rust-lexical-write-float+radix-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+radix-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-core+std-devel = " \
 cargo \
 rust-lexical-core-devel \
 rust-lexical-parse-float+std-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+std-devel \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+std-devel \
 rust-lexical-write-float+std-devel \
 rust-lexical-write-float-devel \
 rust-lexical-write-integer+std-devel \
 rust-lexical-write-integer-devel \
 "
RDEPENDS:rust-lexical-core+write-devel = " \
 cargo \
 rust-lexical-core+write-floats-devel \
 rust-lexical-core+write-integers-devel \
 rust-lexical-core-devel \
 "
RDEPENDS:rust-lexical-core+write-floats-devel = " \
 cargo \
 rust-lexical-core+lexical-write-float-devel \
 rust-lexical-core-devel \
 "
RDEPENDS:rust-lexical-core+write-integers-devel = " \
 cargo \
 rust-lexical-core+lexical-write-integer-devel \
 rust-lexical-core-devel \
 "
RDEPENDS:rust-lexical-core-devel = " \
 cargo \
 rust \
 rust-lexical-util-devel \
 "
