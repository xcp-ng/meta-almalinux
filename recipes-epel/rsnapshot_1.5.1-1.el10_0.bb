# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsnapshot"
PV = "1.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rsnapshot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rsnapshot-1.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c5987b7c7b953a2958e13956e8d0e6f1aefc1010797289be4293ccfc6932570"

URI_x86_64_v2_rsnapshot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rsnapshot-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rsnapshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsnapshot}"
SRC_URI[x86_64_v2_rsnapshot.sha256sum] = "6a49cd789d775d983fa0186c9d42f71e6dbda61d45aa6cf231ba673bbaad369a"

URI_aarch64_rsnapshot = "${EPEL_MIRROR}/aarch64/Packages/r/rsnapshot-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rsnapshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsnapshot}"
SRC_URI[aarch64_rsnapshot.sha256sum] = "59b8da0a15660eb39b00147799b4268476096940e790e5ac432121bbe315f364"

RDEPENDS:rsnapshot = " \
 openssh-clients \
 perl-DirHandle \
 perl-Fcntl \
 perl-File-Path \
 perl-File-stat \
 perl-Getopt-Std \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-PathTools \
 perl-constant \
 perl-interpreter \
 perl-libs \
 rsync \
 "
