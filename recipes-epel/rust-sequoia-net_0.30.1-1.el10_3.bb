# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-net"
PV = "0.30.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-sequoia-net+default-devel \
 rust-sequoia-net-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-net-0.30.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9a05d846579d20aebf6a73054d60b57203397b44fdd70e94b5821387a06a3b1"

URI_x86_64_v2_rust-sequoia-net+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-net+default-devel-0.30.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-net+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-net+default-devel}"
SRC_URI[x86_64_v2_rust-sequoia-net+default-devel.sha256sum] = "69f8f441c654081e2b5c10b4aa73b21dab89112a0fb1b41fbbfe62a734628c4d"

URI_x86_64_v2_rust-sequoia-net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-net-devel-0.30.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-net-devel}"
SRC_URI[x86_64_v2_rust-sequoia-net-devel.sha256sum] = "9c4c0ddac50f9aa0ff6dd2119ff5c7b45c7df42f79102a897fbbd2b2a05c58c0"

URI_aarch64_rust-sequoia-net+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-net+default-devel-0.30.1-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-net+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-net+default-devel}"
SRC_URI[aarch64_rust-sequoia-net+default-devel.sha256sum] = "c7e2658b20e39f4fa90ababf4b27837ce025fbbd182b75c95afa64afe767ab45"

URI_aarch64_rust-sequoia-net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-net-devel-0.30.1-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-net-devel}"
SRC_URI[aarch64_rust-sequoia-net-devel.sha256sum] = "9fe055f211c4042570ce9c5a1a41852c47c429c566d18f1e5f6f2d0204f5f514"

RDEPENDS:rust-sequoia-net+default-devel = " \
 cargo \
 rust-sequoia-net-devel \
 "
RDEPENDS:rust-sequoia-net-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-base64_0.22+default-devel \
 rust-futures-util+default-devel \
 rust-hickory-client+default-devel \
 rust-hickory-resolver0.24+default-devel \
 rust-hickory-resolver0.24+dnssec-openssl-devel \
 rust-http+default-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper-tls+default-devel \
 rust-libc+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqwest0.12+default-devel \
 rust-sequoia-openpgp-devel \
 rust-tokio+default-devel \
 rust-tokio+macros-devel \
 rust-url+default-devel \
 rust-z-base-32+default-devel \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
