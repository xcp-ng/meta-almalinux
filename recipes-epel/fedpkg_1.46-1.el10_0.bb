# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedpkg"
PV = "1.46"
PR = "1.el10_0"
PACKAGES = " \
 fedpkg \
 fedpkg-stage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedpkg-1.46-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95d30ad8c33ce5cbbbaf58596a2c0b2ce2dd22c79cc1f2dff453929b363b5d08"

URI_x86_64_v2_fedpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedpkg-1.46-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fedpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedpkg}"
SRC_URI[x86_64_v2_fedpkg.sha256sum] = "db70271642965f57fc27cc023ca28130a09112ec76a914e29d1349028756ec02"

URI_x86_64_v2_fedpkg-stage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedpkg-stage-1.46-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fedpkg-stage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedpkg-stage}"
SRC_URI[x86_64_v2_fedpkg-stage.sha256sum] = "330a70a0d30049f24f814c26d2ea1a3c1a533fdfaac55ab7389f36b2dd8ae10c"

URI_aarch64_fedpkg = "${EPEL_MIRROR}/aarch64/Packages/f/fedpkg-1.46-1.el10_0.noarch.rpm;name=aarch64_fedpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedpkg}"
SRC_URI[aarch64_fedpkg.sha256sum] = "f8547cb4f55b35d511600eb49b656e7b583488efb2fff96e07e59f2b428ffa60"

URI_aarch64_fedpkg-stage = "${EPEL_MIRROR}/aarch64/Packages/f/fedpkg-stage-1.46-1.el10_0.noarch.rpm;name=aarch64_fedpkg-stage;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedpkg-stage}"
SRC_URI[aarch64_fedpkg-stage.sha256sum] = "7d7fbdce5c96e0750a94619f05120cdcf4f6f605f28c5e70514a5375d21fc8c6"

RDEPENDS:fedpkg = " \
 bodhi-client \
 koji \
 python3 \
 python3-argcomplete \
 python3-bugzilla \
 python3-distro \
 python3-openidc-client \
 python3-rpkg \
 python3-setuptools \
 redhat-rpm-config \
 "
RDEPENDS:fedpkg-stage = " \
 fedpkg \
 python3 \
 "
