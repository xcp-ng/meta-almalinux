# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_edit"
PV = "0.25.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-toml_edit+debug-devel \
 rust-toml_edit+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit+serde-devel \
 rust-toml_edit+unbounded-devel \
 rust-toml_edit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_edit-0.25.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11cb95769623bea29be3c033a48578ff8e41595fc70f086dbd88cc7e9405d84c"

URI_x86_64_v2_rust-toml_edit+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+debug-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+debug-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+debug-devel.sha256sum] = "ff9e8b6beaaf66608311d6b0e3ebdd3c526085e10bee219ce0b21cceb44f7bae"

URI_x86_64_v2_rust-toml_edit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+default-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+default-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+default-devel.sha256sum] = "6307334fdd6b0911c54fd4d5a5fa572480bfa8c27650a503adcf427e0104cd8a"

URI_x86_64_v2_rust-toml_edit+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+display-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+display-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+display-devel.sha256sum] = "83e258aeb17651d21d0a89c87388ea0753c91f542ca749bfda9d82eadb987b2f"

URI_x86_64_v2_rust-toml_edit+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+parse-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+parse-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+parse-devel.sha256sum] = "b050ba87e0c485781b4ea2573f577e1b16dca9238a2debad14e7cdcad1f7a486"

URI_x86_64_v2_rust-toml_edit+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+serde-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+serde-devel.sha256sum] = "b249851e4f176c9f48bf2ae080b840e460f62bbf5db073871940f5f190aebaf3"

URI_x86_64_v2_rust-toml_edit+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+unbounded-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+unbounded-devel.sha256sum] = "a15bf236d3082407e7b1a0200d350bf3ff3716b1413bc6a49e5dae89fc2acd86"

URI_x86_64_v2_rust-toml_edit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit-devel}"
SRC_URI[x86_64_v2_rust-toml_edit-devel.sha256sum] = "ee76f9de89ee5d759b92be99ff4abf67df0df6fc5b5c6cc1830c5e535d9c4e70"

URI_aarch64_rust-toml_edit+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+debug-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml_edit+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+debug-devel}"
SRC_URI[aarch64_rust-toml_edit+debug-devel.sha256sum] = "07849ae0b73d8c5cab8fb91730c51ec612567333787f4ff088ad1460ac08d935"

URI_aarch64_rust-toml_edit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+default-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml_edit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+default-devel}"
SRC_URI[aarch64_rust-toml_edit+default-devel.sha256sum] = "761f34415e9e590df7d896f8b157ed7eb0fe8405d9be95a57332ffdd0785096e"

URI_aarch64_rust-toml_edit+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+display-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml_edit+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+display-devel}"
SRC_URI[aarch64_rust-toml_edit+display-devel.sha256sum] = "e5cc655d0ad304f8f1329f27f5fee4fcec44a59313edbebf0db3f1ea0e530141"

URI_aarch64_rust-toml_edit+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+parse-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml_edit+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+parse-devel}"
SRC_URI[aarch64_rust-toml_edit+parse-devel.sha256sum] = "b322f8cfe0583b91ad5ca871635e3d104c82fc8b2efac9b8f3b95b00420a0641"

URI_aarch64_rust-toml_edit+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+serde-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml_edit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+serde-devel}"
SRC_URI[aarch64_rust-toml_edit+serde-devel.sha256sum] = "c3fee83e3e72ed4aacb94b30d4b265c4545e0b54193123efcaef1a4f53507599"

URI_aarch64_rust-toml_edit+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+unbounded-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml_edit+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+unbounded-devel}"
SRC_URI[aarch64_rust-toml_edit+unbounded-devel.sha256sum] = "58834091128bf3812e3613c04cbae56fe51c589590effc49532aa1b0d248c58b"

URI_aarch64_rust-toml_edit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-toml_edit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit-devel}"
SRC_URI[aarch64_rust-toml_edit-devel.sha256sum] = "27769ad206a37e100c5407e9edbd6389789f94833af021f8ad713f9695124558"

RDEPENDS:rust-toml_edit+debug-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser+default-devel \
 "
RDEPENDS:rust-toml_edit+default-devel = " \
 cargo \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+display-devel = " \
 cargo \
 rust-toml_edit-devel \
 rust-toml_writer+default-devel \
 "
RDEPENDS:rust-toml_edit+parse-devel = " \
 cargo \
 rust-toml_edit-devel \
 rust-toml_parser+default-devel \
 rust-winnow+default-devel \
 "
RDEPENDS:rust-toml_edit+serde-devel = " \
 cargo \
 rust-serde_core+default-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-toml_datetime+serde-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+unbounded-devel = " \
 cargo \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-toml_datetime+default-devel \
 "
