# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd-epel"
PE = "1"
PV = "3.26.1"
PR = "3.el10_2"
PACKAGES = " \
 gpsd-devel \
 gpsd-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpsd-epel-3.26.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55e91ebe0e3196bc49a6120769b2ffdc56ae220239d1dfc0c3ac806d504b8a66"

URI_x86_64_v2_gpsd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpsd-devel-3.26.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpsd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd-devel}"
SRC_URI[x86_64_v2_gpsd-devel.sha256sum] = "77b48c8ccd7a466cca4d04903449ecc7233cc28431c580e388909f0640293c03"

URI_x86_64_v2_gpsd-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpsd-libs-3.26.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpsd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd-libs}"
SRC_URI[x86_64_v2_gpsd-libs.sha256sum] = "393f46fc41e9e0e39e0465e47b9f16488cea81ad9b789886e00d5284af4c0b2c"

URI_aarch64_gpsd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gpsd-devel-3.26.1-3.el10_2.aarch64.rpm;name=aarch64_gpsd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-devel}"
SRC_URI[aarch64_gpsd-devel.sha256sum] = "8d512b1fe3dd254637f48543c3da6f1cdaeba3096030d7a5f7f06001fd5bfb3f"

URI_aarch64_gpsd-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gpsd-libs-3.26.1-3.el10_2.aarch64.rpm;name=aarch64_gpsd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-libs}"
SRC_URI[aarch64_gpsd-libs.sha256sum] = "6dedf51a1282f1a66e79b658ba1146909237ef3ed9c04dc0c7f5357f38b3df10"

RDEPENDS:gpsd-devel = " \
 gpsd-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gpsd-libs:x86_64_v2 = " \
 dbus-libs \
 glibc \
 libstdc++ \
"
RDEPENDS:gpsd-libs:aarch64 = " \
 dbus-libs \
 glibc \
"
