# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libdeflater"
PV = "1.25.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-libdeflater+default-devel \
 rust-libdeflater+dynamic-devel \
 rust-libdeflater+freestanding-devel \
 rust-libdeflater+use_rust_alloc-devel \
 rust-libdeflater-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libdeflater-1.25.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33f5470e84286e452d30ea7ce613bf4df63e52616fa15e226fb5545a119e2e70"

URI_x86_64_v2_rust-libdeflater+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+default-devel-1.25.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+default-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+default-devel.sha256sum] = "4df8fcdbc305ae023817642966c38448350ebf3a86d7ae159ab3a0923b12bf90"

URI_x86_64_v2_rust-libdeflater+dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+dynamic-devel-1.25.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+dynamic-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+dynamic-devel.sha256sum] = "1caea87a3f1c831bbf3119267c37ca15597b03c72d20c2600a3813c0e8c5c6f5"

URI_x86_64_v2_rust-libdeflater+freestanding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+freestanding-devel-1.25.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+freestanding-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+freestanding-devel.sha256sum] = "12a166339e14e0fc93c0837baaf2235bc5513b574311637470e364cfd9709b4d"

URI_x86_64_v2_rust-libdeflater+use_rust_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+use_rust_alloc-devel-1.25.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+use_rust_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+use_rust_alloc-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+use_rust_alloc-devel.sha256sum] = "8061aa08c294b3835c581bd0ded07eb409bc4e9f7a5775249d97f37ac742296c"

URI_x86_64_v2_rust-libdeflater-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater-devel-1.25.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater-devel}"
SRC_URI[x86_64_v2_rust-libdeflater-devel.sha256sum] = "2f67337e0b08593ab8d2ebb7cb16e5d8577884ee79d7846714fd0f32b4085588"

URI_aarch64_rust-libdeflater+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+default-devel-1.25.2-1.el10_1.noarch.rpm;name=aarch64_rust-libdeflater+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+default-devel}"
SRC_URI[aarch64_rust-libdeflater+default-devel.sha256sum] = "b9450722389f0f695377d3d641f23ebbad3990e515674593885e17c61da304c8"

URI_aarch64_rust-libdeflater+dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+dynamic-devel-1.25.2-1.el10_1.noarch.rpm;name=aarch64_rust-libdeflater+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+dynamic-devel}"
SRC_URI[aarch64_rust-libdeflater+dynamic-devel.sha256sum] = "a43e8fd01f5fb5f76066423d6e227b4c3b19b37c480b9737f197e7c60fe4d498"

URI_aarch64_rust-libdeflater+freestanding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+freestanding-devel-1.25.2-1.el10_1.noarch.rpm;name=aarch64_rust-libdeflater+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+freestanding-devel}"
SRC_URI[aarch64_rust-libdeflater+freestanding-devel.sha256sum] = "73c39b53a4ef27a5e0854a7fd695f06c60854cb857bc1e888117fab36a9c7857"

URI_aarch64_rust-libdeflater+use_rust_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+use_rust_alloc-devel-1.25.2-1.el10_1.noarch.rpm;name=aarch64_rust-libdeflater+use_rust_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+use_rust_alloc-devel}"
SRC_URI[aarch64_rust-libdeflater+use_rust_alloc-devel.sha256sum] = "17452b41244a031deb5df6a60283eedfc665f7602d008ab6b8618be9054cd1af"

URI_aarch64_rust-libdeflater-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater-devel-1.25.2-1.el10_1.noarch.rpm;name=aarch64_rust-libdeflater-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater-devel}"
SRC_URI[aarch64_rust-libdeflater-devel.sha256sum] = "7fa7e4f6c9ca08e888c763c6f4ea5b16ef942a392520c48770c0cdae3dff4f07"

RDEPENDS:rust-libdeflater+default-devel = " \
 cargo \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+dynamic-devel = " \
 cargo \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+freestanding-devel = " \
 cargo \
 rust-libdeflate-sys+freestanding-devel \
 rust-libdeflater+use_rust_alloc-devel \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+use_rust_alloc-devel = " \
 cargo \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater-devel = " \
 cargo \
 rust-libdeflate-sys+default-devel \
 "
