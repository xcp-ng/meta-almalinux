# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive"
PV = "0.21.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-cursive+builder-devel \
 rust-cursive+crossterm-backend-devel \
 rust-cursive+default-devel \
 rust-cursive+doc-cfg-devel \
 rust-cursive+termion-backend-devel \
 rust-cursive+toml-devel \
 rust-cursive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive-0.21.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eee7d808c51b7e2781605bd9224178f28767205f73282faa6865a8caf08527cc"

URI_x86_64_v2_rust-cursive+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+builder-devel-0.21.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+builder-devel}"
SRC_URI[x86_64_v2_rust-cursive+builder-devel.sha256sum] = "985eb3d72e29b7fe07ebfd2765e3a73a439c7c8494a1c92ed9a2518a9d13193d"

URI_x86_64_v2_rust-cursive+crossterm-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+crossterm-backend-devel-0.21.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+crossterm-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive+crossterm-backend-devel.sha256sum] = "cea1231b32c8dfeb282f83fac9d9663b9f8a97a1721df3ad97c40c8e89d4b2c5"

URI_x86_64_v2_rust-cursive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+default-devel-0.21.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+default-devel}"
SRC_URI[x86_64_v2_rust-cursive+default-devel.sha256sum] = "1d49e265b53b27ae13cc4e4e381472f497df63bd7937c2b424c52703a52b52ed"

URI_x86_64_v2_rust-cursive+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+doc-cfg-devel-0.21.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-cursive+doc-cfg-devel.sha256sum] = "d10872e42ee62cade9d76e21de753a1eb4c02673e7ca72cba1642c44c2ca44f7"

URI_x86_64_v2_rust-cursive+termion-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+termion-backend-devel-0.21.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+termion-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive+termion-backend-devel.sha256sum] = "93f8e1ccb7260f8639ada7e187ebcd8690799a54210bd292e8bf765feb0256a4"

URI_x86_64_v2_rust-cursive+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive+toml-devel-0.21.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive+toml-devel}"
SRC_URI[x86_64_v2_rust-cursive+toml-devel.sha256sum] = "d7bb0f610451aafbd83a6f8bd97b10380d2b0e45e5ca26c19886f2b686627bbb"

URI_x86_64_v2_rust-cursive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-devel-0.21.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-devel}"
SRC_URI[x86_64_v2_rust-cursive-devel.sha256sum] = "23049a05742c76454443735633605dc7dd46f5c0a8438001295c9c3f4af0ed32"

URI_aarch64_rust-cursive+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+builder-devel-0.21.1-2.el10_0.noarch.rpm;name=aarch64_rust-cursive+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+builder-devel}"
SRC_URI[aarch64_rust-cursive+builder-devel.sha256sum] = "9fe1e5e390b44c9773208ab65a98e0af2a994dd5ac01590fb5ee74c82cc12b35"

URI_aarch64_rust-cursive+crossterm-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+crossterm-backend-devel-0.21.1-2.el10_0.noarch.rpm;name=aarch64_rust-cursive+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+crossterm-backend-devel}"
SRC_URI[aarch64_rust-cursive+crossterm-backend-devel.sha256sum] = "3bdd93f6468e2f3bc6040abf036b4d00ffe863cc99110ff1593a8bef0262000e"

URI_aarch64_rust-cursive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+default-devel-0.21.1-2.el10_0.noarch.rpm;name=aarch64_rust-cursive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+default-devel}"
SRC_URI[aarch64_rust-cursive+default-devel.sha256sum] = "5be2f0baeebc2c100c595aff1aa3cbc66965be46cbba40274c93f77d0ea68232"

URI_aarch64_rust-cursive+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+doc-cfg-devel-0.21.1-2.el10_0.noarch.rpm;name=aarch64_rust-cursive+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+doc-cfg-devel}"
SRC_URI[aarch64_rust-cursive+doc-cfg-devel.sha256sum] = "bec6a99138ac47e9ecdafe32a9e1a56879a9eb0d5a1305cbb65c1bad87d96f67"

URI_aarch64_rust-cursive+termion-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+termion-backend-devel-0.21.1-2.el10_0.noarch.rpm;name=aarch64_rust-cursive+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+termion-backend-devel}"
SRC_URI[aarch64_rust-cursive+termion-backend-devel.sha256sum] = "fadd5ff32c04585cafb55a33c04ca2c27485f76babdeb0184fdd67e8dfe9b6db"

URI_aarch64_rust-cursive+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive+toml-devel-0.21.1-2.el10_0.noarch.rpm;name=aarch64_rust-cursive+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive+toml-devel}"
SRC_URI[aarch64_rust-cursive+toml-devel.sha256sum] = "5915d224b0caaddb8340db84672b7831c2a715fb8adca83a321ecae5d8d34e4c"

URI_aarch64_rust-cursive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-devel-0.21.1-2.el10_0.noarch.rpm;name=aarch64_rust-cursive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-devel}"
SRC_URI[aarch64_rust-cursive-devel.sha256sum] = "30e1d4c169e468e5b288dc82181dceb4084d7928915352e5f3dece03a291e68f"

RDEPENDS:rust-cursive+builder-devel = " \
 cargo \
 rust-cursive-devel \
 rust-cursive_core+builder-devel \
 "
RDEPENDS:rust-cursive+crossterm-backend-devel = " \
 cargo \
 rust-crossterm+default-devel \
 rust-cursive-devel \
 "
RDEPENDS:rust-cursive+default-devel = " \
 cargo \
 rust-cursive+crossterm-backend-devel \
 rust-cursive-devel \
 "
RDEPENDS:rust-cursive+doc-cfg-devel = " \
 cargo \
 rust-cursive-devel \
 rust-cursive_core+doc-cfg-devel \
 "
RDEPENDS:rust-cursive+termion-backend-devel = " \
 cargo \
 rust-cursive-devel \
 rust-termion+default-devel \
 "
RDEPENDS:rust-cursive+toml-devel = " \
 cargo \
 rust-cursive-devel \
 rust-cursive_core+toml-devel \
 "
RDEPENDS:rust-cursive-devel = " \
 cargo \
 rust-ahash+default-devel \
 rust-cfg-if+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-cursive_core+default-devel \
 rust-lazy_static+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-signal-hook+default-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 "
