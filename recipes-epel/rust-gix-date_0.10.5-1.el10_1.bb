# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-date"
PV = "0.10.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-date+default-devel \
 rust-gix-date+document-features-devel \
 rust-gix-date+serde-devel \
 rust-gix-date-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-date-0.10.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67d9b0c3d635f1f0237b4778abd1190c2947d3d199d217c7f4c810ed7400daab"

URI_x86_64_v2_rust-gix-date+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+default-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+default-devel}"
SRC_URI[x86_64_v2_rust-gix-date+default-devel.sha256sum] = "ca1ded33b8a9bd874303215be897638ace8f8994e9e5a63b48d2459ba01a1f18"

URI_x86_64_v2_rust-gix-date+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+document-features-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-date+document-features-devel.sha256sum] = "6853eab3ff52e27605a747c27aa17fc51839a7e9f558c2da55ca57f6fb43d49b"

URI_x86_64_v2_rust-gix-date+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date+serde-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-date+serde-devel.sha256sum] = "3dfa9930e492caec11274a85bfe39c354bac813546d59a607cedaa0fa092951b"

URI_x86_64_v2_rust-gix-date-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-date-devel-0.10.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-date-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-date-devel}"
SRC_URI[x86_64_v2_rust-gix-date-devel.sha256sum] = "8d9680424eebfc22dc640338e086dfc4e82776d7f0d831a080a6bddf9c09af9b"

URI_aarch64_rust-gix-date+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+default-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-gix-date+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+default-devel}"
SRC_URI[aarch64_rust-gix-date+default-devel.sha256sum] = "4b6e75a27283d5dda773bcbed5aee0a5b36a46e8e65125a13a5bd18b3e249fd2"

URI_aarch64_rust-gix-date+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+document-features-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-gix-date+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+document-features-devel}"
SRC_URI[aarch64_rust-gix-date+document-features-devel.sha256sum] = "e4f3a2e92b132e1e78e7a442cfbc8319f4835210492e69355cf9472a006dfab2"

URI_aarch64_rust-gix-date+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date+serde-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-gix-date+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date+serde-devel}"
SRC_URI[aarch64_rust-gix-date+serde-devel.sha256sum] = "db27590c754fcb3f3e768ffae4f1c6eacaf9d279f8d90b15df90fe5188d302ff"

URI_aarch64_rust-gix-date-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-date-devel-0.10.5-1.el10_1.noarch.rpm;name=aarch64_rust-gix-date-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-date-devel}"
SRC_URI[aarch64_rust-gix-date-devel.sha256sum] = "d0f5cbb332cfe117b0e2d85c2b7aae6e773474fbae069913878d1e568f346d69"

RDEPENDS:rust-gix-date+default-devel = " \
 cargo \
 rust-gix-date-devel \
 "
RDEPENDS:rust-gix-date+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-date-devel \
 "
RDEPENDS:rust-gix-date+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-date-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-date-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-itoa+default-devel \
 rust-jiff+default-devel \
 rust-smallvec+default-devel \
 rust-smallvec+write-devel \
 rust-thiserror+default-devel \
 "
