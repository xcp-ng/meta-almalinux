# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-attribute-derive"
PV = "0.10.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-attribute-derive+default-devel \
 rust-attribute-derive+syn-full-devel \
 rust-attribute-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-attribute-derive-0.10.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eaebd474e3f342dd2c99f88680a342d3cc99a6004c101fdd7f0f450699850f5"

URI_x86_64_v2_rust-attribute-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-attribute-derive+default-devel-0.10.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-attribute-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-attribute-derive+default-devel}"
SRC_URI[x86_64_v2_rust-attribute-derive+default-devel.sha256sum] = "b640cc5745a0786e8c1058b09548a3598beb88fe1b4b2c48c7973c39edce264b"

URI_x86_64_v2_rust-attribute-derive+syn-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-attribute-derive+syn-full-devel-0.10.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-attribute-derive+syn-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-attribute-derive+syn-full-devel}"
SRC_URI[x86_64_v2_rust-attribute-derive+syn-full-devel.sha256sum] = "a7ec0165a22a84193f3e0b01d5789eadb0b42a31c657f7891ab5613f5c535b47"

URI_x86_64_v2_rust-attribute-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-attribute-derive-devel-0.10.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-attribute-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-attribute-derive-devel}"
SRC_URI[x86_64_v2_rust-attribute-derive-devel.sha256sum] = "697d8ef54b400b5e9e532d9af2e89ebcc2c5d32533a075b0247b6344a7ed643f"

URI_aarch64_rust-attribute-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-attribute-derive+default-devel-0.10.5-1.el10_2.noarch.rpm;name=aarch64_rust-attribute-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-attribute-derive+default-devel}"
SRC_URI[aarch64_rust-attribute-derive+default-devel.sha256sum] = "abf3021fd504bd8a6699ee907675d9470bab6e81a85a0d0a60675d3a1cc4b841"

URI_aarch64_rust-attribute-derive+syn-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-attribute-derive+syn-full-devel-0.10.5-1.el10_2.noarch.rpm;name=aarch64_rust-attribute-derive+syn-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-attribute-derive+syn-full-devel}"
SRC_URI[aarch64_rust-attribute-derive+syn-full-devel.sha256sum] = "1bfb542098a6a6deb639767ce70e9ae5f51a16416c2e58a155cd4bea92c40105"

URI_aarch64_rust-attribute-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-attribute-derive-devel-0.10.5-1.el10_2.noarch.rpm;name=aarch64_rust-attribute-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-attribute-derive-devel}"
SRC_URI[aarch64_rust-attribute-derive-devel.sha256sum] = "ccd57865e200a7aac627ff6c649b495cd0a351aeac04227ea43c2cb00a819195"

RDEPENDS:rust-attribute-derive+default-devel = " \
 cargo \
 rust-attribute-derive-devel \
 "
RDEPENDS:rust-attribute-derive+syn-full-devel = " \
 cargo \
 rust-attribute-derive-devel \
 rust-syn2+full-devel \
 "
RDEPENDS:rust-attribute-derive-devel = " \
 cargo \
 rust-attribute-derive-macro+default-devel \
 rust-derive-where+default-devel \
 rust-manyhow+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
