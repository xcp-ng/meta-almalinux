# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scc"
PV = "2.3.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-scc+default-devel \
 rust-scc+equivalent-devel \
 rust-scc+serde-devel \
 rust-scc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scc-2.3.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9fef311d76cfdd759c345631e8809389875ab6fa582908cbcb0250da506bff8"

URI_x86_64_v2_rust-scc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc+default-devel-2.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc+default-devel}"
SRC_URI[x86_64_v2_rust-scc+default-devel.sha256sum] = "8317758c4a16fda2af62d21c6179d2ef19fdab8d2df2289c1e3e96a8da7dddbb"

URI_x86_64_v2_rust-scc+equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc+equivalent-devel-2.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc+equivalent-devel}"
SRC_URI[x86_64_v2_rust-scc+equivalent-devel.sha256sum] = "571626c6ba7cad27e42043064d59238a57ff827dc677d3e149394ceb57c66553"

URI_x86_64_v2_rust-scc+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc+serde-devel-2.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc+serde-devel}"
SRC_URI[x86_64_v2_rust-scc+serde-devel.sha256sum] = "31b5da72f9ed18eab52a7958dcddb9188aac20f27c158b34179a73d9f2128478"

URI_x86_64_v2_rust-scc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc-devel-2.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc-devel}"
SRC_URI[x86_64_v2_rust-scc-devel.sha256sum] = "63e34c76d80260b69ecce70f99310503a2c725e8f684e5e524c07e5fb76a2d25"

URI_aarch64_rust-scc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc+default-devel-2.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-scc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc+default-devel}"
SRC_URI[aarch64_rust-scc+default-devel.sha256sum] = "bae102da4f659845842efe17e08341afb637969aa6d643c6d583852f1fdf0d2b"

URI_aarch64_rust-scc+equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc+equivalent-devel-2.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-scc+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc+equivalent-devel}"
SRC_URI[aarch64_rust-scc+equivalent-devel.sha256sum] = "09cf31235627f7ba4b038c44dd37dcc32b4e3eff6e69bab3fbc4f24dd816bb26"

URI_aarch64_rust-scc+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc+serde-devel-2.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-scc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc+serde-devel}"
SRC_URI[aarch64_rust-scc+serde-devel.sha256sum] = "61ea28864e73a698433f17183cb0790cda2d22d889296661995e4a96e7f8d7fa"

URI_aarch64_rust-scc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc-devel-2.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-scc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc-devel}"
SRC_URI[aarch64_rust-scc-devel.sha256sum] = "dd3d459f624fc34ab572b5489da4d40f715d2900fbfffa7a78ba5171b7d7bade"

RDEPENDS:rust-scc+default-devel = " \
 cargo \
 rust-scc-devel \
 "
RDEPENDS:rust-scc+equivalent-devel = " \
 cargo \
 rust-equivalent+default-devel \
 rust-scc-devel \
 "
RDEPENDS:rust-scc+serde-devel = " \
 cargo \
 rust-scc-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-scc-devel = " \
 cargo \
 rust \
 rust-sdd+default-devel \
 "
