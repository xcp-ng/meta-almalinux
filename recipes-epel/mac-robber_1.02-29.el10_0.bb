# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mac-robber"
PV = "1.02"
PR = "29.el10_0"
PACKAGES = " \
 mac-robber \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mac-robber-1.02-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7612b136f853fab0f8d28dee60b6364761460af5897fd47e18603d7c928b518b"

URI_x86_64_v2_mac-robber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mac-robber-1.02-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mac-robber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mac-robber}"
SRC_URI[x86_64_v2_mac-robber.sha256sum] = "fd192946cc2db83b3cf5d7a83ff89d69d2a2226c0d13b063d31a10227777e0cc"

URI_aarch64_mac-robber = "${EPEL_MIRROR}/aarch64/Packages/m/mac-robber-1.02-29.el10_0.aarch64.rpm;name=aarch64_mac-robber;unpack=0"
SRC_URI:append = " ${URI_aarch64_mac-robber}"
SRC_URI[aarch64_mac-robber.sha256sum] = "ee420c0ddf5083c7eff8f86e1a03d1e9138266d35a51152cd0224ae158e65107"

RDEPENDS:mac-robber = " \
 glibc \
 "
