# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-deepmerge"
PV = "2.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-deepmerge \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-deepmerge-2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55cb51e3e1ca57d3c46c854dc68e8be361f025b22b65dddb14826bb81014d696"

URI_x86_64_v2_python3-deepmerge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-deepmerge-2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-deepmerge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-deepmerge}"
SRC_URI[x86_64_v2_python3-deepmerge.sha256sum] = "50b0682651750171e7b7cab4bd96d105caa3b1cc7f6053bc476e7333af856af6"

URI_aarch64_python3-deepmerge = "${EPEL_MIRROR}/aarch64/Packages/p/python3-deepmerge-2.0-1.el10_1.noarch.rpm;name=aarch64_python3-deepmerge;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-deepmerge}"
SRC_URI[aarch64_python3-deepmerge.sha256sum] = "7806228f6ad3df6c2c778033abb08ec80da6c914828f48415d6ee5cc82615741"

RDEPENDS:python3-deepmerge = " \
 python3 \
 "
