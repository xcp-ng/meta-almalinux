# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-baloo"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-baloo \
 kf6-baloo-devel \
 kf6-baloo-doc \
 kf6-baloo-file \
 kf6-baloo-html \
 kf6-baloo-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-baloo-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c9f58cc34e254a8ab4eb66d9170a790507f1f95827a30470345ccea29e89a91"

URI_x86_64_v2_kf6-baloo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo}"
SRC_URI[x86_64_v2_kf6-baloo.sha256sum] = "0093d88af0db6c116f0b5501dbe73771d83367f25e035e23cda4f7fbcd195339"

URI_x86_64_v2_kf6-baloo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-devel}"
SRC_URI[x86_64_v2_kf6-baloo-devel.sha256sum] = "beff6af0bb01767f0e44c34e4cfa3fb96ce42980f73d19f445829447e417592f"

URI_x86_64_v2_kf6-baloo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-baloo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-doc}"
SRC_URI[x86_64_v2_kf6-baloo-doc.sha256sum] = "8295b62ffe5d807aa5ef8c28c91e1be7831f6a847be55c78cd5e342ef81da324"

URI_x86_64_v2_kf6-baloo-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-file-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-file}"
SRC_URI[x86_64_v2_kf6-baloo-file.sha256sum] = "0fcc84936adcd11f75dba414fe14cd2b7db87d548a1197b8d4a6348f64b20d82"

URI_x86_64_v2_kf6-baloo-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-baloo-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-html}"
SRC_URI[x86_64_v2_kf6-baloo-html.sha256sum] = "70f8f3120bfc81b3051bf03a94854d73e7bda9bebffe13d0b5ed0cdcf56a83a0"

URI_x86_64_v2_kf6-baloo-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-libs-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-libs}"
SRC_URI[x86_64_v2_kf6-baloo-libs.sha256sum] = "495408b6053d71e319a9c6f8847bc6caae7375dca9600e401d34edc8207ba8ca"

URI_aarch64_kf6-baloo = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-baloo;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo}"
SRC_URI[aarch64_kf6-baloo.sha256sum] = "081b8cc698d778f0f9e2973f400a4d2d7346c1df7a2a745815abf9f906558874"

URI_aarch64_kf6-baloo-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-baloo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-devel}"
SRC_URI[aarch64_kf6-baloo-devel.sha256sum] = "ac603536f2910063cab2875643f6d915bc513c285a32aafc7338342e58590517"

URI_aarch64_kf6-baloo-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-baloo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-doc}"
SRC_URI[aarch64_kf6-baloo-doc.sha256sum] = "6755979394ff855b0c304571f446527fba057b7cb5b7b8f12e182c81870566f6"

URI_aarch64_kf6-baloo-file = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-file-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-baloo-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-file}"
SRC_URI[aarch64_kf6-baloo-file.sha256sum] = "465cb8fbc273e03b61bc1b6e9d1a4bdc63957ea3a6a037249d7bf825b5450552"

URI_aarch64_kf6-baloo-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-baloo-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-html}"
SRC_URI[aarch64_kf6-baloo-html.sha256sum] = "45e4782efee2be440f396436015ea2d220bea5e1a33adab96f699e9cdb7c7652"

URI_aarch64_kf6-baloo-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-libs-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-baloo-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-libs}"
SRC_URI[aarch64_kf6-baloo-libs.sha256sum] = "3a0fde6170be04ed9a77e98363dc0cc103e102010b8a2242e5d367de025ab8dd"

RDEPENDS:kf6-baloo = " \
 glibc \
 kf6-baloo-libs \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-baloo-devel = " \
 cmake-filesystem \
 kf6-baloo-libs \
 kf6-kcoreaddons-devel \
 kf6-kfilemetadata-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-baloo-doc = " \
 "
RDEPENDS:kf6-baloo-file = " \
 glibc \
 kf6-baloo-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kidletime \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-baloo-html = " \
 "
RDEPENDS:kf6-baloo-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-solid \
 libstdc++ \
 lmdb-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
