# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-indexed-traversable"
PV = "0.1.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-indexed-traversable \
 ghc-indexed-traversable-devel \
 ghc-indexed-traversable-doc \
 ghc-indexed-traversable-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-indexed-traversable-0.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b9fdbb591e27d8313852f528aef9f90d0e62d8e077aa5c2ffda45462b745aa1"

URI_x86_64_v2_ghc-indexed-traversable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-indexed-traversable-0.1.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-indexed-traversable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-indexed-traversable}"
SRC_URI[x86_64_v2_ghc-indexed-traversable.sha256sum] = "4aba9426847fc19b80f98dd982f176efa169d36d268f89fcd4429522f4eb7092"

URI_x86_64_v2_ghc-indexed-traversable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-indexed-traversable-devel-0.1.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-indexed-traversable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-indexed-traversable-devel}"
SRC_URI[x86_64_v2_ghc-indexed-traversable-devel.sha256sum] = "88b615e23218e7cd9f0dd366561c55fd0f32186e46d724c5d1e84a178fbb1ebf"

URI_x86_64_v2_ghc-indexed-traversable-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-indexed-traversable-doc-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-indexed-traversable-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-indexed-traversable-doc}"
SRC_URI[x86_64_v2_ghc-indexed-traversable-doc.sha256sum] = "ea4ac1a287867a246eafc27ea25be2276d6a2eec3a149d95414f638c280d02ac"

URI_x86_64_v2_ghc-indexed-traversable-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-indexed-traversable-prof-0.1.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-indexed-traversable-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-indexed-traversable-prof}"
SRC_URI[x86_64_v2_ghc-indexed-traversable-prof.sha256sum] = "e8a65a892b6cff05193f55099f3042c1b21874958dc13dd8b22437975530f32b"

URI_aarch64_ghc-indexed-traversable = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-indexed-traversable-0.1.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-indexed-traversable;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-indexed-traversable}"
SRC_URI[aarch64_ghc-indexed-traversable.sha256sum] = "626625e2ed04efef5f653f5c65f99dbce336cc27bec6028c1654cbfaaefc21f5"

URI_aarch64_ghc-indexed-traversable-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-indexed-traversable-devel-0.1.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-indexed-traversable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-indexed-traversable-devel}"
SRC_URI[aarch64_ghc-indexed-traversable-devel.sha256sum] = "1ee906be375dbbb63cc394c2d2f826c4ca622953d35c269bb8345435ef911801"

URI_aarch64_ghc-indexed-traversable-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-indexed-traversable-doc-0.1.4-1.el10_0.noarch.rpm;name=aarch64_ghc-indexed-traversable-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-indexed-traversable-doc}"
SRC_URI[aarch64_ghc-indexed-traversable-doc.sha256sum] = "7498c3cdfeecba05783afb929df7268a3ba631ee82649fc79e5ae767a80561b1"

URI_aarch64_ghc-indexed-traversable-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-indexed-traversable-prof-0.1.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-indexed-traversable-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-indexed-traversable-prof}"
SRC_URI[aarch64_ghc-indexed-traversable-prof.sha256sum] = "9a57f566001ca8087b480999dbee382722f7be135639d24ee77a77cd6c223363"

RDEPENDS:ghc-indexed-traversable = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-indexed-traversable-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-indexed-traversable \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-indexed-traversable-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-indexed-traversable-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-indexed-traversable-devel \
 ghc-transformers-prof \
 "
