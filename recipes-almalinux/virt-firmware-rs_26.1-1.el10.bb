# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-firmware-rs"
PV = "26.1"
PR = "1.el10"
PACKAGES = " \
 virt-firmware-rs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-firmware-rs-26.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ef69a71f8c6779f036edf144b7f3b56bce3b54f431f35324174770271758d45"

URI_x86_64_v2_virt-firmware-rs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-firmware-rs-26.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_virt-firmware-rs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-firmware-rs}"
SRC_URI[x86_64_v2_virt-firmware-rs.sha256sum] = "6ab6ab8419b17bccceb9797e5671ec57fe9454d4fe2faae7b7f56d82432b5faf"

URI_aarch64_virt-firmware-rs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-firmware-rs-26.1-1.el10.aarch64.rpm;name=aarch64_virt-firmware-rs;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-firmware-rs}"
SRC_URI[aarch64_virt-firmware-rs.sha256sum] = "f941eea1f418f43b996f94df5c0ca502031bd70f7f9ab3a7eb79ca255d9cf00f"

RDEPENDS:virt-firmware-rs = " \
 glibc \
 libgcc \
 systemd-libs \
 "
