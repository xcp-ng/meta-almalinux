# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-form_urlencoded"
PV = "1.2.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-form_urlencoded+alloc-devel \
 rust-form_urlencoded+default-devel \
 rust-form_urlencoded+std-devel \
 rust-form_urlencoded-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-form_urlencoded-1.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b54bc1cdf023bc8cd8eaa2df51ef3a108c87246527f80b39769117bd38d233f3"

URI_x86_64_v2_rust-form_urlencoded+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-form_urlencoded+alloc-devel-1.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-form_urlencoded+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-form_urlencoded+alloc-devel}"
SRC_URI[x86_64_v2_rust-form_urlencoded+alloc-devel.sha256sum] = "5fc1f3762e92f340cf8424c2b1e45ab3b0391483ec8cf7e338e7d0fef348eb91"

URI_x86_64_v2_rust-form_urlencoded+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-form_urlencoded+default-devel-1.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-form_urlencoded+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-form_urlencoded+default-devel}"
SRC_URI[x86_64_v2_rust-form_urlencoded+default-devel.sha256sum] = "4a1addb2df3aa6d3d8f41074073bc8ef439affb4d52765c37904f380f1f59159"

URI_x86_64_v2_rust-form_urlencoded+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-form_urlencoded+std-devel-1.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-form_urlencoded+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-form_urlencoded+std-devel}"
SRC_URI[x86_64_v2_rust-form_urlencoded+std-devel.sha256sum] = "550559bae1fde1c734b5facfaa59fc52198571f1b30788edbb04e73aa6189d79"

URI_x86_64_v2_rust-form_urlencoded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-form_urlencoded-devel-1.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-form_urlencoded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-form_urlencoded-devel}"
SRC_URI[x86_64_v2_rust-form_urlencoded-devel.sha256sum] = "b5c8f3b10a73c0d9a3c2c761d49e3177feedd408c319a14551caae7dde6901bd"

URI_aarch64_rust-form_urlencoded+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-form_urlencoded+alloc-devel-1.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-form_urlencoded+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-form_urlencoded+alloc-devel}"
SRC_URI[aarch64_rust-form_urlencoded+alloc-devel.sha256sum] = "0d2d5343fb1c855c1887f8d73aacb711e29b14bc1efbb8d2f0c350f36ee15837"

URI_aarch64_rust-form_urlencoded+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-form_urlencoded+default-devel-1.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-form_urlencoded+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-form_urlencoded+default-devel}"
SRC_URI[aarch64_rust-form_urlencoded+default-devel.sha256sum] = "c0cddd8b7e9a8de5a2bfcbdbbee4623444c7ddaaa5481b6048ea73852292a129"

URI_aarch64_rust-form_urlencoded+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-form_urlencoded+std-devel-1.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-form_urlencoded+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-form_urlencoded+std-devel}"
SRC_URI[aarch64_rust-form_urlencoded+std-devel.sha256sum] = "d48a8a8e2b1fe8ba9581ac9d116c4ff5d3991124cfdf2c0c32b1ebff8b2cb1d7"

URI_aarch64_rust-form_urlencoded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-form_urlencoded-devel-1.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-form_urlencoded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-form_urlencoded-devel}"
SRC_URI[aarch64_rust-form_urlencoded-devel.sha256sum] = "0395319c06eb813350022193fea84284c8d97720224b129ee0224321fdff93dd"

RDEPENDS:rust-form_urlencoded+alloc-devel = " \
 cargo \
 rust-form_urlencoded-devel \
 rust-percent-encoding+alloc-devel \
 "
RDEPENDS:rust-form_urlencoded+default-devel = " \
 cargo \
 rust-form_urlencoded+std-devel \
 rust-form_urlencoded-devel \
 "
RDEPENDS:rust-form_urlencoded+std-devel = " \
 cargo \
 rust-form_urlencoded+alloc-devel \
 rust-form_urlencoded-devel \
 rust-percent-encoding+std-devel \
 "
RDEPENDS:rust-form_urlencoded-devel = " \
 cargo \
 rust \
 rust-percent-encoding-devel \
 "
