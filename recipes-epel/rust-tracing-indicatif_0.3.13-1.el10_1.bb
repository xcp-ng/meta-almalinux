# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-indicatif"
PV = "0.3.13"
PR = "1.el10_1"
PACKAGES = " \
 rust-tracing-indicatif+default-devel \
 rust-tracing-indicatif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-indicatif-0.3.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c166c719c63dc518ae0a57f14eaad3893bb735b8102440c4a279ae9cfcb227f2"

URI_x86_64_v2_rust-tracing-indicatif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-indicatif+default-devel-0.3.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-indicatif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-indicatif+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-indicatif+default-devel.sha256sum] = "19e12e9daa59e92a087e0e0a60b24786460356ad16055d9e8185b4c1bbb26cae"

URI_x86_64_v2_rust-tracing-indicatif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-indicatif-devel-0.3.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-indicatif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-indicatif-devel}"
SRC_URI[x86_64_v2_rust-tracing-indicatif-devel.sha256sum] = "f9aaaeb015b8d040caff45eaf6162441cf16f15007f73bfb316ab51776de2578"

URI_aarch64_rust-tracing-indicatif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-indicatif+default-devel-0.3.13-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-indicatif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-indicatif+default-devel}"
SRC_URI[aarch64_rust-tracing-indicatif+default-devel.sha256sum] = "3fa84f5b3017c054cdbe59a60034ed69c6c13538efa1d1290a978c93e5aea45d"

URI_aarch64_rust-tracing-indicatif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-indicatif-devel-0.3.13-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-indicatif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-indicatif-devel}"
SRC_URI[aarch64_rust-tracing-indicatif-devel.sha256sum] = "227f4a642291d5a612c7b7fd4c153078c6508843e6f5d459fdec2d1b375f5983"

RDEPENDS:rust-tracing-indicatif+default-devel = " \
 cargo \
 rust-tracing-indicatif-devel \
 "
RDEPENDS:rust-tracing-indicatif-devel = " \
 cargo \
 rust-indicatif+default-devel \
 rust-indicatif+in_memory-devel \
 rust-tracing+default-devel \
 rust-tracing-core+default-devel \
 rust-tracing-subscriber+default-devel \
 "
