# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-webrick"
PV = "1.7.0"
PR = "9.el10_0"
PACKAGES = " \
 rubygem-webrick \
 rubygem-webrick-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-webrick-1.7.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e32cf7e458d9c4e245cff57e37778d6e1cfb45c2a00f3dd2af84930dec88e0b1"

URI_x86_64_v2_rubygem-webrick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-webrick-1.7.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-webrick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-webrick}"
SRC_URI[x86_64_v2_rubygem-webrick.sha256sum] = "be96466e56c8e5e311985d79615a4b5fe774a61d6bfa3c417e32dcbd6b3a87f5"

URI_x86_64_v2_rubygem-webrick-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-webrick-doc-1.7.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-webrick-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-webrick-doc}"
SRC_URI[x86_64_v2_rubygem-webrick-doc.sha256sum] = "23833301a0080ed9f06161339bbeaf1d82e3a011d74d33f50c88bc690e667928"

URI_aarch64_rubygem-webrick = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-webrick-1.7.0-9.el10_0.noarch.rpm;name=aarch64_rubygem-webrick;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-webrick}"
SRC_URI[aarch64_rubygem-webrick.sha256sum] = "ff5fae8380ad0dc60e54826a895ca4a88b59fcc1839505b514dd66647e254e96"

URI_aarch64_rubygem-webrick-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-webrick-doc-1.7.0-9.el10_0.noarch.rpm;name=aarch64_rubygem-webrick-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-webrick-doc}"
SRC_URI[aarch64_rubygem-webrick-doc.sha256sum] = "c98ad8b59ff21d23ae6c91a2363ad2e9d0a19c4354b6c8b3f4ae92620ae51efa"

RDEPENDS:rubygem-webrick = " \
 bash \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-webrick-doc = " \
 rubygem-webrick \
 "
