# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx"
PE = "2"
PV = "1.26.3"
PR = "2.el10_1.2"
PACKAGES = " \
 nginx \
 nginx-all-modules \
 nginx-core \
 nginx-filesystem \
 nginx-mod-devel \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nginx-1.26.3-2.el10_1.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ed93feaf3bd6a57ff09959b8b291aad553d1757ce007826cb4254d4e7a66b35"

URI_x86_64_v2_nginx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-1.26.3-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx}"
SRC_URI[x86_64_v2_nginx.sha256sum] = "8382d8d638788c908d7ec5c0c96bf35f5caa9401ee23c5635bb25838b14343a6"
RPROVIDES:nginx:append:x86_64_v2 = " virtual/httpd_or_nginx virtual/webserver"

URI_x86_64_v2_nginx-all-modules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-all-modules-1.26.3-2.el10_1.2.noarch.rpm;name=x86_64_v2_nginx-all-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-all-modules}"
SRC_URI[x86_64_v2_nginx-all-modules.sha256sum] = "487c71ee60f7a459f646497450e575d4e562d7df568ee0519d01b69f5c58606f"

URI_x86_64_v2_nginx-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-core-1.26.3-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_nginx-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-core}"
SRC_URI[x86_64_v2_nginx-core.sha256sum] = "39eb4f00813d03b52bb46976a5eb8bdb5b308c6878647aa9da1e6ed99bdf2185"

URI_x86_64_v2_nginx-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-filesystem-1.26.3-2.el10_1.2.noarch.rpm;name=x86_64_v2_nginx-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-filesystem}"
SRC_URI[x86_64_v2_nginx-filesystem.sha256sum] = "17c0ee529e26540f99c7d4886207be72c68418e4250f0a71f3a6aeb34a8e324a"

URI_x86_64_v2_nginx-mod-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nginx-mod-devel-1.26.3-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-devel}"
SRC_URI[x86_64_v2_nginx-mod-devel.sha256sum] = "0135f046c3d06d3644dffa2e24df0b492603d37f23a15a119031ef8c88727473"

URI_x86_64_v2_nginx-mod-http-image-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-image-filter-1.26.3-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-image-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-image-filter}"
SRC_URI[x86_64_v2_nginx-mod-http-image-filter.sha256sum] = "8d391d1ebffd9a16c85b1fa1c0ee7a21dff550ba5955ee7244d7dd07a6b4175b"

URI_x86_64_v2_nginx-mod-http-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-perl-1.26.3-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-perl}"
SRC_URI[x86_64_v2_nginx-mod-http-perl.sha256sum] = "8c81e62f41d084ff4d59d950c2539d5b4fc42a54a402422f0ae572cfdc16dec1"

URI_x86_64_v2_nginx-mod-http-xslt-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-xslt-filter-1.26.3-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-http-xslt-filter}"
SRC_URI[x86_64_v2_nginx-mod-http-xslt-filter.sha256sum] = "d7b71b946beb850e03b84edcadfd0197357d0ef3be16e0080cd76fd0cf8e1ef0"

URI_x86_64_v2_nginx-mod-mail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-mail-1.26.3-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-mail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-mail}"
SRC_URI[x86_64_v2_nginx-mod-mail.sha256sum] = "f3bc553ba8d8514097de83f6edaaa1e05ad2a522493e016669a76aae06a309d8"

URI_x86_64_v2_nginx-mod-stream = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-stream-1.26.3-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-stream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-stream}"
SRC_URI[x86_64_v2_nginx-mod-stream.sha256sum] = "de4afbae8a35edcf524d562b77e4192cd2518d7d0a81c495c87b37638bea4e36"

URI_aarch64_nginx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-1.26.3-2.el10_1.2.aarch64.rpm;name=aarch64_nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx}"
SRC_URI[aarch64_nginx.sha256sum] = "77356bbaf30f8eb744c4d5cd961bc31968b7a58ba0524fe20fcc552b3dab3145"
RPROVIDES:nginx:append:aarch64 = " virtual/httpd_or_nginx virtual/webserver"

URI_aarch64_nginx-all-modules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-all-modules-1.26.3-2.el10_1.2.noarch.rpm;name=aarch64_nginx-all-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-all-modules}"
SRC_URI[aarch64_nginx-all-modules.sha256sum] = "487c71ee60f7a459f646497450e575d4e562d7df568ee0519d01b69f5c58606f"

URI_aarch64_nginx-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-core-1.26.3-2.el10_1.2.aarch64.rpm;name=aarch64_nginx-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-core}"
SRC_URI[aarch64_nginx-core.sha256sum] = "61a4e8ed7cc07a2d337c6d7e565b00839616308f7032cca0793c5be47321d499"

URI_aarch64_nginx-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-filesystem-1.26.3-2.el10_1.2.noarch.rpm;name=aarch64_nginx-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-filesystem}"
SRC_URI[aarch64_nginx-filesystem.sha256sum] = "17c0ee529e26540f99c7d4886207be72c68418e4250f0a71f3a6aeb34a8e324a"

URI_aarch64_nginx-mod-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nginx-mod-devel-1.26.3-2.el10_1.2.aarch64.rpm;name=aarch64_nginx-mod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-devel}"
SRC_URI[aarch64_nginx-mod-devel.sha256sum] = "eabf7eb21083949a6e96f597e9046aab9bb1b7a733bf6b43d137d832504cf96e"

URI_aarch64_nginx-mod-http-image-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-image-filter-1.26.3-2.el10_1.2.aarch64.rpm;name=aarch64_nginx-mod-http-image-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-image-filter}"
SRC_URI[aarch64_nginx-mod-http-image-filter.sha256sum] = "a4a129b069c8fe99e9e91ba8487c292e6f5030748bb16c94f7fecd6c7b9a9a1f"

URI_aarch64_nginx-mod-http-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-perl-1.26.3-2.el10_1.2.aarch64.rpm;name=aarch64_nginx-mod-http-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-perl}"
SRC_URI[aarch64_nginx-mod-http-perl.sha256sum] = "3bf63bf8ccbe64d716b2cfb324ac394396f67bb3f4be66ca8ace7a23495a1ad3"

URI_aarch64_nginx-mod-http-xslt-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-xslt-filter-1.26.3-2.el10_1.2.aarch64.rpm;name=aarch64_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-http-xslt-filter}"
SRC_URI[aarch64_nginx-mod-http-xslt-filter.sha256sum] = "fc42b55b7424e6540ac6a73757df55f148e42be89ddaec5e3686b69068af3d2c"

URI_aarch64_nginx-mod-mail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-mail-1.26.3-2.el10_1.2.aarch64.rpm;name=aarch64_nginx-mod-mail;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-mail}"
SRC_URI[aarch64_nginx-mod-mail.sha256sum] = "dbe95ecf96543a5aa776015f135fb7dbfbce4b8a6d0150a2e5de6dd34e06be2c"

URI_aarch64_nginx-mod-stream = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-stream-1.26.3-2.el10_1.2.aarch64.rpm;name=aarch64_nginx-mod-stream;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-stream}"
SRC_URI[aarch64_nginx-mod-stream.sha256sum] = "8ae2b77c6b854a1971246bd4c99d2e00b0f1769b968e485f1c9cbd8ab3cbb863"

RDEPENDS:nginx = " \
 almalinux-logos-httpd \
 bash \
 nginx-core \
 nginx-filesystem \
 systemd \
 "
RDEPENDS:nginx-all-modules = " \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "
RDEPENDS:nginx-core = " \
 glibc \
 libxcrypt \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:nginx-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:nginx-mod-devel = " \
 bash \
 gcc \
 gd-devel \
 libxslt-devel \
 make \
 nginx \
 openssl-devel \
 pcre2-devel \
 perl-Exporter \
 perl-ExtUtils-Embed \
 perl-constant \
 perl-devel \
 perl-interpreter \
 perl-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:nginx-mod-http-image-filter = " \
 bash \
 gd \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-http-perl = " \
 bash \
 glibc \
 nginx \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
RDEPENDS:nginx-mod-http-xslt-filter = " \
 bash \
 glibc \
 libxml2 \
 libxslt \
 nginx \
 "
RDEPENDS:nginx-mod-mail = " \
 bash \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-stream = " \
 bash \
 glibc \
 nginx \
 "
