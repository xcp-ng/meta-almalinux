# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros-backend"
PV = "0.29.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-pyo3-macros-backend+default-devel \
 rust-pyo3-macros-backend+experimental-async-devel \
 rust-pyo3-macros-backend+experimental-inspect-devel \
 rust-pyo3-macros-backend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-backend-0.29.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d92a2d879494ae3aacd3c28bd185fbefb5a57a47a4b64b672c0a20affa16491"

URI_x86_64_v2_rust-pyo3-macros-backend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+default-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+default-devel.sha256sum] = "5be66bad4c641b8aaa423d3b1dee943200a57dccbffdf0e04cd22d30d7b0b9a7"

URI_x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+experimental-async-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+experimental-async-devel.sha256sum] = "ecf72b7804a2c1a1d0623e933c7e6c4d888079cb3f7ad2118ceea7dc2e18e971"

URI_x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend+experimental-inspect-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend+experimental-inspect-devel.sha256sum] = "14265c06f197c92464d7c9b8df0296571637a0e4b9e3e41b5cd17c2c411f0755"

URI_x86_64_v2_rust-pyo3-macros-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend-devel.sha256sum] = "3e599152c443f1f1195b39235fa53e7e8c58cdbce2c8854d86d25ddef1d93fcc"

URI_aarch64_rust-pyo3-macros-backend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+default-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+default-devel.sha256sum] = "03cf510b2dfc57a016a9250bbab8e36e3ede6905a7dc510f37e8542d1a35a7e0"

URI_aarch64_rust-pyo3-macros-backend+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+experimental-async-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+experimental-async-devel.sha256sum] = "3f6248a80399f16756b6b9156398fbf71aa143ed123814c49029247f7797531f"

URI_aarch64_rust-pyo3-macros-backend+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend+experimental-inspect-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros-backend+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend+experimental-inspect-devel.sha256sum] = "8c18bd84fb96742d35b290551d160f9b3015869a7039d8afb9cf171c1ad7be2f"

URI_aarch64_rust-pyo3-macros-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-macros-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend-devel.sha256sum] = "79375f1f607512cd902657e23da80f4517954d376237b5ea930623c8410c1ab6"

RDEPENDS:rust-pyo3-macros-backend+default-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend-devel \
 "
RDEPENDS:rust-pyo3-macros-backend-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn2+clone-impls-devel \
 rust-syn2+derive-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+visit-mut-devel \
 rust-syn2-devel \
 "
