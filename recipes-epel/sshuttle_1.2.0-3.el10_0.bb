# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sshuttle"
PV = "1.2.0"
PR = "3.el10_0"
PACKAGES = " \
 sshuttle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sshuttle-1.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c39709a734e60f6d3ed7097e22743285d7628a2f0aeed73b176ef4d59a4296c6"

URI_x86_64_v2_sshuttle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sshuttle-1.2.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sshuttle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sshuttle}"
SRC_URI[x86_64_v2_sshuttle.sha256sum] = "a134359982ed86531cc03976f3baeb160996a937e16b7bf74b243edfa55df334"

URI_aarch64_sshuttle = "${EPEL_MIRROR}/aarch64/Packages/s/sshuttle-1.2.0-3.el10_0.noarch.rpm;name=aarch64_sshuttle;unpack=0"
SRC_URI:append = " ${URI_aarch64_sshuttle}"
SRC_URI[aarch64_sshuttle.sha256sum] = "43ba87d2e989c37d1c9baae1e59d14bb515dae0fe66bf93135e585821fcd4e22"

RDEPENDS:sshuttle = " \
 iptables-nft \
 openssh-clients \
 python3 \
 "
