# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ratatui0.26"
PV = "0.26.3"
PR = "5.el10_1"
PACKAGES = " \
 rust-ratatui0.26+all-widgets-devel \
 rust-ratatui0.26+crossterm-devel \
 rust-ratatui0.26+default-devel \
 rust-ratatui0.26+document-features-devel \
 rust-ratatui0.26+macros-devel \
 rust-ratatui0.26+serde-devel \
 rust-ratatui0.26+termion-devel \
 rust-ratatui0.26+underline-color-devel \
 rust-ratatui0.26+unstable-devel \
 rust-ratatui0.26+unstable-rendered-line-info-devel \
 rust-ratatui0.26+unstable-widget-ref-devel \
 rust-ratatui0.26+widget-calendar-devel \
 rust-ratatui0.26-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ratatui0.26-0.26.3-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f267890493f547da5be9fc35255d242c47a87ab11f00a160a3ab123333597e23"

URI_x86_64_v2_rust-ratatui0.26+all-widgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+all-widgets-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+all-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+all-widgets-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+all-widgets-devel.sha256sum] = "3bd766028c85d7c746afb7dc67cfbb0ae37b06e20e0e8722f9c29d1700d4a466"

URI_x86_64_v2_rust-ratatui0.26+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+crossterm-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+crossterm-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+crossterm-devel.sha256sum] = "997dd6f194ce793a036385628c43fe491c79a1bf0366436ff403819d9805ae0f"

URI_x86_64_v2_rust-ratatui0.26+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+default-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+default-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+default-devel.sha256sum] = "5f80ecfbb926ec1f039334a8342ab7a4c914f4bcfb32e2ec2c216e7b4a792da9"

URI_x86_64_v2_rust-ratatui0.26+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+document-features-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+document-features-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+document-features-devel.sha256sum] = "ea216820741e3a4102bca310dbb1b5a828f1531c30ba013c0509d6062ecb6a3c"

URI_x86_64_v2_rust-ratatui0.26+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+macros-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+macros-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+macros-devel.sha256sum] = "fee85ba0bb14b73bf6cbe1d028ebb079278801ef40d75c57e12af1a830356a61"

URI_x86_64_v2_rust-ratatui0.26+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+serde-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+serde-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+serde-devel.sha256sum] = "623d0755054d87f5e0e498035ff741ca70a742b145dc386d733d0499f7f69912"

URI_x86_64_v2_rust-ratatui0.26+termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+termion-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+termion-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+termion-devel.sha256sum] = "beeda598f6282668784e8fedee69ca168e313b1800f1c54b1aba3f00eab8f823"

URI_x86_64_v2_rust-ratatui0.26+underline-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+underline-color-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+underline-color-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+underline-color-devel.sha256sum] = "0559a7f12e4415709c0b53b7d1f5add1de23286611a2cfc1b3be0bf1ca424d42"

URI_x86_64_v2_rust-ratatui0.26+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+unstable-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+unstable-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+unstable-devel.sha256sum] = "29e16be72bcdabc16707b6206278073273d1d8bf87d67e7bcd37facc40cfe4ed"

URI_x86_64_v2_rust-ratatui0.26+unstable-rendered-line-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+unstable-rendered-line-info-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+unstable-rendered-line-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+unstable-rendered-line-info-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+unstable-rendered-line-info-devel.sha256sum] = "f4142a4b112b0e37f8379351d92f6324df171626215cbc1c803f725bb0f256e7"

URI_x86_64_v2_rust-ratatui0.26+unstable-widget-ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+unstable-widget-ref-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+unstable-widget-ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+unstable-widget-ref-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+unstable-widget-ref-devel.sha256sum] = "0cf996aa2c9ed0b3c1b4f9b7c3cd2b8ef5982c657e85ef3dee3dc5aedfa038b2"

URI_x86_64_v2_rust-ratatui0.26+widget-calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26+widget-calendar-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26+widget-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26+widget-calendar-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26+widget-calendar-devel.sha256sum] = "643cac879341b645909f3ad218547a8437bc8980235a0bf462097f77a7baf913"

URI_x86_64_v2_rust-ratatui0.26-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui0.26-devel-0.26.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui0.26-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui0.26-devel}"
SRC_URI[x86_64_v2_rust-ratatui0.26-devel.sha256sum] = "3bd093dfb6cdc978de0eb78a1e3102cf3af54da58eea4bad11ed91743531344a"

URI_aarch64_rust-ratatui0.26+all-widgets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+all-widgets-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+all-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+all-widgets-devel}"
SRC_URI[aarch64_rust-ratatui0.26+all-widgets-devel.sha256sum] = "2530f15a3c0cbf40447c71eb2bb901409e1c466be3ca42117324d76c6794d209"

URI_aarch64_rust-ratatui0.26+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+crossterm-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+crossterm-devel}"
SRC_URI[aarch64_rust-ratatui0.26+crossterm-devel.sha256sum] = "914997bb38fa31603b2001027f8eb4dac09d1706d63d156761a3189c7933028f"

URI_aarch64_rust-ratatui0.26+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+default-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+default-devel}"
SRC_URI[aarch64_rust-ratatui0.26+default-devel.sha256sum] = "77126fb63f2d7fb5d4667825c4b6d4bcf198ce2401085c541f2603af6609c68d"

URI_aarch64_rust-ratatui0.26+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+document-features-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+document-features-devel}"
SRC_URI[aarch64_rust-ratatui0.26+document-features-devel.sha256sum] = "a1141d81771609a81034bcba1a7e512253914b568988132574932d3fc7b58358"

URI_aarch64_rust-ratatui0.26+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+macros-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+macros-devel}"
SRC_URI[aarch64_rust-ratatui0.26+macros-devel.sha256sum] = "b3fc89ab2d7ec298fbaea468b0475573e0ec21f5c725342102f92caf6ec4ddce"

URI_aarch64_rust-ratatui0.26+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+serde-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+serde-devel}"
SRC_URI[aarch64_rust-ratatui0.26+serde-devel.sha256sum] = "70522ca9726d104e03e3cdb56fa8ff9d1193a3e86a7f332a55bfd2918065464f"

URI_aarch64_rust-ratatui0.26+termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+termion-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+termion-devel}"
SRC_URI[aarch64_rust-ratatui0.26+termion-devel.sha256sum] = "31923699b007ff12a875d1f00dc8166b9a2062154a7f9e2eb0d9504d9e2b4f92"

URI_aarch64_rust-ratatui0.26+underline-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+underline-color-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+underline-color-devel}"
SRC_URI[aarch64_rust-ratatui0.26+underline-color-devel.sha256sum] = "c3b8b8d68b728eb27614f45c11aeb111d7d458dcf28df2caa221817cd6d514d2"

URI_aarch64_rust-ratatui0.26+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+unstable-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+unstable-devel}"
SRC_URI[aarch64_rust-ratatui0.26+unstable-devel.sha256sum] = "a824f3b1a3947039a4521aa188b3110e35eb88b5f8106d865372c5a4760e6312"

URI_aarch64_rust-ratatui0.26+unstable-rendered-line-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+unstable-rendered-line-info-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+unstable-rendered-line-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+unstable-rendered-line-info-devel}"
SRC_URI[aarch64_rust-ratatui0.26+unstable-rendered-line-info-devel.sha256sum] = "578b57c1160147d978a9b9783cb1843ca8da97b9c5906fddca1cc8b0581229b6"

URI_aarch64_rust-ratatui0.26+unstable-widget-ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+unstable-widget-ref-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+unstable-widget-ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+unstable-widget-ref-devel}"
SRC_URI[aarch64_rust-ratatui0.26+unstable-widget-ref-devel.sha256sum] = "eb170c61362b693448040bd05c70fff1db3467fdb08051c6ca1f92b8a2bd4cd8"

URI_aarch64_rust-ratatui0.26+widget-calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26+widget-calendar-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26+widget-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26+widget-calendar-devel}"
SRC_URI[aarch64_rust-ratatui0.26+widget-calendar-devel.sha256sum] = "c1d02683093ab0ce892e8b6e0a484d04da4b1a50cf281333db2bcfc8a5f92f2e"

URI_aarch64_rust-ratatui0.26-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui0.26-devel-0.26.3-5.el10_1.noarch.rpm;name=aarch64_rust-ratatui0.26-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui0.26-devel}"
SRC_URI[aarch64_rust-ratatui0.26-devel.sha256sum] = "c1f3c750cedad652119e9f66bfb92301262415d223d512ba0a88b8b663f4ba8b"

RDEPENDS:rust-ratatui0.26+all-widgets-devel = " \
 cargo \
 rust-ratatui0.26+widget-calendar-devel \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-ratatui0.26+crossterm-devel = " \
 cargo \
 rust-crossterm0.27+default-devel \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-ratatui0.26+default-devel = " \
 cargo \
 rust-ratatui0.26+crossterm-devel \
 rust-ratatui0.26+underline-color-devel \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-ratatui0.26+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-ratatui0.26+macros-devel = " \
 cargo \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-ratatui0.26+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-compact_str0.9+serde-devel \
 rust-ratatui0.26-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-ratatui0.26+termion-devel = " \
 cargo \
 rust-ratatui0.26-devel \
 rust-termion+default-devel \
 "
RDEPENDS:rust-ratatui0.26+underline-color-devel = " \
 cargo \
 rust-crossterm0.27+default-devel \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-ratatui0.26+unstable-devel = " \
 cargo \
 rust-ratatui0.26+unstable-rendered-line-info-devel \
 rust-ratatui0.26+unstable-widget-ref-devel \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-ratatui0.26+unstable-rendered-line-info-devel = " \
 cargo \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-ratatui0.26+unstable-widget-ref-devel = " \
 cargo \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-ratatui0.26+widget-calendar-devel = " \
 cargo \
 rust-ratatui0.26-devel \
 rust-time+default-devel \
 rust-time+local-offset-devel \
 "
RDEPENDS:rust-ratatui0.26-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cassowary+default-devel \
 rust-compact_str0.9+default-devel \
 rust-itertools0.12+default-devel \
 rust-lru0.12+default-devel \
 rust-paste+default-devel \
 rust-stability+default-devel \
 rust-strum0.26+default-devel \
 rust-strum0.26+derive-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-truncate1+default-devel \
 rust-unicode-width0.1+default-devel \
 "
