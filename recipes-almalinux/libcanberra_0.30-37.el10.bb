# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcanberra"
PV = "0.30"
PR = "37.el10"
PACKAGES = " \
 libcanberra \
 libcanberra-devel \
 libcanberra-gtk3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libcanberra-0.30-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e8bb6af5d935d89cf300e5015277d58dc41f9841bb03dc285b4cfaf666e339e"

URI_x86_64_v2_libcanberra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcanberra-0.30-37.el10.x86_64_v2.rpm;name=x86_64_v2_libcanberra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcanberra}"
SRC_URI[x86_64_v2_libcanberra.sha256sum] = "5df0395d1075cf89478bcf313b7bd5d85edab22f64578f3f4811295e4f2e3db6"

URI_x86_64_v2_libcanberra-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcanberra-devel-0.30-37.el10.x86_64_v2.rpm;name=x86_64_v2_libcanberra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcanberra-devel}"
SRC_URI[x86_64_v2_libcanberra-devel.sha256sum] = "a0310cf737cd88b14396999888c609dd1ca9f835d6eb35cea5e3d4550e99cc81"

URI_x86_64_v2_libcanberra-gtk3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcanberra-gtk3-0.30-37.el10.x86_64_v2.rpm;name=x86_64_v2_libcanberra-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcanberra-gtk3}"
SRC_URI[x86_64_v2_libcanberra-gtk3.sha256sum] = "1f904d9b6742ab72f571f84d4c3a4371b2b43da3d80c3a354d05c014d9b5d8ab"

URI_aarch64_libcanberra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcanberra-0.30-37.el10.aarch64.rpm;name=aarch64_libcanberra;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcanberra}"
SRC_URI[aarch64_libcanberra.sha256sum] = "3029bdfc16e79727be5cb2ae18a556c5fda0c813bc23d377ac9e95c99d4a7c48"

URI_aarch64_libcanberra-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcanberra-devel-0.30-37.el10.aarch64.rpm;name=aarch64_libcanberra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcanberra-devel}"
SRC_URI[aarch64_libcanberra-devel.sha256sum] = "c3d07d28c92af693e513d99affbe3497605fd257ae13879feb91dfc7bfec7f3b"

URI_aarch64_libcanberra-gtk3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcanberra-gtk3-0.30-37.el10.aarch64.rpm;name=aarch64_libcanberra-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcanberra-gtk3}"
SRC_URI[aarch64_libcanberra-gtk3.sha256sum] = "7e03114e7611f3d551397a9ad8a8a11193810ddfbfc6c271d0db2873d9646c8e"

RDEPENDS:libcanberra = " \
 alsa-lib \
 bash \
 glib2 \
 glibc \
 gstreamer1 \
 libtdb \
 libtool-ltdl \
 libvorbis \
 pulseaudio-libs \
 sound-theme-freedesktop \
 systemd-libs \
 "
RDEPENDS:libcanberra-devel = " \
 gtk3-devel \
 libcanberra \
 libcanberra-devel \
 libcanberra-gtk3 \
 pkgconf-pkg-config \
 "
RDEPENDS:libcanberra-gtk3 = " \
 atk \
 bash \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libcanberra \
 libtdb \
 libtool-ltdl \
 libvorbis \
 pango \
 "
