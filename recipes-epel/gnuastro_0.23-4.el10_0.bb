# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnuastro"
PV = "0.23"
PR = "4.el10_0"
PACKAGES = " \
 gnuastro \
 gnuastro-devel \
 gnuastro-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnuastro-0.23-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f593cebbb7e3610f7e4a9cf2d835651d9e1694a08be13bde1f04dd0f5505e740"

URI_x86_64_v2_gnuastro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-0.23-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuastro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuastro}"
SRC_URI[x86_64_v2_gnuastro.sha256sum] = "f845364b286a5a2cb650d8fcf1ab88557828bbb763d1b82a1970d569252d8aae"

URI_x86_64_v2_gnuastro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-devel-0.23-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuastro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuastro-devel}"
SRC_URI[x86_64_v2_gnuastro-devel.sha256sum] = "83838a9627c20b2138ce8689d79f5a6772f4008e910c7b80391b63787108852f"

URI_x86_64_v2_gnuastro-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-doc-0.23-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnuastro-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuastro-doc}"
SRC_URI[x86_64_v2_gnuastro-doc.sha256sum] = "4ce6393771defdcc4f9334d757278dfa8a360b6988a922092d14e40ad8376f02"

URI_aarch64_gnuastro = "${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-0.23-4.el10_0.aarch64.rpm;name=aarch64_gnuastro;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuastro}"
SRC_URI[aarch64_gnuastro.sha256sum] = "a012b30c899044eb234290ca419a03cac2c4022fc3ce83be72b252bcb32cc15e"

URI_aarch64_gnuastro-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-devel-0.23-4.el10_0.aarch64.rpm;name=aarch64_gnuastro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuastro-devel}"
SRC_URI[aarch64_gnuastro-devel.sha256sum] = "8670593e2f06fcb37ed8d61b9193385fa9443010722e19ed78be6d6027d58da3"

URI_aarch64_gnuastro-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-doc-0.23-4.el10_0.noarch.rpm;name=aarch64_gnuastro-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuastro-doc}"
SRC_URI[aarch64_gnuastro-doc.sha256sum] = "eca57a396882e164d165a822efcf4e0c5a3871a4344fa20605c052aadb498ad5"

RDEPENDS:gnuastro = " \
 bash \
 cfitsio \
 glibc \
 gsl \
 libgit2 \
 libjpeg-turbo \
 libtiff \
 wcslib \
 zlib-ng-compat \
 "
RDEPENDS:gnuastro-devel = " \
 cfitsio-devel \
 gnuastro \
 gsl-devel \
 libgit2-devel \
 libjpeg-turbo-devel \
 libtiff-devel \
 pkgconf-pkg-config \
 wcslib-devel \
 "
RDEPENDS:gnuastro-doc = " \
 "
