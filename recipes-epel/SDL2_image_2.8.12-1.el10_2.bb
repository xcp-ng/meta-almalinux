# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SDL2_image"
PV = "2.8.12"
PR = "1.el10_2"
PACKAGES = " \
 SDL2_image \
 SDL2_image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SDL2_image-2.8.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5227bbe6bf291d51be8f1efdae75ff0594b1b566b5ab5a3cf7cae315aa7c2e3"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - SDL2_image-devel: pkgconfig(sdl2) >= 2.0.9

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - SDL2_image-devel: pkgconfig(sdl2) >= 2.0.9

URI_x86_64_v2_SDL2_image = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_image-2.8.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_image;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_image}"
SRC_URI[x86_64_v2_SDL2_image.sha256sum] = "580468989e6221e8d0926d04b469b508b3c18d4d094ddc2104c75cdc7a8c7b0b"

URI_x86_64_v2_SDL2_image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_image-devel-2.8.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_image-devel}"
SRC_URI[x86_64_v2_SDL2_image-devel.sha256sum] = "d48fa311d7e893557100d21dccda6de6047f404e4dfc793bed31b437531e82af"

URI_aarch64_SDL2_image = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_image-2.8.12-1.el10_2.aarch64.rpm;name=aarch64_SDL2_image;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_image}"
SRC_URI[aarch64_SDL2_image.sha256sum] = "4ea49d3247f5d490a03f826755c1bbc484321e8e2306fbd284b772e644ab8223"

URI_aarch64_SDL2_image-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_image-devel-2.8.12-1.el10_2.aarch64.rpm;name=aarch64_SDL2_image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_image-devel}"
SRC_URI[aarch64_SDL2_image-devel.sha256sum] = "ad55f86f33da53eb4082a2e4cdea1afb1288e5aad7d10ab101b390ec6ca904fe"

RDEPENDS:SDL2_image = " \
 glibc \
 libavif \
 libjxl \
 libtiff \
 libwebp \
 sdl2-compat \
 "
RDEPENDS:SDL2_image-devel = " \
 SDL2_image \
 libavif-devel \
 libjxl-devel \
 libtiff-devel \
 libwebp-devel \
 pkgconf-pkg-config \
 "
