# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-uritemplate"
PV = "4.2.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-uritemplate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-uritemplate-4.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a0e2a5294bfad56f2fdb33336494abf68b9eada641acb9854f30eb8b0e0c662"

URI_x86_64_v2_python3-uritemplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uritemplate-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-uritemplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uritemplate}"
SRC_URI[x86_64_v2_python3-uritemplate.sha256sum] = "6710af88444472b5776a96f160623d1eb7c1d5bbd32ace037603f30a58f8efb5"

URI_aarch64_python3-uritemplate = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uritemplate-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-uritemplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uritemplate}"
SRC_URI[aarch64_python3-uritemplate.sha256sum] = "285f97978a2f230f0a729331981c135e191e85305a5aebc58e29ba166c204062"

RDEPENDS:python3-uritemplate = " \
 python3 \
 "
