# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cronie"
PV = "1.7.0"
PR = "9.el10"
PACKAGES = " \
 cronie \
 cronie-anacron \
 cronie-noanacron \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cronie-1.7.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eab3497f7f78e29a32757ad77c70409cff83ce566447e511898d28bbe279d3e0"

URI_x86_64_v2_cronie = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-1.7.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_cronie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cronie}"
SRC_URI[x86_64_v2_cronie.sha256sum] = "4d7d6c921bd5d7bc77e5dea89ee2c7c1e7d2c8202b7ab304dd988f2508877353"

URI_x86_64_v2_cronie-anacron = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-anacron-1.7.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_cronie-anacron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cronie-anacron}"
SRC_URI[x86_64_v2_cronie-anacron.sha256sum] = "8e75ffcb886df7e1ed033e2def89476428895bd10680af0a898c94b8aa77feb2"
RPROVIDES:cronie-anacron:x86_64_v2 = "virtual/dailyjobs"

URI_x86_64_v2_cronie-noanacron = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cronie-noanacron-1.7.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_cronie-noanacron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cronie-noanacron}"
SRC_URI[x86_64_v2_cronie-noanacron.sha256sum] = "1e85aa9cb993ddc9bc5c5aadeafea6bdb08cefc6108bcc60748ba7745492578f"
RPROVIDES:cronie-noanacron:x86_64_v2 = "virtual/dailyjobs"

URI_aarch64_cronie = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-1.7.0-9.el10.aarch64.rpm;name=aarch64_cronie;unpack=0"
SRC_URI:append = " ${URI_aarch64_cronie}"
SRC_URI[aarch64_cronie.sha256sum] = "55021b0a11886ec7262b06e4b20102ba97f5dcd13c518add2069b98bfff7f284"

URI_aarch64_cronie-anacron = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-anacron-1.7.0-9.el10.aarch64.rpm;name=aarch64_cronie-anacron;unpack=0"
SRC_URI:append = " ${URI_aarch64_cronie-anacron}"
SRC_URI[aarch64_cronie-anacron.sha256sum] = "3a801266fac7b94a8234fc75b07b1b709b5c7bddeb8ad7567fafbd4c6316cbcc"
RPROVIDES:cronie-anacron:aarch64 = "virtual/dailyjobs"

URI_aarch64_cronie-noanacron = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cronie-noanacron-1.7.0-9.el10.aarch64.rpm;name=aarch64_cronie-noanacron;unpack=0"
SRC_URI:append = " ${URI_aarch64_cronie-noanacron}"
SRC_URI[aarch64_cronie-noanacron.sha256sum] = "f6157ca060531140f5df5c2c31a4168a52511a2d807138a74318fd57e740b858"
RPROVIDES:cronie-noanacron:aarch64 = "virtual/dailyjobs"

RDEPENDS:cronie = " \
 audit-libs \
 bash \
 glibc \
 libselinux \
 pam \
 pam-libs \
 sed \
 virtual/coreutils \
 virtual/dailyjobs \
 "
RDEPENDS:cronie-anacron = " \
 bash \
 cronie \
 crontabs \
 glibc \
 virtual/coreutils \
 "
RDEPENDS:cronie-noanacron = " \
 cronie \
 crontabs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/dailyjobs"

PROVIDES:append:aarch64 = " rpm/virtual/dailyjobs"
