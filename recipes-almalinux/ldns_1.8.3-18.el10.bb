# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ldns"
PV = "1.8.3"
PR = "18.el10"
PACKAGES = " \
 ldns \
 ldns-devel \
 ldns-doc \
 ldns-utils \
 perl-ldns \
 python3-ldns \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ldns-1.8.3-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ba06ef6bbf6647053953d03c4ab5b7f867505bd03f153baa4778c5b448b1e66"

URI_x86_64_v2_ldns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ldns-1.8.3-18.el10.x86_64_v2.rpm;name=x86_64_v2_ldns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldns}"
SRC_URI[x86_64_v2_ldns.sha256sum] = "b3a535a7dbd787bb36b5de450c577708cfc2e1597dc4cee33938a418ee4fcb16"

URI_x86_64_v2_ldns-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ldns-devel-1.8.3-18.el10.x86_64_v2.rpm;name=x86_64_v2_ldns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldns-devel}"
SRC_URI[x86_64_v2_ldns-devel.sha256sum] = "f4bc0e9979dd94d35d712c7c6aeb5b5788846234a002ca63b1f6bc3dd9307c0b"

URI_x86_64_v2_ldns-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ldns-doc-1.8.3-18.el10.noarch.rpm;name=x86_64_v2_ldns-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldns-doc}"
SRC_URI[x86_64_v2_ldns-doc.sha256sum] = "e2b614646106982b624b16dc496580749c9368ed073ba5e0ac58ce8858667647"

URI_x86_64_v2_ldns-utils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ldns-utils-1.8.3-18.el10.x86_64_v2.rpm;name=x86_64_v2_ldns-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldns-utils}"
SRC_URI[x86_64_v2_ldns-utils.sha256sum] = "93d866a3bb8f8bab2988475236d56748c2523abb4a703bead81cbb1ff3bb029b"

URI_x86_64_v2_perl-ldns = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-ldns-1.8.3-18.el10.x86_64_v2.rpm;name=x86_64_v2_perl-ldns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ldns}"
SRC_URI[x86_64_v2_perl-ldns.sha256sum] = "e0cb6891c63c0f07806d1154ea668753d71a5e23e342e67084232c43099d1900"

URI_x86_64_v2_python3-ldns = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-ldns-1.8.3-18.el10.x86_64_v2.rpm;name=x86_64_v2_python3-ldns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ldns}"
SRC_URI[x86_64_v2_python3-ldns.sha256sum] = "f9c2ff603504527d69b6a377b23438aae0cd0097d031d793882be06e9d8a4438"

URI_aarch64_ldns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ldns-1.8.3-18.el10.aarch64.rpm;name=aarch64_ldns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldns}"
SRC_URI[aarch64_ldns.sha256sum] = "e29399dfd703d8c7d3246824500a0fa66d50a996373965cba8b0acef1ebf7f0c"

URI_aarch64_ldns-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ldns-devel-1.8.3-18.el10.aarch64.rpm;name=aarch64_ldns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldns-devel}"
SRC_URI[aarch64_ldns-devel.sha256sum] = "0304a91a3f6d37ec631636ed733334857ce785c1cad505ec7f601ba7cac1efc9"

URI_aarch64_ldns-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ldns-doc-1.8.3-18.el10.noarch.rpm;name=aarch64_ldns-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldns-doc}"
SRC_URI[aarch64_ldns-doc.sha256sum] = "e2b614646106982b624b16dc496580749c9368ed073ba5e0ac58ce8858667647"

URI_aarch64_ldns-utils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ldns-utils-1.8.3-18.el10.aarch64.rpm;name=aarch64_ldns-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldns-utils}"
SRC_URI[aarch64_ldns-utils.sha256sum] = "d9f843515d79c58fa63300b7e1abdb45e08d9d8b5b4b2ba4c994f735864c036c"

URI_aarch64_perl-ldns = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-ldns-1.8.3-18.el10.aarch64.rpm;name=aarch64_perl-ldns;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ldns}"
SRC_URI[aarch64_perl-ldns.sha256sum] = "009cdbb56b23cfd1864ddce6f005d2485439d144105f75fde665cd0fa1d0c399"

URI_aarch64_python3-ldns = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-ldns-1.8.3-18.el10.aarch64.rpm;name=aarch64_python3-ldns;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ldns}"
SRC_URI[aarch64_python3-ldns.sha256sum] = "82185b1cbfaaf9d7de1b1a59c4c7492945eab01ff8893d22e84f1da9a1b8f509"

RDEPENDS:ldns = " \
 ca-certificates \
 glibc \
 openssl-libs \
 "
RDEPENDS:ldns-devel = " \
 bash \
 ldns \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ldns-doc = " \
 "
RDEPENDS:ldns-utils = " \
 glibc \
 ldns \
 libpcap \
 openssl-libs \
 "
RDEPENDS:perl-ldns = " \
 glibc \
 ldns \
 perl-AutoLoader \
 perl-Carp \
 perl-Exporter \
 perl-ldns \
 perl-libs \
 "
RDEPENDS:python3-ldns = " \
 glibc \
 ldns \
 openssl-libs \
 python3 \
 python3-libs \
 "
