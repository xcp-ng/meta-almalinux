# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-yesod"
PV = "1.6.2.1"
PR = "7.el10_0"
PACKAGES = " \
 ghc-yesod \
 ghc-yesod-devel \
 ghc-yesod-doc \
 ghc-yesod-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-yesod-1.6.2.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9a9bfd6a3653a146ea1368cef0ee72cb19d73b0c7b9d79c32036ce16403a3db"

URI_x86_64_v2_ghc-yesod = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-1.6.2.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod}"
SRC_URI[x86_64_v2_ghc-yesod.sha256sum] = "d3965d16ce0ede01d40bf185dc9b9028345730860cc73c4e854117940e9634d1"

URI_x86_64_v2_ghc-yesod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-devel-1.6.2.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-devel}"
SRC_URI[x86_64_v2_ghc-yesod-devel.sha256sum] = "0a27c843521a81f155121983571f8600f98c32389382f5ff17c84f3d1a0ca93a"

URI_x86_64_v2_ghc-yesod-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-doc-1.6.2.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-yesod-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-doc}"
SRC_URI[x86_64_v2_ghc-yesod-doc.sha256sum] = "b11a9b110407b6a7f5d813c2c053ca43a3e9bc91b39b79b73c88e96744999dd2"

URI_x86_64_v2_ghc-yesod-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-prof-1.6.2.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-prof}"
SRC_URI[x86_64_v2_ghc-yesod-prof.sha256sum] = "3a858d8fc0779e56efa19f1eed53a19947a1cbc209c2f39f04244d88294a4f62"

URI_aarch64_ghc-yesod = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-1.6.2.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-yesod;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod}"
SRC_URI[aarch64_ghc-yesod.sha256sum] = "ba945f56d9e0c6bf281155a7a406e8fb9daf0b1ad2d4742a77e88a02a732c5be"

URI_aarch64_ghc-yesod-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-devel-1.6.2.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-devel}"
SRC_URI[aarch64_ghc-yesod-devel.sha256sum] = "b8ef2fa9a390ce72f8e1de5474b2894b1642ee6e2a87f7a71cc293398aee4224"

URI_aarch64_ghc-yesod-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-doc-1.6.2.1-7.el10_0.noarch.rpm;name=aarch64_ghc-yesod-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-doc}"
SRC_URI[aarch64_ghc-yesod-doc.sha256sum] = "a723a49e3d2c68a55cb2a22efdef341c023162d3a97ddb75abd2898f4f98809b"

URI_aarch64_ghc-yesod-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-prof-1.6.2.1-7.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-prof}"
SRC_URI[aarch64_ghc-yesod-prof.sha256sum] = "2ec6ecd91a2e17bbe3f8c60a91dc298ba6b26bbeaf9feeef1d9980117dc7d52b"

RDEPENDS:ghc-yesod = " \
 ghc-HUnit \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-attoparsec-iso8601 \
 ghc-auto-update \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bsb-http-chunked \
 ghc-byteable \
 ghc-byteorder \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-clientsession \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypto-api \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-cryptonite \
 ghc-css-text \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-easy-file \
 ghc-email-validate \
 ghc-entropy \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-api-data \
 ghc-http-date \
 ghc-http-types \
 ghc-http2 \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-conversion \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-libyaml \
 ghc-lift-type \
 ghc-lifted-base \
 ghc-memory \
 ghc-monad-control \
 ghc-monad-logger \
 ghc-monad-loops \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-byte-order \
 ghc-network-control \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-path-pieces \
 ghc-pem \
 ghc-persistent \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-psqueues \
 ghc-random \
 ghc-recv \
 ghc-resource-pool \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-setenv \
 ghc-shakespeare \
 ghc-silently \
 ghc-simple-sendfile \
 ghc-skein \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-stm-chans \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-tagsoup \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-time-manager \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-wai \
 ghc-wai-extra \
 ghc-wai-logger \
 ghc-warp \
 ghc-witherable \
 ghc-word8 \
 ghc-xss-sanitize \
 ghc-yaml \
 ghc-yesod-core \
 ghc-yesod-form \
 ghc-yesod-persistent \
 ghc-zlib \
 glibc \
 gmp \
 libyaml \
 zlib-ng-compat \
 "
RDEPENDS:ghc-yesod-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-data-default-class-devel \
 ghc-directory-devel \
 ghc-fast-logger-devel \
 ghc-file-embed-devel \
 ghc-monad-logger-devel \
 ghc-shakespeare-devel \
 ghc-streaming-commons-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-unix-devel \
 ghc-unordered-containers-devel \
 ghc-wai-devel \
 ghc-wai-extra-devel \
 ghc-wai-logger-devel \
 ghc-warp-devel \
 ghc-yaml-devel \
 ghc-yesod \
 ghc-yesod-core-devel \
 ghc-yesod-form-devel \
 ghc-yesod-persistent-devel \
 "
RDEPENDS:ghc-yesod-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-yesod-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-conduit-prof \
 ghc-data-default-class-prof \
 ghc-directory-prof \
 ghc-fast-logger-prof \
 ghc-file-embed-prof \
 ghc-monad-logger-prof \
 ghc-shakespeare-prof \
 ghc-streaming-commons-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-unix-prof \
 ghc-unordered-containers-prof \
 ghc-wai-extra-prof \
 ghc-wai-logger-prof \
 ghc-wai-prof \
 ghc-warp-prof \
 ghc-yaml-prof \
 ghc-yesod-core-prof \
 ghc-yesod-devel \
 ghc-yesod-form-prof \
 ghc-yesod-persistent-prof \
 "
