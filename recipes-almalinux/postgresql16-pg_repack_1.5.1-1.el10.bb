# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16-pg_repack"
PV = "1.5.1"
PR = "1.el10"
PACKAGES = " \
 pg_repack \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-pg_repack-1.5.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80af2090f7bf60dd9cbee34b51d2bdd85629af232ae48e8ca48d5877e9e870a2"

URI_x86_64_v2_pg_repack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pg_repack-1.5.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_pg_repack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pg_repack}"
SRC_URI[x86_64_v2_pg_repack.sha256sum] = "6c33251e588893d53ecdefad41f7e55b4b324676b675eb44e23ec54452dc9440"

URI_aarch64_pg_repack = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pg_repack-1.5.1-1.el10.aarch64.rpm;name=aarch64_pg_repack;unpack=0"
SRC_URI:append = " ${URI_aarch64_pg_repack}"
SRC_URI[aarch64_pg_repack.sha256sum] = "aa705cdbb3d3d06307115f997f12f9601f86e75a34fc91ca49254916564fd09b"

RDEPENDS:pg_repack = " \
 glibc \
 postgresql-private-libs \
 postgresql-server \
 "
