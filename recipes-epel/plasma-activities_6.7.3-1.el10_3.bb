# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-activities"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-activities \
 plasma-activities-devel \
 plasma-activities-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-activities-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75de82fc65b3e5da8ed951cefa83647d5b53c098eaf256583cb3fe7dbcb9e497"

URI_x86_64_v2_plasma-activities = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities}"
SRC_URI[x86_64_v2_plasma-activities.sha256sum] = "5afbf3bf22afc1b6ced102bd77b35e157f42dd7b9d85abc85f564f8025399dfe"

URI_x86_64_v2_plasma-activities-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-devel}"
SRC_URI[x86_64_v2_plasma-activities-devel.sha256sum] = "75dcbeeee39c606f7e2d1371b435ec279a1caaa961fcb630b740490e10175ba6"

URI_x86_64_v2_plasma-activities-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-doc-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-activities-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-doc}"
SRC_URI[x86_64_v2_plasma-activities-doc.sha256sum] = "1e4ad45a4179f06b84cf4f2049d80998613fd4ca76dea48f3872e8304d1eea89"

URI_aarch64_plasma-activities = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-activities;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities}"
SRC_URI[aarch64_plasma-activities.sha256sum] = "f37e82cde176d3f5c767248dbb28d3187a068d5cb5d6b963768f63c742140d03"

URI_aarch64_plasma-activities-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-activities-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-devel}"
SRC_URI[aarch64_plasma-activities-devel.sha256sum] = "b4ec773b39a869d0b3921c25aa553f00c0daeff525e6e6d5aed321792e6c64da"

URI_aarch64_plasma-activities-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-doc-6.7.3-1.el10_3.noarch.rpm;name=aarch64_plasma-activities-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-doc}"
SRC_URI[aarch64_plasma-activities-doc.sha256sum] = "ecee4435aecf204f26f216dc2453f9407a5ba5cc1c7a19664c3100894668f39f"

RDEPENDS:plasma-activities = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-activities-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plasma-activities \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma-activities-doc = " \
 "
