# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bgpq3"
PV = "0.1.38"
PR = "1.el10_2"
PACKAGES = " \
 bgpq3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bgpq3-0.1.38-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a42d23bef84779acff8a5a4c7a020e8915a602d5de7cf8456b4b4bde3e506e7f"

URI_x86_64_v2_bgpq3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bgpq3-0.1.38-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bgpq3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bgpq3}"
SRC_URI[x86_64_v2_bgpq3.sha256sum] = "8e288629d90b9935f4a1992ef794617b705b7282944191b396c21ca0c379b088"

URI_aarch64_bgpq3 = "${EPEL_MIRROR}/aarch64/Packages/b/bgpq3-0.1.38-1.el10_2.aarch64.rpm;name=aarch64_bgpq3;unpack=0"
SRC_URI:append = " ${URI_aarch64_bgpq3}"
SRC_URI[aarch64_bgpq3.sha256sum] = "3caeabc0bf3d39b519466cac844e6d94186e37977b86b167055cdd7d43ba3f40"

RDEPENDS:bgpq3 = " \
 glibc \
 "
