# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerline"
PV = "2.8.4"
PR = "1.el10_0"
PACKAGES = " \
 powerline \
 powerline-docs \
 powerline-fonts \
 tmux-powerline \
 vim-powerline \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/powerline-2.8.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c5bf819ac60232554dc35cd327de500303d5e52390742dc3131fb1417f45e1cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerline-2.8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerline;unpack=0"
SRC_URI[x86_64_v2_powerline.sha256sum] = "4f8254bfdd15f60fd90281d328a3a36f7068fe9de1872480340f3e506f23ca93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerline-docs-2.8.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_powerline-docs;unpack=0"
SRC_URI[x86_64_v2_powerline-docs.sha256sum] = "7fa25c6fa5cb4f666322cf46eac772be737636146c38ff511220ba8ed0c2e142"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerline-fonts-2.8.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_powerline-fonts;unpack=0"
SRC_URI[x86_64_v2_powerline-fonts.sha256sum] = "754395db534cb02939729d2610aa957fea6557dcc6983dc84026252b3b9a3f9a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmux-powerline-2.8.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_tmux-powerline;unpack=0"
SRC_URI[x86_64_v2_tmux-powerline.sha256sum] = "e1a12efb56bb2ead7c7bb56773ecf75e81a867354111ca8f660170442d0b0592"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vim-powerline-2.8.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_vim-powerline;unpack=0"
SRC_URI[x86_64_v2_vim-powerline.sha256sum] = "a2f55f70fef1f33a6f03be8aab4fd4763e2a02757ec49de1eb106eed79b5bbda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/powerline-2.8.4-1.el10_0.aarch64.rpm;name=aarch64_powerline;unpack=0"
SRC_URI[aarch64_powerline.sha256sum] = "3c0048b653b086cd1f8a9a970c6a12f18be4be91540cc5f9421d5039fc52fbfa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/powerline-docs-2.8.4-1.el10_0.noarch.rpm;name=aarch64_powerline-docs;unpack=0"
SRC_URI[aarch64_powerline-docs.sha256sum] = "55e1b9980786ea69126b1a7d6baf73dd1518e4ae4b3f565abfd8c393ed238c24"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/powerline-fonts-2.8.4-1.el10_0.noarch.rpm;name=aarch64_powerline-fonts;unpack=0"
SRC_URI[aarch64_powerline-fonts.sha256sum] = "9be937eb8ec607109f2310030eea5cd90cb9e99a337a6a964a51a8697b32acfb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tmux-powerline-2.8.4-1.el10_0.noarch.rpm;name=aarch64_tmux-powerline;unpack=0"
SRC_URI[aarch64_tmux-powerline.sha256sum] = "002431e553d405a0f75ce8147b9533ef11104f2b68b757f717714a86f53a860b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vim-powerline-2.8.4-1.el10_0.noarch.rpm;name=aarch64_vim-powerline;unpack=0"
SRC_URI[aarch64_vim-powerline.sha256sum] = "baa66e8d1ab3a355c44727e4053ba850df083bb18560d4433f0a0583ef50de4a"

RDEPENDS:powerline = " \
 bash \
 glibc \
 powerline-fonts \
 python3 \
 systemd \
 "
RDEPENDS:powerline-docs = " \
 "
RDEPENDS:powerline-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:tmux-powerline = " \
 powerline \
 tmux \
 "
RDEPENDS:vim-powerline = " \
 powerline \
 vim-enhanced \
 "
