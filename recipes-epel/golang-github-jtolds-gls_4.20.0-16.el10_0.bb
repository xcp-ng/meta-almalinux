# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jtolds-gls"
PV = "4.20.0"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-jtolds-gls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jtolds-gls-4.20.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5176774755b275dd1607cb71d740c3f053ed73e440619a6824f7799d4c44654"

URI_x86_64_v2_golang-github-jtolds-gls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jtolds-gls-devel-4.20.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jtolds-gls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jtolds-gls-devel}"
SRC_URI[x86_64_v2_golang-github-jtolds-gls-devel.sha256sum] = "27ad787e99c70faff627edbf0d75a6b6b83c3b276283d39c8cc7ecd17074b031"

URI_aarch64_golang-github-jtolds-gls-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jtolds-gls-devel-4.20.0-16.el10_0.noarch.rpm;name=aarch64_golang-github-jtolds-gls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jtolds-gls-devel}"
SRC_URI[aarch64_golang-github-jtolds-gls-devel.sha256sum] = "2bc7422d71f894b1b7bfaaabbc5e106cf2387fa5677ecea64520ba2f975ecfb6"

RDEPENDS:golang-github-jtolds-gls-devel = " \
 go-filesystem \
 "
