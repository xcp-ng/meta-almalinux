# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khealthcertificate"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 khealthcertificate \
 khealthcertificate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khealthcertificate-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee3ca15721fdef5f0275f00aed158d4653f682b10ddc2c2c33cace74317e84ca"

URI_x86_64_v2_khealthcertificate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khealthcertificate-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khealthcertificate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khealthcertificate}"
SRC_URI[x86_64_v2_khealthcertificate.sha256sum] = "1d455291b8da45d7a87ab122e1775684d4f68c1377f35de4ba62c90c8be67d20"

URI_x86_64_v2_khealthcertificate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khealthcertificate-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khealthcertificate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khealthcertificate-devel}"
SRC_URI[x86_64_v2_khealthcertificate-devel.sha256sum] = "3d877c0dff16c6edfd19ca788484f43519c3e625877161019be10ba8063e8d13"

URI_aarch64_khealthcertificate = "${EPEL_MIRROR}/aarch64/Packages/k/khealthcertificate-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_khealthcertificate;unpack=0"
SRC_URI:append = " ${URI_aarch64_khealthcertificate}"
SRC_URI[aarch64_khealthcertificate.sha256sum] = "1c46db9147873ef5ebb763bb80fdd6873a7812e10d528b15c2fefae40f69467d"

URI_aarch64_khealthcertificate-devel = "${EPEL_MIRROR}/aarch64/Packages/k/khealthcertificate-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_khealthcertificate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_khealthcertificate-devel}"
SRC_URI[aarch64_khealthcertificate-devel.sha256sum] = "ac0fe973fc87993a9abb49a10c6891a28c4e7e4d845579fb34edcc28c4ff8564"

RDEPENDS:khealthcertificate = " \
 glibc \
 kf6-karchive \
 kf6-kcodecs \
 kf6-ki18n \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:khealthcertificate-devel = " \
 cmake-filesystem \
 khealthcertificate \
 "
