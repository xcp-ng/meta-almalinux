# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Runtime-Conflicts"
PV = "0.003"
PR = "25.el10_0"
PACKAGES = " \
 perl-Module-Runtime-Conflicts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Runtime-Conflicts-0.003-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eac8ba09f8d1aca2669796b81f43edb934d363426389810ff41b5918c73ab0c2"

URI_x86_64_v2_perl-Module-Runtime-Conflicts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Runtime-Conflicts-0.003-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Runtime-Conflicts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Runtime-Conflicts}"
SRC_URI[x86_64_v2_perl-Module-Runtime-Conflicts.sha256sum] = "96cda1e7f69bc0eb84c8038c5af570ad9a3b391227b05d1ac03468fe19dadc17"

URI_aarch64_perl-Module-Runtime-Conflicts = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Runtime-Conflicts-0.003-25.el10_0.noarch.rpm;name=aarch64_perl-Module-Runtime-Conflicts;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Runtime-Conflicts}"
SRC_URI[aarch64_perl-Module-Runtime-Conflicts.sha256sum] = "557f42af599dc4040d44c9e00e1a003a9117eeb7941cbf57eddfdb4a14428ca4"

RDEPENDS:perl-Module-Runtime-Conflicts = " \
 perl-Dist-CheckConflicts \
 perl-Module-Runtime \
 perl-libs \
 "
