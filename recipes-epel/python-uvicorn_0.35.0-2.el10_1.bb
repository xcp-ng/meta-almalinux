# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-uvicorn"
PV = "0.35.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-uvicorn \
 python3-uvicorn+standard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-uvicorn-0.35.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6236bdea311a232ba08c8e270c8bd273582a982a271082d616229a53b9209652"

URI_x86_64_v2_python3-uvicorn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uvicorn-0.35.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-uvicorn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uvicorn}"
SRC_URI[x86_64_v2_python3-uvicorn.sha256sum] = "2f055733d41df1279cd912f0db8fb72f8b9bd6b963d91773d5fe79e25f9f2868"

URI_x86_64_v2_python3-uvicorn+standard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uvicorn+standard-0.35.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-uvicorn+standard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uvicorn+standard}"
SRC_URI[x86_64_v2_python3-uvicorn+standard.sha256sum] = "2497963d29e311bf1da5c4a8f31b6ec737d60d5551fc150100b4116548cfb2e3"

URI_aarch64_python3-uvicorn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uvicorn-0.35.0-2.el10_1.noarch.rpm;name=aarch64_python3-uvicorn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uvicorn}"
SRC_URI[aarch64_python3-uvicorn.sha256sum] = "b63b13932af6844bd9b1648c5668fafeccee9a7bc3d1ae6287c2b3f9a12cb53b"

URI_aarch64_python3-uvicorn+standard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uvicorn+standard-0.35.0-2.el10_1.noarch.rpm;name=aarch64_python3-uvicorn+standard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uvicorn+standard}"
SRC_URI[aarch64_python3-uvicorn+standard.sha256sum] = "d34907475bc116cbccf57b3cbe12e21988a7abed25d1585f787087f849db25d4"

RDEPENDS:python3-uvicorn = " \
 python3 \
 python3-click \
 python3-h11 \
 "
RDEPENDS:python3-uvicorn+standard = " \
 python3 \
 python3-dotenv \
 python3-httptools \
 python3-pyyaml \
 python3-uvicorn \
 python3-uvloop \
 python3-watchfiles \
 python3-websockets \
 "
