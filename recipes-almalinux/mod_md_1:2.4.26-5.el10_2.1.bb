# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_md"
PE = "1"
PV = "2.4.26"
PR = "5.el10_2.1"
PACKAGES = " \
 mod_md \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_md-2.4.26-5.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b10d0d0ee6e217cb6d272e81bf640f6cffd41319a313646e2184c51ac1dedbfa"

URI_x86_64_v2_mod_md = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_md-2.4.26-5.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_mod_md;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_md}"
SRC_URI[x86_64_v2_mod_md.sha256sum] = "523d61c77972b7497df3868dbc3686aa5e51a180e6f20dc3dc63743fd3ed44dc"

URI_aarch64_mod_md = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_md-2.4.26-5.el10_2.1.aarch64.rpm;name=aarch64_mod_md;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_md}"
SRC_URI[aarch64_mod_md.sha256sum] = "d3da73530b616cdf1ffe4f9e887cc93f9da15e1c81b8c0cece791842c8047220"

RDEPENDS:mod_md = " \
 apr \
 apr-util \
 glibc \
 httpd-core \
 jansson \
 mod_ssl \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
