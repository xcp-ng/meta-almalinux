# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samba"
PV = "4.22.4"
PR = "121.el10_1"
PACKAGES:x86_64_v2 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
 samba-winexe \
"
PACKAGES:aarch64 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/samba-4.22.4-121.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fb94588941aae649862af8cfd6dba2f3d1cc3d9c937358bb31380aef471bef5"

URI_x86_64_v2_ldb-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ldb-tools-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_ldb-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldb-tools}"
SRC_URI[x86_64_v2_ldb-tools.sha256sum] = "4514ad6393bd5750c1079e921a1ff9959338c66b18d677c063bbba13c698cd1d"

URI_x86_64_v2_libldb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libldb-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_libldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libldb}"
SRC_URI[x86_64_v2_libldb.sha256sum] = "56b53b2c2c85f10e1f48d7529d6eb9f91118509764f349917046e0bb6b65a8c7"

URI_x86_64_v2_libldb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libldb-devel-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_libldb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libldb-devel}"
SRC_URI[x86_64_v2_libldb-devel.sha256sum] = "6af5e8b3ed968154bae3c609514aac88d8c5d73364a949338db81a89f2c4b9cb"

URI_x86_64_v2_libnetapi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnetapi-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_libnetapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetapi}"
SRC_URI[x86_64_v2_libnetapi.sha256sum] = "91947e2f4170d37e7c86918ae5eaac1a6c3ddcf2ae763440ebf20bd43784658f"

URI_x86_64_v2_libnetapi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnetapi-devel-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_libnetapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetapi-devel}"
SRC_URI[x86_64_v2_libnetapi-devel.sha256sum] = "22e1501660e0bbe80084b07a22e5fed2d3a3fe5be149d2842339d64bbc8198ed"

URI_x86_64_v2_libsmbclient = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmbclient-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_libsmbclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmbclient}"
SRC_URI[x86_64_v2_libsmbclient.sha256sum] = "e76020eefd6639a954bef1cb0cf6eb5c18729fd336f62ee2e7c4a779c7f4886a"

URI_x86_64_v2_libsmbclient-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmbclient-devel-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_libsmbclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmbclient-devel}"
SRC_URI[x86_64_v2_libsmbclient-devel.sha256sum] = "39700ebb275f5d2b5202275ee1aea005e0047dfb5b4eea32efb53572e9bc145f"

URI_x86_64_v2_libwbclient = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libwbclient-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_libwbclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwbclient}"
SRC_URI[x86_64_v2_libwbclient.sha256sum] = "11535618c4b6b44cdae1e9b4e9d41cc589fff81bcfacf9a7af1845cfd343ed13"

URI_x86_64_v2_libwbclient-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwbclient-devel-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_libwbclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwbclient-devel}"
SRC_URI[x86_64_v2_libwbclient-devel.sha256sum] = "2767023b245ab7cb89e1b84eed30071836bbc7bcf9bc58c63f9de84acd437a11"

URI_x86_64_v2_python3-ldb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-ldb-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-ldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ldb}"
SRC_URI[x86_64_v2_python3-ldb.sha256sum] = "fa158b34c74dde1f573d8b68560071fff6fc701de63a5a19b7e170caea71a8f9"

URI_x86_64_v2_python3-samba = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba}"
SRC_URI[x86_64_v2_python3-samba.sha256sum] = "b87d79f0c829ba1abebf31e1044d68f633bcf3191092114104543c25b57a6780"

URI_x86_64_v2_python3-samba-dc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-dc-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-samba-dc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba-dc}"
SRC_URI[x86_64_v2_python3-samba-dc.sha256sum] = "65547d67de12296f0e1d61acde1b78a78bed3076469c62405cb936745176d30c"

URI_x86_64_v2_python3-samba-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-samba-test-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-samba-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba-test}"
SRC_URI[x86_64_v2_python3-samba-test.sha256sum] = "f9e1838a517ac9568f8e03b1d783c23c09244657471eeb442243264348c09ce4"

URI_x86_64_v2_samba = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba}"
SRC_URI[x86_64_v2_samba.sha256sum] = "5e56e071a59e89e8130169b990e231edb6a8538b63d949eecd4508e540065d03"

URI_x86_64_v2_samba-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-client-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-client}"
SRC_URI[x86_64_v2_samba-client.sha256sum] = "22306dd99b2689c77dab0d9cf165ce556d45141147a8d31bc03ee80f8993e847"

URI_x86_64_v2_samba-client-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-client-libs-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-client-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-client-libs}"
SRC_URI[x86_64_v2_samba-client-libs.sha256sum] = "0d23c455b0d03bfd1e6835439d71e1494a062e6aef2f73b3e88e6518743d205a"

URI_x86_64_v2_samba-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-4.22.4-121.el10_1.noarch.rpm;name=x86_64_v2_samba-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common}"
SRC_URI[x86_64_v2_samba-common.sha256sum] = "118ca2ce2e084daeaa497cc52d41cb8a071c5ab96694c21d573abf2ae185acf5"

URI_x86_64_v2_samba-common-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-libs-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-common-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common-libs}"
SRC_URI[x86_64_v2_samba-common-libs.sha256sum] = "75cbf38b362e4f5cf1b7f967fae0241981339aa49af5912466ca92779b4f9290"

URI_x86_64_v2_samba-common-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-tools-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-common-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common-tools}"
SRC_URI[x86_64_v2_samba-common-tools.sha256sum] = "fc7a15d01984029320e561f3b8953d012e0567d393db0ee78888d1148a47007a"

URI_x86_64_v2_samba-dc-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dc-libs-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-dc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-dc-libs}"
SRC_URI[x86_64_v2_samba-dc-libs.sha256sum] = "85ec2d59f8dba9f2b37a62ff75a4b477f32cde16221695b6238a2a8c2b5cd12e"

URI_x86_64_v2_samba-dcerpc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dcerpc-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-dcerpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-dcerpc}"
SRC_URI[x86_64_v2_samba-dcerpc.sha256sum] = "589563e5ea55e75c0134c72327dd95e2c545d90856ced5d28191f42d89807745"

URI_x86_64_v2_samba-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-devel-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-devel}"
SRC_URI[x86_64_v2_samba-devel.sha256sum] = "40e921da0d59873bef401277636e2f9c3cfefa8a9b4303f36c0389b10c772a4d"

URI_x86_64_v2_samba-gpupdate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-gpupdate-4.22.4-121.el10_1.noarch.rpm;name=x86_64_v2_samba-gpupdate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-gpupdate}"
SRC_URI[x86_64_v2_samba-gpupdate.sha256sum] = "2bb8ff4a8f123459531eaf19f809e49f5335a4acc9a2d4c5dac66a6931d9445e"

URI_x86_64_v2_samba-krb5-printing = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-krb5-printing-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-krb5-printing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-krb5-printing}"
SRC_URI[x86_64_v2_samba-krb5-printing.sha256sum] = "f10c94ff4c7d3445aac16e42c2a0a1bac13a6d52c2233e65ad615a6877329ec0"

URI_x86_64_v2_samba-ldb-ldap-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-ldb-ldap-modules-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-ldb-ldap-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-ldb-ldap-modules}"
SRC_URI[x86_64_v2_samba-ldb-ldap-modules.sha256sum] = "7d129d5b2ea944a1d65d53e990add0e6b776a55d93a46d1925420912bd37f236"

URI_x86_64_v2_samba-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-libs-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-libs}"
SRC_URI[x86_64_v2_samba-libs.sha256sum] = "e832c64102ff7ece13ae53ad541aa2f74c9300171058460683f94c0b2e9f5b04"

URI_x86_64_v2_samba-pidl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-pidl-4.22.4-121.el10_1.noarch.rpm;name=x86_64_v2_samba-pidl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-pidl}"
SRC_URI[x86_64_v2_samba-pidl.sha256sum] = "31209bfab6173ff331b7295331b2d8b93812e7e0ec4f96a1ef35af6dcbab07b7"

URI_x86_64_v2_samba-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-test}"
SRC_URI[x86_64_v2_samba-test.sha256sum] = "851eb7fc281cc765ed77bf624767f03ac42899ebbf0b4bf12457d52a4a438150"

URI_x86_64_v2_samba-test-libs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-libs-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-test-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-test-libs}"
SRC_URI[x86_64_v2_samba-test-libs.sha256sum] = "2ccfab34c8565595ba43fed1658bf293b71717c21280d925ad3cf41b80cc5ea0"

URI_x86_64_v2_samba-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-tools-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-tools}"
SRC_URI[x86_64_v2_samba-tools.sha256sum] = "4e1acb5e4c4c693f00e98f7bcb041494ef396e9c981ad82f39106d4f2f66eaca"

URI_x86_64_v2_samba-usershares = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-usershares-4.22.4-121.el10_1.noarch.rpm;name=x86_64_v2_samba-usershares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-usershares}"
SRC_URI[x86_64_v2_samba-usershares.sha256sum] = "2ff1ea714c71e8a8b47d343d61ed43abcb7b8368a694d95c84b907c042e2605f"

URI_x86_64_v2_samba-vfs-iouring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-vfs-iouring-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-vfs-iouring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-vfs-iouring}"
SRC_URI[x86_64_v2_samba-vfs-iouring.sha256sum] = "da39f63c65593d8094ff0e66ffad15a50ed89aeb2664ce6e2bcc716f5332dff0"

URI_x86_64_v2_samba-winbind = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-winbind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind}"
SRC_URI[x86_64_v2_samba-winbind.sha256sum] = "e4b0111131831b050754118a9a014cd8fd1b6b6a00d3d7cae2953ca159d8600c"

URI_x86_64_v2_samba-winbind-clients = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-clients-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-clients}"
SRC_URI[x86_64_v2_samba-winbind-clients.sha256sum] = "97ce9fd3fbe065dd5c44e1b9abc2b2c46ec2acca973e014e8270397ef22560b4"

URI_x86_64_v2_samba-winbind-krb5-locator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-krb5-locator-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-krb5-locator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-krb5-locator}"
SRC_URI[x86_64_v2_samba-winbind-krb5-locator.sha256sum] = "832c6dc1244ac7cee3a7efa819e6408ecccbc2d7875d32a56b8a939b418a315c"

URI_x86_64_v2_samba-winbind-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-modules-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-modules}"
SRC_URI[x86_64_v2_samba-winbind-modules.sha256sum] = "8ccb35c5c10af90c3b1c3ae06d978beb56910cce9302c1d3bb18f5694e69b5b6"

URI_x86_64_v2_samba-winexe = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winexe-4.22.4-121.el10_1.x86_64_v2.rpm;name=x86_64_v2_samba-winexe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winexe}"
SRC_URI[x86_64_v2_samba-winexe.sha256sum] = "8c90c81299b6a28ead7f121692ac1172caa2c98bf8f57b266a12a499b854ac69"

URI_aarch64_ldb-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ldb-tools-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_ldb-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldb-tools}"
SRC_URI[aarch64_ldb-tools.sha256sum] = "2b31349d91dfbf92ede9d00f6b4de34d549358ebce9325b0bc1e92cdfb9255e3"

URI_aarch64_libldb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libldb-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_libldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libldb}"
SRC_URI[aarch64_libldb.sha256sum] = "487e8635ce392bba15fc287c5c6fc3bc9876aebafe84124d21d84f3d0a0a1c7c"

URI_aarch64_libldb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libldb-devel-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_libldb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libldb-devel}"
SRC_URI[aarch64_libldb-devel.sha256sum] = "0ebd0e7f8987f4e8da3e96707e236403f419016f96b105367cc8d399edcaf8da"

URI_aarch64_libnetapi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnetapi-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_libnetapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetapi}"
SRC_URI[aarch64_libnetapi.sha256sum] = "f77e16d7e7274950a9b5dfa5665bb534f39a8d641580db30577758e6669835ad"

URI_aarch64_libnetapi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnetapi-devel-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_libnetapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetapi-devel}"
SRC_URI[aarch64_libnetapi-devel.sha256sum] = "b7e7e918604201e58fa1a0dfe7b3141b1038a9b1f330dcd909c4e40753ffeef8"

URI_aarch64_libsmbclient = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmbclient-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_libsmbclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmbclient}"
SRC_URI[aarch64_libsmbclient.sha256sum] = "d9e94551d0301e755e3fb45a6668dd36d02dcce2ab3de66baa83602649513573"

URI_aarch64_libsmbclient-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmbclient-devel-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_libsmbclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmbclient-devel}"
SRC_URI[aarch64_libsmbclient-devel.sha256sum] = "c6ac215b836fc6d8920e672f402a277d968ac6df0f0054ae599ddf747ff371e2"

URI_aarch64_libwbclient = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libwbclient-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_libwbclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwbclient}"
SRC_URI[aarch64_libwbclient.sha256sum] = "dfa089327c849a25efbd91efe8a08383986c53dbd0ba95be71507f13aa606a27"

URI_aarch64_libwbclient-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwbclient-devel-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_libwbclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwbclient-devel}"
SRC_URI[aarch64_libwbclient-devel.sha256sum] = "fe7beaf9fbc67789a4915fadcf111362cb13d7403323c3aea9a1616ce1147741"

URI_aarch64_python3-ldb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-ldb-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_python3-ldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ldb}"
SRC_URI[aarch64_python3-ldb.sha256sum] = "7076dadb46d3671de69a970ad3a6cc24ceb8cb7f48a02800c4f119fe903be0be"

URI_aarch64_python3-samba = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_python3-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba}"
SRC_URI[aarch64_python3-samba.sha256sum] = "86459fbda0494831887736ab698d1d6405236b7d49a6b1aeb31215d462d4b3a1"

URI_aarch64_python3-samba-dc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-dc-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_python3-samba-dc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba-dc}"
SRC_URI[aarch64_python3-samba-dc.sha256sum] = "4e948e2a1d7931df942ebeca8b53cee4a37e4a7b86db6bcdc43b25b8962bcb68"

URI_aarch64_python3-samba-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-samba-test-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_python3-samba-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba-test}"
SRC_URI[aarch64_python3-samba-test.sha256sum] = "5dd6df97a7093b1ccd0f83c9990499bd670727aeb25f58df48762c5261a67d53"

URI_aarch64_samba = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba}"
SRC_URI[aarch64_samba.sha256sum] = "bb360c3033da049c321ddacece45a27a490b022f83a082c12ed1e7377dbd7e9d"

URI_aarch64_samba-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-client-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-client}"
SRC_URI[aarch64_samba-client.sha256sum] = "835e6f6963a1357f28067805ca751dcb1c2659b9efd124c73f29e22fabb4cbc5"

URI_aarch64_samba-client-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-client-libs-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-client-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-client-libs}"
SRC_URI[aarch64_samba-client-libs.sha256sum] = "2d57383fee8ecfbf9d3b197d7f466db1d83416b3115eda413194934b8c0c8d95"

URI_aarch64_samba-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-4.22.4-121.el10_1.noarch.rpm;name=aarch64_samba-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common}"
SRC_URI[aarch64_samba-common.sha256sum] = "118ca2ce2e084daeaa497cc52d41cb8a071c5ab96694c21d573abf2ae185acf5"

URI_aarch64_samba-common-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-libs-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-common-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common-libs}"
SRC_URI[aarch64_samba-common-libs.sha256sum] = "f4a7c35b4c30594c1d83a80d400b9e7e0bd2ea7176b6dd5a87799d1ae329cd5b"

URI_aarch64_samba-common-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-tools-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-common-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common-tools}"
SRC_URI[aarch64_samba-common-tools.sha256sum] = "af2894b27f0b51298566c94039cbe19c389beb1605cfd20e21abcd4730574365"

URI_aarch64_samba-dc-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dc-libs-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-dc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-dc-libs}"
SRC_URI[aarch64_samba-dc-libs.sha256sum] = "6fca8a364bf6ec0b9873767a13370a8fdf137e8a519000d97fa6143ec8c630c7"

URI_aarch64_samba-dcerpc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dcerpc-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-dcerpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-dcerpc}"
SRC_URI[aarch64_samba-dcerpc.sha256sum] = "cf35705296a2a74fed9180fc63dd496564f135ba3d51dcb8add65e0dbd6c3bc7"

URI_aarch64_samba-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-devel-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-devel}"
SRC_URI[aarch64_samba-devel.sha256sum] = "3241a12c295cbd5802011305530dea62c17684cde6f166cf749c38fd0cc7513f"

URI_aarch64_samba-gpupdate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-gpupdate-4.22.4-121.el10_1.noarch.rpm;name=aarch64_samba-gpupdate;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-gpupdate}"
SRC_URI[aarch64_samba-gpupdate.sha256sum] = "2bb8ff4a8f123459531eaf19f809e49f5335a4acc9a2d4c5dac66a6931d9445e"

URI_aarch64_samba-krb5-printing = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-krb5-printing-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-krb5-printing;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-krb5-printing}"
SRC_URI[aarch64_samba-krb5-printing.sha256sum] = "eca3d933f8ddb4a2cd72e5c5891e8c3e4289abc01c5b80f1434f48afd05a7ec4"

URI_aarch64_samba-ldb-ldap-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-ldb-ldap-modules-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-ldb-ldap-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-ldb-ldap-modules}"
SRC_URI[aarch64_samba-ldb-ldap-modules.sha256sum] = "77ebbeea477bb05b3c42a317987b014540084b8949ca2ddda8c76e664bf3e877"

URI_aarch64_samba-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-libs-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-libs}"
SRC_URI[aarch64_samba-libs.sha256sum] = "98c0450dfb9da7a6197f31ea634d38924976109c4d4b5d953750143e3d35bbf1"

URI_aarch64_samba-pidl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-pidl-4.22.4-121.el10_1.noarch.rpm;name=aarch64_samba-pidl;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-pidl}"
SRC_URI[aarch64_samba-pidl.sha256sum] = "31209bfab6173ff331b7295331b2d8b93812e7e0ec4f96a1ef35af6dcbab07b7"

URI_aarch64_samba-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-test}"
SRC_URI[aarch64_samba-test.sha256sum] = "39e1a26a96514991af655bdf6c04a2f34ec1ca322447f2e7adf565bad937b624"

URI_aarch64_samba-test-libs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-libs-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-test-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-test-libs}"
SRC_URI[aarch64_samba-test-libs.sha256sum] = "72449a6f29a1dd55d95880f3b7ac37db7fbd3b757c6eddc55efa408d5a0f6264"

URI_aarch64_samba-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-tools-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-tools}"
SRC_URI[aarch64_samba-tools.sha256sum] = "10ecc9529930495165b5cadf56320ed4b99d9768370fcf19e478397daa24aef9"

URI_aarch64_samba-usershares = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-usershares-4.22.4-121.el10_1.noarch.rpm;name=aarch64_samba-usershares;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-usershares}"
SRC_URI[aarch64_samba-usershares.sha256sum] = "2ff1ea714c71e8a8b47d343d61ed43abcb7b8368a694d95c84b907c042e2605f"

URI_aarch64_samba-vfs-iouring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-vfs-iouring-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-vfs-iouring;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-vfs-iouring}"
SRC_URI[aarch64_samba-vfs-iouring.sha256sum] = "e3234b1859d595110a8813ba70d5489341a4029642c81206153ac410a4710439"

URI_aarch64_samba-winbind = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-winbind;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind}"
SRC_URI[aarch64_samba-winbind.sha256sum] = "5e33b9eb474029520adabb2bca1ff3020a638c8545c8447fd6f7cb7042433845"

URI_aarch64_samba-winbind-clients = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-clients-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-winbind-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-clients}"
SRC_URI[aarch64_samba-winbind-clients.sha256sum] = "37ecd4f7a6351aea028e7956c26afa3f7ccfa6fca33a71c6cc1c0d5d6b4aa59c"

URI_aarch64_samba-winbind-krb5-locator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-krb5-locator-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-winbind-krb5-locator;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-krb5-locator}"
SRC_URI[aarch64_samba-winbind-krb5-locator.sha256sum] = "fb27fb22417b0ce2556c2b7cdf8b70080001946c8c85fb5acb03cf3ad856431e"

URI_aarch64_samba-winbind-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-modules-4.22.4-121.el10_1.aarch64.rpm;name=aarch64_samba-winbind-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-modules}"
SRC_URI[aarch64_samba-winbind-modules.sha256sum] = "5d404c29ff8eca11e104b372aae0fbba718ba05236217161eab19549dcecc843"

RDEPENDS:ldb-tools = " \
 glibc \
 libldb \
 libtalloc \
 popt \
 "
RDEPENDS:libldb = " \
 glibc \
 libtalloc \
 libtdb \
 libtevent \
 lmdb-libs \
 "
RDEPENDS:libldb-devel = " \
 libldb \
 libtalloc-devel \
 libtdb-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libnetapi = " \
 glibc \
 gnutls \
 libgcc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:libnetapi-devel = " \
 libnetapi \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmbclient = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:libsmbclient-devel = " \
 libsmbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:libwbclient = " \
 bash \
 glibc \
 samba-client-libs \
 "
RDEPENDS:libwbclient-devel = " \
 libwbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-ldb = " \
 glibc \
 libldb \
 libtalloc \
 python3 \
 python3-libs \
 python3-tdb \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:python3-samba = " \
 glibc \
 gnutls \
 krb5-libs \
 libgcc \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 python3 \
 python3-cryptography \
 python3-dns \
 python3-ldb \
 python3-libs \
 python3-requests \
 python3-talloc \
 python3-tdb \
 python3-tevent \
 samba-client-libs \
 samba-common-libs \
 samba-dc-libs \
 samba-libs \
 "
RDEPENDS:python3-samba-dc = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 python3 \
 python3-libs \
 python3-markdown \
 python3-samba \
 python3-talloc \
 samba-client-libs \
 samba-dc-libs \
 "
RDEPENDS:python3-samba-test = " \
 python3 \
 python3-samba \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba = " \
 bash \
 cups-libs \
 dbus-libs \
 glibc \
 gnutls \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 pam \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dcerpc \
 samba-libs \
 "
RDEPENDS:samba-client = " \
 alternatives \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libarchive \
 libcom_err \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 ncurses-libs \
 popt \
 readline \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 "
RDEPENDS:samba-client-libs = " \
 avahi-libs \
 glibc \
 glibc-gconv-extra \
 gnutls \
 jansson \
 krb5-libs \
 libacl \
 libcap \
 libcom_err \
 libgcc \
 libicu \
 libldb \
 libtalloc \
 libtasn1 \
 libtdb \
 libtevent \
 libtirpc \
 libwbclient \
 libxcrypt \
 openldap \
 pam-libs \
 popt \
 samba-common \
 samba-common-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:samba-common = " \
 bash \
 systemd \
 "
RDEPENDS:samba-common-libs = " \
 glibc \
 libldb \
 libtalloc \
 libtdb \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common \
 "
RDEPENDS:samba-common-tools = " \
 glibc \
 gnutls \
 jansson \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 python3 \
 readline \
 samba-client-libs \
 samba-common-libs \
 samba-ldb-ldap-modules \
 samba-libs \
 "
RDEPENDS:samba-dc-libs = " \
 glibc \
 gnutls \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-dcerpc = " \
 cups-libs \
 glibc \
 gnutls \
 jansson \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-devel = " \
 libldb-devel \
 libnetapi \
 libtalloc-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 samba-client-libs \
 samba-dc-libs \
 samba-devel \
 samba-libs \
 "
RDEPENDS:samba-gpupdate = " \
 cepces-certmonger \
 certmonger \
 python3 \
 python3-samba \
 python3-samba-dc \
 samba-ldb-ldap-modules \
 "
RDEPENDS:samba-krb5-printing = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 samba-client \
 samba-client-libs \
 "
RDEPENDS:samba-ldb-ldap-modules = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 openldap \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:samba-libs = " \
 glibc \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common-libs \
 "
RDEPENDS:samba-pidl = " \
 perl-Exporter \
 perl-File-Basename \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Parse-Yapp \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-parent \
 perl-vars \
 samba-pidl \
 "
RDEPENDS:samba-test = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libsmbclient \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 perl-Archive-Tar \
 popt \
 python3-samba \
 readline \
 samba \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-dc-libs \
 samba-libs \
 samba-test-libs \
 samba-winbind \
 "
RDEPENDS:samba-test-libs = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-common-libs \
 samba-libs \
 "
RDEPENDS:samba-tools = " \
 python3 \
 python3-samba \
 python3-samba-dc \
 "
RDEPENDS:samba-usershares = " \
 bash \
 samba \
 samba-common-tools \
 "
RDEPENDS:samba-vfs-iouring = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 liburing \
 libwbclient \
 samba \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba-winbind = " \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-common-tools \
 samba-dcerpc \
 samba-libs \
 samba-winbind-modules \
 "
RDEPENDS:samba-winbind-clients = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-libs \
 samba-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-krb5-locator = " \
 alternatives \
 bash \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-modules = " \
 glibc \
 libtalloc \
 libwbclient \
 pam \
 pam-libs \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba-winexe = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common-libs \
 "
