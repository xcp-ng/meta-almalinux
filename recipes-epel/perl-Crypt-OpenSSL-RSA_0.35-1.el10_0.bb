# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-RSA"
PV = "0.35"
PR = "1.el10_0"
PACKAGES = " \
 perl-Crypt-OpenSSL-RSA \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-RSA-0.35-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d882e79b7c2a7c7758593cefd748a1a943eb4c0aae97a4da01670e9b7aa765c"

URI_x86_64_v2_perl-Crypt-OpenSSL-RSA = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-RSA-0.35-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-RSA;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-RSA}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-RSA.sha256sum] = "2c8ef403f068a1659f5ebb6ab5bcd913c1377be0afe78eec1ca88e1b360625db"

URI_aarch64_perl-Crypt-OpenSSL-RSA = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-RSA-0.35-1.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-RSA;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-RSA}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-RSA.sha256sum] = "6e21bbc6add8de5f63144109e226f79754b85a13607401453400e1f224da3c65"

RDEPENDS:perl-Crypt-OpenSSL-RSA = " \
 glibc \
 openssl-libs \
 perl-Carp \
 perl-Crypt-OpenSSL-Bignum \
 perl-Crypt-OpenSSL-Random \
 perl-libs \
 "
