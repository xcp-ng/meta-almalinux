# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kactivitymanagerd"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 kactivitymanagerd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kactivitymanagerd-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b66ac9052020988867273415e320bd236d0425b9959889ffc675b2d906c5af47"

URI_x86_64_v2_kactivitymanagerd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kactivitymanagerd-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kactivitymanagerd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kactivitymanagerd}"
SRC_URI[x86_64_v2_kactivitymanagerd.sha256sum] = "05fd1c2244493ff177b3a424d587be39e5e7bb120b9dd032b971048b7c62cad0"

URI_aarch64_kactivitymanagerd = "${EPEL_MIRROR}/aarch64/Packages/k/kactivitymanagerd-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kactivitymanagerd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kactivitymanagerd}"
SRC_URI[aarch64_kactivitymanagerd.sha256sum] = "0a29407b245ef6fd03ee992fe26c3900f6671f9db5782e052ec2e3a1af89e9d1"

RDEPENDS:kactivitymanagerd = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
