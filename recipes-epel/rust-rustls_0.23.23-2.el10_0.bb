# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls"
PV = "0.23.23"
PR = "2.el10_0"
PACKAGES = " \
 rust-rustls+brotli-devel \
 rust-rustls+custom-provider-devel \
 rust-rustls+default-devel \
 rust-rustls+hashbrown-devel \
 rust-rustls+log-devel \
 rust-rustls+logging-devel \
 rust-rustls+read_buf-devel \
 rust-rustls+ring-devel \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls+zlib-devel \
 rust-rustls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-0.23.23-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31c56269ad7b88d8e19ebdc40b894935d3ddf44f2364e6c9c4ea23dbcd698223"

URI_x86_64_v2_rust-rustls+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+brotli-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+brotli-devel}"
SRC_URI[x86_64_v2_rust-rustls+brotli-devel.sha256sum] = "a3828aea1b02bd7d84b9627ca829a62598c5e76ce276e4dbf6cc9850baf8d481"

URI_x86_64_v2_rust-rustls+custom-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+custom-provider-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+custom-provider-devel}"
SRC_URI[x86_64_v2_rust-rustls+custom-provider-devel.sha256sum] = "8a13b90df74a48927a2b0ec882e5f06fd6c2af1e579e127a41cc1aef01ae14b8"

URI_x86_64_v2_rust-rustls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+default-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+default-devel}"
SRC_URI[x86_64_v2_rust-rustls+default-devel.sha256sum] = "cae78d3b07da41953524bcea97864dc167ebc2df42aaa6dedd31df7353a880a9"

URI_x86_64_v2_rust-rustls+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+hashbrown-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-rustls+hashbrown-devel.sha256sum] = "c4ee32a64577732e9efe0eb658dceb0a5d0cf809c7738e15ad836cf33101f8d4"

URI_x86_64_v2_rust-rustls+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+log-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+log-devel}"
SRC_URI[x86_64_v2_rust-rustls+log-devel.sha256sum] = "76e45dae67b7b4520fb7cff9ef05e838bc63d715ed3bf26ad43d7bbb4c7dcb67"

URI_x86_64_v2_rust-rustls+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+logging-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+logging-devel}"
SRC_URI[x86_64_v2_rust-rustls+logging-devel.sha256sum] = "688cf456416692745e152d1b412ed959d3be88fa9f90e47c9a0141e4b920bf00"

URI_x86_64_v2_rust-rustls+read_buf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+read_buf-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+read_buf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+read_buf-devel}"
SRC_URI[x86_64_v2_rust-rustls+read_buf-devel.sha256sum] = "e984636fc4e503a4d00d4a7eb2f537bc9aa403e69177d4a8eec3ef337dc35ce6"

URI_x86_64_v2_rust-rustls+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+ring-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+ring-devel}"
SRC_URI[x86_64_v2_rust-rustls+ring-devel.sha256sum] = "0cbed56e8c202dcf68a7dea692088c9437b9d9bbf1fca9936a8495c32d90d0bd"

URI_x86_64_v2_rust-rustls+rustversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+rustversion-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+rustversion-devel}"
SRC_URI[x86_64_v2_rust-rustls+rustversion-devel.sha256sum] = "663d0ae04b40adb229cb277c60ad7f84546c28b089c1ac60ec6037a621658c92"

URI_x86_64_v2_rust-rustls+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+std-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+std-devel}"
SRC_URI[x86_64_v2_rust-rustls+std-devel.sha256sum] = "41481cd94eadebb4d20081ad4fb19ef4e219b2091126dfdcef988dff0cf4a4d9"

URI_x86_64_v2_rust-rustls+tls12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+tls12-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+tls12-devel}"
SRC_URI[x86_64_v2_rust-rustls+tls12-devel.sha256sum] = "77db75546992074f205f82177321a27de5de53c49a252c4f273c4997be606a80"

URI_x86_64_v2_rust-rustls+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+zlib-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+zlib-devel}"
SRC_URI[x86_64_v2_rust-rustls+zlib-devel.sha256sum] = "2c241156b4e398377e29765a917393f87904661cb155165fcc3ca807aa6462b9"

URI_x86_64_v2_rust-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-devel-0.23.23-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-devel}"
SRC_URI[x86_64_v2_rust-rustls-devel.sha256sum] = "454228cac4670bb1df8dc95e6a35012cc9d9dff04692f0d23f3ca2acc1e3fde2"

URI_aarch64_rust-rustls+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+brotli-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+brotli-devel}"
SRC_URI[aarch64_rust-rustls+brotli-devel.sha256sum] = "d6120aec8221f778b3689f7116911dddb805d8118f0297b2272abec49e9a3607"

URI_aarch64_rust-rustls+custom-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+custom-provider-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+custom-provider-devel}"
SRC_URI[aarch64_rust-rustls+custom-provider-devel.sha256sum] = "8293ed6cafdfe1cdcaca3811d2e684fdf0d866984457c68431f9283650972107"

URI_aarch64_rust-rustls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+default-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+default-devel}"
SRC_URI[aarch64_rust-rustls+default-devel.sha256sum] = "ffb0137173cbaad4c5de59efe29042041bc94ac46bac0332ba832778d92694e0"

URI_aarch64_rust-rustls+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+hashbrown-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+hashbrown-devel}"
SRC_URI[aarch64_rust-rustls+hashbrown-devel.sha256sum] = "f083d78027353f50903cc38b96ebc567983bf5bfd3cd77f9a02e7c0697d1154c"

URI_aarch64_rust-rustls+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+log-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+log-devel}"
SRC_URI[aarch64_rust-rustls+log-devel.sha256sum] = "a539c690139b8b41b119d035af7d89b615f82f8f2bf7d2c2eae113ac5af24737"

URI_aarch64_rust-rustls+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+logging-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+logging-devel}"
SRC_URI[aarch64_rust-rustls+logging-devel.sha256sum] = "bd09813c0be18840f82f23d4e1b7367d916709f48596b4b5f417de6937617bb4"

URI_aarch64_rust-rustls+read_buf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+read_buf-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+read_buf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+read_buf-devel}"
SRC_URI[aarch64_rust-rustls+read_buf-devel.sha256sum] = "2c3d4d39b273ebbc4e1cb76f111d07e9ba04bbeb3579a9ecc3c03ee69b568982"

URI_aarch64_rust-rustls+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+ring-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+ring-devel}"
SRC_URI[aarch64_rust-rustls+ring-devel.sha256sum] = "d84f85b21c2ff86bea49711dae15fd603d5068c565c9a80ba6225a0dd06fe1c4"

URI_aarch64_rust-rustls+rustversion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+rustversion-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+rustversion-devel}"
SRC_URI[aarch64_rust-rustls+rustversion-devel.sha256sum] = "7d5a947f20b706ea624085378e95f304d7463a0c48ee42be599096c6523f39dd"

URI_aarch64_rust-rustls+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+std-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+std-devel}"
SRC_URI[aarch64_rust-rustls+std-devel.sha256sum] = "e457494c5f7d84ce279702a7d757f19139e1032d29e2ccfada53d52521f50542"

URI_aarch64_rust-rustls+tls12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+tls12-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+tls12-devel}"
SRC_URI[aarch64_rust-rustls+tls12-devel.sha256sum] = "d435067baeb22a81d4acaf528e609c0a8b76ed1bab9b100ff89c1685d148e3d0"

URI_aarch64_rust-rustls+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+zlib-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+zlib-devel}"
SRC_URI[aarch64_rust-rustls+zlib-devel.sha256sum] = "16509db6acb7b2aa0aac423a4c5ffee92ffd6afeba44ad554fa77259851546f5"

URI_aarch64_rust-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-devel-0.23.23-2.el10_0.noarch.rpm;name=aarch64_rust-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-devel}"
SRC_URI[aarch64_rust-rustls-devel.sha256sum] = "cc6a9af8eb4a3b492ea16c4930cd7bb3e676ab2c1194633b639d1958c43f3dfe"

RDEPENDS:rust-rustls+brotli-devel = " \
 cargo \
 rust-brotli+std-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+custom-provider-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+default-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+hashbrown-devel = " \
 cargo \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+logging-devel = " \
 cargo \
 rust-rustls+log-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+read_buf-devel = " \
 cargo \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-rustls-devel \
 rust-rustls-webpki+ring-devel \
 "
RDEPENDS:rust-rustls+rustversion-devel = " \
 cargo \
 rust-rustls-devel \
 rust-rustversion+default-devel \
 "
RDEPENDS:rust-rustls+std-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-rustls-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+std-devel \
 "
RDEPENDS:rust-rustls+tls12-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+zlib-devel = " \
 cargo \
 rust-rustls-devel \
 rust-zlib-rs+default-devel \
 "
RDEPENDS:rust-rustls-devel = " \
 cargo \
 rust \
 rust-once_cell+alloc-devel \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 rust-subtle-devel \
 rust-zeroize+default-devel \
 "
