# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-apt"
PV = "3.1.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-apt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-apt-3.1.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9476ded0da0159d104f47fc07e2b3f55970e5e3f734ec26059dea0b87b1696e5"

URI_x86_64_v2_python3-apt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-apt-3.1.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-apt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-apt}"
SRC_URI[x86_64_v2_python3-apt.sha256sum] = "16122f8b6fd90b1cb8cc3be066c864c2969a10c86d47b72e9ba40b1537ca7c79"

URI_aarch64_python3-apt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-apt-3.1.0-2.el10_1.aarch64.rpm;name=aarch64_python3-apt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-apt}"
SRC_URI[aarch64_python3-apt.sha256sum] = "4a965e46c4d24d89dda7491ceb552fe67ce0d68887b94abc2ddf5a179ba2a598"

RDEPENDS:python3-apt = " \
 apt-libs \
 dpkg \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
