# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hstr"
PV = "3.1"
PR = "4.el10_0"
PACKAGES = " \
 hstr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hstr-3.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "486d7382edc3a6cf4a4c0c51809a0ea8f3b63cbd03256f68104cf89213f8e781"

URI_x86_64_v2_hstr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hstr-3.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hstr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hstr}"
SRC_URI[x86_64_v2_hstr.sha256sum] = "adc1036c90e10ae20226250530e056ee49786d2be31849d7df3ce18512a4c593"

URI_aarch64_hstr = "${EPEL_MIRROR}/aarch64/Packages/h/hstr-3.1-4.el10_0.aarch64.rpm;name=aarch64_hstr;unpack=0"
SRC_URI:append = " ${URI_aarch64_hstr}"
SRC_URI[aarch64_hstr.sha256sum] = "25ad91eee36b6a7c10a29f6f270699f502433b1c5ee366d0c7e3130eeb19c296"

RDEPENDS:hstr = " \
 glibc \
 ncurses-libs \
 readline \
 "
