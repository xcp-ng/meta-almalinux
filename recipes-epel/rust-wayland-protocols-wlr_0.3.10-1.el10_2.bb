# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-protocols-wlr"
PV = "0.3.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-wayland-protocols-wlr+client-devel \
 rust-wayland-protocols-wlr+default-devel \
 rust-wayland-protocols-wlr+server-devel \
 rust-wayland-protocols-wlr+wayland-client-devel \
 rust-wayland-protocols-wlr+wayland-server-devel \
 rust-wayland-protocols-wlr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-protocols-wlr-0.3.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbbf4c7c970f29064b998562c9a16f9c80931a2aa21eb60a0f688ced956aad4d"

URI_x86_64_v2_rust-wayland-protocols-wlr+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+client-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+client-devel.sha256sum] = "e090e7104dd43ac781c95be5fd6c095f06de845279e57df14957e4c54b06b977"

URI_x86_64_v2_rust-wayland-protocols-wlr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+default-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+default-devel.sha256sum] = "bd362cae5ddd5c30e7ae6e1f129301dc4b6f55d3f271e3a59a36bc4734dbf335"

URI_x86_64_v2_rust-wayland-protocols-wlr+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+server-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+server-devel.sha256sum] = "ad1a45715d0c0a821a6b9aa26c2f0303796dac9f309d7f0e0b29ec81a966a56e"

URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+wayland-client-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+wayland-client-devel.sha256sum] = "3940f81d1891226540d073cb5a0ed08d89ef2fd90de8f0aa910dd6615ac70a82"

URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr+wayland-server-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr+wayland-server-devel.sha256sum] = "ac7b2b207e9855c850bafc4baff0be903aad6a8fb20ff0e4d5cd605c2637c1ec"

URI_x86_64_v2_rust-wayland-protocols-wlr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-wlr-devel-0.3.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-wlr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-wlr-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-wlr-devel.sha256sum] = "13c2e9bc6089b0e1f548c7ed4704441fd2aa2c3d5dd171058e2e398fb30fbc56"

URI_aarch64_rust-wayland-protocols-wlr+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+client-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+client-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+client-devel.sha256sum] = "e5f090578693c0b76d44ceb45642a32b2d3fe3b1f7be8af65b3c966d56088a25"

URI_aarch64_rust-wayland-protocols-wlr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+default-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+default-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+default-devel.sha256sum] = "b9ff742ec9a07c7a68928f43182150bb9627b82c24bbb5931e5d4ec4eb86878e"

URI_aarch64_rust-wayland-protocols-wlr+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+server-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+server-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+server-devel.sha256sum] = "3f1c7b53b1045ff8a3c44744c274712ee81844b8fdd704d339cda482ac627d1c"

URI_aarch64_rust-wayland-protocols-wlr+wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+wayland-client-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+wayland-client-devel.sha256sum] = "f045ca646d895604b1be1ff444151dc13957dcdfd895630b3238560cf5459a9e"

URI_aarch64_rust-wayland-protocols-wlr+wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr+wayland-server-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr+wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr+wayland-server-devel.sha256sum] = "37853cd65bcc74038efed981af051d0b464d68dc1deb247b47f6f21cff86d9a6"

URI_aarch64_rust-wayland-protocols-wlr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-wlr-devel-0.3.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols-wlr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-wlr-devel}"
SRC_URI[aarch64_rust-wayland-protocols-wlr-devel.sha256sum] = "63cb9fc2ecc5472aca6746197ca7fb3b0fab728b14c1cab4ffb5c3cf47da2d93"

RDEPENDS:rust-wayland-protocols-wlr+client-devel = " \
 cargo \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols-wlr+wayland-client-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+default-devel = " \
 cargo \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+server-devel = " \
 cargo \
 rust-wayland-protocols+server-devel \
 rust-wayland-protocols-wlr+wayland-server-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+wayland-client-devel = " \
 cargo \
 rust-wayland-client+default-devel \
 rust-wayland-protocols-wlr-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr+wayland-server-devel = " \
 cargo \
 rust-wayland-protocols-wlr-devel \
 rust-wayland-server+default-devel \
 "
RDEPENDS:rust-wayland-protocols-wlr-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-scanner+default-devel \
 "
