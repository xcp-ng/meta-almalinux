# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lz4"
PV = "1.9.4"
PR = "8.el10"
PACKAGES = " \
 lz4 \
 lz4-devel \
 lz4-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lz4-1.9.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "857dad0eba0bd29adac43626551f10b4a4033389bd138469e40c9126756c9b22"

URI_x86_64_v2_lz4 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lz4-1.9.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_lz4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lz4}"
SRC_URI[x86_64_v2_lz4.sha256sum] = "a5bddf5e329546ad25cb73c3e1377da32ad2213e23344a105c33e589128df347"

URI_x86_64_v2_lz4-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lz4-devel-1.9.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_lz4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lz4-devel}"
SRC_URI[x86_64_v2_lz4-devel.sha256sum] = "ed76352204f892bae207368e5bfe80ed8326d741f05c0f7adaa0055a0d1a60f0"

URI_x86_64_v2_lz4-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lz4-libs-1.9.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_lz4-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lz4-libs}"
SRC_URI[x86_64_v2_lz4-libs.sha256sum] = "a0657ca2436584eb4457750517184b652ab4db63bf47a308cbc0a6893e48b0fd"

URI_aarch64_lz4 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lz4-1.9.4-8.el10.aarch64.rpm;name=aarch64_lz4;unpack=0"
SRC_URI:append = " ${URI_aarch64_lz4}"
SRC_URI[aarch64_lz4.sha256sum] = "3af1ca5592d7f088a0d8c8a43933c51af3c5e5d4b624fe65cfebd14ebb4cc825"

URI_aarch64_lz4-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lz4-devel-1.9.4-8.el10.aarch64.rpm;name=aarch64_lz4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lz4-devel}"
SRC_URI[aarch64_lz4-devel.sha256sum] = "aab6c52225e8b33d3bf0d72c9989bfe180d8eabd3377060e1c3a2667c7b372e0"

URI_aarch64_lz4-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lz4-libs-1.9.4-8.el10.aarch64.rpm;name=aarch64_lz4-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lz4-libs}"
SRC_URI[aarch64_lz4-libs.sha256sum] = "f5a4df096215c09262d42d83cecc83d1980f803e0172c6495f82a6c90d292f12"

RDEPENDS:lz4 = " \
 glibc \
 "
RDEPENDS:lz4-devel = " \
 lz4-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:lz4-libs = " \
 glibc \
 "
