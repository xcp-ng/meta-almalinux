# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akregator"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 akregator \
 akregator-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akregator-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cafd4bdb6877b93c16833cc3ec34c60ae74a45930b76be1f5c7aa240e2f74db"

URI_x86_64_v2_akregator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akregator-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akregator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akregator}"
SRC_URI[x86_64_v2_akregator.sha256sum] = "1e77a96633754a29b2d88cf6159b7768588533f45e238526590cf266561a172c"

URI_x86_64_v2_akregator-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akregator-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akregator-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akregator-libs}"
SRC_URI[x86_64_v2_akregator-libs.sha256sum] = "a6cc5f1c9b5be76333fe321a342ec8e8afff888c33502aa8735f192e336efe78"

URI_aarch64_akregator = "${EPEL_MIRROR}/aarch64/Packages/a/akregator-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akregator;unpack=0"
SRC_URI:append = " ${URI_aarch64_akregator}"
SRC_URI[aarch64_akregator.sha256sum] = "85ec7801ed69dfe28a6dc9843c8b2e0bfd29fa84ea7a4995ea00e3000ea179fe"

URI_aarch64_akregator-libs = "${EPEL_MIRROR}/aarch64/Packages/a/akregator-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akregator-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_akregator-libs}"
SRC_URI[aarch64_akregator-libs.sha256sum] = "05ec7d6de9bf2b6aad9bfa9731f467061b156617d736c771d53cd5ca668bdcf0"

RDEPENDS:akregator = " \
 akregator-libs \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syndication \
 kontactinterface \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akregator-libs = " \
 akregator \
 glibc \
 grantleetheme \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-ktexttemplate \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syndication \
 kontactinterface \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
