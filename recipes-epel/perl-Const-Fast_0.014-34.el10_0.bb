# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Const-Fast"
PV = "0.014"
PR = "34.el10_0"
PACKAGES = " \
 perl-Const-Fast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Const-Fast-0.014-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bc71d482b93bca662dc32eb32ff4fe11ec7cf6bf857eb9cf8994e81087f5715"

URI_x86_64_v2_perl-Const-Fast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Const-Fast-0.014-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Const-Fast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Const-Fast}"
SRC_URI[x86_64_v2_perl-Const-Fast.sha256sum] = "b85c941c43ae22ff6307db78f59775b06637c0ddf163dae9426f6bb8219d438e"

URI_aarch64_perl-Const-Fast = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Const-Fast-0.014-34.el10_0.noarch.rpm;name=aarch64_perl-Const-Fast;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Const-Fast}"
SRC_URI[aarch64_perl-Const-Fast.sha256sum] = "44dfc05b3b927a4aff0b2f510c0e21d4025aa6fb9c7057d5fa0d311904f5d051"

RDEPENDS:perl-Const-Fast = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-Sub-Exporter-Progressive \
 perl-libs \
 "
