# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBI"
PV = "1.643"
PR = "29.el10"
PACKAGES = " \
 perl-DBI \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-DBI-1.643-29.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3c016ab3a6cf819a649590b35102ea16aa6de213a71a19967d45416d43fd8746"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBI-1.643-29.el10.x86_64_v2.rpm;name=x86_64_v2_perl-DBI;unpack=0"
SRC_URI[x86_64_v2_perl-DBI.sha256sum] = "fcf60bb96763509557f39dedc0103d7aebc8d990f84dfa7ef68e634dc71cd679"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBI-1.643-29.el10.aarch64.rpm;name=aarch64_perl-DBI;unpack=0"
SRC_URI[aarch64_perl-DBI.sha256sum] = "02ecadf332b55fa9a90fa857c995b141be1ba532e5f2a38d9976f6dad8c5faf0"

RDEPENDS:perl-DBI = " \
 glibc \
 perl-Carp \
 perl-DBI \
 perl-Data-Dumper \
 perl-DynaLoader \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Math-BigInt \
 perl-Module-Load \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Symbol \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
