# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "toolbox"
PV = "0.2"
PR = "1.el10_0"
PACKAGES = " \
 toolbox \
 toolbox-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/toolbox-0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39dce054d3172cdf41dd9432840e97c9dc3f5d6d283c730c63ec9bfe25994258"

URI_x86_64_v2_toolbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/toolbox-0.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_toolbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_toolbox}"
SRC_URI[x86_64_v2_toolbox.sha256sum] = "4f7a782a9c5312efb1439530b9f67da040a7466736c4a2959dbb2308c5f7dcdb"

URI_x86_64_v2_toolbox-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/toolbox-tests-0.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_toolbox-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_toolbox-tests}"
SRC_URI[x86_64_v2_toolbox-tests.sha256sum] = "1d659c8eeac440ee5b70fddd887f6e0d4dab684f94e02541c7757e0d54b9d57b"

URI_aarch64_toolbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/toolbox-0.2-1.el10_0.aarch64.rpm;name=aarch64_toolbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_toolbox}"
SRC_URI[aarch64_toolbox.sha256sum] = "664bed6e3dbb4847814b1999f5bd12f93249c1dca4ef5665c841bc12e811ee77"

URI_aarch64_toolbox-tests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/toolbox-tests-0.2-1.el10_0.aarch64.rpm;name=aarch64_toolbox-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_toolbox-tests}"
SRC_URI[aarch64_toolbox-tests.sha256sum] = "3719998f03dc492e8d702aa240da2bbd14ca25f799278a6af33e3d3b3ffaf79a"

RDEPENDS:toolbox = " \
 containers-common \
 flatpak-session-helper \
 glibc \
 podman \
 shadow-utils-subid \
 "
RDEPENDS:toolbox-tests = " \
 diffutils \
 glib2 \
 grep \
 httpd-tools \
 openssl \
 python3 \
 skopeo \
 toolbox \
 virtual/coreutils \
 "
