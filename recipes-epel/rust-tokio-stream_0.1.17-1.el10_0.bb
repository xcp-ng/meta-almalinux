# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-stream"
PV = "0.1.17"
PR = "1.el10_0"
PACKAGES = " \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+fs-devel \
 rust-tokio-stream+full-devel \
 rust-tokio-stream+io-util-devel \
 rust-tokio-stream+net-devel \
 rust-tokio-stream+signal-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-stream+time-devel \
 rust-tokio-stream+tokio-util-devel \
 rust-tokio-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-stream-0.1.17-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21f92c3758814164f6567bdfcc48ffe293a47fc0e34ccb940e6fdfb92aecb544"

URI_x86_64_v2_rust-tokio-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+default-devel-0.1.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+default-devel.sha256sum] = "a881c8966c0ea6772289f75939c9f7387eded273bb34798c0acbaca767a7d826"

URI_x86_64_v2_rust-tokio-stream+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+fs-devel-0.1.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+fs-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+fs-devel.sha256sum] = "7a07188d31685d0c2e066c2ff2d82c2cb0f2170d2a5c6fae9f7803f4509d69ca"

URI_x86_64_v2_rust-tokio-stream+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+full-devel-0.1.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+full-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+full-devel.sha256sum] = "ddb4009ed6cda992a1e23679dc58e4585abaf5d7380209581fef53538e444781"

URI_x86_64_v2_rust-tokio-stream+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+io-util-devel-0.1.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+io-util-devel.sha256sum] = "66458c450d9710f62ed0da2270005e76cf9a2522e28a7f61db91c4ee8b313aec"

URI_x86_64_v2_rust-tokio-stream+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+net-devel-0.1.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+net-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+net-devel.sha256sum] = "93b2413a923ed3318b53a8c9e1dcf7615c156b6aa7a091cb895c6c5a753d6629"

URI_x86_64_v2_rust-tokio-stream+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+signal-devel-0.1.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+signal-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+signal-devel.sha256sum] = "5d896a923bed8e3a14aabe57f0ac5afc5c17289e9de7c8e7e6efc5f20b15fdf3"

URI_x86_64_v2_rust-tokio-stream+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+sync-devel-0.1.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+sync-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+sync-devel.sha256sum] = "bce45171ba47c31f4f39dc1e7f02a7621918bef1442e5afe420ac4df82e66896"

URI_x86_64_v2_rust-tokio-stream+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+time-devel-0.1.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+time-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+time-devel.sha256sum] = "b3ab7993de48abbf0ee4755b4bcc258ec129540e840de10d4834a1cfef8c6fe8"

URI_x86_64_v2_rust-tokio-stream+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+tokio-util-devel-0.1.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+tokio-util-devel.sha256sum] = "6ebb3094d01f9cfb298c0e5eb37e3fac4035eec030d295c3b7367bfc0624aebb"

URI_x86_64_v2_rust-tokio-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream-devel-0.1.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream-devel.sha256sum] = "11bac5e5f9bcccac65c3e31924a3ef02e59280da9f12b524ff799134233e7bfd"

URI_aarch64_rust-tokio-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+default-devel-0.1.17-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+default-devel}"
SRC_URI[aarch64_rust-tokio-stream+default-devel.sha256sum] = "e39869f241ed8cbd4f49165dc082562a1d77bc80339e4ad967fb8414e53a6efe"

URI_aarch64_rust-tokio-stream+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+fs-devel-0.1.17-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-stream+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+fs-devel}"
SRC_URI[aarch64_rust-tokio-stream+fs-devel.sha256sum] = "3154a444abebe2a3f02816c1a9fe4fa7f8fbad33f6d024c888b3fa8182645023"

URI_aarch64_rust-tokio-stream+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+full-devel-0.1.17-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-stream+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+full-devel}"
SRC_URI[aarch64_rust-tokio-stream+full-devel.sha256sum] = "d6585dfa3cc9c1c50ae679716c9690cbb22246413c5fe677d58e41fff77ca2d8"

URI_aarch64_rust-tokio-stream+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+io-util-devel-0.1.17-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-stream+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+io-util-devel}"
SRC_URI[aarch64_rust-tokio-stream+io-util-devel.sha256sum] = "a25b4558654471751bbee7702e83572a5273060e9f3e3cd87cfb9926d1191f2e"

URI_aarch64_rust-tokio-stream+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+net-devel-0.1.17-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-stream+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+net-devel}"
SRC_URI[aarch64_rust-tokio-stream+net-devel.sha256sum] = "835123209aa885c0798b253f67b7e86a45c9c02abdd3a667b15975ec8f372d99"

URI_aarch64_rust-tokio-stream+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+signal-devel-0.1.17-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-stream+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+signal-devel}"
SRC_URI[aarch64_rust-tokio-stream+signal-devel.sha256sum] = "33d4d3e228e3f6ce59a425d67f9c24a8a603dbec1512b8d01cd22371e321a945"

URI_aarch64_rust-tokio-stream+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+sync-devel-0.1.17-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-stream+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+sync-devel}"
SRC_URI[aarch64_rust-tokio-stream+sync-devel.sha256sum] = "72f71a929d8d0726e93c6a33a58659698ca1faf4423697eb69e6fa0f3f98ab2e"

URI_aarch64_rust-tokio-stream+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+time-devel-0.1.17-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-stream+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+time-devel}"
SRC_URI[aarch64_rust-tokio-stream+time-devel.sha256sum] = "cb08b2da2974fef4470964cddb8f3272c803c3bab0b7a6efb9a009cca3b97b23"

URI_aarch64_rust-tokio-stream+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+tokio-util-devel-0.1.17-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-stream+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+tokio-util-devel}"
SRC_URI[aarch64_rust-tokio-stream+tokio-util-devel.sha256sum] = "0d8ee0efc65b9e29f5102db4decbcdb4c685e5abcc7e403297addb8f18be219c"

URI_aarch64_rust-tokio-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream-devel-0.1.17-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream-devel}"
SRC_URI[aarch64_rust-tokio-stream-devel.sha256sum] = "68334fa915583a33d85ac685fe5b30c1f76af32666e298752358d30bf5c6f2e7"

RDEPENDS:rust-tokio-stream+default-devel = " \
 cargo \
 rust-tokio-stream+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+fs-devel = " \
 cargo \
 rust-tokio+fs-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+full-devel = " \
 cargo \
 rust-tokio-stream+fs-devel \
 rust-tokio-stream+io-util-devel \
 rust-tokio-stream+net-devel \
 rust-tokio-stream+signal-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-stream+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+io-util-devel = " \
 cargo \
 rust-tokio+io-util-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+net-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+signal-devel = " \
 cargo \
 rust-tokio+signal-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+sync-devel = " \
 cargo \
 rust-tokio+sync-devel \
 rust-tokio-stream+tokio-util-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+time-devel = " \
 cargo \
 rust-tokio+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+tokio-util-devel = " \
 cargo \
 rust-tokio-stream-devel \
 rust-tokio-util+default-devel \
 "
RDEPENDS:rust-tokio-stream-devel = " \
 cargo \
 rust \
 rust-futures-core+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
