# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "roundcubemail"
PV = "1.6.15"
PR = "1.el10_1"
PACKAGES = " \
 roundcubemail \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/roundcubemail-1.6.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32d19e7249bc5ca85bb522e84c3ea2b3fa33a582a93401f8ada0bbde24defdd5"

URI_x86_64_v2_roundcubemail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roundcubemail-1.6.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_roundcubemail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_roundcubemail}"
SRC_URI[x86_64_v2_roundcubemail.sha256sum] = "23d7684b6f899c9e569e6a0408d9e4b1e653e4e62a2b05009521b178dd131cb2"

URI_aarch64_roundcubemail = "${EPEL_MIRROR}/aarch64/Packages/r/roundcubemail-1.6.15-1.el10_1.noarch.rpm;name=aarch64_roundcubemail;unpack=0"
SRC_URI:append = " ${URI_aarch64_roundcubemail}"
SRC_URI[aarch64_roundcubemail.sha256sum] = "db9e2acd43f1b2f2047401e181fc00860adbcc23252a6a9da1f4022d8cf47d6d"

RDEPENDS:roundcubemail = " \
 bash \
 httpd-filesystem \
 mailcap \
 nginx-filesystem \
 php-common \
 php-fpm \
 php-gd \
 php-intl \
 php-ldap \
 php-mbstring \
 php-pdo \
 php-pecl-zip \
 php-process \
 php-xml \
 virtual/webserver \
 "
