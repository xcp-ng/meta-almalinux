# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-xdg-utils"
PV = "1.0.6"
PR = "1.el10"
PACKAGES = " \
 flatpak-spawn \
 flatpak-xdg-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/flatpak-xdg-utils-1.0.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd017837443aaf9c3f72bce03ce9eb57f4566c54f91beacb4376250c93973358"

URI_x86_64_v2_flatpak-spawn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-spawn-1.0.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-spawn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-spawn}"
SRC_URI[x86_64_v2_flatpak-spawn.sha256sum] = "4fe559a20884cd463dcf475b37b4bfc2b917215e91570478c3a3a439cfd941c5"

URI_x86_64_v2_flatpak-xdg-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flatpak-xdg-utils-1.0.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-xdg-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-xdg-utils}"
SRC_URI[x86_64_v2_flatpak-xdg-utils.sha256sum] = "98808af4ffff077c0859b7dcc4d8fde0990f3b41d276a7859125729990f0c7e4"

URI_aarch64_flatpak-spawn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-spawn-1.0.6-1.el10.aarch64.rpm;name=aarch64_flatpak-spawn;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-spawn}"
SRC_URI[aarch64_flatpak-spawn.sha256sum] = "f6b727718238e017a61750e2be02d88cf969562245681530b5db6b9e04afa2db"

URI_aarch64_flatpak-xdg-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flatpak-xdg-utils-1.0.6-1.el10.aarch64.rpm;name=aarch64_flatpak-xdg-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-xdg-utils}"
SRC_URI[aarch64_flatpak-xdg-utils.sha256sum] = "3b2c567c5055ec055c108185cd1bd7ec5e30ae456fe891b9466a5012cd4d298c"

RDEPENDS:flatpak-spawn = " \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:flatpak-xdg-utils = " \
 flatpak-spawn \
 glib2 \
 glibc \
 libgcc \
 "
