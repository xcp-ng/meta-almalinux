# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtscxml"
PV = "6.8.1"
PR = "3.el10"
PACKAGES = " \
 qt6-qtscxml \
 qt6-qtscxml-devel \
 qt6-qtscxml-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtscxml-6.8.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43467d3cc13acce44be231bbab057d0a4dd5764b75277a0360ff984ebad7890e"

URI_x86_64_v2_qt6-qtscxml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtscxml-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtscxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtscxml}"
SRC_URI[x86_64_v2_qt6-qtscxml.sha256sum] = "1eb62be07118507e841f915a7dfc62e8ecdf0ae9126216bbcc4608f239250559"

URI_x86_64_v2_qt6-qtscxml-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtscxml-devel-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtscxml-devel}"
SRC_URI[x86_64_v2_qt6-qtscxml-devel.sha256sum] = "d243dc1463a12870d7f03d629fe776fa72b79f26d5b8a1d6b6357b11d638d2e8"

URI_x86_64_v2_qt6-qtscxml-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtscxml-examples-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtscxml-examples}"
SRC_URI[x86_64_v2_qt6-qtscxml-examples.sha256sum] = "11182010c5de878052565c456621dba2fd12d304adc03ecace73f71496443e28"

URI_aarch64_qt6-qtscxml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtscxml-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtscxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtscxml}"
SRC_URI[aarch64_qt6-qtscxml.sha256sum] = "9cce96a2dd183290ee06d2367ec690316bd0707a5d8c9e0977ae79ec3aacaf6a"

URI_aarch64_qt6-qtscxml-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtscxml-devel-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtscxml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtscxml-devel}"
SRC_URI[aarch64_qt6-qtscxml-devel.sha256sum] = "bed8716bd22427308a83d5e865442b3ac91fff8356922a4cebf129ce5a84f1e2"

URI_aarch64_qt6-qtscxml-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtscxml-examples-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtscxml-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtscxml-examples}"
SRC_URI[aarch64_qt6-qtscxml-examples.sha256sum] = "6b5410be92c03d8efe5f39060e9cd46c1378a1cf42d1cb66114d554e0cadbc4e"

RDEPENDS:qt6-qtscxml = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtscxml-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtscxml \
 qt6-qtscxml-devel \
 "
RDEPENDS:qt6-qtscxml-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtscxml \
 "
