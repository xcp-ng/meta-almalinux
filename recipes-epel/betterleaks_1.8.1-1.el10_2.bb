# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "betterleaks"
PV = "1.8.1"
PR = "1.el10_2"
PACKAGES = " \
 betterleaks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/betterleaks-1.8.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0d8a969f18dabfee949a2fb4ce4760856614b2a82e58a2b7d41d4047377af803"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/betterleaks-1.8.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_betterleaks;unpack=0"
SRC_URI[x86_64_v2_betterleaks.sha256sum] = "bf3444571142b1e3a1bf56159550cc32a096b11a32985f00d9cddd2ddc4d9b8a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/betterleaks-1.8.1-1.el10_2.aarch64.rpm;name=aarch64_betterleaks;unpack=0"
SRC_URI[aarch64_betterleaks.sha256sum] = "558b3cceff84d937b420d6bfdf3cc460d8b378cc978a186ad6305899c2ca4c49"

RDEPENDS:betterleaks = " \
 git-core \
 glibc \
 "
