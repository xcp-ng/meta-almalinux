# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libudfread"
PV = "1.1.2"
PR = "9.el10_0"
PACKAGES = " \
 libudfread \
 libudfread-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libudfread-1.1.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acfc2c938c3673aeb1e520109fca88b9cd5bf7775efeafdf8042fef2c2a2adef"

URI_x86_64_v2_libudfread = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libudfread-1.1.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libudfread;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libudfread}"
SRC_URI[x86_64_v2_libudfread.sha256sum] = "2135023121f2f91986180867d83a342949f45d0838c624a2490e5202ce4140f0"

URI_x86_64_v2_libudfread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libudfread-devel-1.1.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libudfread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libudfread-devel}"
SRC_URI[x86_64_v2_libudfread-devel.sha256sum] = "f5b6defc5b622f73f7119d2356e4f2926232cfc8a16b2e3fc4b7c4b48aeed7ff"

URI_aarch64_libudfread = "${EPEL_MIRROR}/aarch64/Packages/l/libudfread-1.1.2-9.el10_0.aarch64.rpm;name=aarch64_libudfread;unpack=0"
SRC_URI:append = " ${URI_aarch64_libudfread}"
SRC_URI[aarch64_libudfread.sha256sum] = "acdbdd75f660f80a6e13a96fed043e8f798d0e735b315b7d7cca86d31509d5c1"

URI_aarch64_libudfread-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libudfread-devel-1.1.2-9.el10_0.aarch64.rpm;name=aarch64_libudfread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libudfread-devel}"
SRC_URI[aarch64_libudfread-devel.sha256sum] = "12a0627d846804f313407edac0215cd99924bcff4ed312f9d5c2daccd0ad096d"

RDEPENDS:libudfread = " \
 glibc \
 "
RDEPENDS:libudfread-devel = " \
 libudfread \
 pkgconf-pkg-config \
 "
