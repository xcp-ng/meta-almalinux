# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libspectre"
PV = "0.2.12"
PR = "8.el10"
PACKAGES = " \
 libspectre \
 libspectre-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libspectre-0.2.12-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6eceedcf0e42f0c44b4e1e16d2e2c9b127eb287f9bfc7a0426f6d925b5e9fe6f"

URI_x86_64_v2_libspectre = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libspectre-0.2.12-8.el10.x86_64_v2.rpm;name=x86_64_v2_libspectre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspectre}"
SRC_URI[x86_64_v2_libspectre.sha256sum] = "a2a69188aa6e52f093b305589e2b71496292bad1fcfb0222a155d2eef96fcdf0"

URI_x86_64_v2_libspectre-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libspectre-devel-0.2.12-8.el10.x86_64_v2.rpm;name=x86_64_v2_libspectre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspectre-devel}"
SRC_URI[x86_64_v2_libspectre-devel.sha256sum] = "0b96d4a567e771b666b72b1c7e88b1ab5c3b4304d6acb9aa90bf37b5857a5731"

URI_aarch64_libspectre = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libspectre-0.2.12-8.el10.aarch64.rpm;name=aarch64_libspectre;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspectre}"
SRC_URI[aarch64_libspectre.sha256sum] = "fdd86954c32f7f5ebb3bfcb1f0759150f5bb0455d0315f1879eff2181196d9ce"

URI_aarch64_libspectre-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libspectre-devel-0.2.12-8.el10.aarch64.rpm;name=aarch64_libspectre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspectre-devel}"
SRC_URI[aarch64_libspectre-devel.sha256sum] = "3c96e4461ab714efdd3bdae06c9ecffbdfa866dc85de9bb2b115fbf12c7b0fb6"

RDEPENDS:libspectre = " \
 glibc \
 libgs \
 "
RDEPENDS:libspectre-devel = " \
 libspectre \
 pkgconf-pkg-config \
 "
