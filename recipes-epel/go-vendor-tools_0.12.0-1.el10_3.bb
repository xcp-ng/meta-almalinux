# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-vendor-tools"
PV = "0.12.0"
PR = "1.el10_3"
PACKAGES = " \
 go-vendor-tools \
 go-vendor-tools+all \
 go-vendor-tools-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/go-vendor-tools-0.12.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9d90b9c6bc6f06e5f58c6517fe9c168b2dda31f8faec3d71903a476cc58b356"

URI_x86_64_v2_go-vendor-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools}"
SRC_URI[x86_64_v2_go-vendor-tools.sha256sum] = "b49f1083367c312a56a0babc875f7c3b5f8180aba0840616457b87026ae5f53e"

URI_x86_64_v2_go-vendor-tools+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools+all-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools+all}"
SRC_URI[x86_64_v2_go-vendor-tools+all.sha256sum] = "1f3cadae9315345815ed8b936bbf2cc516e0907f0198c72df2c910793d074159"

URI_x86_64_v2_go-vendor-tools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools-doc-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools-doc}"
SRC_URI[x86_64_v2_go-vendor-tools-doc.sha256sum] = "d92e95457f15b1f84aa30a8b33026685903229a5033201f5cc38813b57b4ef4e"

URI_aarch64_go-vendor-tools = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools-0.12.0-1.el10_3.noarch.rpm;name=aarch64_go-vendor-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools}"
SRC_URI[aarch64_go-vendor-tools.sha256sum] = "fb56e3b40044ce65878a0b72a26cd3ac5d7f0013325c812ea8121ea1d88ef790"

URI_aarch64_go-vendor-tools+all = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools+all-0.12.0-1.el10_3.noarch.rpm;name=aarch64_go-vendor-tools+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools+all}"
SRC_URI[aarch64_go-vendor-tools+all.sha256sum] = "eacd294d807da16c0a924eb285db078225905837dbf146dd38ea14f453823f06"

URI_aarch64_go-vendor-tools-doc = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools-doc-0.12.0-1.el10_3.noarch.rpm;name=aarch64_go-vendor-tools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools-doc}"
SRC_URI[aarch64_go-vendor-tools-doc.sha256sum] = "964c8e0ff8d92ec890693fa6da22ebc2dfa0c2e1b5421909c87d2789e43b4567"

RDEPENDS:go-vendor-tools = " \
 python3 \
 python3-license-expression \
 "
RDEPENDS:go-vendor-tools+all = " \
 go-vendor-tools \
 python3 \
 python3-argcomplete \
 python3-specfile \
 python3-tomlkit \
 python3-zstarfile \
 "
RDEPENDS:go-vendor-tools-doc = " \
 "
