# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyxdameraulevenshtein"
PV = "1.10.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-pyxdameraulevenshtein \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyxdameraulevenshtein-1.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ce2d8fd32a2db0c2ed7e1ecca820cca5eddb2fce1004e607d11981da81c9f93"

URI_x86_64_v2_python3-pyxdameraulevenshtein = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyxdameraulevenshtein-1.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyxdameraulevenshtein;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyxdameraulevenshtein}"
SRC_URI[x86_64_v2_python3-pyxdameraulevenshtein.sha256sum] = "21c2279721d7290998a9f0784cc8f4c159356143ffe9606e0bfe8361a478b040"

URI_aarch64_python3-pyxdameraulevenshtein = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyxdameraulevenshtein-1.10.0-1.el10_2.aarch64.rpm;name=aarch64_python3-pyxdameraulevenshtein;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyxdameraulevenshtein}"
SRC_URI[aarch64_python3-pyxdameraulevenshtein.sha256sum] = "60e153cac8c9f487be8a7b5fdcbc3362ae0354fb46ae3b1d23e0f812804d4dd7"

RDEPENDS:python3-pyxdameraulevenshtein = " \
 glibc \
 python3 \
 "
