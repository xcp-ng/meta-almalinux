# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "autofs"
PE = "1"
PV = "5.1.9"
PR = "11.el10"
PACKAGES = " \
 autofs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/autofs-5.1.9-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b16995e09a445aa5dbc2c1a19cb12b956f8c2a9bc6fd8daf9a44a61d92ac9f78"

URI_x86_64_v2_autofs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/autofs-5.1.9-11.el10.x86_64_v2.rpm;name=x86_64_v2_autofs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_autofs}"
SRC_URI[x86_64_v2_autofs.sha256sum] = "d6a0dc693b5987e91765438f068cacebc0aa7de768b44b9c5196e792d1e6caa8"

URI_aarch64_autofs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/autofs-5.1.9-11.el10.aarch64.rpm;name=aarch64_autofs;unpack=0"
SRC_URI:append = " ${URI_aarch64_autofs}"
SRC_URI[aarch64_autofs.sha256sum] = "2ec04a9fef36f30ec8bd7653c619155b82133ef8f6258b80739e78cfe51b53fe"

RDEPENDS:autofs = " \
 bash \
 cyrus-sasl-lib \
 gawk \
 glibc \
 grep \
 kmod \
 krb5-libs \
 libcom_err \
 libgcc \
 libtirpc \
 libxml2 \
 openldap \
 procps-ng \
 sed \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
