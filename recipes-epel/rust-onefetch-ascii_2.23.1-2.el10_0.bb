# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch-ascii"
PV = "2.23.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-onefetch-ascii+default-devel \
 rust-onefetch-ascii-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-ascii-2.23.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6d49ae2175ad2c37e8b803e4cf4839562f9130018dfa577d307c0584b06d8ab"

URI_x86_64_v2_rust-onefetch-ascii+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-ascii+default-devel-2.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-ascii+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-ascii+default-devel}"
SRC_URI[x86_64_v2_rust-onefetch-ascii+default-devel.sha256sum] = "2def82f7318ab65181c6e7f229e6947c94ca9a53cceea664c1d68ffbd33f1f02"

URI_x86_64_v2_rust-onefetch-ascii-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-ascii-devel-2.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-ascii-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-ascii-devel}"
SRC_URI[x86_64_v2_rust-onefetch-ascii-devel.sha256sum] = "c67c81863aaabc8cb91d9a11a880ef371d0fa1207dce5b6b93c778ab5db6d5a4"

URI_aarch64_rust-onefetch-ascii+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-ascii+default-devel-2.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-onefetch-ascii+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-ascii+default-devel}"
SRC_URI[aarch64_rust-onefetch-ascii+default-devel.sha256sum] = "7ce50d750c4a335ae68c170764a2aa4a2345bbc5f42612fb9855e64a7ba47595"

URI_aarch64_rust-onefetch-ascii-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-ascii-devel-2.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-onefetch-ascii-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-ascii-devel}"
SRC_URI[aarch64_rust-onefetch-ascii-devel.sha256sum] = "f0c3c58d9673690d1cf9f08c84b582c40deff1c8149ee072eb650a97b2d5e23f"

RDEPENDS:rust-onefetch-ascii+default-devel = " \
 cargo \
 rust-onefetch-ascii-devel \
 "
RDEPENDS:rust-onefetch-ascii-devel = " \
 cargo \
 rust-owo-colors+default-devel \
 "
