# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "haproxy"
PV = "3.0.5"
PR = "4.el10"
PACKAGES = " \
 haproxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/haproxy-3.0.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a257d02f6cf2fa571e81f6ca0c0d43feea26d507ef593c08e6d72bb9dbc9d737"

URI_x86_64_v2_haproxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/haproxy-3.0.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_haproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_haproxy}"
SRC_URI[x86_64_v2_haproxy.sha256sum] = "8a6e279236989eb74496998db1560662b228610418a757d03e077c60dcc604b3"

URI_aarch64_haproxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/haproxy-3.0.5-4.el10.aarch64.rpm;name=aarch64_haproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_haproxy}"
SRC_URI[aarch64_haproxy.sha256sum] = "f76cf255548a4e0243510c27689ad0c1dc894a3c26d6ee269addd011a832d8d9"

RDEPENDS:haproxy = " \
 bash \
 glibc \
 libxcrypt \
 lua-libs \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 "
