# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-actix-macros"
PV = "0.2.4"
PR = "4.el10_1"
PACKAGES = " \
 rust-actix-macros+default-devel \
 rust-actix-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-actix-macros-0.2.4-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c68a73e7151af1c779bdcc32504266dc741bc7ced5e95cd8c9c87c8af5ed69a"

URI_x86_64_v2_rust-actix-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-macros+default-devel-0.2.4-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-actix-macros+default-devel}"
SRC_URI[x86_64_v2_rust-actix-macros+default-devel.sha256sum] = "fe7fefe484bd5f69d49884e0fd3763ba43de295d872f534fdc135b3e13683eb5"

URI_x86_64_v2_rust-actix-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-macros-devel-0.2.4-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-actix-macros-devel}"
SRC_URI[x86_64_v2_rust-actix-macros-devel.sha256sum] = "66c4ccbf0c727f3bff308ec471e2fa88734fbe8342d1b110d88188ae421167ae"

URI_aarch64_rust-actix-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-macros+default-devel-0.2.4-4.el10_1.noarch.rpm;name=aarch64_rust-actix-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-actix-macros+default-devel}"
SRC_URI[aarch64_rust-actix-macros+default-devel.sha256sum] = "a5a37f7d48ed5cd148f10c282d54e07f2b20e08bd74bdd6a7cdd9084456975bb"

URI_aarch64_rust-actix-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-macros-devel-0.2.4-4.el10_1.noarch.rpm;name=aarch64_rust-actix-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-actix-macros-devel}"
SRC_URI[aarch64_rust-actix-macros-devel.sha256sum] = "8e13638b28286b88864c39ebc944e462949b7beb1959fff000198ba9d7b729d6"

RDEPENDS:rust-actix-macros+default-devel = " \
 cargo \
 rust-actix-macros-devel \
 "
RDEPENDS:rust-actix-macros-devel = " \
 cargo \
 rust \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
