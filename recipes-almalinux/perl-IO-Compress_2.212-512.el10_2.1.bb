# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Compress"
PV = "2.212"
PR = "512.el10_2.1"
PACKAGES = " \
 perl-IO-Compress \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-IO-Compress-2.212-512.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcee78462e365e0d4f1003f5313f05cc9426cd5bfaa62100093d8de1eb41a4ae"

URI_x86_64_v2_perl-IO-Compress = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IO-Compress-2.212-512.el10_2.1.noarch.rpm;name=x86_64_v2_perl-IO-Compress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Compress}"
SRC_URI[x86_64_v2_perl-IO-Compress.sha256sum] = "741508f5ad1fac081838f6f573ee7ee5aed1ab60be165fde7eab4c556b6b2f28"

URI_aarch64_perl-IO-Compress = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IO-Compress-2.212-512.el10_2.1.noarch.rpm;name=aarch64_perl-IO-Compress;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Compress}"
SRC_URI[aarch64_perl-IO-Compress.sha256sum] = "741508f5ad1fac081838f6f573ee7ee5aed1ab60be165fde7eab4c556b6b2f28"

RDEPENDS:perl-IO-Compress = " \
 perl-Carp \
 perl-Compress-Raw-Bzip2 \
 perl-Compress-Raw-Zlib \
 perl-Data-Dumper \
 perl-Encode \
 perl-Exporter \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Compress \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-Time-Local \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-parent \
 "
