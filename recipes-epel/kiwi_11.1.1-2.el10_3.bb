# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi"
PV = "11.1.1"
PR = "2.el10_3"
PACKAGES:x86_64_v2 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-pxeboot \
 kiwi-selinux \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-boxbuild \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 kiwi-systemdeps-stackbuild \
 python3-kiwi \
"
PACKAGES:aarch64 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-selinux \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-boxbuild \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 kiwi-systemdeps-stackbuild \
 python3-kiwi \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kiwi-11.1.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "44a60a6f638d2398fa932e0b5a831f171b51d9d5dbd26c83c57462dd923bc02a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-lib-11.1.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-lib;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-lib.sha256sum] = "25129f3cd029cc8c68c33d8753f74caefa73f82db90ee31d210c5ceb590cc74b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-live-11.1.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-live;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-live.sha256sum] = "7de460d971bfe3bcc381cb037439f310bc5741e059bfcecb7d84848677721d49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-dump-11.1.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-dump;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-oem-dump.sha256sum] = "b287bba8c592e34273dfaeb1e02dc95a99a112bf1688220d7355b5bf49c0e34d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-repart-11.1.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-repart;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-oem-repart.sha256sum] = "85386437da2ae678c1d0def2d70325f0702cbf526e1ab6566ba63c2bb8aa4603"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-overlay-11.1.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-overlay;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-overlay.sha256sum] = "56872d537d731aacc6c8da1b3d59ef29913dcdac200973071de9e60dc5aebbd7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-verity-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dracut-kiwi-verity;unpack=0"
SRC_URI[x86_64_v2_dracut-kiwi-verity.sha256sum] = "032afdb56bbf0779a9121b1cc8bec53fb616bbc90dd79fd8e33241e104fe0e18"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-cli-11.1.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-cli;unpack=0"
SRC_URI[x86_64_v2_kiwi-cli.sha256sum] = "a45751e772d6719146fa1aed5b77136d49d07a0abbc5105364e98e43f8a1cbf4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-pxeboot-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-pxeboot;unpack=0"
SRC_URI[x86_64_v2_kiwi-pxeboot.sha256sum] = "d3231859e6d816d187bf195f91b0a40f0dd8ff6bb146eba5a5e513e6036570b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-selinux-11.1.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-selinux;unpack=0"
SRC_URI[x86_64_v2_kiwi-selinux.sha256sum] = "3f78611c0a135e3cfdcca82dab5b0b968efaa04e88edad0722e12b6d8230e80b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps.sha256sum] = "572e3a29d158766c3ef91d42c65edcd310f80a53951135a3f49d7709090085b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-bootloaders-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-bootloaders.sha256sum] = "80d6ccc965bbd22ed2fae870cece0183042d4f9cd5f21a5eed8193cde7582bb3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-boxbuild-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-boxbuild;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-boxbuild.sha256sum] = "b040ed908e8bed27af603a486462ca14b893a881c8dd219d977644d43514f959"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-containers-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-containers;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-containers.sha256sum] = "d0a2a39c6ce30bcc822368b3d725f4d094159f77a467f42925d0f6b58f56d7d0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-core-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-core;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-core.sha256sum] = "7e25e72d77b7820ab9f3a5344a05ba6140746ac73059e78eb3aa1fdf70d64feb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-disk-images-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-disk-images.sha256sum] = "ea4c02c97f3436e799b24109e90d8756830c0bc86262bc5b44f91991067b3b68"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-filesystems-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-filesystems.sha256sum] = "d8d358857009c0ab9420eb06ae7c4cec526fa4c330695e9866b9fcee669967c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-image-validation-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-image-validation.sha256sum] = "b6d0732afe963398606b357136ea55b7434b22ea3b7a576c85384e85254ad769"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-iso-media-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-iso-media.sha256sum] = "9044704d21085e6b0ff2cbe8c3845455ac76264b105d11dc4c39d3e229972b1f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-stackbuild-11.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-stackbuild;unpack=0"
SRC_URI[x86_64_v2_kiwi-systemdeps-stackbuild.sha256sum] = "8a43f5f4604683d6ba653e031a6adc7630aaf0dc20d0c7d05186db706aa353d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-11.1.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi;unpack=0"
SRC_URI[x86_64_v2_python3-kiwi.sha256sum] = "8760075ad0fd8328ec8a3791570d463fc8cf5e77cb23f57bbfd89e6014802a40"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-lib-11.1.1-2.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-lib;unpack=0"
SRC_URI[aarch64_dracut-kiwi-lib.sha256sum] = "a80348cab8f1e61b73dd1ef363f16af94ad65e112c28a00322c25c050135024f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-live-11.1.1-2.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-live;unpack=0"
SRC_URI[aarch64_dracut-kiwi-live.sha256sum] = "5c0a7a95b27ba1f104fbcefa8a31d06194cf2c041403c883aab6d7d7a266f364"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-dump-11.1.1-2.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-oem-dump;unpack=0"
SRC_URI[aarch64_dracut-kiwi-oem-dump.sha256sum] = "c35169f93ca4e076671c7e71fe55194ce30ebe57d0a1ed821b1e8c3167598ea1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-repart-11.1.1-2.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-oem-repart;unpack=0"
SRC_URI[aarch64_dracut-kiwi-oem-repart.sha256sum] = "a66d8f176b8c6cb3348b87303e49c36440d428e86c96ad36eaa51e7708fb18ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-overlay-11.1.1-2.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-overlay;unpack=0"
SRC_URI[aarch64_dracut-kiwi-overlay.sha256sum] = "a79c022f934628dc9be415b7c8450ab598d2f01150d2ca824a233636ebe05ac8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-verity-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_dracut-kiwi-verity;unpack=0"
SRC_URI[aarch64_dracut-kiwi-verity.sha256sum] = "d96259a19e529287183db082325b1cc74785594a64fcd4b997f9e8c268af0eaf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-cli-11.1.1-2.el10_3.noarch.rpm;name=aarch64_kiwi-cli;unpack=0"
SRC_URI[aarch64_kiwi-cli.sha256sum] = "cf67eed557b8c9728e690580426356a27ddc20a2a1f1ae134ab87a3c68d219a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-selinux-11.1.1-2.el10_3.noarch.rpm;name=aarch64_kiwi-selinux;unpack=0"
SRC_URI[aarch64_kiwi-selinux.sha256sum] = "df71a4550280d45c0b4e63c9ce0a8a4b73fb15dea5707f8409ef6dc4c3c2568b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps.sha256sum] = "64508ab361a9de2be17e27349b2392689aac457985d03f0a1ca85eda8cd90768"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-bootloaders-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-bootloaders.sha256sum] = "04afdad6191ea43af41f9f3a8e65cf92ee944ee50cab3092271433c9fcc18ff9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-boxbuild-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-boxbuild;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-boxbuild.sha256sum] = "a25df02b8e8f09f25ea3b2e34e1c34501a0bdeddafccfdcd451d822aae978c33"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-containers-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-containers;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-containers.sha256sum] = "553f3f3773fc6f00cf2121cb58c3759950f47219638072eda37493fa72b3f124"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-core-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-core;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-core.sha256sum] = "589b38ec347a363730fa6bafefd7cad144dd9b82836d9fa90bde9d6c4c405808"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-disk-images-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-disk-images.sha256sum] = "34c86374c0264fb6a6940b04e97cda350e8f33cdec4a5baa87248ee0918dc484"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-filesystems-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-filesystems.sha256sum] = "946881d32706aec8747b6055e4e60fb1f87e74c975349ec37cb17310915f0e95"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-image-validation-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-image-validation.sha256sum] = "efc669a1ef337326d93c52f6353ff9da6353dac155f7104a06d59544730e2de2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-iso-media-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-iso-media.sha256sum] = "6ec9459b0bf590b6c472d00cb500bc59bd083d873760ec2eca7f91c9e48a4dbb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-stackbuild-11.1.1-2.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-stackbuild;unpack=0"
SRC_URI[aarch64_kiwi-systemdeps-stackbuild.sha256sum] = "9756161d8715e5737b84fc7eccf9caa082847a7e37b99339ac777a0f2108e252"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-11.1.1-2.el10_3.noarch.rpm;name=aarch64_python3-kiwi;unpack=0"
SRC_URI[aarch64_python3-kiwi.sha256sum] = "2a9ab2d605c6a5c5872a6ec4d5c1c68282b8753b68836b89843565a39c457116"

RDEPENDS:dracut-kiwi-lib = " \
 bash \
 bc \
 cryptsetup \
 curl \
 device-mapper \
 dialog \
 dracut \
 e2fsprogs \
 gdisk \
 grep \
 kpartx \
 lvm2 \
 mdadm \
 parted \
 pv \
 util-linux \
 virtual/coreutils \
 xfsprogs \
 xz \
 "
RDEPENDS:dracut-kiwi-live = " \
 bash \
 device-mapper \
 dialog \
 dracut \
 dracut-kiwi-lib \
 dracut-network \
 e2fsprogs \
 parted \
 util-linux \
 xfsprogs \
 "
RDEPENDS:dracut-kiwi-oem-dump = " \
 bash \
 dracut-kiwi-lib \
 gawk \
 kexec-tools \
 "
RDEPENDS:dracut-kiwi-oem-repart = " \
 bash \
 dracut-kiwi-lib \
 "
RDEPENDS:dracut-kiwi-overlay = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 util-linux \
 "
RDEPENDS:dracut-kiwi-verity = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 glibc \
 "
RDEPENDS:kiwi-cli = " \
 bash-completion \
 kiwi-selinux \
 python3-kiwi \
 "
RDEPENDS:kiwi-pxeboot = " \
 syslinux \
 tftp-server \
 "
RDEPENDS:kiwi-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
RDEPENDS:kiwi-systemdeps = " \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 "
RDEPENDS:kiwi-systemdeps-bootloaders:x86_64_v2 = " \
 grub2-efi-x64 \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-bootloaders:aarch64 = " \
 grub2-efi-aa64-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-boxbuild = " \
 kiwi-systemdeps-core \
 qemu-kvm \
 "
RDEPENDS:kiwi-systemdeps-containers = " \
 appx-util \
 buildah \
 skopeo \
 "
RDEPENDS:kiwi-systemdeps-core = " \
 dnf \
 file \
 lsof \
 microdnf \
 mtools \
 openssl \
 python3-dnf \
 rsync \
 screen \
 sed \
 tar \
 xz \
 "
RDEPENDS:kiwi-systemdeps-disk-images = " \
 cryptsetup \
 gdisk \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 kpartx \
 lvm2 \
 mdadm \
 open-vmdk \
 util-linux \
 "
RDEPENDS:kiwi-systemdeps-filesystems = " \
 dosfstools \
 e2fsprogs \
 erofs-utils \
 kiwi-systemdeps-core \
 qemu-img \
 squashfs-tools \
 xfsprogs \
 "
RDEPENDS:kiwi-systemdeps-image-validation = " \
 python3-solv \
 "
RDEPENDS:kiwi-systemdeps-iso-media:x86_64_v2 = " \
 grub2-efi-x64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 syslinux \
 syslinux-nonlinux \
 xorriso \
"
RDEPENDS:kiwi-systemdeps-iso-media:aarch64 = " \
 grub2-efi-aa64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 xorriso \
"
RDEPENDS:kiwi-systemdeps-stackbuild = " \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 podman \
 rsync \
 "
RDEPENDS:python3-kiwi = " \
 kiwi-systemdeps-core \
 python3 \
 python3-cerberus \
 python3-lxml \
 python3-progressbar2 \
 python3-pyyaml \
 python3-requests \
 python3-simplejson \
 python3-typer \
 "
