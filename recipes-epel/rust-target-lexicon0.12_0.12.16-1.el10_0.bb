# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-target-lexicon0.12"
PV = "0.12.16"
PR = "1.el10_0"
PACKAGES = " \
 rust-target-lexicon0.12+arch_zkasm-devel \
 rust-target-lexicon0.12+default-devel \
 rust-target-lexicon0.12+serde-devel \
 rust-target-lexicon0.12+serde_support-devel \
 rust-target-lexicon0.12+std-devel \
 rust-target-lexicon0.12-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-target-lexicon0.12-0.12.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0e058d38c27d4f4a55b52836e27bc73a721b493c458d1695c960c7e7e1ceeb0"

URI_x86_64_v2_rust-target-lexicon0.12+arch_zkasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon0.12+arch_zkasm-devel-0.12.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon0.12+arch_zkasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon0.12+arch_zkasm-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon0.12+arch_zkasm-devel.sha256sum] = "902458129c90d142d193a8eff3ac3dd295c43bcbe39928d8f1391cf4c7b5d737"

URI_x86_64_v2_rust-target-lexicon0.12+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon0.12+default-devel-0.12.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon0.12+default-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon0.12+default-devel.sha256sum] = "ef0ddd08630357adf13587cb0ddff5dbe1bfe05bcd7f805ee4b2104e524be69e"

URI_x86_64_v2_rust-target-lexicon0.12+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon0.12+serde-devel-0.12.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon0.12+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon0.12+serde-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon0.12+serde-devel.sha256sum] = "473759130d84141dc595e6b7bfd3cdfe778f6bcfbbe558fec1203658f45a962b"

URI_x86_64_v2_rust-target-lexicon0.12+serde_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon0.12+serde_support-devel-0.12.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon0.12+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon0.12+serde_support-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon0.12+serde_support-devel.sha256sum] = "114a44c5658b288f030983c5ea70a5ca8898721f9520cc733915f82d1160ba01"

URI_x86_64_v2_rust-target-lexicon0.12+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon0.12+std-devel-0.12.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon0.12+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon0.12+std-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon0.12+std-devel.sha256sum] = "9b437502d5d9a77f4393d34417aba9035c1e7544cae4c2fc3ecb78765afc39d2"

URI_x86_64_v2_rust-target-lexicon0.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon0.12-devel-0.12.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon0.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon0.12-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon0.12-devel.sha256sum] = "28810a8fba7d15c4c42d0905ec6d2591fd8ac6ee7aa696775f2d35e840eaec21"

URI_aarch64_rust-target-lexicon0.12+arch_zkasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon0.12+arch_zkasm-devel-0.12.16-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon0.12+arch_zkasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon0.12+arch_zkasm-devel}"
SRC_URI[aarch64_rust-target-lexicon0.12+arch_zkasm-devel.sha256sum] = "df454df4ad7c1df7dd04769017e5aaca1023dd3229d52e327552e0454f6c5623"

URI_aarch64_rust-target-lexicon0.12+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon0.12+default-devel-0.12.16-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon0.12+default-devel}"
SRC_URI[aarch64_rust-target-lexicon0.12+default-devel.sha256sum] = "1f4c871fad69a969663b7dcc8b532e4d4aeb6e954e226fdadb8d0c542653c5d9"

URI_aarch64_rust-target-lexicon0.12+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon0.12+serde-devel-0.12.16-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon0.12+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon0.12+serde-devel}"
SRC_URI[aarch64_rust-target-lexicon0.12+serde-devel.sha256sum] = "167e8389a44d9b4d928b4cfe09556e7daef934d7a14b93d13bc750b4701e04b1"

URI_aarch64_rust-target-lexicon0.12+serde_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon0.12+serde_support-devel-0.12.16-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon0.12+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon0.12+serde_support-devel}"
SRC_URI[aarch64_rust-target-lexicon0.12+serde_support-devel.sha256sum] = "5f2a83d147b182240277a6c85504d71ae2b704c802aea455d3b974cab5851554"

URI_aarch64_rust-target-lexicon0.12+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon0.12+std-devel-0.12.16-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon0.12+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon0.12+std-devel}"
SRC_URI[aarch64_rust-target-lexicon0.12+std-devel.sha256sum] = "28fc1a534b7cfb59084514d170b3a4bc02e3701c20760734b0df9eacaea68146"

URI_aarch64_rust-target-lexicon0.12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon0.12-devel-0.12.16-1.el10_0.noarch.rpm;name=aarch64_rust-target-lexicon0.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon0.12-devel}"
SRC_URI[aarch64_rust-target-lexicon0.12-devel.sha256sum] = "6fd7e5e13329dc144a43795b3d32da6eaa57c40ea52b45722b8c7fb40ad41545"

RDEPENDS:rust-target-lexicon0.12+arch_zkasm-devel = " \
 cargo \
 rust-target-lexicon0.12-devel \
 "
RDEPENDS:rust-target-lexicon0.12+default-devel = " \
 cargo \
 rust-target-lexicon0.12-devel \
 "
RDEPENDS:rust-target-lexicon0.12+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-target-lexicon0.12-devel \
 "
RDEPENDS:rust-target-lexicon0.12+serde_support-devel = " \
 cargo \
 rust-target-lexicon0.12+serde-devel \
 rust-target-lexicon0.12+std-devel \
 rust-target-lexicon0.12-devel \
 "
RDEPENDS:rust-target-lexicon0.12+std-devel = " \
 cargo \
 rust-target-lexicon0.12-devel \
 "
RDEPENDS:rust-target-lexicon0.12-devel = " \
 bash \
 cargo \
 "
