# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scons"
PV = "4.11.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-scons \
 scons-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scons-4.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78745ef9d4ae74862aef1bee3559bbd151234a91c834ae06b96cc4f0bf4477a9"

URI_x86_64_v2_python3-scons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scons-4.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-scons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scons}"
SRC_URI[x86_64_v2_python3-scons.sha256sum] = "6cd4255bd86d23e0114c3228bd7ec846fd6c4f0a90a930889f879f50c3f5bcdb"

URI_x86_64_v2_scons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scons-doc-4.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_scons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scons-doc}"
SRC_URI[x86_64_v2_scons-doc.sha256sum] = "66fb38becc1785ba08ad187cea42e0019184033a737543e1e4d14e548cbf545e"

URI_aarch64_python3-scons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scons-4.11.0-1.el10_3.noarch.rpm;name=aarch64_python3-scons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scons}"
SRC_URI[aarch64_python3-scons.sha256sum] = "54ba6ef9baef66761ff4aebe179fd8bf32ae8d9b035f700c3597ff32426e576a"

URI_aarch64_scons-doc = "${EPEL_MIRROR}/aarch64/Packages/s/scons-doc-4.11.0-1.el10_3.noarch.rpm;name=aarch64_scons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scons-doc}"
SRC_URI[aarch64_scons-doc.sha256sum] = "d097ae3f217adf9c2aeec0e248ad48cd04117d4d0e50fb1b7018a75bc5f474de"

RDEPENDS:python3-scons = " \
 python3 \
 "
RDEPENDS:scons-doc = " \
 "
