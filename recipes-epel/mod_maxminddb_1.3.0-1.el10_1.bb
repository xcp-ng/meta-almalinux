# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_maxminddb"
PV = "1.3.0"
PR = "1.el10_1"
PACKAGES = " \
 mod_maxminddb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mod_maxminddb-1.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42c42862e011b995ddc9f4b7ad385a4b0094e845f2de3ba1d7bfb491d2e03a6a"

URI_x86_64_v2_mod_maxminddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_maxminddb-1.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_maxminddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_maxminddb}"
SRC_URI[x86_64_v2_mod_maxminddb.sha256sum] = "c920cd9418adf43e07081b90779a271ffbf7202da858e87f11a1f237e67b9dc7"

URI_aarch64_mod_maxminddb = "${EPEL_MIRROR}/aarch64/Packages/m/mod_maxminddb-1.3.0-1.el10_1.aarch64.rpm;name=aarch64_mod_maxminddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_maxminddb}"
SRC_URI[aarch64_mod_maxminddb.sha256sum] = "0eb1b08154397b8d3965481269d937205d49b1305049d965077f893a1b974fc1"

RDEPENDS:mod_maxminddb = " \
 glibc \
 httpd-core \
 libmaxminddb \
 "
