# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "can-utils"
PV = "2025.01"
PR = "3.el10_0"
PACKAGES = " \
 can-utils \
 can-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/can-utils-2025.01-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "925764be1a2ac4017fecaa32c59fa28aea3917e8e925a955c6a03e8ef5d14f80"

URI_x86_64_v2_can-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/can-utils-2025.01-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_can-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_can-utils}"
SRC_URI[x86_64_v2_can-utils.sha256sum] = "cbfface5935412e907dfc765fd20bb08a27d4842b9a61b84db7e33534bfb28c1"

URI_x86_64_v2_can-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/can-utils-devel-2025.01-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_can-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_can-utils-devel}"
SRC_URI[x86_64_v2_can-utils-devel.sha256sum] = "39980323fa973503942628518009ebfc9d926dfaa7f79426e3ebb33b3f0ff0ae"

URI_aarch64_can-utils = "${EPEL_MIRROR}/aarch64/Packages/c/can-utils-2025.01-3.el10_0.aarch64.rpm;name=aarch64_can-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_can-utils}"
SRC_URI[aarch64_can-utils.sha256sum] = "4562a2d946d8f77af06c2f4ab0997e2e943138424dc843b9eef84540c8ba97ec"

URI_aarch64_can-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/c/can-utils-devel-2025.01-3.el10_0.aarch64.rpm;name=aarch64_can-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_can-utils-devel}"
SRC_URI[aarch64_can-utils-devel.sha256sum] = "28921b1ae8dcb544c2cdf489f3588a162f082862f285c9e1fd773308ba662021"

RDEPENDS:can-utils = " \
 glibc \
 "
RDEPENDS:can-utils-devel = " \
 can-utils \
 glibc \
 "
