# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdb"
PV = "14.2"
PR = "4.1.el10_0"
PACKAGES = " \
 gdb \
 gdb-doc \
 gdb-gdbserver \
 gdb-headless \
 gdb-minimal \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdb-14.2-4.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65504fb43593dc5e768f3fc3aa6129cfc30489e4b8435597b05915b8cb1bfee4"

URI_x86_64_v2_gdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-14.2-4.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb}"
SRC_URI[x86_64_v2_gdb.sha256sum] = "ee4e35627af5c0f53a7c763a0a4129331c52af608daa524b0993bb04c13694b4"

URI_x86_64_v2_gdb-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-doc-14.2-4.1.el10_0.noarch.rpm;name=x86_64_v2_gdb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-doc}"
SRC_URI[x86_64_v2_gdb-doc.sha256sum] = "0b904a28a68facc4e7181e332ef547c737c8d246a610bb05a624722644842238"

URI_x86_64_v2_gdb-gdbserver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-gdbserver-14.2-4.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdb-gdbserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-gdbserver}"
SRC_URI[x86_64_v2_gdb-gdbserver.sha256sum] = "42648aff40cf32e5d3786404407c5539c4c20e007e99717814a650067bd00d74"

URI_x86_64_v2_gdb-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-headless-14.2-4.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdb-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-headless}"
SRC_URI[x86_64_v2_gdb-headless.sha256sum] = "7c34199832c8f1e00668992ce210762f3b22ba2e095aa6d1fdfa46234b0b5eef"
RPROVIDES:gdb-headless:x86_64_v2 = "virtual//usr/bin/gdb-add-index"

URI_x86_64_v2_gdb-minimal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-minimal-14.2-4.1.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdb-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdb-minimal}"
SRC_URI[x86_64_v2_gdb-minimal.sha256sum] = "2d68935eccbfe2e1e68bec4f343d46f1f9697bcc5f86098000b5fca6abddd62d"
RPROVIDES:gdb-minimal:x86_64_v2 = "virtual//usr/bin/gdb-add-index"

URI_aarch64_gdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-14.2-4.1.el10_0.aarch64.rpm;name=aarch64_gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb}"
SRC_URI[aarch64_gdb.sha256sum] = "95e752f7dd8f18e2d62183577cae4911895b639987e3b09088e78638a227fe78"

URI_aarch64_gdb-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-doc-14.2-4.1.el10_0.noarch.rpm;name=aarch64_gdb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-doc}"
SRC_URI[aarch64_gdb-doc.sha256sum] = "0b904a28a68facc4e7181e332ef547c737c8d246a610bb05a624722644842238"

URI_aarch64_gdb-gdbserver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-gdbserver-14.2-4.1.el10_0.aarch64.rpm;name=aarch64_gdb-gdbserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-gdbserver}"
SRC_URI[aarch64_gdb-gdbserver.sha256sum] = "c79006723ed0e0ba6cc238a046a26458bdcb61b940ad13e7b7d9ec40875212da"

URI_aarch64_gdb-headless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-headless-14.2-4.1.el10_0.aarch64.rpm;name=aarch64_gdb-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-headless}"
SRC_URI[aarch64_gdb-headless.sha256sum] = "c1fc62af767fece08c4ae8def64aa40daa3433eb90aee764ac02a5de3392a136"
RPROVIDES:gdb-headless:aarch64 = "virtual//usr/bin/gdb-add-index"

URI_aarch64_gdb-minimal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-minimal-14.2-4.1.el10_0.aarch64.rpm;name=aarch64_gdb-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdb-minimal}"
SRC_URI[aarch64_gdb-minimal.sha256sum] = "44cdc04d1e13b6d6506656f1158d21e74fa018128f1daf51dbdce49826731530"
RPROVIDES:gdb-minimal:aarch64 = "virtual//usr/bin/gdb-add-index"

RDEPENDS:gdb = " \
 bash \
 gdb-headless \
 "
RDEPENDS:gdb-doc = " \
 "
RDEPENDS:gdb-gdbserver = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gdb-headless:x86_64_v2 = " \
 bash \
 elfutils-debuginfod-client \
 expat \
 glibc \
 gmp \
 libbabeltrace \
 libgcc \
 libipt \
 libstdc++ \
 mpfr \
 ncurses-libs \
 python3-libs \
 readline \
 source-highlight \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdb-headless:aarch64 = " \
 bash \
 elfutils-debuginfod-client \
 expat \
 glibc \
 gmp \
 libbabeltrace \
 libgcc \
 libstdc++ \
 mpfr \
 ncurses-libs \
 python3-libs \
 readline \
 source-highlight \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdb-minimal = " \
 bash \
 elfutils-debuginfod-client \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 mpfr \
 ncurses-libs \
 readline \
 xz-libs \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/gdb-add-index"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/gdb-add-index"
