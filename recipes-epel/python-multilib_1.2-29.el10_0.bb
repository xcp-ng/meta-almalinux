# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-multilib"
PV = "1.2"
PR = "29.el10_0"
PACKAGES = " \
 python-multilib-conf \
 python3-multilib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-multilib-1.2-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab70889f75015595e431fe4c975990454c03c6bcba0dc31a811dcae8b6b96218"

URI_x86_64_v2_python-multilib-conf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-multilib-conf-1.2-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-multilib-conf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-multilib-conf}"
SRC_URI[x86_64_v2_python-multilib-conf.sha256sum] = "9a1739ac8fd5b63d50416dea9321c52ace2ba6ab42fa05b01ddef404112247ed"

URI_x86_64_v2_python3-multilib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-multilib-1.2-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-multilib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-multilib}"
SRC_URI[x86_64_v2_python3-multilib.sha256sum] = "3894ffe683ce0b43ae3cbb83622e12a5fcc3a72db39058fd4c4dfe255a8fa49f"

URI_aarch64_python-multilib-conf = "${EPEL_MIRROR}/aarch64/Packages/p/python-multilib-conf-1.2-29.el10_0.noarch.rpm;name=aarch64_python-multilib-conf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-multilib-conf}"
SRC_URI[aarch64_python-multilib-conf.sha256sum] = "1d64af6a149a2f6af68e43e2b64043c2281c84e46fa4142254b8c0fd6d276d93"

URI_aarch64_python3-multilib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-multilib-1.2-29.el10_0.noarch.rpm;name=aarch64_python3-multilib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-multilib}"
SRC_URI[aarch64_python3-multilib.sha256sum] = "5d0825a96b522d8b7cf774675bb9306784a4ab50138331fd39f656a9cbc28d0d"

RDEPENDS:python-multilib-conf = " \
 "
RDEPENDS:python3-multilib = " \
 python-multilib-conf \
 python3 \
 python3-six \
 "
