# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-TimeZone"
PV = "2.70"
PR = "1.el10_2"
PACKAGES = " \
 perl-DateTime-TimeZone \
 perl-DateTime-TimeZone-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-TimeZone-2.70-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "da5bcd0da82a7abb96e6c86c24e2ef8b5b1dcabecbfa589c9c1ad5b301539f24"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-2.70-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone;unpack=0"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone.sha256sum] = "b60654d6f7bb6d94af2771a107292dda30259b0fb4cbcdfb318c5d5a36ed3104"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-tests-2.70-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone-tests;unpack=0"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone-tests.sha256sum] = "23e72f659cf6f70cd8f744889dd0d32f67820d807095363aa810fb3d265b9792"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-2.70-1.el10_2.noarch.rpm;name=aarch64_perl-DateTime-TimeZone;unpack=0"
SRC_URI[aarch64_perl-DateTime-TimeZone.sha256sum] = "4478f049eb46853efecb875d11abb21b54e554a0dddfec146a4e61a0962231ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-tests-2.70-1.el10_2.noarch.rpm;name=aarch64_perl-DateTime-TimeZone-tests;unpack=0"
SRC_URI[aarch64_perl-DateTime-TimeZone-tests.sha256sum] = "a691971a9904e666bdce5b505fa30cd5e5f48732a520e361b1c90f4ba235a9a8"

RDEPENDS:perl-DateTime-TimeZone = " \
 perl-Class-Singleton \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-DateTime-TimeZone-Tzfile \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Find \
 perl-Module-Runtime \
 perl-Params-ValidationCompiler \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Specio \
 perl-Try-Tiny \
 perl-constant \
 perl-libs \
 perl-namespace-autoclean \
 perl-parent \
 "
RDEPENDS:perl-DateTime-TimeZone-tests = " \
 bash \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Output \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-Test-Taint \
 perl-Try-Tiny \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
