# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcachegrind"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kcachegrind \
 kcachegrind-converters \
 qcachegrind \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kcachegrind-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5b8418f214133be84790087a393cbe61b37fbb3f61c1dc99235b36f29d44c5e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcachegrind-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcachegrind;unpack=0"
SRC_URI[x86_64_v2_kcachegrind.sha256sum] = "df37c0e67ef3002b00ebb25074f012ce3665b107ef4cac0868998cd6ab6d3356"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcachegrind-converters-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcachegrind-converters;unpack=0"
SRC_URI[x86_64_v2_kcachegrind-converters.sha256sum] = "7e4d0c9adb01334f7aacb6bb85a3b7b7c7346a224a5036a3c105412461c6c0b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcachegrind-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcachegrind;unpack=0"
SRC_URI[x86_64_v2_qcachegrind.sha256sum] = "58807aabcd13c253eb2f24fb139330159923ac37094cb1b972221005d2d6daab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcachegrind-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kcachegrind;unpack=0"
SRC_URI[aarch64_kcachegrind.sha256sum] = "5c1e8760ba4b3ae35a68f93a37f527faf1365732f47fae624fbe0646f02d9b03"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcachegrind-converters-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kcachegrind-converters;unpack=0"
SRC_URI[aarch64_kcachegrind-converters.sha256sum] = "b73f9d8667a3332289c8d2eef6814d6e5fe188e5ae64836e257246cc020ff0de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qcachegrind-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_qcachegrind;unpack=0"
SRC_URI[aarch64_qcachegrind.sha256sum] = "b51567a81c6fe01919df378dfd6302f43b4bfeeb1cbda492f43487ae14c94423"

RDEPENDS:kcachegrind = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcachegrind-converters = " \
 kcachegrind \
 perl-Getopt-Std \
 perl-IO \
 perl-interpreter \
 perl-libs \
 python3 \
 virtual//usr/bin/php \
 "
RDEPENDS:qcachegrind = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
