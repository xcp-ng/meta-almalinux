# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-astropy"
PV = "7.0.1"
PR = "2.el10_1"
PACKAGES = " \
 astropy-tools \
 python3-astropy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-astropy-7.0.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bed26ee6b98d0b5d0f78ee16d9270bf7461ffd2fdc7d54999bbfeef8f7a995dd"

URI_x86_64_v2_astropy-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/astropy-tools-7.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_astropy-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_astropy-tools}"
SRC_URI[x86_64_v2_astropy-tools.sha256sum] = "9dd7a1e11938bac742ed6681e3d9370c62b9e74981e3878c3b90dbdf6fe344e0"

URI_x86_64_v2_python3-astropy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-astropy-7.0.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-astropy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-astropy}"
SRC_URI[x86_64_v2_python3-astropy.sha256sum] = "5febe041720e4e18070c1256aca0654c85b3a665eecfb03fd93aa10de757af8c"

URI_aarch64_astropy-tools = "${EPEL_MIRROR}/aarch64/Packages/a/astropy-tools-7.0.1-2.el10_1.noarch.rpm;name=aarch64_astropy-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_astropy-tools}"
SRC_URI[aarch64_astropy-tools.sha256sum] = "c2be5461786cabe8829733a8fd8b399b36e3a0c746bdd4ae3a0304f194d15cdf"

URI_aarch64_python3-astropy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-astropy-7.0.1-2.el10_1.aarch64.rpm;name=aarch64_python3-astropy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-astropy}"
SRC_URI[aarch64_python3-astropy.sha256sum] = "dbdab3957111b9e0d8f169690cd0da666d08a2303e5e397a5216714243ea9e18"

RDEPENDS:astropy-tools = " \
 python3 \
 python3-astropy \
 "
RDEPENDS:python3-astropy = " \
 expat \
 glibc \
 python3 \
 python3-astropy-iers-data \
 python3-configobj \
 python3-numpy \
 python3-packaging \
 python3-ply \
 python3-pyerfa \
 python3-pyyaml \
 wcslib \
 "
