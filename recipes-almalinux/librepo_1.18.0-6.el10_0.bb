# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librepo"
PV = "1.18.0"
PR = "6.el10_0"
PACKAGES = " \
 librepo \
 librepo-devel \
 python3-librepo \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/librepo-1.18.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28074465c1375d3505350ef4dc87cb5cdad0744262f0f121a9472ab491814097"

URI_x86_64_v2_librepo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librepo-1.18.0-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_librepo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librepo}"
SRC_URI[x86_64_v2_librepo.sha256sum] = "b008f1175dec61514a5e0766524c3de5dd94965d390d43ee79557a46e87bec31"

URI_x86_64_v2_librepo-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/librepo-devel-1.18.0-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_librepo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librepo-devel}"
SRC_URI[x86_64_v2_librepo-devel.sha256sum] = "a9949556b37a8974117b642a6b66780c237ac251f4b2e81e1340fd991f61bdc3"

URI_x86_64_v2_python3-librepo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-librepo-1.18.0-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-librepo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-librepo}"
SRC_URI[x86_64_v2_python3-librepo.sha256sum] = "ff2448292a4f314ec9bf5614014b20f195784c8011bcc126661fb9c9b0cef3f2"

URI_aarch64_librepo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librepo-1.18.0-6.el10_0.aarch64.rpm;name=aarch64_librepo;unpack=0"
SRC_URI:append = " ${URI_aarch64_librepo}"
SRC_URI[aarch64_librepo.sha256sum] = "61181e06a645d31c5a132eb47d993d09f64a235ed1f33d7e2b2cddcd8e9cc6b4"

URI_aarch64_librepo-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/librepo-devel-1.18.0-6.el10_0.aarch64.rpm;name=aarch64_librepo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librepo-devel}"
SRC_URI[aarch64_librepo-devel.sha256sum] = "0f297dbc47661e7cf2dfcf079de23efc4c56f6ea07ff4f8d6477c9a00c69de86"

URI_aarch64_python3-librepo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-librepo-1.18.0-6.el10_0.aarch64.rpm;name=aarch64_python3-librepo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-librepo}"
SRC_URI[aarch64_python3-librepo.sha256sum] = "6e87f7200d6b94f61762dc7ff36cd4e20c3bfa88582c4510b96b0d938dd7894e"

RDEPENDS:librepo:x86_64_v2 = " \
 glib2 \
 glibc \
 libgcc \
 libxml2 \
 openssl-libs \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_7.52.0 \
"
RDEPENDS:librepo:aarch64 = " \
 glib2 \
 glibc \
 libgcc \
 libxml2 \
 openssl-libs \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_7.52.0 \
"
RDEPENDS:librepo-devel = " \
 glib2-devel \
 libcurl-devel \
 librepo \
 libxml2-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-librepo = " \
 glib2 \
 glibc \
 libgcc \
 librepo \
 python3 \
 python3-libs \
 "
