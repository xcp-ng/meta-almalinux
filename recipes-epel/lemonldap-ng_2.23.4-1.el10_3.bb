# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lemonldap-ng"
PV = "2.23.4"
PR = "1.el10_3"
PACKAGES = " \
 lemonldap-ng \
 lemonldap-ng-common \
 lemonldap-ng-doc \
 lemonldap-ng-fastcgi-server \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 lemonldap-ng-selinux \
 lemonldap-ng-test \
 lemonldap-ng-uwsgi-app \
 perl-Lemonldap-NG-SSOaaS-Apache-Client \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lemonldap-ng-2.23.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1f3f53749caf72466316476c94c1872f73b73d2553ac6e3dcb4f9e42da665330"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng.sha256sum] = "087864129f0bf6c93d776ab2ba22ba4f1deffd497c65eaa4d717180732740a47"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-common-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-common;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-common.sha256sum] = "87fbd5d5a7c351fa5528222d76f8f4775cbd74bb128928d54fe020e463f5e550"
RPROVIDES:lemonldap-ng-common:append:x86_64_v2 = " virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-doc-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-doc;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-doc.sha256sum] = "14d35509378847af52549748c69bdf26b8d6b2f5ad75af6ea443df4f5a346669"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-fastcgi-server-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-fastcgi-server;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-fastcgi-server.sha256sum] = "8bf2da2fa07bdf463c0be9d618aeb070058de83bebeb2d28a8e337a04fbb7300"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-handler-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-handler;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-handler.sha256sum] = "29596a6d0a2b4cbc102a8cf8d40fc5f97d47f858dcc3717a5a6ed175f04e1c1a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-manager-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-manager;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-manager.sha256sum] = "79268ae58259bfaa54631e9f3e3ba6359d638052c30de65a401612544ec8b502"
RPROVIDES:lemonldap-ng-manager:append:x86_64_v2 = " virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-portal-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-portal;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-portal.sha256sum] = "5e4cad289ceb30de64e624129bb68c06ec141ade584e6b496bdd547680a612dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-selinux-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-selinux;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-selinux.sha256sum] = "ec15c0d4014ab0944c35b9dfdc79883184d39467cddb06774d5efa17b502e792"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-test-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-test;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-test.sha256sum] = "98e9189a5a35481732f4a58b258e847f8ee2bee350a5082d8ac49b7dee5368ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-uwsgi-app-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-uwsgi-app;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-uwsgi-app.sha256sum] = "199d1f3cb0360656554aec144ba1b6d10eb0d8da3749aff16fe96b1c48b503be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lemonldap-NG-SSOaaS-Apache-Client-2.23.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client;unpack=0"
SRC_URI[x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client.sha256sum] = "7d72743f20a2ca935572fa043c5a542b7f7405faeffd16cc18a82943fc0591cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-2.23.4-1.el10_3.noarch.rpm;name=aarch64_lemonldap-ng;unpack=0"
SRC_URI[aarch64_lemonldap-ng.sha256sum] = "080d916b4eca6a13e9c87e433e8f6abaf3d837e80e41fc16af8e52eda59843e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-common-2.23.4-1.el10_3.noarch.rpm;name=aarch64_lemonldap-ng-common;unpack=0"
SRC_URI[aarch64_lemonldap-ng-common.sha256sum] = "5e768dcd6505907af5c38818a59de83968c0d64e0317e1ec2de85b13b2488af8"
RPROVIDES:lemonldap-ng-common:append:aarch64 = " virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-doc-2.23.4-1.el10_3.noarch.rpm;name=aarch64_lemonldap-ng-doc;unpack=0"
SRC_URI[aarch64_lemonldap-ng-doc.sha256sum] = "2fc32beeb6008f570448efc0ffb8ebbc2f444ad4f516208ed41e1af4168b1895"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-fastcgi-server-2.23.4-1.el10_3.noarch.rpm;name=aarch64_lemonldap-ng-fastcgi-server;unpack=0"
SRC_URI[aarch64_lemonldap-ng-fastcgi-server.sha256sum] = "7610a0c5e928ad148435178c6e4799596b0005bd9b5f42370e50ad588e100d57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-handler-2.23.4-1.el10_3.noarch.rpm;name=aarch64_lemonldap-ng-handler;unpack=0"
SRC_URI[aarch64_lemonldap-ng-handler.sha256sum] = "e6165944701a365c1775423fe535e10923a61988889c84e03219d9d4a44e16b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-manager-2.23.4-1.el10_3.noarch.rpm;name=aarch64_lemonldap-ng-manager;unpack=0"
SRC_URI[aarch64_lemonldap-ng-manager.sha256sum] = "46bf8e5d178a04538dd56f7eb0b89948279c05df42d92be61d008a767b693f97"
RPROVIDES:lemonldap-ng-manager:append:aarch64 = " virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-portal-2.23.4-1.el10_3.noarch.rpm;name=aarch64_lemonldap-ng-portal;unpack=0"
SRC_URI[aarch64_lemonldap-ng-portal.sha256sum] = "2fcbf7004476abeef8803c27a09ec68056d39fb396194c9a5f28c15d207f171b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-selinux-2.23.4-1.el10_3.noarch.rpm;name=aarch64_lemonldap-ng-selinux;unpack=0"
SRC_URI[aarch64_lemonldap-ng-selinux.sha256sum] = "cc4dbdc912730236c0c55e7175548ea37827a1d5230973c65e0b6053d9dabe37"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-test-2.23.4-1.el10_3.noarch.rpm;name=aarch64_lemonldap-ng-test;unpack=0"
SRC_URI[aarch64_lemonldap-ng-test.sha256sum] = "3e9391f9e8be9452b178f0415c3f28b479931e4be1f8f765bb39cd247d127c08"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-uwsgi-app-2.23.4-1.el10_3.noarch.rpm;name=aarch64_lemonldap-ng-uwsgi-app;unpack=0"
SRC_URI[aarch64_lemonldap-ng-uwsgi-app.sha256sum] = "825d498df292b4b22815714e7227b4f73d52b19632e7d4d6c2316691e805f222"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Lemonldap-NG-SSOaaS-Apache-Client-2.23.4-1.el10_3.noarch.rpm;name=aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client;unpack=0"
SRC_URI[aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client.sha256sum] = "6816c1c2c8d42ace482325ea819093cbf5e1f9cdaf25978e42af13677736f307"

RDEPENDS:lemonldap-ng = " \
 lemonldap-ng-common \
 lemonldap-ng-doc \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 lemonldap-ng-selinux \
 lemonldap-ng-test \
 "
RDEPENDS:lemonldap-ng-common = " \
 bash \
 httpd-filesystem \
 lemonldap-ng-common \
 mod_fcgid \
 mod_perl \
 nginx-filesystem \
 perl-Apache-Session \
 perl-Apache-Session-Browseable \
 perl-AutoLoader \
 perl-Cache-Cache \
 perl-Config-IniFiles \
 perl-Convert-Base32 \
 perl-Convert-PEM \
 perl-Crypt-OpenSSL-RSA \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-Rijndael \
 perl-Crypt-URandom \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Email-Date-Format \
 perl-Email-Sender \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-HTML-Template \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-IO-String \
 perl-JSON \
 perl-JSON-XS \
 perl-LDAP \
 perl-Log-Log4perl \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mouse \
 perl-Net-CIDR \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Plack \
 perl-Pod-Usage \
 perl-Protocol-WebSocket \
 perl-SOAP-Lite \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Sentry-Raven \
 perl-String-Random \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-TimeDate \
 perl-URI \
 perl-XML-LibXML \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 virtual/httpd_or_nginx \
 virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_ \
 "
RDEPENDS:lemonldap-ng-doc = " \
 lemonldap-ng-common \
 "
RDEPENDS:lemonldap-ng-fastcgi-server = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 mod_fcgid \
 perl-FCGI-ProcManager \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Plack \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-handler = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 mod_perl \
 perl-Apache-Session \
 perl-AutoLoader \
 perl-Cache-Memcached \
 perl-Digest-SHA \
 perl-Exporter \
 perl-Getopt-Std \
 perl-HTTP-Message \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Mouse \
 perl-Plack \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-URI \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-manager = " \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 perl-Crypt-URandom \
 perl-Data-Dumper \
 perl-English \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-Hash-Merge-Simple \
 perl-Hash-MultiValue \
 perl-IO-String \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Mouse \
 perl-POSIX \
 perl-PathTools \
 perl-Plack-Handler-FCGI \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-Regexp-Common \
 perl-Safe \
 perl-Storable \
 perl-URI \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-portal = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-portal \
 perl-Authen-PAM \
 perl-Authen-Radius \
 perl-Cache-Cache \
 perl-Carp \
 perl-Clone \
 perl-Crypt-JWT \
 perl-Crypt-OpenSSL-RSA \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-URandom \
 perl-DBI \
 perl-DateTime-Format-RFC3339 \
 perl-Digest-SHA \
 perl-Email-Date-Format \
 perl-Email-Sender \
 perl-Encode \
 perl-Exporter \
 perl-File-Temp \
 perl-GD-SecurityImage \
 perl-GSSAPI \
 perl-Getopt-Long \
 perl-HTML-FormatText-WithLinks \
 perl-HTML-Parser \
 perl-HTML-Template \
 perl-HTTP-Message \
 perl-Hash-MultiValue \
 perl-IO-Socket-Timeout \
 perl-IO-String \
 perl-IPC-Run \
 perl-JSON \
 perl-LDAP \
 perl-List-MoreUtils \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mouse \
 perl-Net-CIDR \
 perl-Net-OpenID-Server \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Plack-Handler-FCGI \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-SOAP-Lite \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-String-Random \
 perl-Text-Unidecode \
 perl-Time-Local \
 perl-TimeDate \
 perl-URI \
 perl-Web-ID \
 perl-XML-LibXML \
 perl-XML-LibXSLT \
 perl-base \
 perl-constant \
 perl-fields \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:lemonldap-ng-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:lemonldap-ng-test = " \
 lemonldap-ng-common \
 perl-CGI \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-JSON \
 perl-MIME-Base64 \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:lemonldap-ng-uwsgi-app = " \
 uwsgi-plugin-psgi \
 "
RDEPENDS:perl-Lemonldap-NG-SSOaaS-Apache-Client = " \
 perl-FCGI-Client \
 perl-IO \
 perl-URI \
 perl-constant \
 perl-libs \
 "
