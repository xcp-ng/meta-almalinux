# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mosh"
PV = "1.4.0"
PR = "7.el10_0"
PACKAGES = " \
 mosh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mosh-1.4.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f9996b7bd2d24cd026da3322bfe88479172e47628feceda54610279549e7237"

URI_x86_64_v2_mosh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mosh-1.4.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mosh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mosh}"
SRC_URI[x86_64_v2_mosh.sha256sum] = "69a4efc74b10a667e3899f40b87c6a6d0942e66c6ec23c5ef173a513fe8b7ab1"

URI_aarch64_mosh = "${EPEL_MIRROR}/aarch64/Packages/m/mosh-1.4.0-7.el10_0.aarch64.rpm;name=aarch64_mosh;unpack=0"
SRC_URI:append = " ${URI_aarch64_mosh}"
SRC_URI[aarch64_mosh.sha256sum] = "53d905db922172075fb28368e2caef46c36f0e1ffcf42b464b170620f9ab4f22"

RDEPENDS:mosh = " \
 glibc \
 libgcc \
 libstdc++ \
 libutempter \
 ncurses-libs \
 openssh-clients \
 openssl \
 openssl-libs \
 perl-Errno \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Socket-IP \
 perl-POSIX \
 perl-Socket \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-libs \
 protobuf \
 zlib-ng-compat \
 "
