# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DynaLoader-Functions"
PV = "0.004"
PR = "5.el10_0"
PACKAGES = " \
 perl-DynaLoader-Functions \
 perl-DynaLoader-Functions-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DynaLoader-Functions-0.004-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0475e346ea4e597e9d8f6ed23da274e91c637dc5277a750a7fc29270261a8803"

URI_x86_64_v2_perl-DynaLoader-Functions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DynaLoader-Functions-0.004-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DynaLoader-Functions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DynaLoader-Functions}"
SRC_URI[x86_64_v2_perl-DynaLoader-Functions.sha256sum] = "652d1b268fba6e1d411e763355d1e7519f81abeee42a18e172bb94cfebe3e103"

URI_x86_64_v2_perl-DynaLoader-Functions-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DynaLoader-Functions-tests-0.004-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DynaLoader-Functions-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DynaLoader-Functions-tests}"
SRC_URI[x86_64_v2_perl-DynaLoader-Functions-tests.sha256sum] = "72e017e8187a3541d330f71b4d9fe44bf08a609c05e80348df70ad96c0e74fd9"

URI_aarch64_perl-DynaLoader-Functions = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DynaLoader-Functions-0.004-5.el10_0.noarch.rpm;name=aarch64_perl-DynaLoader-Functions;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DynaLoader-Functions}"
SRC_URI[aarch64_perl-DynaLoader-Functions.sha256sum] = "f784290e8fee98d81dea18499a644cc89f5b5646c9473229a02d3abf4de72ba0"

URI_aarch64_perl-DynaLoader-Functions-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DynaLoader-Functions-tests-0.004-5.el10_0.noarch.rpm;name=aarch64_perl-DynaLoader-Functions-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DynaLoader-Functions-tests}"
SRC_URI[aarch64_perl-DynaLoader-Functions-tests.sha256sum] = "eb37c8fe36de897128d550900166dd9aad695c4476f464499c82d7e36740f695"

RDEPENDS:perl-DynaLoader-Functions = " \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-DynaLoader-Functions-tests = " \
 bash \
 perl-DynaLoader-Functions \
 perl-ExtUtils-CBuilder \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 virtual/coreutils \
 "
