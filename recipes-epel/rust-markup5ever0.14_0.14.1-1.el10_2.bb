# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-markup5ever0.14"
PV = "0.14.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-markup5ever0.14+default-devel \
 rust-markup5ever0.14-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-markup5ever0.14-0.14.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e47082660b8d23a371b20a022b0922ddbb388dd1fc5ecfff2fb2b402dc2b23c"

URI_x86_64_v2_rust-markup5ever0.14+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever0.14+default-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever0.14+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever0.14+default-devel}"
SRC_URI[x86_64_v2_rust-markup5ever0.14+default-devel.sha256sum] = "2055147fb303e40961ecf794ae2ca71af6d7d28c0354de11b90b89da11b28e48"

URI_x86_64_v2_rust-markup5ever0.14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever0.14-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever0.14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever0.14-devel}"
SRC_URI[x86_64_v2_rust-markup5ever0.14-devel.sha256sum] = "abb8e024406adf81cf54081351f0f2da8faaf7a5f239d9170605a0078711fae1"

URI_aarch64_rust-markup5ever0.14+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever0.14+default-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-markup5ever0.14+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever0.14+default-devel}"
SRC_URI[aarch64_rust-markup5ever0.14+default-devel.sha256sum] = "dffe303e1e67b2e196b43032ed8cab4cb81c610a4d13d2439a8de3e5ecce7ac4"

URI_aarch64_rust-markup5ever0.14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever0.14-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-markup5ever0.14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever0.14-devel}"
SRC_URI[aarch64_rust-markup5ever0.14-devel.sha256sum] = "0ba526c6efde154bcf2e83eadc08987c0ddf906e3d4779bb8c2a9db6f327bfdd"

RDEPENDS:rust-markup5ever0.14+default-devel = " \
 cargo \
 rust-markup5ever0.14-devel \
 "
RDEPENDS:rust-markup5ever0.14-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-phf0.11+default-devel \
 rust-phf_codegen0.11+default-devel \
 rust-string_cache0.8+default-devel \
 rust-string_cache_codegen0.5+default-devel \
 rust-tendril0.4+default-devel \
 "
