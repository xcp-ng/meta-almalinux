# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluechi"
PV = "1.2.2"
PR = "1.el10_1"
PACKAGES = " \
 bluechi-agent \
 bluechi-controller \
 bluechi-ctl \
 bluechi-is-online \
 bluechi-selinux \
 python3-bluechi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bluechi-1.2.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2cfed863dac221c45ec351dd2aadffe7a065d337313e63c21b0ad83d08835a7"

URI_x86_64_v2_bluechi-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-agent-1.2.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-agent}"
SRC_URI[x86_64_v2_bluechi-agent.sha256sum] = "166bafab1782edd0889a2362e43f952d4cc6a76aa88c927b00dd771bfeb6f937"

URI_x86_64_v2_bluechi-controller = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-controller-1.2.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-controller;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-controller}"
SRC_URI[x86_64_v2_bluechi-controller.sha256sum] = "e5eeec234cfe3bfadbe42a3d643a1b11e10723f50dba6e3a222685686c319925"

URI_x86_64_v2_bluechi-ctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-ctl-1.2.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-ctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-ctl}"
SRC_URI[x86_64_v2_bluechi-ctl.sha256sum] = "96289def1f108d1de8f93bddc2237bda71b80d8dc9d984867fe95bcdc244bfde"

URI_x86_64_v2_bluechi-is-online = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-is-online-1.2.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-is-online;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-is-online}"
SRC_URI[x86_64_v2_bluechi-is-online.sha256sum] = "667634cc3f2634c38d970f37f4e943757cff66c17573702f5e5801ccb70eeb48"

URI_x86_64_v2_bluechi-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-selinux-1.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_bluechi-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-selinux}"
SRC_URI[x86_64_v2_bluechi-selinux.sha256sum] = "6306bbe6c20d3b9646e9b9f8b42fcff23739156b60ce6e763938f8d55b5b8d51"

URI_x86_64_v2_python3-bluechi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bluechi-1.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-bluechi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bluechi}"
SRC_URI[x86_64_v2_python3-bluechi.sha256sum] = "d216f45880ba090f1e3485e759c751256a541e7df69e36ac04c917325fd66e53"

URI_aarch64_bluechi-agent = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-agent-1.2.2-1.el10_1.aarch64.rpm;name=aarch64_bluechi-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-agent}"
SRC_URI[aarch64_bluechi-agent.sha256sum] = "8a847afa927c0345cf5ce693a7591f9a4aa685d1ec1b3d1c27649ebec8bc3766"

URI_aarch64_bluechi-controller = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-controller-1.2.2-1.el10_1.aarch64.rpm;name=aarch64_bluechi-controller;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-controller}"
SRC_URI[aarch64_bluechi-controller.sha256sum] = "57b860ab1d892a63a19b1a613879ad83b794fb4cc4ee9c082753e1611dc67c60"

URI_aarch64_bluechi-ctl = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-ctl-1.2.2-1.el10_1.aarch64.rpm;name=aarch64_bluechi-ctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-ctl}"
SRC_URI[aarch64_bluechi-ctl.sha256sum] = "ee949f5710fa17bf5d537d2ed47c8698a8e86039fee27d7654046dfefd254dc5"

URI_aarch64_bluechi-is-online = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-is-online-1.2.2-1.el10_1.aarch64.rpm;name=aarch64_bluechi-is-online;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-is-online}"
SRC_URI[aarch64_bluechi-is-online.sha256sum] = "db48a48b92cdad669cffc6ce5160148cca83c5a9efa940679750d471b2fd7155"

URI_aarch64_bluechi-selinux = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-selinux-1.2.2-1.el10_1.noarch.rpm;name=aarch64_bluechi-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-selinux}"
SRC_URI[aarch64_bluechi-selinux.sha256sum] = "6d484092e64a4fa26f83c1c076c94093a2bbc55db64bb3d70827fc8ab3c25a69"

URI_aarch64_python3-bluechi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bluechi-1.2.2-1.el10_1.noarch.rpm;name=aarch64_python3-bluechi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bluechi}"
SRC_URI[aarch64_python3-bluechi.sha256sum] = "6f710c450954881a41644a6d2ea7f7b8c9a9f70b969924f836f9054af13c2e85"

RDEPENDS:bluechi-agent = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluechi-controller = " \
 bash \
 glibc \
 libgcc \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluechi-ctl = " \
 bluechi-controller \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:bluechi-is-online = " \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:bluechi-selinux = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.7 \
 "
RDEPENDS:python3-bluechi = " \
 python3 \
 python3-dasbus \
 "
