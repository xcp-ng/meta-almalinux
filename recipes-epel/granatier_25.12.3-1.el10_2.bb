# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "granatier"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 granatier \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/granatier-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac9bdb3502283b358153e2ce6364296da457cbef690d0a67c556dadbb2d55476"

URI_x86_64_v2_granatier = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/granatier-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_granatier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_granatier}"
SRC_URI[x86_64_v2_granatier.sha256sum] = "9d126cc2ca50985bfe684fca4452adc24ce83989fb7764a0a0d0a81f94abab20"

URI_aarch64_granatier = "${EPEL_MIRROR}/aarch64/Packages/g/granatier-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_granatier;unpack=0"
SRC_URI:append = " ${URI_aarch64_granatier}"
SRC_URI[aarch64_granatier.sha256sum] = "a0639dcdfe364b28b37833f8f708fdbd5b7564d9358fd34d124dc9cf7783a16d"

RDEPENDS:granatier = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
