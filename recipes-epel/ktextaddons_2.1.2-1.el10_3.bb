# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktextaddons"
PV = "2.1.2"
PR = "1.el10_3"
PACKAGES = " \
 ktextaddons-common \
 ktextaddons-qt6 \
 ktextaddons-qt6-devel \
 ktextaddons-qt6-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ktextaddons-2.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "33eab8b09a862218e505f6611a2a9500914664014b67e7724e61dc258a2e563f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-common-2.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ktextaddons-common;unpack=0"
SRC_URI[x86_64_v2_ktextaddons-common.sha256sum] = "bfb1a607e20f1f652b45cf96e8a838f9fb0a4a9b88ace71f4247774ebba2830f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-2.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktextaddons-qt6;unpack=0"
SRC_URI[x86_64_v2_ktextaddons-qt6.sha256sum] = "8fd74cac6f5b191ec9ca045879810e168ff5ce210f25dba50a57e9c720df1598"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-devel-2.1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktextaddons-qt6-devel;unpack=0"
SRC_URI[x86_64_v2_ktextaddons-qt6-devel.sha256sum] = "63041b8ce1815788f914455f7e8dd1f08f1536fed194db0b0c68059d3554471b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-doc-2.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ktextaddons-qt6-doc;unpack=0"
SRC_URI[x86_64_v2_ktextaddons-qt6-doc.sha256sum] = "0a73ec75f8d8fc24407d1ed7c5630b076cb70d8eb0816844c4224125a1a9721c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-common-2.1.2-1.el10_3.noarch.rpm;name=aarch64_ktextaddons-common;unpack=0"
SRC_URI[aarch64_ktextaddons-common.sha256sum] = "9091348ddc8e16114bb3d7742853de99eeab58a861da16922109c545d388b74e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-2.1.2-1.el10_3.aarch64.rpm;name=aarch64_ktextaddons-qt6;unpack=0"
SRC_URI[aarch64_ktextaddons-qt6.sha256sum] = "7cf70c681a724194ad72bdb798b95cc017fe5be3030f7f6a239e9e25b069d606"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-devel-2.1.2-1.el10_3.aarch64.rpm;name=aarch64_ktextaddons-qt6-devel;unpack=0"
SRC_URI[aarch64_ktextaddons-qt6-devel.sha256sum] = "1ff1728ad1f208efae90c687ca9709c9245f5c1d2723c40f047d50fab0620f05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-doc-2.1.2-1.el10_3.noarch.rpm;name=aarch64_ktextaddons-qt6-doc;unpack=0"
SRC_URI[aarch64_ktextaddons-qt6-doc.sha256sum] = "c272d654a45c3f12f291f3807b96c44ac400da73bd0fa9e4b701b5ffbbc126e2"

RDEPENDS:ktextaddons-common = " \
 "
RDEPENDS:ktextaddons-qt6 = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-common \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 qtkeychain-qt6 \
 "
RDEPENDS:ktextaddons-qt6-devel = " \
 cmake-filesystem \
 glibc \
 kf6-ki18n \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:ktextaddons-qt6-doc = " \
 "
