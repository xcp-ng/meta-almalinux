# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cty"
PV = "0.2.2"
PR = "10.el10_0"
PACKAGES = " \
 rust-cty+default-devel \
 rust-cty-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cty-0.2.2-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90956b271b945418b94963ac817c41b5dfde89991a6bd75678626ca3b55f8033"

URI_x86_64_v2_rust-cty+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cty+default-devel-0.2.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cty+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cty+default-devel}"
SRC_URI[x86_64_v2_rust-cty+default-devel.sha256sum] = "d769680a208665db127bc02d090d4cbe59305a4eaac3abb20cdd4f1fb99cc906"

URI_x86_64_v2_rust-cty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cty-devel-0.2.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cty-devel}"
SRC_URI[x86_64_v2_rust-cty-devel.sha256sum] = "70e94dd72e6f2e5a084d45d8163b923cce47771cceffee79bb6fc2b86ae6a8bd"

URI_aarch64_rust-cty+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cty+default-devel-0.2.2-10.el10_0.noarch.rpm;name=aarch64_rust-cty+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cty+default-devel}"
SRC_URI[aarch64_rust-cty+default-devel.sha256sum] = "d17b40a9edae5c3179ac00eae0aa462f31ab71e437976a88e6360b2fb71f97a6"

URI_aarch64_rust-cty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cty-devel-0.2.2-10.el10_0.noarch.rpm;name=aarch64_rust-cty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cty-devel}"
SRC_URI[aarch64_rust-cty-devel.sha256sum] = "bc57f7e0251945a5645e86528d7e1956ab51541240f6e638cee7041118feb7e0"

RDEPENDS:rust-cty+default-devel = " \
 cargo \
 rust-cty-devel \
 "
RDEPENDS:rust-cty-devel = " \
 cargo \
 "
