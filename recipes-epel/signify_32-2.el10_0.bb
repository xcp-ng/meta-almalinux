# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signify"
PV = "32"
PR = "2.el10_0"
PACKAGES = " \
 signify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/signify-32-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ad55f8be18e808a6f917da92aa90a43ed17a4198be2819a07d24b1e607ef920"

URI_x86_64_v2_signify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signify-32-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signify}"
SRC_URI[x86_64_v2_signify.sha256sum] = "f7e95a3799de9b7f4c51129adefd389cac0ebedf2e3fb30b6ab6262aa0770f2a"

URI_aarch64_signify = "${EPEL_MIRROR}/aarch64/Packages/s/signify-32-2.el10_0.aarch64.rpm;name=aarch64_signify;unpack=0"
SRC_URI:append = " ${URI_aarch64_signify}"
SRC_URI[aarch64_signify.sha256sum] = "6cc0d9523e30c5629ac751aae1d20a362831d42eea3551425ee5550f757c3b76"

RDEPENDS:signify = " \
 glibc \
 libbsd \
 "
