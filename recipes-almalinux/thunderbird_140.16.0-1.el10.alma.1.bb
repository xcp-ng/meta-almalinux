# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thunderbird"
PV = "140.16.0"
PR = "1.el10.alma.1"
PACKAGES = " \
 thunderbird \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/thunderbird-140.16.0-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8000c6d6d778805bdf2392288b1f4bdd3f1d935c42307b562ff747180cd55445"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/thunderbird-140.16.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_thunderbird;unpack=0"
SRC_URI[x86_64_v2_thunderbird.sha256sum] = "e1db72531a6bf7e8ea3a3280810ffad908e10be7dc28216d930fde860a66348e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/thunderbird-140.16.0-1.el10.alma.1.aarch64.rpm;name=aarch64_thunderbird;unpack=0"
SRC_URI[aarch64_thunderbird.sha256sum] = "721434910a11d9e6d076d4f78bf7056993889ee867bae0383bf4c03336bd504f"

RDEPENDS:thunderbird = " \
 alsa-lib \
 atk \
 bash \
 bzip2-libs \
 cairo \
 cairo-gobject \
 dbus-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libffi \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libxcb \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 p11-kit-trust \
 pango \
 pciutils-libs \
 zlib-ng-compat \
 "
