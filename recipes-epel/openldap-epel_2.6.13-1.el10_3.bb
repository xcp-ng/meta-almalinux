# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openldap-epel"
PV = "2.6.13"
PR = "1.el10_3"
PACKAGES = " \
 openldap-servers \
 openldap-slapi \
 openldap-slapi-compat \
 openldap-slapi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openldap-epel-2.6.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5186c0fc6ae0ff2b6f4589487222b810f771e09bb2d9536dba52aec7aa55b73"

URI_x86_64_v2_openldap-servers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-servers-2.6.13-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-servers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-servers}"
SRC_URI[x86_64_v2_openldap-servers.sha256sum] = "a33d192fda2f607cf3830fd184eb5fbcd36e3385557653266f5288f8d4ff446a"

URI_x86_64_v2_openldap-slapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-2.6.13-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-slapi}"
SRC_URI[x86_64_v2_openldap-slapi.sha256sum] = "7588b3c3dfeb719a63d78ebc2178802e426999f4807d0c1d2655207e0c903e85"

URI_x86_64_v2_openldap-slapi-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-compat-2.6.13-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-slapi-compat}"
SRC_URI[x86_64_v2_openldap-slapi-compat.sha256sum] = "f02aa61ed8f67f39bac316a59af7d2cc4e077f23f15b6b65ac5d72ff6b6f834a"

URI_x86_64_v2_openldap-slapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-devel-2.6.13-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-slapi-devel}"
SRC_URI[x86_64_v2_openldap-slapi-devel.sha256sum] = "f667d2419165244c4b68a2a9903cf7b6b2a1b837fb81175c1d5a477db16b8042"

URI_aarch64_openldap-servers = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-servers-2.6.13-1.el10_3.aarch64.rpm;name=aarch64_openldap-servers;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-servers}"
SRC_URI[aarch64_openldap-servers.sha256sum] = "6bc0414211f53408b82a1da216ab4f1edaeda8f46ebcc75941586f017184ff01"

URI_aarch64_openldap-slapi = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-2.6.13-1.el10_3.aarch64.rpm;name=aarch64_openldap-slapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-slapi}"
SRC_URI[aarch64_openldap-slapi.sha256sum] = "05ed6f36269bf0bfd3f3c24042545624bab127267097918745e0d0c499661008"

URI_aarch64_openldap-slapi-compat = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-compat-2.6.13-1.el10_3.aarch64.rpm;name=aarch64_openldap-slapi-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-slapi-compat}"
SRC_URI[aarch64_openldap-slapi-compat.sha256sum] = "4fa7a16010b5ede7a18ef1c6860b57d2f96c980d4c841796eae69c3f61d7e4b1"

URI_aarch64_openldap-slapi-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-devel-2.6.13-1.el10_3.aarch64.rpm;name=aarch64_openldap-slapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-slapi-devel}"
SRC_URI[aarch64_openldap-slapi-devel.sha256sum] = "a802e438ee89265f783c97956e5612454fec7b62b0999a7bac8930deb428d2d5"

RDEPENDS:openldap-servers = " \
 bash \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 libevent \
 libgcc \
 libtool-ltdl \
 libxcrypt \
 openldap \
 openldap-slapi \
 openssl-libs \
 perl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:openldap-slapi = " \
 glibc \
 libtool-ltdl \
 "
RDEPENDS:openldap-slapi-compat = " \
 glibc \
 openldap-slapi \
 "
RDEPENDS:openldap-slapi-devel = " \
 openldap-devel \
 openldap-slapi \
 "
