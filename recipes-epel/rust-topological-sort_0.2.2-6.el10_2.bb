# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-topological-sort"
PV = "0.2.2"
PR = "6.el10_2"
PACKAGES = " \
 rust-topological-sort+default-devel \
 rust-topological-sort-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-topological-sort-0.2.2-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0eccaed674c36338c44661d872e76f5397be7b42fe20180a3f405e78079578d"

URI_x86_64_v2_rust-topological-sort+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-topological-sort+default-devel-0.2.2-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-topological-sort+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-topological-sort+default-devel}"
SRC_URI[x86_64_v2_rust-topological-sort+default-devel.sha256sum] = "2cff21a862819b5c7892f2a9128809f0a8ea127e9213b8f1becd74294395a011"

URI_x86_64_v2_rust-topological-sort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-topological-sort-devel-0.2.2-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-topological-sort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-topological-sort-devel}"
SRC_URI[x86_64_v2_rust-topological-sort-devel.sha256sum] = "a38c1e32293b2991a9ccfdbef6245323aed30812e245cdba7f38750e11de6b95"

URI_aarch64_rust-topological-sort+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-topological-sort+default-devel-0.2.2-6.el10_2.noarch.rpm;name=aarch64_rust-topological-sort+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-topological-sort+default-devel}"
SRC_URI[aarch64_rust-topological-sort+default-devel.sha256sum] = "b0c191737bd17576fc755565cc60ef20b980fea3ea7ad25ae39bd68ae7a4b73d"

URI_aarch64_rust-topological-sort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-topological-sort-devel-0.2.2-6.el10_2.noarch.rpm;name=aarch64_rust-topological-sort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-topological-sort-devel}"
SRC_URI[aarch64_rust-topological-sort-devel.sha256sum] = "3ad8709ccd5826dc025e01fd33f7445a73c5cd60e8757f277b0ebc3f1e37038e"

RDEPENDS:rust-topological-sort+default-devel = " \
 cargo \
 rust-topological-sort-devel \
 "
RDEPENDS:rust-topological-sort-devel = " \
 cargo \
 rust \
 "
