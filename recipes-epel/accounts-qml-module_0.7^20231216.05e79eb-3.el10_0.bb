# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accounts-qml-module"
PV = "0.7^20231216.05e79eb"
PR = "3.el10_0"
PACKAGES = " \
 accounts-qml-module-doc \
 accounts-qml-module-qt5 \
 accounts-qml-module-qt6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/accounts-qml-module-0.7^20231216.05e79eb-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b289215fbc0b2283f06f03ad467ea7f98fe133d8345f8b789a96cb65f84d0b9"

URI_x86_64_v2_accounts-qml-module-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/accounts-qml-module-doc-0.7^20231216.05e79eb-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_accounts-qml-module-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accounts-qml-module-doc}"
SRC_URI[x86_64_v2_accounts-qml-module-doc.sha256sum] = "aed45374b423674229e02912f8263e528542ae9e13293d2b22e63b8a42feebf2"

URI_x86_64_v2_accounts-qml-module-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/accounts-qml-module-qt5-0.7^20231216.05e79eb-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_accounts-qml-module-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accounts-qml-module-qt5}"
SRC_URI[x86_64_v2_accounts-qml-module-qt5.sha256sum] = "90f13f913311cf2905f429119c40b94f46a2964639ffc1cc9b09da1020f82bea"

URI_x86_64_v2_accounts-qml-module-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/accounts-qml-module-qt6-0.7^20231216.05e79eb-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_accounts-qml-module-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accounts-qml-module-qt6}"
SRC_URI[x86_64_v2_accounts-qml-module-qt6.sha256sum] = "193205c226d3b91142b3db8f68f67560a8926ae1a8fae289627bef9d4e4c7ade"

URI_aarch64_accounts-qml-module-doc = "${EPEL_MIRROR}/aarch64/Packages/a/accounts-qml-module-doc-0.7^20231216.05e79eb-3.el10_0.noarch.rpm;name=aarch64_accounts-qml-module-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_accounts-qml-module-doc}"
SRC_URI[aarch64_accounts-qml-module-doc.sha256sum] = "974aefc1433c80d57af2c5887f9b6531cba6288b2a9b580b19100e4fa0975726"

URI_aarch64_accounts-qml-module-qt5 = "${EPEL_MIRROR}/aarch64/Packages/a/accounts-qml-module-qt5-0.7^20231216.05e79eb-3.el10_0.aarch64.rpm;name=aarch64_accounts-qml-module-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_accounts-qml-module-qt5}"
SRC_URI[aarch64_accounts-qml-module-qt5.sha256sum] = "8e413f54c3d3cc20f40a5d343ca5b8e249a3b856fd6e632d032f730b88110e65"

URI_aarch64_accounts-qml-module-qt6 = "${EPEL_MIRROR}/aarch64/Packages/a/accounts-qml-module-qt6-0.7^20231216.05e79eb-3.el10_0.aarch64.rpm;name=aarch64_accounts-qml-module-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_accounts-qml-module-qt6}"
SRC_URI[aarch64_accounts-qml-module-qt6.sha256sum] = "106ed334b62dd9c5e0576a1dd529c450465b979c9d2bb3c69379115bba9c1146"

RDEPENDS:accounts-qml-module-doc = " \
 "
RDEPENDS:accounts-qml-module-qt5 = " \
 glibc \
 libaccounts-qt5 \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 signon-qt5 \
 "
RDEPENDS:accounts-qml-module-qt6 = " \
 glibc \
 libaccounts-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 signon-qt6 \
 "
