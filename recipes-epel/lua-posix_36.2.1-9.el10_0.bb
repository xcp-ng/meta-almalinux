# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-posix"
PV = "36.2.1"
PR = "9.el10_0"
PACKAGES = " \
 lua-posix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-posix-36.2.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20187d9d18b459c2dc3c73bb2deee78a89ac75f3b935c6ab2f74ec9bf20accf4"

URI_x86_64_v2_lua-posix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-posix-36.2.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-posix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-posix}"
SRC_URI[x86_64_v2_lua-posix.sha256sum] = "d72283c3a9e7e557fdb401af67f2eafc9eb63697c1263788d1cdcda7b469e03b"

URI_aarch64_lua-posix = "${EPEL_MIRROR}/aarch64/Packages/l/lua-posix-36.2.1-9.el10_0.aarch64.rpm;name=aarch64_lua-posix;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-posix}"
SRC_URI[aarch64_lua-posix.sha256sum] = "6b0cc2137e1546d4d7111f2ab9f45e5af4b7817105808765b98354b8bb8ee27e"

RDEPENDS:lua-posix = " \
 glibc \
 libxcrypt \
 lua-libs \
 "
