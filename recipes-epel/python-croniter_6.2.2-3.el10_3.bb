# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-croniter"
PV = "6.2.2"
PR = "3.el10_3"
PACKAGES = " \
 python3-croniter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-croniter-6.2.2-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8eb20eba5271b95917bdb7104dff0b94f2dbcf48bae7d69c30b0e525b66b0f9c"

URI_x86_64_v2_python3-croniter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-croniter-6.2.2-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-croniter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-croniter}"
SRC_URI[x86_64_v2_python3-croniter.sha256sum] = "3c03ab7f93af0c1e80827def27a63cd2a4b9e3e7a89e492fc8f1a8a01f76d956"

URI_aarch64_python3-croniter = "${EPEL_MIRROR}/aarch64/Packages/p/python3-croniter-6.2.2-3.el10_3.noarch.rpm;name=aarch64_python3-croniter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-croniter}"
SRC_URI[aarch64_python3-croniter.sha256sum] = "81b71aabc32d556fc20489a52086131b418986f19c8b9db32b4b0c11d743a374"

RDEPENDS:python3-croniter = " \
 python3 \
 python3-dateutil \
 "
