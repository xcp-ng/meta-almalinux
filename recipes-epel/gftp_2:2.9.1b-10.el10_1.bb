# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gftp"
PE = "2"
PV = "2.9.1b"
PR = "10.el10_1"
PACKAGES = " \
 gftp \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gftp-2.9.1b-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2a2c8d57e99421bf66996c10607312ea7843f3451ad19e7beb1bdb459f8d2c22"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gftp-2.9.1b-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gftp;unpack=0"
SRC_URI[x86_64_v2_gftp.sha256sum] = "1602211a4f45e841d4434dd95443106588f099e886585f9d10a691f4c96bc26d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gftp-2.9.1b-10.el10_1.aarch64.rpm;name=aarch64_gftp;unpack=0"
SRC_URI[aarch64_gftp.sha256sum] = "4765d079903f45f9319268bf4222e0e9b4240b8572fd6d4bbfaf930f7831f92b"

RDEPENDS:gftp = " \
 bash \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 openssl-libs \
 readline \
 "
