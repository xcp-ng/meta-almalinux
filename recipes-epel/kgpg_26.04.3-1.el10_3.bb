# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgpg"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kgpg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgpg-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8baaa7c40fb760a9e6e706cb085be8902cc48fb93785af2805cc058733302ac"

URI_x86_64_v2_kgpg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgpg-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgpg}"
SRC_URI[x86_64_v2_kgpg.sha256sum] = "e910bff2205fec578050068e61a24746f0a3379d4a18592c0e41fd30f1fe35fe"

URI_aarch64_kgpg = "${EPEL_MIRROR}/aarch64/Packages/k/kgpg-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kgpg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgpg}"
SRC_URI[aarch64_kgpg.sha256sum] = "df09b887a9fd1b6a3e4b21f72196d0baa32fad2392b584d3736ab0143a6f4dae"

RDEPENDS:kgpg = " \
 akonadi-contacts \
 akonadi-server \
 glibc \
 gnupg2 \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
