# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghostwriter"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ghostwriter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghostwriter-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07eac3a58a70a0786a512dd778f19777a0d63e09c986c08ed9a6b51bcfa12aa6"

URI_x86_64_v2_ghostwriter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghostwriter-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghostwriter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghostwriter}"
SRC_URI[x86_64_v2_ghostwriter.sha256sum] = "72c664baf4b8bd7fb5c5a20b175a6e64af05d76cf8d5ec53bd30d52c4db087b8"

URI_aarch64_ghostwriter = "${EPEL_MIRROR}/aarch64/Packages/g/ghostwriter-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ghostwriter;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghostwriter}"
SRC_URI[aarch64_ghostwriter.sha256sum] = "d93e43e381fabacf2646c3812436db1bae90dafd7ecedd28a02095dd64e9e5c2"

RDEPENDS:ghostwriter = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
