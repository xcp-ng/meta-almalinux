# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-uuid"
PV = "1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-uuid \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-uuid-1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "65f41def58fdca4b8f8bb2c71cd9e3db11f65c764ff44e51a05c8f81622612b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-uuid-1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-uuid;unpack=0"
SRC_URI[x86_64_v2_php-pecl-uuid.sha256sum] = "ce3978eba8f13fd3156bb2663d05b30c0c1edf04831a9c9a216b9ea1955337b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-uuid-1.2.1-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-uuid;unpack=0"
SRC_URI[aarch64_php-pecl-uuid.sha256sum] = "9a1438dcbc9f79728a878d7b30fb808f5072f98ea4b61593b3cc669f89fa3461"

RDEPENDS:php-pecl-uuid = " \
 glibc \
 libuuid \
 php-common \
 "
