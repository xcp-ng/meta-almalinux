# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-oid-registry"
PV = "0.8.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-oid-registry+crypto-devel \
 rust-oid-registry+default-devel \
 rust-oid-registry+kdf-devel \
 rust-oid-registry+ms_spc-devel \
 rust-oid-registry+nist_algs-devel \
 rust-oid-registry+pkcs1-devel \
 rust-oid-registry+pkcs12-devel \
 rust-oid-registry+pkcs7-devel \
 rust-oid-registry+pkcs9-devel \
 rust-oid-registry+registry-devel \
 rust-oid-registry+x500-devel \
 rust-oid-registry+x509-devel \
 rust-oid-registry+x962-devel \
 rust-oid-registry-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-oid-registry-0.8.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6dcacbcd9cf0b3cea9493cbc61d36bb460f0678ab896b0f5b740b1563372107"

URI_x86_64_v2_rust-oid-registry+crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+crypto-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+crypto-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+crypto-devel.sha256sum] = "016769d85bd8ca67050e780d4dc293868e925054019bcea51ed72546b91c0526"

URI_x86_64_v2_rust-oid-registry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+default-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+default-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+default-devel.sha256sum] = "8e726c138fb92e386a0fcfd3b3d26738ada54ff01f01bce591ee25f5688b7c84"

URI_x86_64_v2_rust-oid-registry+kdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+kdf-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+kdf-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+kdf-devel.sha256sum] = "34ec9140ff0dee34874a73e2b950ae9b306d9b130c1caca6aef782e7f9506f4d"

URI_x86_64_v2_rust-oid-registry+ms_spc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+ms_spc-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+ms_spc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+ms_spc-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+ms_spc-devel.sha256sum] = "90258be09a74b4a42238a3812b04978929eb197da71c5d397d2aadf1f3793a72"

URI_x86_64_v2_rust-oid-registry+nist_algs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+nist_algs-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+nist_algs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+nist_algs-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+nist_algs-devel.sha256sum] = "089b88c744daf333ee242776d21f16a3f863c15b4de4e5b41cb3784b78cd1ba8"

URI_x86_64_v2_rust-oid-registry+pkcs1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs1-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs1-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs1-devel.sha256sum] = "0267cfd54366f29bb50822f1ec5b9851623c9948d34eda2552abd71eafd0cc1c"

URI_x86_64_v2_rust-oid-registry+pkcs12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs12-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs12-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs12-devel.sha256sum] = "86f377fe7c2a811cb2f423e62e96c18ae5234a60bd5fbfd101913b2f68830ac3"

URI_x86_64_v2_rust-oid-registry+pkcs7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs7-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs7-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs7-devel.sha256sum] = "4f11544c9e893973f4c765f7c2030449642b51e874f9b198ab9dd6906560f411"

URI_x86_64_v2_rust-oid-registry+pkcs9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs9-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs9-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs9-devel.sha256sum] = "3db3cd86262314f3ec99a7b44e11f36d135894170c8e30ea0c965848104e6b63"

URI_x86_64_v2_rust-oid-registry+registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+registry-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+registry-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+registry-devel.sha256sum] = "eb37b3c5f47dd8fd2d2dd007f567f5939546dc18ee6ffc218697ac3e13313d23"

URI_x86_64_v2_rust-oid-registry+x500-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+x500-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+x500-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+x500-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+x500-devel.sha256sum] = "a80291c2d63476c63447035e4a6afbe63583bc7f492aeda03252ee0607dbc13d"

URI_x86_64_v2_rust-oid-registry+x509-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+x509-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+x509-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+x509-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+x509-devel.sha256sum] = "b26971a25c486bae18aa4558886a59b0801623cf9bdd9bb3f39e53077e397713"

URI_x86_64_v2_rust-oid-registry+x962-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+x962-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+x962-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+x962-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+x962-devel.sha256sum] = "6cbd1add464eecd1605d4df71b4c00551aab2b9c313d95b0d7085f8c6428b734"

URI_x86_64_v2_rust-oid-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry-devel-0.8.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry-devel}"
SRC_URI[x86_64_v2_rust-oid-registry-devel.sha256sum] = "61ff7005e577dcd9b1067c97921c566ae8d47a869b16a4574e397dc7967389f9"

URI_aarch64_rust-oid-registry+crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+crypto-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+crypto-devel}"
SRC_URI[aarch64_rust-oid-registry+crypto-devel.sha256sum] = "e0c1acb6b299954d099ab1319483d14e522cde07b13cb0eb471c393fbf6dfc69"

URI_aarch64_rust-oid-registry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+default-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+default-devel}"
SRC_URI[aarch64_rust-oid-registry+default-devel.sha256sum] = "f0e16e8d17ec876927f93b122f2d5b1cf6ee93efc676a7e790640122fb3197ba"

URI_aarch64_rust-oid-registry+kdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+kdf-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+kdf-devel}"
SRC_URI[aarch64_rust-oid-registry+kdf-devel.sha256sum] = "59a05c27b3dc89d084df7daa68e3adcfd2ad1dad340ce6ead15a49dd6471f8d2"

URI_aarch64_rust-oid-registry+ms_spc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+ms_spc-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+ms_spc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+ms_spc-devel}"
SRC_URI[aarch64_rust-oid-registry+ms_spc-devel.sha256sum] = "bfb1ff917f096daa7c4e70b335afe656ffbeb738828ce9c96027f32bd93e1faf"

URI_aarch64_rust-oid-registry+nist_algs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+nist_algs-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+nist_algs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+nist_algs-devel}"
SRC_URI[aarch64_rust-oid-registry+nist_algs-devel.sha256sum] = "42fee21c37f36f0fcd46638aaac914601bf5139ed824720f5d2cf733646893d6"

URI_aarch64_rust-oid-registry+pkcs1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs1-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+pkcs1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs1-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs1-devel.sha256sum] = "f90170b28efd4edb3d77922a38ed9253d1d58c67f73e3b44fd9a5577ebba9a7b"

URI_aarch64_rust-oid-registry+pkcs12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs12-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+pkcs12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs12-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs12-devel.sha256sum] = "82989ee9c623242b22f47e8d512406cbe9ccfc547b4058bcdc903c219c04d15f"

URI_aarch64_rust-oid-registry+pkcs7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs7-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+pkcs7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs7-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs7-devel.sha256sum] = "1bd095b0ae2c8a989f598515fb981d4f5f92c0bc4a4d0cde0adf85d85601862e"

URI_aarch64_rust-oid-registry+pkcs9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs9-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+pkcs9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs9-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs9-devel.sha256sum] = "bbbb7a5666a394823889eb2bbc018a13d8f7a77a54d09ca96b2a960bb92d0f43"

URI_aarch64_rust-oid-registry+registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+registry-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+registry-devel}"
SRC_URI[aarch64_rust-oid-registry+registry-devel.sha256sum] = "624eb127a6508d12c649d6fd2ab0a5211dd088fea3370b5cc5ca06f1dca3f7fb"

URI_aarch64_rust-oid-registry+x500-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+x500-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+x500-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+x500-devel}"
SRC_URI[aarch64_rust-oid-registry+x500-devel.sha256sum] = "3aa58145e7068dba19a1ef118f2f1bf86fbb06f4528609776952e0332fece220"

URI_aarch64_rust-oid-registry+x509-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+x509-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+x509-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+x509-devel}"
SRC_URI[aarch64_rust-oid-registry+x509-devel.sha256sum] = "a7758b657fae1bef7a3b24838b06c45b6ac66a1a45047a2ba6d02e201db76cb3"

URI_aarch64_rust-oid-registry+x962-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+x962-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry+x962-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+x962-devel}"
SRC_URI[aarch64_rust-oid-registry+x962-devel.sha256sum] = "0934398917e73de63263f67469d164d04b3adf4e21196fc1727010d890044e1a"

URI_aarch64_rust-oid-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry-devel-0.8.1-2.el10_2.noarch.rpm;name=aarch64_rust-oid-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry-devel}"
SRC_URI[aarch64_rust-oid-registry-devel.sha256sum] = "1605c487266239c249509227e448732d0c280663e55cf372998688309f27be2c"

RDEPENDS:rust-oid-registry+crypto-devel = " \
 cargo \
 rust-oid-registry+kdf-devel \
 rust-oid-registry+nist_algs-devel \
 rust-oid-registry+pkcs1-devel \
 rust-oid-registry+pkcs12-devel \
 rust-oid-registry+pkcs7-devel \
 rust-oid-registry+pkcs9-devel \
 rust-oid-registry+x962-devel \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+default-devel = " \
 cargo \
 rust-oid-registry+registry-devel \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+kdf-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+ms_spc-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+nist_algs-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs1-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs12-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs7-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs9-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+registry-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+x500-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+x509-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+x962-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry-devel = " \
 cargo \
 rust \
 rust-asn1-rs+default-devel \
 "
