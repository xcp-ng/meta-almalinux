# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpng"
PE = "2"
PV = "1.6.40"
PR = "11.el10_2.1"
PACKAGES = " \
 libpng \
 libpng-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libpng-1.6.40-11.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "accb9e0e4408fe5aaf18f0c8cf8483af277e825dee56ae84a3dc476ecc547f8b"

URI_x86_64_v2_libpng = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpng-1.6.40-11.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libpng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpng}"
SRC_URI[x86_64_v2_libpng.sha256sum] = "2c542e14681fe2f435a51651c6bbb71cd80f561bfbf3eb38b3517ba83ed167f2"

URI_x86_64_v2_libpng-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpng-devel-1.6.40-11.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libpng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpng-devel}"
SRC_URI[x86_64_v2_libpng-devel.sha256sum] = "6e09119dceec5719e20cc6015ac050b3885b59bf528d35a26b11ec6bfce43e99"

URI_aarch64_libpng = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpng-1.6.40-11.el10_2.1.aarch64.rpm;name=aarch64_libpng;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpng}"
SRC_URI[aarch64_libpng.sha256sum] = "3c3100064be5b950f5c4937bfe77cd01a9e57dcf3d59c8c05363a333c7a4d8e4"

URI_aarch64_libpng-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpng-devel-1.6.40-11.el10_2.1.aarch64.rpm;name=aarch64_libpng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpng-devel}"
SRC_URI[aarch64_libpng-devel.sha256sum] = "ce8b7e858f43b99beb04d771a71230666ac47bd4ac2ed6384f66a737a67cb50b"

RDEPENDS:libpng = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libpng-devel = " \
 bash \
 glibc \
 libpng \
 pkgconf-pkg-config \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
