# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaddressbook"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kaddressbook \
 kaddressbook-devel \
 kaddressbook-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaddressbook-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e402ce8dd952eabd9d3a7743b0ff051df9ab0fd251e6039eb5da254dd008705"

URI_x86_64_v2_kaddressbook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook}"
SRC_URI[x86_64_v2_kaddressbook.sha256sum] = "853de0202d32ded2ea7ffb7f2ac70036512dbe590ea15c0cfe1b93a784c8cd94"

URI_x86_64_v2_kaddressbook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook-devel}"
SRC_URI[x86_64_v2_kaddressbook-devel.sha256sum] = "cd2fede9e31582d9ec7aeb24fa39a939832035bcb2f0c76fcb7d8a44135632d2"

URI_x86_64_v2_kaddressbook-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook-libs}"
SRC_URI[x86_64_v2_kaddressbook-libs.sha256sum] = "f67d7ad98269ac48f3683b0278332bf5c4d4253fe54d9d877f21a149d40746d7"

URI_aarch64_kaddressbook = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kaddressbook;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook}"
SRC_URI[aarch64_kaddressbook.sha256sum] = "2498e7c47268e83f7bd60cc93179a144802cc770aea5f64cfdaa9649984c2df2"

URI_aarch64_kaddressbook-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kaddressbook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook-devel}"
SRC_URI[aarch64_kaddressbook-devel.sha256sum] = "2751d903445ec67501e056d3069ebca3a1e1752ad0969f6b644a85992a02087c"

URI_aarch64_kaddressbook-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kaddressbook-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook-libs}"
SRC_URI[aarch64_kaddressbook-libs.sha256sum] = "8e175f48d3e33e6d908e5d4c48daecb08111b43d95b5bbf62af50392009c184b"

RDEPENDS:kaddressbook = " \
 glibc \
 kaddressbook-libs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontactinterface \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kaddressbook-devel = " \
 cmake-filesystem \
 kaddressbook \
 kaddressbook-libs \
 "
RDEPENDS:kaddressbook-libs = " \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 glibc \
 grantleetheme \
 kaddressbook \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kldap \
 kontactinterface \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
