# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-hu"
PV = "0.20090612"
PR = "35.el10"
PACKAGES = " \
 hyphen-hu \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-hu-0.20090612-35.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aeb75697ab2b4c90ab245c84a2625bbd29ba3679ad2735efd7fdd2f89fbda343"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-hu-0.20090612-35.el10.noarch.rpm;name=x86_64_v2_hyphen-hu;unpack=0"
SRC_URI[x86_64_v2_hyphen-hu.sha256sum] = "7eaef8a8e9bd5014c78f3bfe685fea801680ceb3a574856f5bf224a43fa673ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-hu-0.20090612-35.el10.noarch.rpm;name=aarch64_hyphen-hu;unpack=0"
SRC_URI[aarch64_hyphen-hu.sha256sum] = "7eaef8a8e9bd5014c78f3bfe685fea801680ceb3a574856f5bf224a43fa673ea"

RDEPENDS:hyphen-hu = " \
 hyphen \
 "
