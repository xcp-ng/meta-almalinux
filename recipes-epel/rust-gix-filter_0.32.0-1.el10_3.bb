# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-filter"
PV = "0.32.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-filter+default-devel \
 rust-gix-filter+sha1-devel \
 rust-gix-filter+sha256-devel \
 rust-gix-filter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-filter-0.32.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3bab79b3e1c9160375845e48a1d0b0ee61219a2412b5f418269c79a9222757d"

URI_x86_64_v2_rust-gix-filter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-filter+default-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-filter+default-devel}"
SRC_URI[x86_64_v2_rust-gix-filter+default-devel.sha256sum] = "8b6778ef4349dfbda6be4077b7a6bf2867f647470c8bf06acfec4f1905dc59b1"

URI_x86_64_v2_rust-gix-filter+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-filter+sha1-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-filter+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-filter+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-filter+sha1-devel.sha256sum] = "41fde83a323c2c58f14544e85b175973f73e9ec4375d44eb3ac2eeea26e75894"

URI_x86_64_v2_rust-gix-filter+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-filter+sha256-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-filter+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-filter+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-filter+sha256-devel.sha256sum] = "e85c9854c9be8662d076490927884447c2532042cde66d785e84247c1ddc0cb8"

URI_x86_64_v2_rust-gix-filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-filter-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-filter-devel}"
SRC_URI[x86_64_v2_rust-gix-filter-devel.sha256sum] = "8ffc64328d9ee53f53f01e5f5ca8fc58d2c24847739e2fae6a0e71e2d4e98bf4"

URI_aarch64_rust-gix-filter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-filter+default-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-filter+default-devel}"
SRC_URI[aarch64_rust-gix-filter+default-devel.sha256sum] = "b20a8fa71577f6f6603ac76b7a3dabd35539416d8466ab55af23fb53ef4d6d74"

URI_aarch64_rust-gix-filter+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-filter+sha1-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-filter+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-filter+sha1-devel}"
SRC_URI[aarch64_rust-gix-filter+sha1-devel.sha256sum] = "8dcbc51c4a1f85c5a42da0bbd753c64e843807ac0f4fb6dcfa81e9a821a7d99c"

URI_aarch64_rust-gix-filter+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-filter+sha256-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-filter+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-filter+sha256-devel}"
SRC_URI[aarch64_rust-gix-filter+sha256-devel.sha256sum] = "14a80b1f56366ac37443bec706b49b557510f2f35f601e05af012a31f906204b"

URI_aarch64_rust-gix-filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-filter-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-filter-devel}"
SRC_URI[aarch64_rust-gix-filter-devel.sha256sum] = "f255bb2c39e3f77a064f940f46235bf06a8ad207ec9689ccfd04d49fad9c5193"

RDEPENDS:rust-gix-filter+default-devel = " \
 cargo \
 rust-gix-filter-devel \
 "
RDEPENDS:rust-gix-filter+sha1-devel = " \
 cargo \
 rust-gix-filter-devel \
 rust-gix-hash+sha1-devel \
 "
RDEPENDS:rust-gix-filter+sha256-devel = " \
 cargo \
 rust-gix-filter-devel \
 rust-gix-hash+sha256-devel \
 "
RDEPENDS:rust-gix-filter-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-encoding_rs+default-devel \
 rust-gix-attributes+default-devel \
 rust-gix-command+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-packetline+blocking-io-devel \
 rust-gix-packetline+default-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-utils+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
