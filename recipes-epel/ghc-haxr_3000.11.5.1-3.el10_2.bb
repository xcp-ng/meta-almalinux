# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-haxr"
PV = "3000.11.5.1"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 ghc-haxr \
 ghc-haxr-devel \
 ghc-haxr-doc \
"
PACKAGES:aarch64 = " \
 ghc-haxr \
 ghc-haxr-devel \
 ghc-haxr-doc \
 ghc-haxr-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-haxr-3000.11.5.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55c9a66e1d6cb169aa34a489be7af2f7ff9c56e44471a1bc1100573d92ddbc67"

URI_x86_64_v2_ghc-haxr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haxr-3000.11.5.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haxr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haxr}"
SRC_URI[x86_64_v2_ghc-haxr.sha256sum] = "3b29344d4541b4131e177aa483bc148d58256802272896e91259ced6bb95d379"

URI_x86_64_v2_ghc-haxr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haxr-devel-3000.11.5.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haxr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haxr-devel}"
SRC_URI[x86_64_v2_ghc-haxr-devel.sha256sum] = "16c61b6c886b1943b14c304c9ed84ca510788fc939cfc1f8f222ea8b90866da6"

URI_x86_64_v2_ghc-haxr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haxr-doc-3000.11.5.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-haxr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haxr-doc}"
SRC_URI[x86_64_v2_ghc-haxr-doc.sha256sum] = "921e840519121ce2aa9cc71d6690108524c61fb6a95137d21af68dcd34b23be5"

URI_aarch64_ghc-haxr = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haxr-3000.11.5.1-3.el10_2.aarch64.rpm;name=aarch64_ghc-haxr;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haxr}"
SRC_URI[aarch64_ghc-haxr.sha256sum] = "6978904d511a7f3d501e2c383a12aeb4a9874f3953a3f81cd076b6732e1a20a4"

URI_aarch64_ghc-haxr-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haxr-devel-3000.11.5.1-3.el10_2.aarch64.rpm;name=aarch64_ghc-haxr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haxr-devel}"
SRC_URI[aarch64_ghc-haxr-devel.sha256sum] = "96b547d1374671c481c2daf5f8826ee96ba7259ab637857634f736e0b1342be4"

URI_aarch64_ghc-haxr-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haxr-doc-3000.11.5.1-3.el10_2.noarch.rpm;name=aarch64_ghc-haxr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haxr-doc}"
SRC_URI[aarch64_ghc-haxr-doc.sha256sum] = "4e4dfba70b08a385538e74b5cf6bf2e473e81c15dd999a932788ac56acb79618"

URI_aarch64_ghc-haxr-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haxr-prof-3000.11.5.1-3.el10_2.aarch64.rpm;name=aarch64_ghc-haxr-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haxr-prof}"
SRC_URI[aarch64_ghc-haxr-prof.sha256sum] = "333c7722588434afa6a7ba3a8db8fd24d5299f89495265329abb68b8d688bff6"

RDEPENDS:ghc-haxr = " \
 ghc-HaXml \
 ghc-HsOpenSSL \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-blaze-builder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-common \
 ghc-http-streams \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-io-streams \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-openssl-streams \
 ghc-os-string \
 ghc-parsec \
 ghc-polyparse \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 ghc-zlib-bindings \
 glibc \
 gmp \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-haxr-devel = " \
 ghc-HaXml-devel \
 ghc-HsOpenSSL-devel \
 ghc-array-devel \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-blaze-builder-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-haxr \
 ghc-http-streams-devel \
 ghc-http-types-devel \
 ghc-io-streams-devel \
 ghc-mtl-devel \
 ghc-network-devel \
 ghc-network-uri-devel \
 ghc-old-locale-devel \
 ghc-old-time-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-utf8-string-devel \
 "
RDEPENDS:ghc-haxr-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-haxr-prof = " \
 ghc-HaXml-prof \
 ghc-HsOpenSSL-prof \
 ghc-array-prof \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-blaze-builder-prof \
 ghc-bytestring-prof \
 ghc-haxr-devel \
 ghc-http-streams-prof \
 ghc-http-types-prof \
 ghc-io-streams-prof \
 ghc-mtl-prof \
 ghc-network-prof \
 ghc-network-uri-prof \
 ghc-old-locale-prof \
 ghc-old-time-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-utf8-string-prof \
 "
