# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knavalbattle"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 knavalbattle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knavalbattle-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07e7ea7c37f4d62c6df40e3884f29156cd1b16f0b4b8536f3a5ea212bf232cb7"

URI_x86_64_v2_knavalbattle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knavalbattle-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knavalbattle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knavalbattle}"
SRC_URI[x86_64_v2_knavalbattle.sha256sum] = "731c1995ec926e24a60ea797dc15d4f056868137361ef75f10fd0a8032773169"

URI_aarch64_knavalbattle = "${EPEL_MIRROR}/aarch64/Packages/k/knavalbattle-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_knavalbattle;unpack=0"
SRC_URI:append = " ${URI_aarch64_knavalbattle}"
SRC_URI[aarch64_knavalbattle.sha256sum] = "a32a48db645fae6074cb87fd670da2db4ee38e8158eddd8a563f22bb42ab34e0"

RDEPENDS:knavalbattle = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
