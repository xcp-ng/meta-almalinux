# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rcgen"
PV = "0.14.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-rcgen+crypto-devel \
 rust-rcgen+default-devel \
 rust-rcgen+pem-devel \
 rust-rcgen+ring-devel \
 rust-rcgen+x509-parser-devel \
 rust-rcgen+zeroize-devel \
 rust-rcgen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rcgen-0.14.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "323e4aaf4c80a799adaf09ddb79d08811f1b216d94a57124a6fb8c048b63576a"

URI_x86_64_v2_rust-rcgen+crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+crypto-devel-0.14.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+crypto-devel}"
SRC_URI[x86_64_v2_rust-rcgen+crypto-devel.sha256sum] = "1ce24c4742b4afafe1081a7268faf23f416aa43760c6927df10d82f7a114588a"

URI_x86_64_v2_rust-rcgen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+default-devel-0.14.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+default-devel}"
SRC_URI[x86_64_v2_rust-rcgen+default-devel.sha256sum] = "84a5ebc8915f32b400b8a6403232112030bb99e1a1dfb97bc733b41341a77597"

URI_x86_64_v2_rust-rcgen+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+pem-devel-0.14.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+pem-devel}"
SRC_URI[x86_64_v2_rust-rcgen+pem-devel.sha256sum] = "bddc0845c58570b38e5f10a97844da7235061260c600fd5c7813cf791ec4d95a"

URI_x86_64_v2_rust-rcgen+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+ring-devel-0.14.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+ring-devel}"
SRC_URI[x86_64_v2_rust-rcgen+ring-devel.sha256sum] = "c14b6e13c8015602ba82c98049833734086d24cb389008be160e2e7a63a6366a"

URI_x86_64_v2_rust-rcgen+x509-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+x509-parser-devel-0.14.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+x509-parser-devel}"
SRC_URI[x86_64_v2_rust-rcgen+x509-parser-devel.sha256sum] = "016652321ec9917c6cc56d2db8dd6fcb8322449f03480cd0df241fb89891f211"

URI_x86_64_v2_rust-rcgen+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen+zeroize-devel-0.14.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen+zeroize-devel}"
SRC_URI[x86_64_v2_rust-rcgen+zeroize-devel.sha256sum] = "131077767631226774ca070814cf751d47603d31b5b4d1bae6bd2f4a7d5278d4"

URI_x86_64_v2_rust-rcgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rcgen-devel-0.14.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rcgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rcgen-devel}"
SRC_URI[x86_64_v2_rust-rcgen-devel.sha256sum] = "4cba7133278e31dcb610ad7a5c87a40350b6544411de27bc6b27b35b3c6a4eed"

URI_aarch64_rust-rcgen+crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+crypto-devel-0.14.5-1.el10_2.noarch.rpm;name=aarch64_rust-rcgen+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+crypto-devel}"
SRC_URI[aarch64_rust-rcgen+crypto-devel.sha256sum] = "48508cbfe28193bdd58a5eeb96532ecea5ded07b5d7c50e3bdc497f29a8104b6"

URI_aarch64_rust-rcgen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+default-devel-0.14.5-1.el10_2.noarch.rpm;name=aarch64_rust-rcgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+default-devel}"
SRC_URI[aarch64_rust-rcgen+default-devel.sha256sum] = "0a71a101e75af9b084cf77528301a28bf75381785127cef0a7bbd0e942d39e56"

URI_aarch64_rust-rcgen+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+pem-devel-0.14.5-1.el10_2.noarch.rpm;name=aarch64_rust-rcgen+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+pem-devel}"
SRC_URI[aarch64_rust-rcgen+pem-devel.sha256sum] = "c6ca9196c9471878414914aaba9047e79b6572b798426a9c1aed643cb75ce807"

URI_aarch64_rust-rcgen+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+ring-devel-0.14.5-1.el10_2.noarch.rpm;name=aarch64_rust-rcgen+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+ring-devel}"
SRC_URI[aarch64_rust-rcgen+ring-devel.sha256sum] = "550adbfe5cbf2aafc18e45f572804344095211df487ac99cd377543baaae898c"

URI_aarch64_rust-rcgen+x509-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+x509-parser-devel-0.14.5-1.el10_2.noarch.rpm;name=aarch64_rust-rcgen+x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+x509-parser-devel}"
SRC_URI[aarch64_rust-rcgen+x509-parser-devel.sha256sum] = "5f61d35ebd5418a5252c194caafd523730215712b99cf04ceb075d20deb977b7"

URI_aarch64_rust-rcgen+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen+zeroize-devel-0.14.5-1.el10_2.noarch.rpm;name=aarch64_rust-rcgen+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen+zeroize-devel}"
SRC_URI[aarch64_rust-rcgen+zeroize-devel.sha256sum] = "d54b09b330a39534115686990ae4bf37d38b222e73fabbd1b15250546d10ac6d"

URI_aarch64_rust-rcgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rcgen-devel-0.14.5-1.el10_2.noarch.rpm;name=aarch64_rust-rcgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rcgen-devel}"
SRC_URI[aarch64_rust-rcgen-devel.sha256sum] = "43cf0ec49fc0b0ff1389b83caf18ba88ecfc3d191519c2677a920ffbb3fa2e9a"

RDEPENDS:rust-rcgen+crypto-devel = " \
 cargo \
 rust-rcgen-devel \
 "
RDEPENDS:rust-rcgen+default-devel = " \
 cargo \
 rust-rcgen+crypto-devel \
 rust-rcgen+pem-devel \
 rust-rcgen+ring-devel \
 rust-rcgen-devel \
 "
RDEPENDS:rust-rcgen+pem-devel = " \
 cargo \
 rust-pem+default-devel \
 rust-rcgen-devel \
 "
RDEPENDS:rust-rcgen+ring-devel = " \
 cargo \
 rust-rcgen+crypto-devel \
 rust-rcgen-devel \
 rust-ring+default-devel \
 "
RDEPENDS:rust-rcgen+x509-parser-devel = " \
 cargo \
 rust-rcgen-devel \
 rust-x509-parser+default-devel \
 rust-x509-parser+verify-devel \
 "
RDEPENDS:rust-rcgen+zeroize-devel = " \
 cargo \
 rust-rcgen-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-rcgen-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types+default-devel \
 rust-time-devel \
 rust-yasna+default-devel \
 rust-yasna+std-devel \
 rust-yasna+time-devel \
 "
