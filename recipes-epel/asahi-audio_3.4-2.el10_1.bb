# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "asahi-audio"
PV = "3.4"
PR = "2.el10_1"
PACKAGES = " \
 asahi-audio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/asahi-audio-3.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8922baaf6f27eb5c96b8be497ebce47658ff411d23c96081b02bad04ee02ccf8"

URI_x86_64_v2_asahi-audio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asahi-audio-3.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_asahi-audio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asahi-audio}"
SRC_URI[x86_64_v2_asahi-audio.sha256sum] = "c3e1dc57893b0ec989795824b0e16dbdc6730ea819a5f136fef80bc113813de0"

URI_aarch64_asahi-audio = "${EPEL_MIRROR}/aarch64/Packages/a/asahi-audio-3.4-2.el10_1.noarch.rpm;name=aarch64_asahi-audio;unpack=0"
SRC_URI:append = " ${URI_aarch64_asahi-audio}"
SRC_URI[aarch64_asahi-audio.sha256sum] = "2f02cd300ce95a4ee61b724d13e70425599e9371c58db456404db440362065e0"

RDEPENDS:asahi-audio = " \
 lsp-plugins-lv2 \
 lv2-bankstown \
 lv2-triforce \
 pipewire \
 pipewire-module-filter-chain-lv2 \
 wireplumber \
 "
