# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-timer"
PV = "3.0.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-timer+default-devel \
 rust-futures-timer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-timer-3.0.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c32b8da15b90f07bbf9b6a578d1239308f1824b5d0a12109c31e6f883985c99"

URI_x86_64_v2_rust-futures-timer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-timer+default-devel-3.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-timer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-timer+default-devel}"
SRC_URI[x86_64_v2_rust-futures-timer+default-devel.sha256sum] = "89c3f3ff6fa3d1328ab4a5c996603dec1af14974be8a6f4fcf6589b5c0408c4f"

URI_x86_64_v2_rust-futures-timer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-timer-devel-3.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-timer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-timer-devel}"
SRC_URI[x86_64_v2_rust-futures-timer-devel.sha256sum] = "cc14b24734fd4581c3ec62ba31b354bdf2e9bc4e70dd7f4030fb24a8da84551e"

URI_aarch64_rust-futures-timer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-timer+default-devel-3.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-futures-timer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-timer+default-devel}"
SRC_URI[aarch64_rust-futures-timer+default-devel.sha256sum] = "6083358367579365d837593bdef499b0741f493a1c5fb7662d16768c0e9d262b"

URI_aarch64_rust-futures-timer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-timer-devel-3.0.4-1.el10_3.noarch.rpm;name=aarch64_rust-futures-timer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-timer-devel}"
SRC_URI[aarch64_rust-futures-timer-devel.sha256sum] = "17013505dd1a05dfaca3c3b4a65b17ae76668b6f599b1e389ede03c981bc0f77"

RDEPENDS:rust-futures-timer+default-devel = " \
 cargo \
 rust-futures-timer-devel \
 "
RDEPENDS:rust-futures-timer-devel = " \
 cargo \
 "
