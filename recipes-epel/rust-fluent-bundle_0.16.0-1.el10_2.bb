# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fluent-bundle"
PV = "0.16.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-fluent-bundle+all-benchmarks-devel \
 rust-fluent-bundle+default-devel \
 rust-fluent-bundle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fluent-bundle-0.16.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "810bd303988d2b7d3a7961f057ae19108ddbfcc0b5dcbfb8ac695d9771c61a1f"

URI_x86_64_v2_rust-fluent-bundle+all-benchmarks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-bundle+all-benchmarks-devel-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-bundle+all-benchmarks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-bundle+all-benchmarks-devel}"
SRC_URI[x86_64_v2_rust-fluent-bundle+all-benchmarks-devel.sha256sum] = "d06600e341371f0318c1f058f36ee6fba58540e0eff1185a8e3a06f0aa00f5d5"

URI_x86_64_v2_rust-fluent-bundle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-bundle+default-devel-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-bundle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-bundle+default-devel}"
SRC_URI[x86_64_v2_rust-fluent-bundle+default-devel.sha256sum] = "6f5b85422b6dd348da7dafd8196d68bdb7c409fdad6bdf63200b8edd47e58970"

URI_x86_64_v2_rust-fluent-bundle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-bundle-devel-0.16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-bundle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-bundle-devel}"
SRC_URI[x86_64_v2_rust-fluent-bundle-devel.sha256sum] = "47bb8d7cb8acf14ccf8208583e2976593973e0443913122b5d66da15676dcde4"

URI_aarch64_rust-fluent-bundle+all-benchmarks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-bundle+all-benchmarks-devel-0.16.0-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-bundle+all-benchmarks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-bundle+all-benchmarks-devel}"
SRC_URI[aarch64_rust-fluent-bundle+all-benchmarks-devel.sha256sum] = "96420fbc623f8b79bc04e4d04b25ad25b60c42076185742f26d46fdf28235fe7"

URI_aarch64_rust-fluent-bundle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-bundle+default-devel-0.16.0-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-bundle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-bundle+default-devel}"
SRC_URI[aarch64_rust-fluent-bundle+default-devel.sha256sum] = "0e5a2127cca44038577af16f1b8b2b9f6917dba08b30886241f1f1430ffa3fbe"

URI_aarch64_rust-fluent-bundle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-bundle-devel-0.16.0-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-bundle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-bundle-devel}"
SRC_URI[aarch64_rust-fluent-bundle-devel.sha256sum] = "c3d2aec41c0c62ee1d11752c1c07938cf2442658e0e926d2dc78e728c16e03cd"

RDEPENDS:rust-fluent-bundle+all-benchmarks-devel = " \
 cargo \
 rust-fluent-bundle-devel \
 "
RDEPENDS:rust-fluent-bundle+default-devel = " \
 cargo \
 rust-fluent-bundle-devel \
 "
RDEPENDS:rust-fluent-bundle-devel = " \
 cargo \
 rust \
 rust-fluent-langneg+default-devel \
 rust-fluent-syntax+default-devel \
 rust-intl-memoizer+default-devel \
 rust-intl_pluralrules+default-devel \
 rust-rustc-hash+default-devel \
 rust-self_cell+default-devel \
 rust-smallvec+default-devel \
 rust-unic-langid+default-devel \
 "
