# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluechi"
PV = "1.2.2"
PR = "1.el10_2"
PACKAGES = " \
 bluechi-agent \
 bluechi-controller \
 bluechi-ctl \
 bluechi-is-online \
 bluechi-selinux \
 python3-bluechi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bluechi-1.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64046708fbc04f79e41ffe04151ecb0522b1620834a98336a35b0c0dbbe2a80c"

URI_x86_64_v2_bluechi-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-agent-1.2.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-agent}"
SRC_URI[x86_64_v2_bluechi-agent.sha256sum] = "25f5b2e4b81faa93df8c22d9a43caae41f392c6b7a695a7e8c2c310ae5684cac"

URI_x86_64_v2_bluechi-controller = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-controller-1.2.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-controller;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-controller}"
SRC_URI[x86_64_v2_bluechi-controller.sha256sum] = "7fc2b14dda6d7b35731596ca2b58f89214f5142838656cfae134847d512f70a7"

URI_x86_64_v2_bluechi-ctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-ctl-1.2.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-ctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-ctl}"
SRC_URI[x86_64_v2_bluechi-ctl.sha256sum] = "855569f92024fabb7168e7c5bb727ee8d3b543eaeb598586739097ac6d169edd"

URI_x86_64_v2_bluechi-is-online = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-is-online-1.2.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-is-online;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-is-online}"
SRC_URI[x86_64_v2_bluechi-is-online.sha256sum] = "f8c6f5ef7c0c0079fbb5d4808504f918b6fad17c421dd71ae587f0fdee7d91b4"

URI_x86_64_v2_bluechi-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-selinux-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bluechi-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-selinux}"
SRC_URI[x86_64_v2_bluechi-selinux.sha256sum] = "626fcf0cfc4342834a4ce32655c0d17889c5e9ccdcb29a279a49ba1b177b544d"

URI_x86_64_v2_python3-bluechi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bluechi-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-bluechi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bluechi}"
SRC_URI[x86_64_v2_python3-bluechi.sha256sum] = "10569c4baaa5535e217e3a27087025e4f0f6c4870351524fc915473b8fc7b08c"

URI_aarch64_bluechi-agent = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-agent-1.2.2-1.el10_2.aarch64.rpm;name=aarch64_bluechi-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-agent}"
SRC_URI[aarch64_bluechi-agent.sha256sum] = "28ca49abeb060f0c2f9286dd282467c78c5a0890f292de3244b0e3e5b40bfe2c"

URI_aarch64_bluechi-controller = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-controller-1.2.2-1.el10_2.aarch64.rpm;name=aarch64_bluechi-controller;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-controller}"
SRC_URI[aarch64_bluechi-controller.sha256sum] = "13621bf7b9b7ee74cc8e0bfa48ea1ebe94ff9c8dce9877da3e73617b4293c749"

URI_aarch64_bluechi-ctl = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-ctl-1.2.2-1.el10_2.aarch64.rpm;name=aarch64_bluechi-ctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-ctl}"
SRC_URI[aarch64_bluechi-ctl.sha256sum] = "1f53aaa13ce4ce32dcb99f9a02cf410a76fd7fec42ccd86804ef52bb41738964"

URI_aarch64_bluechi-is-online = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-is-online-1.2.2-1.el10_2.aarch64.rpm;name=aarch64_bluechi-is-online;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-is-online}"
SRC_URI[aarch64_bluechi-is-online.sha256sum] = "8d2b34431c67026eb96fbd0207dd49c6fbe1b52fea879a50f84d6824aef3583e"

URI_aarch64_bluechi-selinux = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-selinux-1.2.2-1.el10_2.noarch.rpm;name=aarch64_bluechi-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-selinux}"
SRC_URI[aarch64_bluechi-selinux.sha256sum] = "c61322283ae7a2673addb8a94cebf6b172d054281f338d13a029a8072aeb4bd0"

URI_aarch64_python3-bluechi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bluechi-1.2.2-1.el10_2.noarch.rpm;name=aarch64_python3-bluechi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bluechi}"
SRC_URI[aarch64_python3-bluechi.sha256sum] = "32d15bdaf3292ec8b415a5226c5eedf004a69779c56bda8bc908ac01e7bde7c6"

RDEPENDS:bluechi-agent = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluechi-controller = " \
 bash \
 glibc \
 libgcc \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluechi-ctl = " \
 bluechi-controller \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:bluechi-is-online = " \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:bluechi-selinux = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.15 \
 "
RDEPENDS:python3-bluechi = " \
 python3 \
 python3-dasbus \
 "
