# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "seatd"
PV = "0.9.1"
PR = "1.el10_0"
PACKAGES = " \
 libseat \
 libseat-devel \
 seatd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/seatd-0.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a26d5c1436df698ce72db55737fc28c7833089fc579b37621fdc932bdddcce2c"

URI_x86_64_v2_libseat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libseat-0.9.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libseat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libseat}"
SRC_URI[x86_64_v2_libseat.sha256sum] = "4157dc6045d6d3eb6181d9d13956be3483768b2d81f7106fd7b660e13be5b2fb"

URI_x86_64_v2_libseat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libseat-devel-0.9.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libseat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libseat-devel}"
SRC_URI[x86_64_v2_libseat-devel.sha256sum] = "5f9daf7869152139bdff7c70347ec5a9e1976c132857eab8f653e3abdcdab323"

URI_x86_64_v2_seatd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/seatd-0.9.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_seatd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seatd}"
SRC_URI[x86_64_v2_seatd.sha256sum] = "4e023ecd0e7264a082b8486317a8d4db9721c3106140d34684428bb16bc64ff0"

URI_aarch64_libseat = "${EPEL_MIRROR}/aarch64/Packages/l/libseat-0.9.1-1.el10_0.aarch64.rpm;name=aarch64_libseat;unpack=0"
SRC_URI:append = " ${URI_aarch64_libseat}"
SRC_URI[aarch64_libseat.sha256sum] = "dfe7f966f2971ffc3cb9e057f865cd813ae079ebf81e8e44ee2bedc171daadae"

URI_aarch64_libseat-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libseat-devel-0.9.1-1.el10_0.aarch64.rpm;name=aarch64_libseat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libseat-devel}"
SRC_URI[aarch64_libseat-devel.sha256sum] = "f75d5788c964d0caa108e4a464313d6ba00d88ce15884aab2d9869bb0b335870"

URI_aarch64_seatd = "${EPEL_MIRROR}/aarch64/Packages/s/seatd-0.9.1-1.el10_0.aarch64.rpm;name=aarch64_seatd;unpack=0"
SRC_URI:append = " ${URI_aarch64_seatd}"
SRC_URI[aarch64_seatd.sha256sum] = "ac8d095da109f80a2804994796dfd698ad7c6a900e6a0440347fcfefea9fee36"

RDEPENDS:libseat = " \
 glibc \
 systemd-libs \
 "
RDEPENDS:libseat-devel = " \
 libseat \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:seatd = " \
 bash \
 glibc \
 "
