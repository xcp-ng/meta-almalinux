# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http"
PV = "1.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-http+default-devel \
 rust-http+std-devel \
 rust-http-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-http-1.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c9d302551a20728a0f26b160e85c69fe4f296868e2d0c6cb51946145c1425a6e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+default-devel-1.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http+default-devel.sha256sum] = "0c7f371ef162e4fb4543ee765d1ceaad04a222a8dda6cd109f566c07f9364de7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+std-devel-1.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http+std-devel.sha256sum] = "eff6101f0eba2acf09944c26a2dd6cac25e1c1fd18177e202d6c166a67061c89"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-devel-1.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http-devel.sha256sum] = "36474f826260a69337f5d9b0e18a8d9a1c97377317c1b356c0d8c9e7fb680634"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http+default-devel-1.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-http+default-devel;unpack=0"
SRC_URI[aarch64_rust-http+default-devel.sha256sum] = "cfa98ba1957d3292bb2601c9eb8c01b6c1bf712d0fc58bb5c56f81703ac68640"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http+std-devel-1.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-http+std-devel;unpack=0"
SRC_URI[aarch64_rust-http+std-devel.sha256sum] = "a1cde41f919661cb0cb90f4900fd03f4964dfd767499e88cbafc9d04f333e82a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http-devel-1.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-http-devel;unpack=0"
SRC_URI[aarch64_rust-http-devel.sha256sum] = "27cf7db75970e50fe3aa8d9e212140a660a0fbb7863af2be052eb164c5f37eec"

RDEPENDS:rust-http+default-devel = " \
 cargo \
 rust-http+std-devel \
 rust-http-devel \
 "
RDEPENDS:rust-http+std-devel = " \
 cargo \
 rust-http-devel \
 "
RDEPENDS:rust-http-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-itoa+default-devel \
 "
