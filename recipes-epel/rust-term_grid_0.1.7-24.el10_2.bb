# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-term_grid"
PV = "0.1.7"
PR = "24.el10_2"
PACKAGES = " \
 rust-term_grid+default-devel \
 rust-term_grid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-term_grid-0.1.7-24.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f3294c46b165c9640f439c875c1b746a45e2a45fa7b7502d576e0d4bf3aa05d"

URI_x86_64_v2_rust-term_grid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term_grid+default-devel-0.1.7-24.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term_grid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term_grid+default-devel}"
SRC_URI[x86_64_v2_rust-term_grid+default-devel.sha256sum] = "b90a306b86a4fdb8a52426ec30a61bc1ace5932076ed6815a6b28b96b875e287"

URI_x86_64_v2_rust-term_grid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-term_grid-devel-0.1.7-24.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-term_grid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-term_grid-devel}"
SRC_URI[x86_64_v2_rust-term_grid-devel.sha256sum] = "2ca21352f39728ec3468aeefc055b29998a48a3cfd8e9b37e515f504726129b0"

URI_aarch64_rust-term_grid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term_grid+default-devel-0.1.7-24.el10_2.noarch.rpm;name=aarch64_rust-term_grid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term_grid+default-devel}"
SRC_URI[aarch64_rust-term_grid+default-devel.sha256sum] = "23184a141852c9dd5e7c71ba141d029176e397ccaa4ad710f06c882f31346605"

URI_aarch64_rust-term_grid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-term_grid-devel-0.1.7-24.el10_2.noarch.rpm;name=aarch64_rust-term_grid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-term_grid-devel}"
SRC_URI[aarch64_rust-term_grid-devel.sha256sum] = "91629d10ea426830878c4e9ab43e473bcbc50938d6939c36efc6e18af15db0cc"

RDEPENDS:rust-term_grid+default-devel = " \
 cargo \
 rust-term_grid-devel \
 "
RDEPENDS:rust-term_grid-devel = " \
 cargo \
 rust-unicode-width0.1+default-devel \
 "
