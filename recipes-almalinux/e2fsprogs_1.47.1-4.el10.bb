# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "e2fsprogs"
PV = "1.47.1"
PR = "4.el10"
PACKAGES = " \
 e2fsprogs \
 e2fsprogs-devel \
 e2fsprogs-libs \
 libcom_err \
 libcom_err-devel \
 libss \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/e2fsprogs-1.47.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca63c83393d1909b89b92c68e6ddb4a3b0192bcd45e41b6e3fc2729817067bb2"

URI_x86_64_v2_e2fsprogs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/e2fsprogs-1.47.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_e2fsprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e2fsprogs}"
SRC_URI[x86_64_v2_e2fsprogs.sha256sum] = "f3d8ae9b519aa1d3d2ae8d607c9b77b21fd5afeabb465db2b0a454570e78c7c1"

URI_x86_64_v2_e2fsprogs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/e2fsprogs-devel-1.47.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_e2fsprogs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e2fsprogs-devel}"
SRC_URI[x86_64_v2_e2fsprogs-devel.sha256sum] = "b8d5916621228f381665c32de23a8e1a9212864ea8baabe057ab70deb47c3841"

URI_x86_64_v2_e2fsprogs-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/e2fsprogs-libs-1.47.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_e2fsprogs-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e2fsprogs-libs}"
SRC_URI[x86_64_v2_e2fsprogs-libs.sha256sum] = "835643c01c424a82176a4a7108590036d9986c49d160c4f0a45442a7275f97b9"

URI_x86_64_v2_libcom_err = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcom_err-1.47.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libcom_err;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcom_err}"
SRC_URI[x86_64_v2_libcom_err.sha256sum] = "96ef6bcffa7b33979018aba51f33b3ddd1e72bd43f200cabadb2ad3c6c08606c"

URI_x86_64_v2_libcom_err-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcom_err-devel-1.47.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libcom_err-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcom_err-devel}"
SRC_URI[x86_64_v2_libcom_err-devel.sha256sum] = "7799537689bceecd2bfac5390820a444da539290caa68905a636bf1a95412914"

URI_x86_64_v2_libss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libss-1.47.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libss}"
SRC_URI[x86_64_v2_libss.sha256sum] = "4875eb88c946df797b6d5c4434085d14069631c3e787028f1f10bb26ee1ecba6"

URI_aarch64_e2fsprogs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/e2fsprogs-1.47.1-4.el10.aarch64.rpm;name=aarch64_e2fsprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_e2fsprogs}"
SRC_URI[aarch64_e2fsprogs.sha256sum] = "d5571b25acf15f1804f784f09b08370757de1fbecaa9fce99a3625a8daa567b8"

URI_aarch64_e2fsprogs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/e2fsprogs-devel-1.47.1-4.el10.aarch64.rpm;name=aarch64_e2fsprogs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_e2fsprogs-devel}"
SRC_URI[aarch64_e2fsprogs-devel.sha256sum] = "fc445c8171993bde2d4af74cd160402568cff2aeb78859ffe66e0ba5b97d30d0"

URI_aarch64_e2fsprogs-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/e2fsprogs-libs-1.47.1-4.el10.aarch64.rpm;name=aarch64_e2fsprogs-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_e2fsprogs-libs}"
SRC_URI[aarch64_e2fsprogs-libs.sha256sum] = "6b1e553ffd8097c0c5bfc8a73a963a880aca87d42108cb96d619257178d58e1a"

URI_aarch64_libcom_err = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcom_err-1.47.1-4.el10.aarch64.rpm;name=aarch64_libcom_err;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcom_err}"
SRC_URI[aarch64_libcom_err.sha256sum] = "fbc4115c359c3f5a13cfcff34e53e85d8551bfdeb6f0399053a67ce7e5dd489e"

URI_aarch64_libcom_err-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcom_err-devel-1.47.1-4.el10.aarch64.rpm;name=aarch64_libcom_err-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcom_err-devel}"
SRC_URI[aarch64_libcom_err-devel.sha256sum] = "3805042c8d385603d43053e6825c8f1e7e135a2069b7cd8201b4da5d95be1dae"

URI_aarch64_libss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libss-1.47.1-4.el10.aarch64.rpm;name=aarch64_libss;unpack=0"
SRC_URI:append = " ${URI_aarch64_libss}"
SRC_URI[aarch64_libss.sha256sum] = "2c5a25ccfd53d509731ec50c52b323b829cffcc5cc64db832c8d4bf536089419"

RDEPENDS:e2fsprogs = " \
 e2fsprogs-libs \
 fuse3-libs \
 glibc \
 libblkid \
 libcom_err \
 libss \
 libuuid \
 "
RDEPENDS:e2fsprogs-devel = " \
 e2fsprogs-libs \
 gawk \
 libcom_err-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:e2fsprogs-libs = " \
 glibc \
 libcom_err \
 "
RDEPENDS:libcom_err = " \
 glibc \
 "
RDEPENDS:libcom_err-devel = " \
 bash \
 libcom_err \
 pkgconf-pkg-config \
 "
RDEPENDS:libss = " \
 glibc \
 libcom_err \
 "
