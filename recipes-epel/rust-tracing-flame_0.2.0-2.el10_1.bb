# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-flame"
PV = "0.2.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-tracing-flame+default-devel \
 rust-tracing-flame+smallvec-devel \
 rust-tracing-flame-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-flame-0.2.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10f11cd2e3e879cb6ab281dbdc5ce5a037da45faabf4483a5cd84b1c1fdfc139"

URI_x86_64_v2_rust-tracing-flame+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-flame+default-devel-0.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-flame+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-flame+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-flame+default-devel.sha256sum] = "05f1d252a4b877f7b5a90413bd90f2cd715554a825282a20c31d1f601f6b7953"

URI_x86_64_v2_rust-tracing-flame+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-flame+smallvec-devel-0.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-flame+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-flame+smallvec-devel}"
SRC_URI[x86_64_v2_rust-tracing-flame+smallvec-devel.sha256sum] = "e2fb1567d16c09b2d5b85004375db1304e86e732ab1945cb2a2af6bab6b78880"

URI_x86_64_v2_rust-tracing-flame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-flame-devel-0.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-flame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-flame-devel}"
SRC_URI[x86_64_v2_rust-tracing-flame-devel.sha256sum] = "098111f0a6621b60b953221cc9894ed7409e10f80320dd4b84ad5c98e47753df"

URI_aarch64_rust-tracing-flame+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-flame+default-devel-0.2.0-2.el10_1.noarch.rpm;name=aarch64_rust-tracing-flame+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-flame+default-devel}"
SRC_URI[aarch64_rust-tracing-flame+default-devel.sha256sum] = "664566f04ea24520e6d5c27c44d4c3b6ede2127ee5da25324a9e33bc49ba060a"

URI_aarch64_rust-tracing-flame+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-flame+smallvec-devel-0.2.0-2.el10_1.noarch.rpm;name=aarch64_rust-tracing-flame+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-flame+smallvec-devel}"
SRC_URI[aarch64_rust-tracing-flame+smallvec-devel.sha256sum] = "8b58fd84b13ef7a920588b26de82f223da576db995731f996f2501edd8f702e3"

URI_aarch64_rust-tracing-flame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-flame-devel-0.2.0-2.el10_1.noarch.rpm;name=aarch64_rust-tracing-flame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-flame-devel}"
SRC_URI[aarch64_rust-tracing-flame-devel.sha256sum] = "87f542fa4bd41b115aff89687bf41847c385780daff97f7ccd55bf84fdfab8d1"

RDEPENDS:rust-tracing-flame+default-devel = " \
 cargo \
 rust-tracing-flame+smallvec-devel \
 rust-tracing-flame-devel \
 "
RDEPENDS:rust-tracing-flame+smallvec-devel = " \
 cargo \
 rust-tracing-flame-devel \
 rust-tracing-subscriber+smallvec-devel \
 "
RDEPENDS:rust-tracing-flame-devel = " \
 cargo \
 rust \
 rust-lazy_static+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber-devel \
 "
