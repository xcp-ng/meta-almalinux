# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Params-Check"
PE = "1"
PV = "0.38"
PR = "511.el10"
PACKAGES = " \
 perl-Params-Check \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Params-Check-0.38-511.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a21239ed26da7b0c00be5f03167e9eab7d70693e39f608f08db084920dfae47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Params-Check-0.38-511.el10.noarch.rpm;name=x86_64_v2_perl-Params-Check;unpack=0"
SRC_URI[x86_64_v2_perl-Params-Check.sha256sum] = "a1ed4bda809da65e7217926249ba1699f45ca68e1a8a1acbe235d0e22c74731e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Params-Check-0.38-511.el10.noarch.rpm;name=aarch64_perl-Params-Check;unpack=0"
SRC_URI[aarch64_perl-Params-Check.sha256sum] = "a1ed4bda809da65e7217926249ba1699f45ca68e1a8a1acbe235d0e22c74731e"

RDEPENDS:perl-Params-Check = " \
 perl-Carp \
 perl-Exporter \
 perl-Locale-Maketext-Simple \
 perl-libs \
 perl-vars \
 "
