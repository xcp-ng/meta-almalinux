# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-miniz_oxide0.7"
PV = "0.7.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-miniz_oxide0.7+default-devel \
 rust-miniz_oxide0.7+simd-adler32-devel \
 rust-miniz_oxide0.7+simd-devel \
 rust-miniz_oxide0.7+std-devel \
 rust-miniz_oxide0.7+with-alloc-devel \
 rust-miniz_oxide0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-miniz_oxide0.7-0.7.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f049b93a5f0be43d6e316aee3c868b554856b58d30dd215e5f621139ec26f8d"

URI_x86_64_v2_rust-miniz_oxide0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.7+default-devel-0.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.7+default-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.7+default-devel.sha256sum] = "229b70a3983f30c410a75eba884bdbaf803444925f7064eb1c1f8eb8df1b3276"

URI_x86_64_v2_rust-miniz_oxide0.7+simd-adler32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.7+simd-adler32-devel-0.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.7+simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.7+simd-adler32-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.7+simd-adler32-devel.sha256sum] = "b1289ba8b3e46f8ccdc63a571a29eaa43bca00f5a5c9ecce31a23cd4110688b0"

URI_x86_64_v2_rust-miniz_oxide0.7+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.7+simd-devel-0.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.7+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.7+simd-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.7+simd-devel.sha256sum] = "4945a169b67d66a1f777afbbf38261ab845b122947c2d2a86cb4917800ab1659"

URI_x86_64_v2_rust-miniz_oxide0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.7+std-devel-0.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.7+std-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.7+std-devel.sha256sum] = "7d6f691a07ff1c128e23b4b3e88f6393fe686b28e9a3ef10f4cbe2da35c8494f"

URI_x86_64_v2_rust-miniz_oxide0.7+with-alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.7+with-alloc-devel-0.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.7+with-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.7+with-alloc-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.7+with-alloc-devel.sha256sum] = "2198429e38e31ee5b4665f33aac51b5526efc87cd4ac9e67369ea5d4571c0599"

URI_x86_64_v2_rust-miniz_oxide0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide0.7-devel-0.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide0.7-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide0.7-devel.sha256sum] = "c8e495e48a7f11a9d476573c3f1a36f291bca654dc950a664c70d2701320ec45"

URI_aarch64_rust-miniz_oxide0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.7+default-devel-0.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.7+default-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.7+default-devel.sha256sum] = "52ea7cdcd9ddbde4387d87a871aae25e7589d234f3ce885ab22043df3b5eefae"

URI_aarch64_rust-miniz_oxide0.7+simd-adler32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.7+simd-adler32-devel-0.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide0.7+simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.7+simd-adler32-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.7+simd-adler32-devel.sha256sum] = "0bf761f2946223e6b0cff11c5d9792a3ab240b34c6f6d6925d3416cd77b966cc"

URI_aarch64_rust-miniz_oxide0.7+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.7+simd-devel-0.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide0.7+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.7+simd-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.7+simd-devel.sha256sum] = "b2561656d9615c0dd599d4a7219e6c0ad6bd79154e47f6d44e0c04236ddbc6e6"

URI_aarch64_rust-miniz_oxide0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.7+std-devel-0.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.7+std-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.7+std-devel.sha256sum] = "75c91bbe356d5b9c63ec4d6c126a744df6d4f5ad61471e06130ce917f829db95"

URI_aarch64_rust-miniz_oxide0.7+with-alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.7+with-alloc-devel-0.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide0.7+with-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.7+with-alloc-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.7+with-alloc-devel.sha256sum] = "a044f25d3f7db09a8a22e94184a6bcc567bd18bb5cb8675ddbe06e3eec6106de"

URI_aarch64_rust-miniz_oxide0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide0.7-devel-0.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide0.7-devel}"
SRC_URI[aarch64_rust-miniz_oxide0.7-devel.sha256sum] = "87456832699b6b4ec33df6149a4c1781dcdccc3a53e6534036500755130ad0ec"

RDEPENDS:rust-miniz_oxide0.7+default-devel = " \
 cargo \
 rust-miniz_oxide0.7+with-alloc-devel \
 rust-miniz_oxide0.7-devel \
 "
RDEPENDS:rust-miniz_oxide0.7+simd-adler32-devel = " \
 cargo \
 rust-miniz_oxide0.7-devel \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-miniz_oxide0.7+simd-devel = " \
 cargo \
 rust-miniz_oxide0.7+simd-adler32-devel \
 rust-miniz_oxide0.7-devel \
 "
RDEPENDS:rust-miniz_oxide0.7+std-devel = " \
 cargo \
 rust-miniz_oxide0.7-devel \
 "
RDEPENDS:rust-miniz_oxide0.7+with-alloc-devel = " \
 cargo \
 rust-miniz_oxide0.7-devel \
 "
RDEPENDS:rust-miniz_oxide0.7-devel = " \
 cargo \
 rust-adler-devel \
 "
