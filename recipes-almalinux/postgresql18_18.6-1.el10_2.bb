# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql18"
PV = "18.6"
PR = "1.el10_2"
PACKAGES = " \
 postgresql18 \
 postgresql18-contrib \
 postgresql18-docs \
 postgresql18-plperl \
 postgresql18-plpython3 \
 postgresql18-pltcl \
 postgresql18-private-devel \
 postgresql18-private-libs \
 postgresql18-server \
 postgresql18-server-devel \
 postgresql18-static \
 postgresql18-test \
 postgresql18-test-rpm-macros \
 postgresql18-upgrade \
 postgresql18-upgrade-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql18-18.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a9c2ea30e2490d68b0386c72115ddfcfebb21f8d2f7525476a8904b98feebb4f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18;unpack=0"
SRC_URI[x86_64_v2_postgresql18.sha256sum] = "d9d45e6230c489c4baa61fac4c68055dfd837e5ba48130d9042830e1e79b1aa0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-contrib-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-contrib;unpack=0"
SRC_URI[x86_64_v2_postgresql18-contrib.sha256sum] = "058414dcca83fa9a155399212fff86e9d00bf4936a0a5f7876a06c83def90cf3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-docs-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-docs;unpack=0"
SRC_URI[x86_64_v2_postgresql18-docs.sha256sum] = "efe8fd98cd296ea44d88b4c38d253db9abc2e90dfe9e9d8aa6190566c90ce626"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-plperl-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-plperl;unpack=0"
SRC_URI[x86_64_v2_postgresql18-plperl.sha256sum] = "5a73d4a9b0025de40846b10d6d11247b00c61b6128c140a2b2faf336b8470e49"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-plpython3-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-plpython3;unpack=0"
SRC_URI[x86_64_v2_postgresql18-plpython3.sha256sum] = "923a51afe027fa2afd8501ed657d32bb2914b7dec8e6124aa1901e1ec78a6f63"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-pltcl-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-pltcl;unpack=0"
SRC_URI[x86_64_v2_postgresql18-pltcl.sha256sum] = "7873fc2458d088bb24f0b874e5bbca77553efa6c1c457ba52cf3577718bd4731"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-private-devel-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-private-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql18-private-devel.sha256sum] = "32b02f8f0692e68821bd7faceb9b5a7a63b6f3b021d49a632945cdd9ef89e81c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-private-libs-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-private-libs;unpack=0"
SRC_URI[x86_64_v2_postgresql18-private-libs.sha256sum] = "3ab408f3cdb3dd19b900793178346f2d6b635b0e9c93a561f54f882dbf2ef2b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-server-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-server;unpack=0"
SRC_URI[x86_64_v2_postgresql18-server.sha256sum] = "ec7851924c8c829783ced145bf00ba8834903811d926b37af0feffaa2a61ea4c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-server-devel-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-server-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql18-server-devel.sha256sum] = "f2c013abc48833090e3c4ddc5ba08e4e3859f4fb47ad261ca9917e11e63eb40c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-static-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-static;unpack=0"
SRC_URI[x86_64_v2_postgresql18-static.sha256sum] = "e7856182b99521e3bf63cd08b24d5b8a7cdbf966f553d4a2993506ddd0c5efaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-test-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-test;unpack=0"
SRC_URI[x86_64_v2_postgresql18-test.sha256sum] = "e2f93079cdde213a4a51b5f2b9a9122c0bb56aaeeca5ae25873c1efe6a1d3cb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/postgresql18-test-rpm-macros-18.6-1.el10_2.noarch.rpm;name=x86_64_v2_postgresql18-test-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_postgresql18-test-rpm-macros.sha256sum] = "f2e3b11f55e89c173bf82a5ea89601eb7eb79b7b4a93eb73188bd59580feebb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-upgrade-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-upgrade;unpack=0"
SRC_URI[x86_64_v2_postgresql18-upgrade.sha256sum] = "bc9ffcef630b44d3150b0bb790b4539041ffcf4648cc28006f2f2b461a3c26ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-upgrade-devel-18.6-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-upgrade-devel;unpack=0"
SRC_URI[x86_64_v2_postgresql18-upgrade-devel.sha256sum] = "9df39cb30c59d9d3bf4197aac5808ed36a0d6bea7a085feb73b6be028e8b4ead"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18;unpack=0"
SRC_URI[aarch64_postgresql18.sha256sum] = "99d148f498a7eae39d482a9e8176b454027ebe4ee16826b3a181b7df6d071874"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-contrib-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-contrib;unpack=0"
SRC_URI[aarch64_postgresql18-contrib.sha256sum] = "9a9bc34bf3f09fb82686a3b915da87a8498ff8ee9a6fd03712d3b32ad28816e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-docs-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-docs;unpack=0"
SRC_URI[aarch64_postgresql18-docs.sha256sum] = "d2fcc9cfc5d5d0ec1f4e1d0cfbaa42d3ad6b61a65d19e57263240eb30ad52d9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-plperl-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-plperl;unpack=0"
SRC_URI[aarch64_postgresql18-plperl.sha256sum] = "649ffea8a8ec258b0d52146a97deabf5093c30d68f238d7fcf743987667f1b50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-plpython3-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-plpython3;unpack=0"
SRC_URI[aarch64_postgresql18-plpython3.sha256sum] = "c5fa787f799f70a981bf4fed2e36f3923a3da182d4d19cf1be4ddcfa7f5ae88a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-pltcl-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-pltcl;unpack=0"
SRC_URI[aarch64_postgresql18-pltcl.sha256sum] = "ad79a917d31fc7bec10d94834715268e33beefbefb6002bc499ab801c798396a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-private-devel-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-private-devel;unpack=0"
SRC_URI[aarch64_postgresql18-private-devel.sha256sum] = "0da63811ff68187a814beefb896a0470f4ee6ab06c1e0c012b7cf814e8983ead"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-private-libs-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-private-libs;unpack=0"
SRC_URI[aarch64_postgresql18-private-libs.sha256sum] = "874f155f9931a6ba7b70b607092502a7ab2f0dc7fb5618c13f05fb978353a0b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-server-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-server;unpack=0"
SRC_URI[aarch64_postgresql18-server.sha256sum] = "5515cfe31fbda5a9e31e6c99a75e3414702536be4c675bf09eee762e5395c6a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-server-devel-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-server-devel;unpack=0"
SRC_URI[aarch64_postgresql18-server-devel.sha256sum] = "f01315fcbecf1076bfdba0e46730d67763e5cbb94edada32b7682c43c7c9c1e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-static-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-static;unpack=0"
SRC_URI[aarch64_postgresql18-static.sha256sum] = "d28ab65fbe49ad4c96464cef9818f13fb5552bb4e4b2eee30e2e9d5a0b66eee4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-test-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-test;unpack=0"
SRC_URI[aarch64_postgresql18-test.sha256sum] = "623c5f2a41201d0865355768edf3af978791f6b2535015dba721b158e0911e88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/postgresql18-test-rpm-macros-18.6-1.el10_2.noarch.rpm;name=aarch64_postgresql18-test-rpm-macros;unpack=0"
SRC_URI[aarch64_postgresql18-test-rpm-macros.sha256sum] = "f2e3b11f55e89c173bf82a5ea89601eb7eb79b7b4a93eb73188bd59580feebb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-upgrade-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-upgrade;unpack=0"
SRC_URI[aarch64_postgresql18-upgrade.sha256sum] = "c5213f49c713f6bb263d7caf3d071a4370d28b5cf99499cbc86e41397a3d8880"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-upgrade-devel-18.6-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-upgrade-devel;unpack=0"
SRC_URI[aarch64_postgresql18-upgrade-devel.sha256sum] = "1c38a7a2ff5d496d6be7eacd31ca9112e8e14a6320cea66c0fbd876856b60773"

RDEPENDS:postgresql18 = " \
 glibc \
 libzstd \
 lz4-libs \
 openssl-libs \
 postgresql18-private-libs \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-contrib = " \
 glibc \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-libs \
 postgresql18 \
 postgresql18-private-libs \
 python3-libs \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-docs = " \
 glibc \
 postgresql18 \
 "
RDEPENDS:postgresql18-plperl = " \
 glibc \
 perl-libs \
 postgresql18-server \
 "
RDEPENDS:postgresql18-plpython3 = " \
 glibc \
 postgresql18-server \
 python3-libs \
 "
RDEPENDS:postgresql18-pltcl = " \
 glibc \
 postgresql18-server \
 tcl \
 "
RDEPENDS:postgresql18-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql18-private-libs \
 "
RDEPENDS:postgresql18-private-libs = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:postgresql18-server = " \
 bash \
 glibc \
 krb5-libs \
 libicu \
 libxml2 \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 postgresql18 \
 postgresql18-private-libs \
 systemd \
 systemd-libs \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-server-devel = " \
 bash \
 glibc \
 krb5-devel \
 libicu-devel \
 postgresql18-private-devel \
 postgresql18-private-libs \
 "
RDEPENDS:postgresql18-static = " \
 postgresql18-server-devel \
 "
RDEPENDS:postgresql18-test = " \
 bash \
 glibc \
 postgresql18-contrib \
 postgresql18-server \
 postgresql18-server-devel \
 "
RDEPENDS:postgresql18-test-rpm-macros = " \
 postgresql18-server \
 "
RDEPENDS:postgresql18-upgrade = " \
 glibc \
 krb5-libs \
 libicu \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 perl-libs \
 postgresql18-private-libs \
 postgresql18-server \
 python3-libs \
 tcl \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-upgrade-devel = " \
 bash \
 glibc \
 postgresql18-private-libs \
 postgresql18-upgrade \
 "
