# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-readme-renderer"
PV = "43.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-readme-renderer \
 python3-readme-renderer+md \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-readme-renderer-43.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75218d09bc9ddc32a1bd5099857a656bf648a70b8599e0de788f6a520fa06cd7"

URI_x86_64_v2_python3-readme-renderer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-readme-renderer-43.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-readme-renderer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-readme-renderer}"
SRC_URI[x86_64_v2_python3-readme-renderer.sha256sum] = "35b65bff1dc9dc96152bb5376c4f3694d736807b667f78b5d91aaf1575d99548"

URI_x86_64_v2_python3-readme-renderer+md = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-readme-renderer+md-43.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-readme-renderer+md;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-readme-renderer+md}"
SRC_URI[x86_64_v2_python3-readme-renderer+md.sha256sum] = "ea0178268c51780ce14780c9530b319461a8840f0aba8e08be1b531b4e8e8e06"

URI_aarch64_python3-readme-renderer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-readme-renderer-43.0-1.el10_1.noarch.rpm;name=aarch64_python3-readme-renderer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-readme-renderer}"
SRC_URI[aarch64_python3-readme-renderer.sha256sum] = "6aa00041e60af8db845c33a144ca6b936df1fdc58b5e3b84bd535b184d165c8b"

URI_aarch64_python3-readme-renderer+md = "${EPEL_MIRROR}/aarch64/Packages/p/python3-readme-renderer+md-43.0-1.el10_1.noarch.rpm;name=aarch64_python3-readme-renderer+md;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-readme-renderer+md}"
SRC_URI[aarch64_python3-readme-renderer+md.sha256sum] = "f99bd65cfe0550950c0273d5c706fda1b949f8121edd5b554b484852bd221d69"

RDEPENDS:python3-readme-renderer = " \
 python3 \
 python3-docutils \
 python3-nh3 \
 python3-pygments \
 "
RDEPENDS:python3-readme-renderer+md = " \
 python3 \
 python3-cmarkgfm \
 python3-readme-renderer \
 "
