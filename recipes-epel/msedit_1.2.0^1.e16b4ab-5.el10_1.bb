# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "msedit"
PV = "1.2.0^1.e16b4ab"
PR = "5.el10_1"
PACKAGES = " \
 msedit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/msedit-1.2.0^1.e16b4ab-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba37e66145c8e14808ff351c54edbc1b933e9cd1992fe17695c54aade75d9430"

URI_x86_64_v2_msedit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/msedit-1.2.0^1.e16b4ab-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_msedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msedit}"
SRC_URI[x86_64_v2_msedit.sha256sum] = "4ce92f9283c1d3f1ca91cd84402dd0d19bf1b0b4161e77cda443ecdf2b693a7c"

URI_aarch64_msedit = "${EPEL_MIRROR}/aarch64/Packages/m/msedit-1.2.0^1.e16b4ab-5.el10_1.aarch64.rpm;name=aarch64_msedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_msedit}"
SRC_URI[aarch64_msedit.sha256sum] = "adaaae51eb6a7481415c52d68d39f2d59cbcf2b220b4d8177d355617f001c2ef"

RDEPENDS:msedit = " \
 glibc \
 libgcc \
 "
