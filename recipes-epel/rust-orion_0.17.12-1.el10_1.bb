# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-orion"
PV = "0.17.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-orion+alloc-devel \
 rust-orion+ct-codecs-devel \
 rust-orion+default-devel \
 rust-orion+experimental-devel \
 rust-orion+getrandom-devel \
 rust-orion+safe_api-devel \
 rust-orion+serde-devel \
 rust-orion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-orion-0.17.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35ac22d458f196e25c96e5c39b71a26c828d080c8c4c0460ee4ddeb00d7e2045"

URI_x86_64_v2_rust-orion+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+alloc-devel-0.17.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+alloc-devel}"
SRC_URI[x86_64_v2_rust-orion+alloc-devel.sha256sum] = "0b9eefcda62833545d7b07328d602d6985a1568a67a17473d32cb49a2b004bc2"

URI_x86_64_v2_rust-orion+ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+ct-codecs-devel-0.17.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-orion+ct-codecs-devel.sha256sum] = "afc814dadcea24af4be6c2e48eda5d06fc759397517bef01b34d621bef720044"

URI_x86_64_v2_rust-orion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+default-devel-0.17.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+default-devel}"
SRC_URI[x86_64_v2_rust-orion+default-devel.sha256sum] = "985604a5bce07340eb83e71f9d81cc5a93f2e750b261f0795968fc2cf204b358"

URI_x86_64_v2_rust-orion+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+experimental-devel-0.17.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+experimental-devel}"
SRC_URI[x86_64_v2_rust-orion+experimental-devel.sha256sum] = "dc844fdb141077218e849394eed8ed5d650aff1851cb73e0506b0efcef9d74c6"

URI_x86_64_v2_rust-orion+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+getrandom-devel-0.17.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+getrandom-devel}"
SRC_URI[x86_64_v2_rust-orion+getrandom-devel.sha256sum] = "f37119775beb70cabe4dbc354a80f3278c335787d36d5761eb0442fb36f94910"

URI_x86_64_v2_rust-orion+safe_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+safe_api-devel-0.17.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+safe_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+safe_api-devel}"
SRC_URI[x86_64_v2_rust-orion+safe_api-devel.sha256sum] = "5c4a9d70e2417528c2bafb63351375df3a1386800c62b8ccc9486b68fe085890"

URI_x86_64_v2_rust-orion+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+serde-devel-0.17.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+serde-devel}"
SRC_URI[x86_64_v2_rust-orion+serde-devel.sha256sum] = "34797551111dd59729fce30490cd5bc2a007185cde726c098fc2711ae9023b85"

URI_x86_64_v2_rust-orion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion-devel-0.17.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion-devel}"
SRC_URI[x86_64_v2_rust-orion-devel.sha256sum] = "fb6a50cd630ba6d9341f25be6d95d80d3973e13dcbddd3801bac646ba8efd193"

URI_aarch64_rust-orion+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+alloc-devel-0.17.12-1.el10_1.noarch.rpm;name=aarch64_rust-orion+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+alloc-devel}"
SRC_URI[aarch64_rust-orion+alloc-devel.sha256sum] = "b87fa0654105af6c46b03314fb3ae5e759d059f83238907c4f617db50c24bd71"

URI_aarch64_rust-orion+ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+ct-codecs-devel-0.17.12-1.el10_1.noarch.rpm;name=aarch64_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+ct-codecs-devel}"
SRC_URI[aarch64_rust-orion+ct-codecs-devel.sha256sum] = "c664d3f72579eab5d7f9e857ef203bff844729fc4c341c85b03abd4cca299d23"

URI_aarch64_rust-orion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+default-devel-0.17.12-1.el10_1.noarch.rpm;name=aarch64_rust-orion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+default-devel}"
SRC_URI[aarch64_rust-orion+default-devel.sha256sum] = "e697d5bc0ae21e4d1f4980ef8856d36128c8ce6bb5ff8341a30bae6987097a5b"

URI_aarch64_rust-orion+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+experimental-devel-0.17.12-1.el10_1.noarch.rpm;name=aarch64_rust-orion+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+experimental-devel}"
SRC_URI[aarch64_rust-orion+experimental-devel.sha256sum] = "8d5716491c9411b93a9992538e5f397d5e1ea2a4d8071d393f02f700ceb439e4"

URI_aarch64_rust-orion+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+getrandom-devel-0.17.12-1.el10_1.noarch.rpm;name=aarch64_rust-orion+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+getrandom-devel}"
SRC_URI[aarch64_rust-orion+getrandom-devel.sha256sum] = "46db3730b846e8bcb2aba6f07b9085f1ec1016df468edff103527dc92f106132"

URI_aarch64_rust-orion+safe_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+safe_api-devel-0.17.12-1.el10_1.noarch.rpm;name=aarch64_rust-orion+safe_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+safe_api-devel}"
SRC_URI[aarch64_rust-orion+safe_api-devel.sha256sum] = "edb04f1cd0cf93bd56f154a7b5154419883ab766812034a51463db45cd8e6980"

URI_aarch64_rust-orion+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+serde-devel-0.17.12-1.el10_1.noarch.rpm;name=aarch64_rust-orion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+serde-devel}"
SRC_URI[aarch64_rust-orion+serde-devel.sha256sum] = "30b3090be8e854b9afc552e99735a8e805ec430518778e863b10932da9a4bf3b"

URI_aarch64_rust-orion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion-devel-0.17.12-1.el10_1.noarch.rpm;name=aarch64_rust-orion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion-devel}"
SRC_URI[aarch64_rust-orion-devel.sha256sum] = "7cfd31938384c5363b20d42ad10fa552d3da0f63dfb276bcbe2d3b90a2673ddb"

RDEPENDS:rust-orion+alloc-devel = " \
 cargo \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+ct-codecs-devel = " \
 cargo \
 rust-ct-codecs+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+default-devel = " \
 cargo \
 rust-orion+safe_api-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+experimental-devel = " \
 cargo \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+safe_api-devel = " \
 cargo \
 rust-orion+ct-codecs-devel \
 rust-orion+getrandom-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+serde-devel = " \
 cargo \
 rust-orion+alloc-devel \
 rust-orion-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-orion-devel = " \
 cargo \
 rust \
 rust-fiat-crypto-devel \
 rust-subtle-devel \
 rust-zeroize-devel \
 "
