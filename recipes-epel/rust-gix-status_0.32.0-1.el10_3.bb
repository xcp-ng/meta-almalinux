# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-status"
PV = "0.32.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-status+default-devel \
 rust-gix-status+document-features-devel \
 rust-gix-status+parallel-devel \
 rust-gix-status+sha1-devel \
 rust-gix-status+sha256-devel \
 rust-gix-status+worktree-rewrites-devel \
 rust-gix-status-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-status-0.32.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c613811bdbeba596b73054cf30a96ca6575dc24b0bd37858a89b72603ea76104"

URI_x86_64_v2_rust-gix-status+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+default-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+default-devel}"
SRC_URI[x86_64_v2_rust-gix-status+default-devel.sha256sum] = "7779c006d1a519f325d73592c374cf37962ca9e6c3c0ab4d5984f632e64859e5"

URI_x86_64_v2_rust-gix-status+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+document-features-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-status+document-features-devel.sha256sum] = "d3b757dc131f436d939fbe768e71f9fbd9abb930825cb91e9528849c598e8ab6"

URI_x86_64_v2_rust-gix-status+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+parallel-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-status+parallel-devel.sha256sum] = "c8d1e18f4d31d9f406804f77fe928c41fe10ee3df1c9bbebaaf0b11e04c1b749"

URI_x86_64_v2_rust-gix-status+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+sha1-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-status+sha1-devel.sha256sum] = "a9d5a232236ff4e7a7ba4abb749692a6c51990d4b559a19f4d43ac7b4f5feb03"

URI_x86_64_v2_rust-gix-status+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+sha256-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-status+sha256-devel.sha256sum] = "d0556b5513a08a00027af762371b060a85c06233a5198b9a8c3f9bebf9a9f132"

URI_x86_64_v2_rust-gix-status+worktree-rewrites-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+worktree-rewrites-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+worktree-rewrites-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+worktree-rewrites-devel}"
SRC_URI[x86_64_v2_rust-gix-status+worktree-rewrites-devel.sha256sum] = "8e1facfbbb71fbb59056e90a115045287e9ad6c08962601de0d45d88dfb6c4a9"

URI_x86_64_v2_rust-gix-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status-devel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status-devel}"
SRC_URI[x86_64_v2_rust-gix-status-devel.sha256sum] = "1dd72d36d04c1ef5c7e99bbfa86bcabe5dbf8d18731699a681add51996035484"

URI_aarch64_rust-gix-status+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+default-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-status+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+default-devel}"
SRC_URI[aarch64_rust-gix-status+default-devel.sha256sum] = "75893d2c3493c6bd08aaf6f91d0acbee401fbe281be5cf610556e6b8030d713a"

URI_aarch64_rust-gix-status+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+document-features-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-status+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+document-features-devel}"
SRC_URI[aarch64_rust-gix-status+document-features-devel.sha256sum] = "a3125174a7057d782f0edc26fa3e5b896747d1e8d63c2d6fb2e199f62c0f97b4"

URI_aarch64_rust-gix-status+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+parallel-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-status+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+parallel-devel}"
SRC_URI[aarch64_rust-gix-status+parallel-devel.sha256sum] = "c5e88d69fea87b6d38c963ef96706a85b6570a04f3a538173e0c0ae37b55f7f9"

URI_aarch64_rust-gix-status+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+sha1-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-status+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+sha1-devel}"
SRC_URI[aarch64_rust-gix-status+sha1-devel.sha256sum] = "a163995cbaf8cab343cc12854e7c0009b0124214de8acb617e0264932f81c7e5"

URI_aarch64_rust-gix-status+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+sha256-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-status+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+sha256-devel}"
SRC_URI[aarch64_rust-gix-status+sha256-devel.sha256sum] = "f87f8e74411c0db2de9a9ef5fa5d7c1877dc20d73acc075f3114afb54994daff"

URI_aarch64_rust-gix-status+worktree-rewrites-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+worktree-rewrites-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-status+worktree-rewrites-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+worktree-rewrites-devel}"
SRC_URI[aarch64_rust-gix-status+worktree-rewrites-devel.sha256sum] = "f5efe8ff183a3f290363a6d5bf393db233dfb066b9caa8b6eb394f5a2a2f4bb9"

URI_aarch64_rust-gix-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status-devel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status-devel}"
SRC_URI[aarch64_rust-gix-status-devel.sha256sum] = "c83308e00084e8f3d3b3a1e56aec51e1c7590988faa6005f2398b8caceee019f"

RDEPENDS:rust-gix-status+default-devel = " \
 cargo \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+parallel-devel = " \
 cargo \
 rust-gix-features+parallel-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+worktree-rewrites-devel = " \
 cargo \
 rust-gix-diff+blob-devel \
 rust-gix-diff-devel \
 rust-gix-dir+default-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-filetime+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-thiserror+default-devel \
 "
