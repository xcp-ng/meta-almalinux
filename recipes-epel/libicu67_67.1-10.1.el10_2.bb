# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libicu67"
PV = "67.1"
PR = "10.1.el10_2"
PACKAGES = " \
 libicu67 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libicu67-67.1-10.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a0e6ff63268c7a4a9606144ebf153eda7fb40a0958ea6d02590ca7bca285875"

URI_x86_64_v2_libicu67 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libicu67-67.1-10.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libicu67;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libicu67}"
SRC_URI[x86_64_v2_libicu67.sha256sum] = "9502f35bea5bdc7c481e4647dd707fc7698022c6e1d47f31c5829786f4a79635"

URI_aarch64_libicu67 = "${EPEL_MIRROR}/aarch64/Packages/l/libicu67-67.1-10.1.el10_2.aarch64.rpm;name=aarch64_libicu67;unpack=0"
SRC_URI:append = " ${URI_aarch64_libicu67}"
SRC_URI[aarch64_libicu67.sha256sum] = "231637f3dbb307d15cc0468d7d10d90b3dfbe37983129ae60dab71df677368ac"

RDEPENDS:libicu67 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
