# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-mai"
PV = "1.0.1"
PR = "32.el10"
PACKAGES = " \
 hunspell-mai \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-mai-1.0.1-32.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "15e18bd2ec8c4fd663c4394d1edc9da7b5d275dcfa1e4795a470968ec2860753"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-mai-1.0.1-32.el10.noarch.rpm;name=x86_64_v2_hunspell-mai;unpack=0"
SRC_URI[x86_64_v2_hunspell-mai.sha256sum] = "937bc8d115454fb7b73c962099910038b05e4a49fdbeb0b460a8bffcc279cd34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-mai-1.0.1-32.el10.noarch.rpm;name=aarch64_hunspell-mai;unpack=0"
SRC_URI[aarch64_hunspell-mai.sha256sum] = "937bc8d115454fb7b73c962099910038b05e4a49fdbeb0b460a8bffcc279cd34"

RDEPENDS:hunspell-mai = " \
 hunspell-filesystem \
 "
