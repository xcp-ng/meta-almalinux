# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rng-tools"
PV = "6.17"
PR = "5.el10"
PACKAGES = " \
 rng-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rng-tools-6.17-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c360e096a362c42492b181db458a8b0142ebc2553095a5b3a24b653842e4d9e"

URI_x86_64_v2_rng-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rng-tools-6.17-5.el10.x86_64_v2.rpm;name=x86_64_v2_rng-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rng-tools}"
SRC_URI[x86_64_v2_rng-tools.sha256sum] = "eaa4321e3a9c0ec9426e0b6016160ea377964d5ce3b9991dcc12c1e46c1d94e1"

URI_aarch64_rng-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rng-tools-6.17-5.el10.aarch64.rpm;name=aarch64_rng-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_rng-tools}"
SRC_URI[aarch64_rng-tools.sha256sum] = "a6ce436bcaeb4bee1f30b543a363c08df9f3e21f01047e56225ca8a95bfcc4ef"

RDEPENDS:rng-tools = " \
 bash \
 glibc \
 jansson \
 jitterentropy \
 libcap \
 openssl-libs \
 selinux-policy \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
