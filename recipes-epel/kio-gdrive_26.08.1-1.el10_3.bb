# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-gdrive"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kio-gdrive \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kio-gdrive-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7a98d41f3ad9fdccc14cbd518c1da4dcfbcbf804cc7442e46e3f8f3ff721bc01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-gdrive-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-gdrive;unpack=0"
SRC_URI[x86_64_v2_kio-gdrive.sha256sum] = "b127d9c8acb301f55ca19d448884a52e27cefa42078d540dfd24338a019eee3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kio-gdrive-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kio-gdrive;unpack=0"
SRC_URI[aarch64_kio-gdrive.sha256sum] = "698249fc11871f2fa2334ca209994de1026dd434cb38172dbb7b021e0c02d9a7"

RDEPENDS:kio-gdrive = " \
 accounts-qml-module-qt6 \
 glibc \
 kaccounts-integration-qt6 \
 kaccounts-providers \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-purpose \
 libaccounts-qt6 \
 libkgapi \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
