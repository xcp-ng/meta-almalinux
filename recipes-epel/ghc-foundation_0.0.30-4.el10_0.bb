# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-foundation"
PV = "0.0.30"
PR = "4.el10_0"
PACKAGES = " \
 ghc-foundation \
 ghc-foundation-devel \
 ghc-foundation-doc \
 ghc-foundation-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-foundation-0.0.30-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2e6324d505d7b1baec53b8756a195cdb5b26d0d7f2a238d0a1540f67bb2a4a0"

URI_x86_64_v2_ghc-foundation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-foundation-0.0.30-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-foundation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-foundation}"
SRC_URI[x86_64_v2_ghc-foundation.sha256sum] = "21a0df5423e4f4d0437b274d0c1cbec7fca4c5f7290105d120f267419c9a9913"

URI_x86_64_v2_ghc-foundation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-foundation-devel-0.0.30-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-foundation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-foundation-devel}"
SRC_URI[x86_64_v2_ghc-foundation-devel.sha256sum] = "3d1bea64a46c6750e964ab96c11fe13c07228f15d58f52b0e3770694e94c3486"

URI_x86_64_v2_ghc-foundation-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-foundation-doc-0.0.30-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-foundation-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-foundation-doc}"
SRC_URI[x86_64_v2_ghc-foundation-doc.sha256sum] = "15c07b905d0956d51fc7dab13a8408e7eb4984b1c16221d1743c130ca3f6e19f"

URI_x86_64_v2_ghc-foundation-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-foundation-prof-0.0.30-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-foundation-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-foundation-prof}"
SRC_URI[x86_64_v2_ghc-foundation-prof.sha256sum] = "e12defd3441ec947bc6c4eed8e2e4df7e84cad58430e9fa791f15c22287208e2"

URI_aarch64_ghc-foundation = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-foundation-0.0.30-4.el10_0.aarch64.rpm;name=aarch64_ghc-foundation;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-foundation}"
SRC_URI[aarch64_ghc-foundation.sha256sum] = "f145dd6151ba187b316a6e38ad795d7e8d5c7d8bd3854c2307a78bb8c2e20fe2"

URI_aarch64_ghc-foundation-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-foundation-devel-0.0.30-4.el10_0.aarch64.rpm;name=aarch64_ghc-foundation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-foundation-devel}"
SRC_URI[aarch64_ghc-foundation-devel.sha256sum] = "fa918f777b970ce598ebc5bd5d94cea0d30d2df7ff0e578abcbe4a88fdf2b2f2"

URI_aarch64_ghc-foundation-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-foundation-doc-0.0.30-4.el10_0.noarch.rpm;name=aarch64_ghc-foundation-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-foundation-doc}"
SRC_URI[aarch64_ghc-foundation-doc.sha256sum] = "3a171b0ec01038068378401b748c5b241637bbc877f126b04c18b21873aa6bf5"

URI_aarch64_ghc-foundation-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-foundation-prof-0.0.30-4.el10_0.aarch64.rpm;name=aarch64_ghc-foundation-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-foundation-prof}"
SRC_URI[aarch64_ghc-foundation-prof.sha256sum] = "b0c07fd3c79c8904ff530054f57861d5fbb8066c91ba556e3522246c60c5414d"

RDEPENDS:ghc-foundation = " \
 ghc-base \
 ghc-basement \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-foundation-devel = " \
 ghc-base-devel \
 ghc-basement-devel \
 ghc-compiler \
 ghc-foundation \
 "
RDEPENDS:ghc-foundation-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-foundation-prof = " \
 ghc-base-prof \
 ghc-basement-prof \
 ghc-foundation-devel \
 "
