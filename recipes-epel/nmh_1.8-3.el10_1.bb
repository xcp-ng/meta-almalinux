# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmh"
PV = "1.8"
PR = "3.el10_1"
PACKAGES = " \
 nmh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nmh-1.8-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7da2af54a7aa336b78cc25625cf5f14199b81948347fc92bc56a8a4f6a11591f"

URI_x86_64_v2_nmh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nmh-1.8-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nmh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmh}"
SRC_URI[x86_64_v2_nmh.sha256sum] = "e15980d26413ad12cff71d6c9c85a2b4da09faacc527dcd3aeab9a71f672be13"

URI_aarch64_nmh = "${EPEL_MIRROR}/aarch64/Packages/n/nmh-1.8-3.el10_1.aarch64.rpm;name=aarch64_nmh;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmh}"
SRC_URI[aarch64_nmh.sha256sum] = "f78ae252dced741857b4723950a09c7458842e215212362a87107777ba3dcc11"

RDEPENDS:nmh = " \
 bash \
 cyrus-sasl-lib \
 gdbm-libs \
 glibc \
 lynx \
 ncurses-libs \
 openssl-libs \
 readline \
 virtual/libcurl.so.4___64bit_ \
 "
