# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-untrusted"
PV = "0.9.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-untrusted+default-devel \
 rust-untrusted-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-untrusted-0.9.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3973c5f58bc01e68fe7f8314164540de42763cf25b1d8860694d67176f200e04"

URI_x86_64_v2_rust-untrusted+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-untrusted+default-devel-0.9.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-untrusted+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-untrusted+default-devel}"
SRC_URI[x86_64_v2_rust-untrusted+default-devel.sha256sum] = "1a22facb2714ea6cf2c06041e2ff5e4cf4964158131957e2f3c383ba89d9c888"

URI_x86_64_v2_rust-untrusted-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-untrusted-devel-0.9.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-untrusted-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-untrusted-devel}"
SRC_URI[x86_64_v2_rust-untrusted-devel.sha256sum] = "286030ba86b674e3e5423fee4263c064fec1abd9cf200df69f74d01ac76b2331"

URI_aarch64_rust-untrusted+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-untrusted+default-devel-0.9.0-3.el10_0.noarch.rpm;name=aarch64_rust-untrusted+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-untrusted+default-devel}"
SRC_URI[aarch64_rust-untrusted+default-devel.sha256sum] = "3643ea29f033d620ba8ef0b7d0de21c18ce8a49e516cd95f474385a1469f3865"

URI_aarch64_rust-untrusted-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-untrusted-devel-0.9.0-3.el10_0.noarch.rpm;name=aarch64_rust-untrusted-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-untrusted-devel}"
SRC_URI[aarch64_rust-untrusted-devel.sha256sum] = "7bd321e9f89c0f7b71b269ea7af7bf23b22d78efa8f79cfec9bc87ac28580a17"

RDEPENDS:rust-untrusted+default-devel = " \
 cargo \
 rust-untrusted-devel \
 "
RDEPENDS:rust-untrusted-devel = " \
 cargo \
 "
