# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cairo"
PV = "1.109"
PR = "20.el10_0"
PACKAGES = " \
 perl-Cairo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cairo-1.109-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73e65adf0821fb31d1023be6090db9a85322c343c32f8ffd5010b9f6d520c6a5"

URI_x86_64_v2_perl-Cairo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cairo-1.109-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cairo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cairo}"
SRC_URI[x86_64_v2_perl-Cairo.sha256sum] = "817f0a7e7965cd4b579b87bf51e486b614a4616cba60fdd7731b409ce818006c"

URI_aarch64_perl-Cairo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cairo-1.109-20.el10_0.aarch64.rpm;name=aarch64_perl-Cairo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cairo}"
SRC_URI[aarch64_perl-Cairo.sha256sum] = "55dd4c6b8d87b321c38249a9be75d0e4e8662a6b600c08bc474faa2a124b1955"

RDEPENDS:perl-Cairo = " \
 cairo \
 glibc \
 perl-DynaLoader \
 perl-libs \
 "
