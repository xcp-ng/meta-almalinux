# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Pod-Markdown"
PV = "3.400"
PR = "6.el10"
PACKAGES = " \
 perl-Pod-Markdown \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Pod-Markdown-3.400-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "090bb8712e0f4fd4f67a7f95eb2f757385ac0ee9e4306e23e697838c62dba9fd"

URI_x86_64_v2_perl-Pod-Markdown = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Pod-Markdown-3.400-6.el10.noarch.rpm;name=x86_64_v2_perl-Pod-Markdown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Pod-Markdown}"
SRC_URI[x86_64_v2_perl-Pod-Markdown.sha256sum] = "07f4b7228e834675cf232713987b24a901cfb10f42e30e8c43256f337b3661fb"

URI_aarch64_perl-Pod-Markdown = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Pod-Markdown-3.400-6.el10.noarch.rpm;name=aarch64_perl-Pod-Markdown;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Pod-Markdown}"
SRC_URI[aarch64_perl-Pod-Markdown.sha256sum] = "07f4b7228e834675cf232713987b24a901cfb10f42e30e8c43256f337b3661fb"

RDEPENDS:perl-Pod-Markdown = " \
 perl-Encode \
 perl-Getopt-Long \
 perl-Pod-Markdown \
 perl-Pod-Simple \
 perl-Pod-Usage \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-parent \
 "
