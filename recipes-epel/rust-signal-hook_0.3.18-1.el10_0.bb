# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook"
PV = "0.3.18"
PR = "1.el10_0"
PACKAGES = " \
 rust-signal-hook+cc-devel \
 rust-signal-hook+channel-devel \
 rust-signal-hook+default-devel \
 rust-signal-hook+extended-siginfo-devel \
 rust-signal-hook+extended-siginfo-raw-devel \
 rust-signal-hook+iterator-devel \
 rust-signal-hook-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook-0.3.18-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6430a3e6e142e6c0e930d24fe5e7117737e8ca2c90a71a31455bbb6bdf4b63d6"

URI_x86_64_v2_rust-signal-hook+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+cc-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+cc-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+cc-devel.sha256sum] = "3abe9e111b34ba8b37890e3480dd1690ed458c1ebd27079085c90d21cd4ffcd5"

URI_x86_64_v2_rust-signal-hook+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+channel-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+channel-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+channel-devel.sha256sum] = "bff1f063977e03a5e494e590d96fb03f06687e7047823b391c9fabf64caf5a69"

URI_x86_64_v2_rust-signal-hook+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+default-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+default-devel.sha256sum] = "7d1c0f2e6949ef7dd684f1d3523dae97392698620548d06d3a8d1d1513936ddc"

URI_x86_64_v2_rust-signal-hook+extended-siginfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+extended-siginfo-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+extended-siginfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+extended-siginfo-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+extended-siginfo-devel.sha256sum] = "050e8d391ecdc0f881b73192cd481370561c50341ae03f165c20ea717b96fdcd"

URI_x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+extended-siginfo-raw-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel.sha256sum] = "0f4c300a5851f2a6a7d5bc2a57e1e9e321cfc13ee965b0347c2df569bc6d311f"

URI_x86_64_v2_rust-signal-hook+iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+iterator-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+iterator-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+iterator-devel.sha256sum] = "d34299d59e82981ffeb800ea9b71bcbb204d0f3fcbc4aae32e2d92f8b3bf224f"

URI_x86_64_v2_rust-signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-devel.sha256sum] = "009699427bf3fc26cf09334f7f1ecd95999c58c80ced4cd32271c161e7881873"

URI_aarch64_rust-signal-hook+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+cc-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+cc-devel}"
SRC_URI[aarch64_rust-signal-hook+cc-devel.sha256sum] = "faecdc7bd0bfcc57a8982aeaaec8448617a67d3b6fdad931dcd2156e9399f86c"

URI_aarch64_rust-signal-hook+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+channel-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+channel-devel}"
SRC_URI[aarch64_rust-signal-hook+channel-devel.sha256sum] = "e6b76b4f3d429a51796e70ca2d746ec0f497748af175442b624a06fa43439b71"

URI_aarch64_rust-signal-hook+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+default-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+default-devel}"
SRC_URI[aarch64_rust-signal-hook+default-devel.sha256sum] = "70f614735f4abe9ade5a75a519781c9c371391276f3a39ab47bb6f0e487f63a6"

URI_aarch64_rust-signal-hook+extended-siginfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+extended-siginfo-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook+extended-siginfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+extended-siginfo-devel}"
SRC_URI[aarch64_rust-signal-hook+extended-siginfo-devel.sha256sum] = "cceb1788d7010ae35962c49b52bafc5e8bb4b72a9582c4b25d8411186b21eec9"

URI_aarch64_rust-signal-hook+extended-siginfo-raw-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+extended-siginfo-raw-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook+extended-siginfo-raw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+extended-siginfo-raw-devel}"
SRC_URI[aarch64_rust-signal-hook+extended-siginfo-raw-devel.sha256sum] = "36d54c03599da260645c230b6c335a8335335057fa88dbc47700a73e43e8ea24"

URI_aarch64_rust-signal-hook+iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+iterator-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook+iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+iterator-devel}"
SRC_URI[aarch64_rust-signal-hook+iterator-devel.sha256sum] = "4622c6dd99fc74d7026e81dc002c2dddcc4641b46851bc569d8c90b57ce35daf"

URI_aarch64_rust-signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-devel}"
SRC_URI[aarch64_rust-signal-hook-devel.sha256sum] = "4bce37414be5eed9ed6295ea26218a61318ca047a3c5b3c2fc6e7653050f52a8"

RDEPENDS:rust-signal-hook+cc-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+channel-devel = " \
 cargo \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+default-devel = " \
 cargo \
 rust-signal-hook+channel-devel \
 rust-signal-hook+iterator-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+extended-siginfo-devel = " \
 cargo \
 rust-signal-hook+channel-devel \
 rust-signal-hook+extended-siginfo-raw-devel \
 rust-signal-hook+iterator-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+extended-siginfo-raw-devel = " \
 cargo \
 rust-signal-hook+cc-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+iterator-devel = " \
 cargo \
 rust-signal-hook+channel-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook-devel = " \
 bash \
 cargo \
 rust-libc+default-devel \
 rust-signal-hook-registry+default-devel \
 "
