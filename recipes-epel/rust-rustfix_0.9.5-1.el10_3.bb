# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustfix"
PV = "0.9.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustfix+default-devel \
 rust-rustfix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustfix-0.9.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e69a1ed3a93f1eb8ed746a10620f38df77d21a7e8f4f618680adb961cf9c435"

URI_x86_64_v2_rust-rustfix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfix+default-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfix+default-devel}"
SRC_URI[x86_64_v2_rust-rustfix+default-devel.sha256sum] = "4eeb0419b72005ff8e3cc43ef997927959cce57e75c5d875a5bb1f9eec129ed7"

URI_x86_64_v2_rust-rustfix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfix-devel-0.9.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfix-devel}"
SRC_URI[x86_64_v2_rust-rustfix-devel.sha256sum] = "c695ac169ae956156f19fa9ed0e3cd6f0246e6f4584d6c6f5f91680496f37930"

URI_aarch64_rust-rustfix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfix+default-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustfix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfix+default-devel}"
SRC_URI[aarch64_rust-rustfix+default-devel.sha256sum] = "9777350ad8e1689e00adf41442e11c787d0cab371e32d054019cb5ce04c89b81"

URI_aarch64_rust-rustfix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfix-devel-0.9.5-1.el10_3.noarch.rpm;name=aarch64_rust-rustfix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfix-devel}"
SRC_URI[aarch64_rust-rustfix-devel.sha256sum] = "ed3b233b35651379b8c7503ec634f0a6d41708f57884cbfece34c41048788de3"

RDEPENDS:rust-rustfix+default-devel = " \
 cargo \
 rust-rustfix-devel \
 "
RDEPENDS:rust-rustfix-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
