# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-te"
PE = "1"
PV = "0.7.0"
PR = "27.el10"
PACKAGES = " \
 hyphen-te \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-te-0.7.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c9e52d136fb1a6c98240dad6352fa83ea22b7e498b82c1d6ca7b485cd87e5067"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-te-0.7.0-27.el10.noarch.rpm;name=x86_64_v2_hyphen-te;unpack=0"
SRC_URI[x86_64_v2_hyphen-te.sha256sum] = "aace9f6c37f29c52e59be260d60ad8c87ff353ed16171a0b0d0183947a765718"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-te-0.7.0-27.el10.noarch.rpm;name=aarch64_hyphen-te;unpack=0"
SRC_URI[aarch64_hyphen-te.sha256sum] = "aace9f6c37f29c52e59be260d60ad8c87ff353ed16171a0b0d0183947a765718"

RDEPENDS:hyphen-te = " \
 hyphen \
 "
