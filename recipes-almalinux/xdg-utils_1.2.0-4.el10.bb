# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-utils"
PV = "1.2.0"
PR = "4.el10"
PACKAGES = " \
 xdg-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdg-utils-1.2.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62a67ec5cb53e9d98d116af2a212abffc5d3c5ef64b78961b701dee40ff0fa5f"

URI_x86_64_v2_xdg-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdg-utils-1.2.0-4.el10.noarch.rpm;name=x86_64_v2_xdg-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-utils}"
SRC_URI[x86_64_v2_xdg-utils.sha256sum] = "4f0d6ac8eb4d5f14e4abac82d4b6c5a78b67b20e2e28b92eb417f48f2f16d52c"

URI_aarch64_xdg-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdg-utils-1.2.0-4.el10.noarch.rpm;name=aarch64_xdg-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-utils}"
SRC_URI[aarch64_xdg-utils.sha256sum] = "4f0d6ac8eb4d5f14e4abac82d4b6c5a78b67b20e2e28b92eb417f48f2f16d52c"

RDEPENDS:xdg-utils = " \
 bash \
 desktop-file-utils \
 virtual/coreutils \
 which \
 "
