# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_segmenter_data"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_segmenter_data+default-devel \
 rust-icu_segmenter_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_segmenter_data-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "419d1bae8093624efaa962c9dea93c36c3dc2043bb23da9194778dc82421d46d"

URI_x86_64_v2_rust-icu_segmenter_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter_data+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter_data+default-devel.sha256sum] = "e24aceecec2e6d050270398d031dc2488c4eea25d4f9eca738ce58b27e56adab"

URI_x86_64_v2_rust-icu_segmenter_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_segmenter_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_segmenter_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_segmenter_data-devel}"
SRC_URI[x86_64_v2_rust-icu_segmenter_data-devel.sha256sum] = "2d9c1c6d9e1d1518d5278ca22e87b07390a58a8b217616e3882be9a1c1c143dd"

URI_aarch64_rust-icu_segmenter_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter_data+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_segmenter_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter_data+default-devel}"
SRC_URI[aarch64_rust-icu_segmenter_data+default-devel.sha256sum] = "14d2621654c179bb19a376c47d1b53b1f10abd98a7aed55b1c18dee45b9fd887"

URI_aarch64_rust-icu_segmenter_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_segmenter_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_segmenter_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_segmenter_data-devel}"
SRC_URI[aarch64_rust-icu_segmenter_data-devel.sha256sum] = "6637b445e842f6e40ed2c56ce75b5ef6ba573c254c65f34fe8cbdf82fe79138e"

RDEPENDS:rust-icu_segmenter_data+default-devel = " \
 cargo \
 rust-icu_segmenter_data-devel \
 "
RDEPENDS:rust-icu_segmenter_data-devel = " \
 cargo \
 rust \
 "
