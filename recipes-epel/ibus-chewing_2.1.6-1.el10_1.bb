# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-chewing"
PV = "2.1.6"
PR = "1.el10_1"
PACKAGES = " \
 ibus-chewing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ibus-chewing-2.1.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6657507b19b9993c69628c87d802fc8f9fe3961b5c4c78434d43c08c35fcb90b"

URI_x86_64_v2_ibus-chewing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ibus-chewing-2.1.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ibus-chewing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-chewing}"
SRC_URI[x86_64_v2_ibus-chewing.sha256sum] = "b647d884fa4b6579fc77c3892db7bd84da33df4e12851483254d37879918e3e3"

URI_aarch64_ibus-chewing = "${EPEL_MIRROR}/aarch64/Packages/i/ibus-chewing-2.1.6-1.el10_1.aarch64.rpm;name=aarch64_ibus-chewing;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-chewing}"
SRC_URI[aarch64_ibus-chewing.sha256sum] = "f33b4f79dea3fee709d3ea980c92a399ad03a411fd70a597d7a730a8b860b157"

RDEPENDS:ibus-chewing = " \
 glib2 \
 glibc \
 gtk4 \
 ibus-libs \
 libadwaita \
 libchewing \
 libgcc \
 "
