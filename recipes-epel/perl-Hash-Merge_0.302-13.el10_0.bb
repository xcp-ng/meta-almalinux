# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Hash-Merge"
PV = "0.302"
PR = "13.el10_0"
PACKAGES = " \
 perl-Hash-Merge \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Hash-Merge-0.302-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d2def24e5dc6ce3e719740773deb59b8f7140c97618ba1565678b005b3ef7f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Hash-Merge-0.302-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Hash-Merge;unpack=0"
SRC_URI[x86_64_v2_perl-Hash-Merge.sha256sum] = "f92ce8856c96abeb13956fd61cb59e04505fe86a29b0463ce887157b5c3833eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Hash-Merge-0.302-13.el10_0.noarch.rpm;name=aarch64_perl-Hash-Merge;unpack=0"
SRC_URI[aarch64_perl-Hash-Merge.sha256sum] = "ccb1210466cb7a3d15e380fbaec57995cd69c9c927d9cdbe096fafdfac838a55"

RDEPENDS:perl-Hash-Merge = " \
 perl-Carp \
 perl-Clone \
 perl-Clone-Choose \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 "
