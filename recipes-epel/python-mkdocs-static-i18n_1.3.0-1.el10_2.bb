# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-static-i18n"
PV = "1.3.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-mkdocs-static-i18n \
 python3-mkdocs-static-i18n+material \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-static-i18n-1.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bde41ee768ef3ef2dc7e770e47195705afd8c7cedb0b796bd5b24bc208976247"

URI_x86_64_v2_python3-mkdocs-static-i18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-static-i18n-1.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-static-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-static-i18n}"
SRC_URI[x86_64_v2_python3-mkdocs-static-i18n.sha256sum] = "5acf3a7b240cfd316bb85bca654bfbade7b399e1e2986d7540efacbe8f6939c9"

URI_x86_64_v2_python3-mkdocs-static-i18n+material = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-static-i18n+material-1.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-static-i18n+material;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-static-i18n+material}"
SRC_URI[x86_64_v2_python3-mkdocs-static-i18n+material.sha256sum] = "70f56026fe75f4ace4738eb26e5b98e2b74582ebdfe6ccc39ba5a2d8460162a1"

URI_aarch64_python3-mkdocs-static-i18n = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-static-i18n-1.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-static-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-static-i18n}"
SRC_URI[aarch64_python3-mkdocs-static-i18n.sha256sum] = "7be45a827e5024b8d00b5d0d21eda4c4716abec44a2d8f36857bf62043338c61"

URI_aarch64_python3-mkdocs-static-i18n+material = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-static-i18n+material-1.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-static-i18n+material;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-static-i18n+material}"
SRC_URI[aarch64_python3-mkdocs-static-i18n+material.sha256sum] = "e881b69a18e9ee18b9cf4776d5b649a2cae59eb04bf6a2bbd58d194647c6b8be"

RDEPENDS:python3-mkdocs-static-i18n = " \
 mkdocs \
 python3 \
 "
RDEPENDS:python3-mkdocs-static-i18n+material = " \
 mkdocs-material \
 python3 \
 python3-mkdocs-static-i18n \
 "
