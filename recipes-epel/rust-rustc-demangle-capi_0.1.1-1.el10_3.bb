# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-demangle-capi"
PV = "0.1.1"
PR = "1.el10_3"
PACKAGES = " \
 librustc_demangle \
 librustc_demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-demangle-capi-0.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eba58a59241a97a824dde397d91212d5ac589b13428d44f453405cf3f718e205"

URI_x86_64_v2_librustc_demangle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librustc_demangle-0.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librustc_demangle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librustc_demangle}"
SRC_URI[x86_64_v2_librustc_demangle.sha256sum] = "69ac0871d02f3ab8ebd9f24c254bcdae5e353812f96526180d69d1c6d9f9d5b0"

URI_x86_64_v2_librustc_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librustc_demangle-devel-0.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librustc_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librustc_demangle-devel}"
SRC_URI[x86_64_v2_librustc_demangle-devel.sha256sum] = "8d57562cdcf9d6b7e4cdebe39b384b3f1c040d8601f5ed2335bab001be8ef922"

URI_aarch64_librustc_demangle = "${EPEL_MIRROR}/aarch64/Packages/l/librustc_demangle-0.1.1-1.el10_3.aarch64.rpm;name=aarch64_librustc_demangle;unpack=0"
SRC_URI:append = " ${URI_aarch64_librustc_demangle}"
SRC_URI[aarch64_librustc_demangle.sha256sum] = "4aabf253aac5ef9dcc14e1373e59cc8571bb6626e79166c1dacb200996173c54"

URI_aarch64_librustc_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librustc_demangle-devel-0.1.1-1.el10_3.aarch64.rpm;name=aarch64_librustc_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librustc_demangle-devel}"
SRC_URI[aarch64_librustc_demangle-devel.sha256sum] = "9f21698c1fab37523efeefe787c0bbc283b628b7321a85f3ccf7c15a576adb32"

RDEPENDS:librustc_demangle = " \
 glibc \
 libgcc \
 "
RDEPENDS:librustc_demangle-devel = " \
 librustc_demangle \
 pkgconf-pkg-config \
 "
