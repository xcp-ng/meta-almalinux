# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_locid"
PV = "1.5.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-icu_locid+databake-devel \
 rust-icu_locid+default-devel \
 rust-icu_locid+serde-devel \
 rust-icu_locid+std-devel \
 rust-icu_locid+zerovec-devel \
 rust-icu_locid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_locid-1.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0093ac77578e0e38001be950a75b22b99d7aa0c4b8f88d10dc24f543dc0a3c96"

URI_x86_64_v2_rust-icu_locid+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid+databake-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid+databake-devel}"
SRC_URI[x86_64_v2_rust-icu_locid+databake-devel.sha256sum] = "ecfbd29b55ca4582452b3e5a5618cedf55d6fcba140eecb09d23a65cea9a098f"

URI_x86_64_v2_rust-icu_locid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid+default-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid+default-devel}"
SRC_URI[x86_64_v2_rust-icu_locid+default-devel.sha256sum] = "9caed90c1af840bc48929b0d0be03c3dd1be990f18efd190bdfdb76cd16d3079"

URI_x86_64_v2_rust-icu_locid+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid+serde-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_locid+serde-devel.sha256sum] = "40b2a3e5bbc8b251d412bd85221b7d2caba62f5f543e665ed3b629f44f6cb766"

URI_x86_64_v2_rust-icu_locid+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid+std-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid+std-devel}"
SRC_URI[x86_64_v2_rust-icu_locid+std-devel.sha256sum] = "bb261cb72bb0eecf9680f83e6fcec8cda5d46f9f443a9cff49e36313b636cc43"

URI_x86_64_v2_rust-icu_locid+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid+zerovec-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid+zerovec-devel}"
SRC_URI[x86_64_v2_rust-icu_locid+zerovec-devel.sha256sum] = "75f69b7eaba94c659fc5d90888aff300ac03711068fad11f758e738dc53e32d5"

URI_x86_64_v2_rust-icu_locid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid-devel}"
SRC_URI[x86_64_v2_rust-icu_locid-devel.sha256sum] = "423b7a4685f8f43c697378b72f1885e8d8a057f374e594fb41e9b9247c21ed60"

URI_aarch64_rust-icu_locid+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid+databake-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_locid+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid+databake-devel}"
SRC_URI[aarch64_rust-icu_locid+databake-devel.sha256sum] = "c92181207053debeb413b5e67a9317333c4914293a6a2252320a048f7f57f30c"

URI_aarch64_rust-icu_locid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid+default-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_locid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid+default-devel}"
SRC_URI[aarch64_rust-icu_locid+default-devel.sha256sum] = "f72484bc8f6c5d72eb39e8fd9b88d11f4e9277001b7357f6e1b4ed614c972ce1"

URI_aarch64_rust-icu_locid+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid+serde-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_locid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid+serde-devel}"
SRC_URI[aarch64_rust-icu_locid+serde-devel.sha256sum] = "b41ae7797f127ab19d71d843759bda820549cfb282ad1da4aed984ef15f8cee5"

URI_aarch64_rust-icu_locid+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid+std-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_locid+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid+std-devel}"
SRC_URI[aarch64_rust-icu_locid+std-devel.sha256sum] = "ed863ecaf11e9b4f0ea37e31eea0230da2574074ebdffe9d17956011fd881b46"

URI_aarch64_rust-icu_locid+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid+zerovec-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_locid+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid+zerovec-devel}"
SRC_URI[aarch64_rust-icu_locid+zerovec-devel.sha256sum] = "3bef7965337a58d3d10a62daaa4c847e6eb9125bd2a044421f816c5cb370e9e0"

URI_aarch64_rust-icu_locid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_locid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid-devel}"
SRC_URI[aarch64_rust-icu_locid-devel.sha256sum] = "b2655624edf6f5e01f8436b870d9875929e0a364b5b619bdeb06aa0ec3e0cb08"

RDEPENDS:rust-icu_locid+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_locid-devel \
 "
RDEPENDS:rust-icu_locid+default-devel = " \
 cargo \
 rust-icu_locid-devel \
 "
RDEPENDS:rust-icu_locid+serde-devel = " \
 cargo \
 rust-icu_locid-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-tinystr+serde-devel \
 "
RDEPENDS:rust-icu_locid+std-devel = " \
 cargo \
 rust-icu_locid-devel \
 "
RDEPENDS:rust-icu_locid+zerovec-devel = " \
 cargo \
 rust-icu_locid-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-icu_locid-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 rust-tinystr+alloc-devel \
 rust-tinystr-devel \
 rust-writeable-devel \
 "
