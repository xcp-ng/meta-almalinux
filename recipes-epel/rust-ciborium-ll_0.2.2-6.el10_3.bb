# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ciborium-ll"
PV = "0.2.2"
PR = "6.el10_3"
PACKAGES = " \
 rust-ciborium-ll+alloc-devel \
 rust-ciborium-ll+default-devel \
 rust-ciborium-ll+std-devel \
 rust-ciborium-ll-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ciborium-ll-0.2.2-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "021c3c758eee3ed00e35cd0d5c97ccaf07d90a67abd13fb191ec5dc58f0c5de9"

URI_x86_64_v2_rust-ciborium-ll+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium-ll+alloc-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium-ll+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ciborium-ll+alloc-devel}"
SRC_URI[x86_64_v2_rust-ciborium-ll+alloc-devel.sha256sum] = "85dcef943083f95f3c1752d74dd6f8a967dc2b591a4e61788f88598a8e387680"

URI_x86_64_v2_rust-ciborium-ll+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium-ll+default-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium-ll+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ciborium-ll+default-devel}"
SRC_URI[x86_64_v2_rust-ciborium-ll+default-devel.sha256sum] = "7e0aea2c2bbd1b3e7af2ae4b77bdf014fe07ae5ae8d6590d86631e72fc956ccc"

URI_x86_64_v2_rust-ciborium-ll+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium-ll+std-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium-ll+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ciborium-ll+std-devel}"
SRC_URI[x86_64_v2_rust-ciborium-ll+std-devel.sha256sum] = "9b63ac8d329dad5f18c8467445702573c6fadb88dd28ee64e47effb55d95bb6c"

URI_x86_64_v2_rust-ciborium-ll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ciborium-ll-devel-0.2.2-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ciborium-ll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ciborium-ll-devel}"
SRC_URI[x86_64_v2_rust-ciborium-ll-devel.sha256sum] = "b6fea637c41b1bec533ad062c76cb949ccc06c48950031927e29c9023faa3777"

URI_aarch64_rust-ciborium-ll+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium-ll+alloc-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium-ll+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ciborium-ll+alloc-devel}"
SRC_URI[aarch64_rust-ciborium-ll+alloc-devel.sha256sum] = "27b4eda6710f72be9e114cd9676e74635d4c47ddeeda45e2c877a6747bff8d99"

URI_aarch64_rust-ciborium-ll+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium-ll+default-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium-ll+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ciborium-ll+default-devel}"
SRC_URI[aarch64_rust-ciborium-ll+default-devel.sha256sum] = "ef097a61376678868defadcd75c1ab14e507ca9b3a4d2ed63eba6ba52ef37608"

URI_aarch64_rust-ciborium-ll+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium-ll+std-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium-ll+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ciborium-ll+std-devel}"
SRC_URI[aarch64_rust-ciborium-ll+std-devel.sha256sum] = "822bf6328dd4c20796d26f6e596373412ace7fac6c01f28afc4bc22e12261fb3"

URI_aarch64_rust-ciborium-ll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ciborium-ll-devel-0.2.2-6.el10_3.noarch.rpm;name=aarch64_rust-ciborium-ll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ciborium-ll-devel}"
SRC_URI[aarch64_rust-ciborium-ll-devel.sha256sum] = "ef6f169b23db8b50bf1ad90f353ce3f3a41c84a02e305a8c1e8d49c119ae146f"

RDEPENDS:rust-ciborium-ll+alloc-devel = " \
 cargo \
 rust-ciborium-ll-devel \
 "
RDEPENDS:rust-ciborium-ll+default-devel = " \
 cargo \
 rust-ciborium-ll-devel \
 "
RDEPENDS:rust-ciborium-ll+std-devel = " \
 cargo \
 rust-ciborium-ll+alloc-devel \
 rust-ciborium-ll-devel \
 rust-half+std-devel \
 "
RDEPENDS:rust-ciborium-ll-devel = " \
 cargo \
 rust \
 rust-ciborium-io+default-devel \
 rust-half-devel \
 "
