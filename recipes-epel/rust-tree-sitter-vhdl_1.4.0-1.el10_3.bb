# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-vhdl"
PV = "1.4.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-vhdl+default-devel \
 rust-tree-sitter-vhdl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-vhdl-1.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72aed69b6dac1cb668949852c0836f7040846e356de665f374ed7f191ad37775"

URI_x86_64_v2_rust-tree-sitter-vhdl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-vhdl+default-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-vhdl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-vhdl+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-vhdl+default-devel.sha256sum] = "ea6149a701bc4c802bdb72b73b9ff73b576c8f3812d8590679f75df1163bfaff"

URI_x86_64_v2_rust-tree-sitter-vhdl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-vhdl-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-vhdl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-vhdl-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-vhdl-devel.sha256sum] = "eb17680931e1e85955e5e1c6534a169a77329e56291d60d81c8fcbb6fd6f4aa8"

URI_aarch64_rust-tree-sitter-vhdl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-vhdl+default-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-vhdl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-vhdl+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-vhdl+default-devel.sha256sum] = "0deb5597400eb64d1200fd22553a04e42c40761bb51ecc1564c268c216c52668"

URI_aarch64_rust-tree-sitter-vhdl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-vhdl-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-vhdl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-vhdl-devel}"
SRC_URI[aarch64_rust-tree-sitter-vhdl-devel.sha256sum] = "1eca09b2567bb5343a3da57ebeb5a62736f59787f950cbc0e7e8957fecc93707"

RDEPENDS:rust-tree-sitter-vhdl+default-devel = " \
 cargo \
 rust-tree-sitter-vhdl-devel \
 "
RDEPENDS:rust-tree-sitter-vhdl-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
