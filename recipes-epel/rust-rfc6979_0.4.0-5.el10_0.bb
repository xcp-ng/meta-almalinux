# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rfc6979"
PV = "0.4.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-rfc6979+default-devel \
 rust-rfc6979-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rfc6979-0.4.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6559bb9bc2d2ff32e579ac387183cd760665c6e138260051cbac0e4f21d3be11"

URI_x86_64_v2_rust-rfc6979+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rfc6979+default-devel-0.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rfc6979+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rfc6979+default-devel}"
SRC_URI[x86_64_v2_rust-rfc6979+default-devel.sha256sum] = "ad57525d2cdc370dfb81cbf8157092cba5d98725b120d490b9d9a7cc85ce710d"

URI_x86_64_v2_rust-rfc6979-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rfc6979-devel-0.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rfc6979-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rfc6979-devel}"
SRC_URI[x86_64_v2_rust-rfc6979-devel.sha256sum] = "3d29936ea31384cadb94b4f04c80d0b3c6461895a793c557ef100a46c14fd63b"

URI_aarch64_rust-rfc6979+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rfc6979+default-devel-0.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-rfc6979+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rfc6979+default-devel}"
SRC_URI[aarch64_rust-rfc6979+default-devel.sha256sum] = "42b8cade8d9d73f459e4efbc38eb0566262231d5fb4931fbc68880eb3b979b81"

URI_aarch64_rust-rfc6979-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rfc6979-devel-0.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-rfc6979-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rfc6979-devel}"
SRC_URI[aarch64_rust-rfc6979-devel.sha256sum] = "2714ffecb65b9062c3bbb57202d889db7857bb465a842e8c90ad2ea1f4fd86bc"

RDEPENDS:rust-rfc6979+default-devel = " \
 cargo \
 rust-rfc6979-devel \
 "
RDEPENDS:rust-rfc6979-devel = " \
 cargo \
 rust \
 rust-hmac+reset-devel \
 rust-hmac-devel \
 rust-subtle-devel \
 "
