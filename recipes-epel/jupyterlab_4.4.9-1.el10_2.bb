# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jupyterlab"
PV = "4.4.9"
PR = "1.el10_2"
PACKAGES = " \
 jupyterlab \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/jupyterlab-4.4.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "67fd2ff8f6140dd15ba5e5ed6d0e1e03988ee7f0c6a0912feece0e850223eb5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jupyterlab-4.4.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_jupyterlab;unpack=0"
SRC_URI[x86_64_v2_jupyterlab.sha256sum] = "7d566d6c7366e638b081d83b5885f4e9f6b38c09163c5d65a1d3df2f822b2a25"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jupyterlab-4.4.9-1.el10_2.noarch.rpm;name=aarch64_jupyterlab;unpack=0"
SRC_URI[aarch64_jupyterlab.sha256sum] = "e99353c8e08e0d0dbefbf4222a90dc750885cb1eba3c86c7ac46583a9b88e30d"

RDEPENDS:jupyterlab = " \
 hicolor-icon-theme \
 python-jupyter-filesystem \
 python3 \
 python3-async-lru \
 python3-httpx \
 python3-ipykernel \
 python3-jinja2 \
 python3-jupyter-core \
 python3-jupyter-lsp \
 python3-jupyter-server \
 python3-jupyterlab-server \
 python3-notebook-shim \
 python3-packaging \
 python3-setuptools \
 python3-tornado \
 python3-traitlets \
 "
