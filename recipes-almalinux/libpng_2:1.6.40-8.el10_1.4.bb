# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpng"
PE = "2"
PV = "1.6.40"
PR = "8.el10_1.4"
PACKAGES = " \
 libpng \
 libpng-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libpng-1.6.40-8.el10_1.4.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f61ba1845d54c78e9560afacf78a373e23b0903ed7df7c0a0af78d9bf8eb0956"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpng-1.6.40-8.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_libpng;unpack=0"
SRC_URI[x86_64_v2_libpng.sha256sum] = "55447189b083e05778eacf42d621697431cb5927c6a95921258e2b627d63a852"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpng-devel-1.6.40-8.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_libpng-devel;unpack=0"
SRC_URI[x86_64_v2_libpng-devel.sha256sum] = "c5312777d1eab26903655741e4ed044674d87a50a2a9c542b4eae5fe5a8afe52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpng-1.6.40-8.el10_1.4.aarch64.rpm;name=aarch64_libpng;unpack=0"
SRC_URI[aarch64_libpng.sha256sum] = "87dd8259b7a5ac2343e68896b6913929a0a4e6dc2023a0e9b974803c0d3ca3f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpng-devel-1.6.40-8.el10_1.4.aarch64.rpm;name=aarch64_libpng-devel;unpack=0"
SRC_URI[aarch64_libpng-devel.sha256sum] = "af717250cd8ea548bf617c70a3ab38b10c709041505a48dc51f186d47ad57f6f"

RDEPENDS:libpng = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libpng-devel = " \
 bash \
 glibc \
 libpng \
 pkgconf-pkg-config \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
