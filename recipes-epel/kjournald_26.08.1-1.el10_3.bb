# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kjournald"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kjournald \
 kjournald-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kjournald-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f84a68006314faf2a708f72bdf0a22d600acf78bf7ab587c100c99c5ef95f8d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjournald-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjournald;unpack=0"
SRC_URI[x86_64_v2_kjournald.sha256sum] = "2cc4197ab89c3903a6b34f4d3feb29c19e533724d0feb04d3d9e4fd80aa93bb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjournald-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjournald-libs;unpack=0"
SRC_URI[x86_64_v2_kjournald-libs.sha256sum] = "d12a51bcf6f0d3512329fc79beeed97407ac19e780b3e1a4b1546777512bc27f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kjournald-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kjournald;unpack=0"
SRC_URI[aarch64_kjournald.sha256sum] = "6c58249c0821933523bcdfb66e1f5d8dc1e2fb07a3de40542c0e826a7f6756fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kjournald-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kjournald-libs;unpack=0"
SRC_URI[aarch64_kjournald-libs.sha256sum] = "378cc9d4a2748ee162ce93e7e45dbb7592d53a1e65db6013a840e942e8b79c9e"

RDEPENDS:kjournald = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kjournald-libs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kjournald-libs = " \
 glibc \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 "
