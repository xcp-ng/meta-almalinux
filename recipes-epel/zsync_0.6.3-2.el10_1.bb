# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zsync"
PV = "0.6.3"
PR = "2.el10_1"
PACKAGES = " \
 zsync \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zsync-0.6.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06bbe20cf76a580dcd1c62ad37838d08f561342e73ddfa6c169f91e66e7ee142"

URI_x86_64_v2_zsync = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zsync-0.6.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zsync}"
SRC_URI[x86_64_v2_zsync.sha256sum] = "1aaae5bf7b75e1e95df4eab0578215a100863b438c4a4d4e214cf910eb6071fd"

URI_aarch64_zsync = "${EPEL_MIRROR}/aarch64/Packages/z/zsync-0.6.3-2.el10_1.aarch64.rpm;name=aarch64_zsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_zsync}"
SRC_URI[aarch64_zsync.sha256sum] = "362c8b7472d1985247e1f48f6a630b7ca524a78b7aa1324f5212be50e4f8aa9f"

RDEPENDS:zsync = " \
 glibc \
 "
