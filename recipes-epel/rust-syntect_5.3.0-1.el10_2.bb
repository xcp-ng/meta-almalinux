# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syntect"
PV = "5.3.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-syntect+bincode-devel \
 rust-syntect+default-devel \
 rust-syntect+default-fancy-devel \
 rust-syntect+default-onig-devel \
 rust-syntect+default-syntaxes-devel \
 rust-syntect+default-themes-devel \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+fancy-regex-devel \
 rust-syntect+flate2-devel \
 rust-syntect+fnv-devel \
 rust-syntect+html-devel \
 rust-syntect+metadata-devel \
 rust-syntect+onig-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+regex-fancy-devel \
 rust-syntect+regex-onig-devel \
 rust-syntect+regex-syntax-devel \
 rust-syntect+yaml-load-devel \
 rust-syntect+yaml-rust-devel \
 rust-syntect-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syntect-5.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd3cdcc0d0bd27a39a521b1b288069abaca8b7f9854ecc079213bbad8edcb19c"

URI_x86_64_v2_rust-syntect+bincode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+bincode-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+bincode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+bincode-devel}"
SRC_URI[x86_64_v2_rust-syntect+bincode-devel.sha256sum] = "0b92195d656392ffa3ba02e5129345f4f6ca930fd8b4562ba2303ecf1d8062f1"

URI_x86_64_v2_rust-syntect+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-devel.sha256sum] = "5df114d42847dc954dd0af77318144080d3673a92d65bd7d99c5ee307bea9a99"

URI_x86_64_v2_rust-syntect+default-fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-fancy-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-fancy-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-fancy-devel.sha256sum] = "a79579de17b57896eb56735b808f67a9a1a4ccdbc1ad1b703cb75dcf9787b693"

URI_x86_64_v2_rust-syntect+default-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-onig-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-onig-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-onig-devel.sha256sum] = "2a72ed352d8a1831f444240f18b05e537c17fab8fed6b09a9438652b6d9ea054"

URI_x86_64_v2_rust-syntect+default-syntaxes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-syntaxes-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-syntaxes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-syntaxes-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-syntaxes-devel.sha256sum] = "a759af72345935e0069eb0e95b92a0e22be530ce10e1849bb0e10275407daef3"

URI_x86_64_v2_rust-syntect+default-themes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-themes-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-themes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-themes-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-themes-devel.sha256sum] = "d3050dd9cf719deee153002a0d89b650d4fe7315b31f74a61d657739a97612ce"

URI_x86_64_v2_rust-syntect+dump-create-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+dump-create-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+dump-create-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+dump-create-devel}"
SRC_URI[x86_64_v2_rust-syntect+dump-create-devel.sha256sum] = "c12cb2202e1751a705e5daf96e118e5191f53238d2b2556281243e64eec27975"

URI_x86_64_v2_rust-syntect+dump-load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+dump-load-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+dump-load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+dump-load-devel}"
SRC_URI[x86_64_v2_rust-syntect+dump-load-devel.sha256sum] = "32655adf4c9622d462923d431fb44c23332d4a6b0b42f0ea1e020da639729f36"

URI_x86_64_v2_rust-syntect+fancy-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+fancy-regex-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+fancy-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+fancy-regex-devel}"
SRC_URI[x86_64_v2_rust-syntect+fancy-regex-devel.sha256sum] = "ea3b053ef93f6b6e4b73ff50dcd94b3b15d69d85971832589c5d7f81eec9ab25"

URI_x86_64_v2_rust-syntect+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+flate2-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+flate2-devel}"
SRC_URI[x86_64_v2_rust-syntect+flate2-devel.sha256sum] = "04a6e18934c8190fd4c23ae81a7b7eab45631086597e01b78389fd0f02a13af3"

URI_x86_64_v2_rust-syntect+fnv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+fnv-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+fnv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+fnv-devel}"
SRC_URI[x86_64_v2_rust-syntect+fnv-devel.sha256sum] = "4fab585c1f9567e77ac018727d9f9669ef4dee38f4eb01dda04a7039bd8b60f1"

URI_x86_64_v2_rust-syntect+html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+html-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+html-devel}"
SRC_URI[x86_64_v2_rust-syntect+html-devel.sha256sum] = "527dc31a2013cbe2f2a303464f076037187deccad6ad9d01f2bfaaacf008d2de"

URI_x86_64_v2_rust-syntect+metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+metadata-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+metadata-devel}"
SRC_URI[x86_64_v2_rust-syntect+metadata-devel.sha256sum] = "2516fa4f77cac992aabe7efb0938d7d73bf6bd10f024141535d1b0c35443a466"

URI_x86_64_v2_rust-syntect+onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+onig-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+onig-devel}"
SRC_URI[x86_64_v2_rust-syntect+onig-devel.sha256sum] = "90cb7d4f190307ec319f7dfae6da61b116dba4307de31f885d6d4c3fcf97e3f8"

URI_x86_64_v2_rust-syntect+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+parsing-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+parsing-devel}"
SRC_URI[x86_64_v2_rust-syntect+parsing-devel.sha256sum] = "d9bd3ca547d5d7e4b5711d3d4e48fd5dedf8b392da2875e2510101276bc3d5fa"

URI_x86_64_v2_rust-syntect+plist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+plist-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+plist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+plist-devel}"
SRC_URI[x86_64_v2_rust-syntect+plist-devel.sha256sum] = "6ed81d6a4096a5307052957196cb28d7bbdaa1da700ce63c5910e1e8f61d3b70"

URI_x86_64_v2_rust-syntect+plist-load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+plist-load-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+plist-load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+plist-load-devel}"
SRC_URI[x86_64_v2_rust-syntect+plist-load-devel.sha256sum] = "4b072d33a9f69c49e6e78d0825ef1d2ef4f577e0c17453a414b72c2c1228d5bc"

URI_x86_64_v2_rust-syntect+regex-fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+regex-fancy-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+regex-fancy-devel}"
SRC_URI[x86_64_v2_rust-syntect+regex-fancy-devel.sha256sum] = "0b912d51943570b211d8ab19281196ee5300bf77b6861c61c8e1b7a5fb9ab428"

URI_x86_64_v2_rust-syntect+regex-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+regex-onig-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+regex-onig-devel}"
SRC_URI[x86_64_v2_rust-syntect+regex-onig-devel.sha256sum] = "712cb9a9f8ab9e23e31d00f06d117b5b1ad6d865817defc7d11a08736cd3dffe"

URI_x86_64_v2_rust-syntect+regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+regex-syntax-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-syntect+regex-syntax-devel.sha256sum] = "5cbaab56235eca50050086910457eed621fed4135aa424257f4fadbc553ec41b"

URI_x86_64_v2_rust-syntect+yaml-load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+yaml-load-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+yaml-load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+yaml-load-devel}"
SRC_URI[x86_64_v2_rust-syntect+yaml-load-devel.sha256sum] = "6986625c268a9f8098123499995fafe80d6b175945e07e7255bd6b78a79fc5be"

URI_x86_64_v2_rust-syntect+yaml-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+yaml-rust-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+yaml-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+yaml-rust-devel}"
SRC_URI[x86_64_v2_rust-syntect+yaml-rust-devel.sha256sum] = "7fa4f23fe7dc4d4e36f2a7f4a361ae8a6c124e063696894203bda6e41d662aa0"

URI_x86_64_v2_rust-syntect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect-devel-5.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect-devel}"
SRC_URI[x86_64_v2_rust-syntect-devel.sha256sum] = "7996e16bda49086d03210ded4b8ec15c55e9c40bedb7d340c76ca0edfa9e2657"

URI_aarch64_rust-syntect+bincode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+bincode-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+bincode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+bincode-devel}"
SRC_URI[aarch64_rust-syntect+bincode-devel.sha256sum] = "5188777741ce21da5cfa66643e802b62916fc469bb4a79133fbe9ff48dd37946"

URI_aarch64_rust-syntect+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-devel}"
SRC_URI[aarch64_rust-syntect+default-devel.sha256sum] = "77232721c6b4c1512ae22a65b761ac13849d4d5092b81d122b1c27a64b6905a4"

URI_aarch64_rust-syntect+default-fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-fancy-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+default-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-fancy-devel}"
SRC_URI[aarch64_rust-syntect+default-fancy-devel.sha256sum] = "7a165ea39dcf3673beaf1db78cc1263e7c976ffef1e69ebf7996240f0699e71f"

URI_aarch64_rust-syntect+default-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-onig-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+default-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-onig-devel}"
SRC_URI[aarch64_rust-syntect+default-onig-devel.sha256sum] = "080d4c697e2d01200a191af593deed4b73c2d4d198b300d51fe918ac92169e90"

URI_aarch64_rust-syntect+default-syntaxes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-syntaxes-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+default-syntaxes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-syntaxes-devel}"
SRC_URI[aarch64_rust-syntect+default-syntaxes-devel.sha256sum] = "5a47787ece94681aa015220ec55660d6b785cfca729ee50efc7317908da6bd07"

URI_aarch64_rust-syntect+default-themes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-themes-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+default-themes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-themes-devel}"
SRC_URI[aarch64_rust-syntect+default-themes-devel.sha256sum] = "acb49db448c851a7a579c8d57cf8b4c3f48eacb0215fb6a7c708d7db089ef0b8"

URI_aarch64_rust-syntect+dump-create-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+dump-create-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+dump-create-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+dump-create-devel}"
SRC_URI[aarch64_rust-syntect+dump-create-devel.sha256sum] = "41b3836b1b820bc8511c694e1c2597e2038c8ee1a214ff70092a6e8c4a669577"

URI_aarch64_rust-syntect+dump-load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+dump-load-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+dump-load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+dump-load-devel}"
SRC_URI[aarch64_rust-syntect+dump-load-devel.sha256sum] = "a4d1f50edd2b5c0b7efcaa4c809fcae4dde881199c1cf94802b9553cfaf6607c"

URI_aarch64_rust-syntect+fancy-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+fancy-regex-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+fancy-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+fancy-regex-devel}"
SRC_URI[aarch64_rust-syntect+fancy-regex-devel.sha256sum] = "c49ba21400907d12ae76dd319302f0cf8b8c407e839d5bd468448fe106c2931e"

URI_aarch64_rust-syntect+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+flate2-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+flate2-devel}"
SRC_URI[aarch64_rust-syntect+flate2-devel.sha256sum] = "353f5d79f1052bee935bef20f3277b995bc322c65ba4dfe1eefbc06a986336a9"

URI_aarch64_rust-syntect+fnv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+fnv-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+fnv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+fnv-devel}"
SRC_URI[aarch64_rust-syntect+fnv-devel.sha256sum] = "3a2afe6e217a0b80c701558c2932c2341d29c8ca939ee71388c35d435d33b0a2"

URI_aarch64_rust-syntect+html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+html-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+html-devel}"
SRC_URI[aarch64_rust-syntect+html-devel.sha256sum] = "c035471789d9bd1596b15a384c2428f377460dfca7b35f314cc37b95724696f0"

URI_aarch64_rust-syntect+metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+metadata-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+metadata-devel}"
SRC_URI[aarch64_rust-syntect+metadata-devel.sha256sum] = "0e8fd002acea4ec16c2b136d1e4e00b1558b3e764792e22768b23bd7f411fab2"

URI_aarch64_rust-syntect+onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+onig-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+onig-devel}"
SRC_URI[aarch64_rust-syntect+onig-devel.sha256sum] = "6ab1e38f77915366cb5089d6f1aa0379593300c703c43d6c87ff428cc85d51f9"

URI_aarch64_rust-syntect+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+parsing-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+parsing-devel}"
SRC_URI[aarch64_rust-syntect+parsing-devel.sha256sum] = "d7e0192e72aeb9a8e604eef3802af5f6b29deba6160005089a5dbb47f8d75bd7"

URI_aarch64_rust-syntect+plist-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+plist-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+plist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+plist-devel}"
SRC_URI[aarch64_rust-syntect+plist-devel.sha256sum] = "62f003f06202026bd6c260ca8ddcdfd805708eddb8826ba22be4bae7ae2f61c7"

URI_aarch64_rust-syntect+plist-load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+plist-load-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+plist-load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+plist-load-devel}"
SRC_URI[aarch64_rust-syntect+plist-load-devel.sha256sum] = "73f36420b599aecbe8ab77afbbfbe4bb19dfd20746220eee320f183a7d158dfa"

URI_aarch64_rust-syntect+regex-fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+regex-fancy-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+regex-fancy-devel}"
SRC_URI[aarch64_rust-syntect+regex-fancy-devel.sha256sum] = "1eebf4c9fb8c6334583614f908ad8a0641149091c39497e2e027b2165d801d43"

URI_aarch64_rust-syntect+regex-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+regex-onig-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+regex-onig-devel}"
SRC_URI[aarch64_rust-syntect+regex-onig-devel.sha256sum] = "3cf6fd76da3a60bd95767134e9bd03edbc1e4dad23e83067fc20a1f06155caa2"

URI_aarch64_rust-syntect+regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+regex-syntax-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+regex-syntax-devel}"
SRC_URI[aarch64_rust-syntect+regex-syntax-devel.sha256sum] = "c7bf15cd7d829018b1af06f9065e98565b73bf9b07b98a4a85711d7704104704"

URI_aarch64_rust-syntect+yaml-load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+yaml-load-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+yaml-load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+yaml-load-devel}"
SRC_URI[aarch64_rust-syntect+yaml-load-devel.sha256sum] = "77e7722970bba95be5e2c788fa973625b24475352bb5b0a85ceb51b818b9f0d9"

URI_aarch64_rust-syntect+yaml-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+yaml-rust-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect+yaml-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+yaml-rust-devel}"
SRC_URI[aarch64_rust-syntect+yaml-rust-devel.sha256sum] = "027042efb6fab0bd21bfff3116991cb599c50ee909d1411ff108d8e4f6249232"

URI_aarch64_rust-syntect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect-devel-5.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-syntect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect-devel}"
SRC_URI[aarch64_rust-syntect-devel.sha256sum] = "44f69e6b71344b63bd41dc4f1363bdf2669a14981136db0830eae13eb2b23446"

RDEPENDS:rust-syntect+bincode-devel = " \
 cargo \
 rust-bincode1+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-devel = " \
 cargo \
 rust-syntect+default-onig-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-fancy-devel = " \
 cargo \
 rust-syntect+default-syntaxes-devel \
 rust-syntect+default-themes-devel \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+html-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+regex-fancy-devel \
 rust-syntect+yaml-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-onig-devel = " \
 cargo \
 rust-syntect+default-syntaxes-devel \
 rust-syntect+default-themes-devel \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+html-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+regex-onig-devel \
 rust-syntect+yaml-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-syntaxes-devel = " \
 cargo \
 rust-syntect+dump-load-devel \
 rust-syntect+parsing-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-themes-devel = " \
 cargo \
 rust-syntect+dump-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+dump-create-devel = " \
 cargo \
 rust-syntect+bincode-devel \
 rust-syntect+flate2-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+dump-load-devel = " \
 cargo \
 rust-syntect+bincode-devel \
 rust-syntect+flate2-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+fancy-regex-devel = " \
 cargo \
 rust-fancy-regex+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+flate2-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+fnv-devel = " \
 cargo \
 rust-fnv+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+html-devel = " \
 cargo \
 rust-syntect+parsing-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+metadata-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+onig-devel = " \
 cargo \
 rust-onig-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+parsing-devel = " \
 cargo \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+fnv-devel \
 rust-syntect+regex-syntax-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+plist-devel = " \
 cargo \
 rust-plist+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+plist-load-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-syntect+plist-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+regex-fancy-devel = " \
 cargo \
 rust-syntect+fancy-regex-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+regex-onig-devel = " \
 cargo \
 rust-syntect+onig-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+regex-syntax-devel = " \
 cargo \
 rust-regex-syntax+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+yaml-load-devel = " \
 cargo \
 rust-syntect+parsing-devel \
 rust-syntect+yaml-rust-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+yaml-rust-devel = " \
 cargo \
 rust-syntect-devel \
 rust-yaml-rust+default-devel \
 "
RDEPENDS:rust-syntect-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-thiserror+default-devel \
 rust-walkdir+default-devel \
 "
