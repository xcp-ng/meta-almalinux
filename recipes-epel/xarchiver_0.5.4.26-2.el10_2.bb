# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xarchiver"
PV = "0.5.4.26"
PR = "2.el10_2"
PACKAGES = " \
 xarchiver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xarchiver-0.5.4.26-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d7a9b1ac787abccb41cd6fe8e368ea7a78f31cc5edcf23e27b237e3715a8c45"

URI_x86_64_v2_xarchiver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xarchiver-0.5.4.26-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xarchiver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xarchiver}"
SRC_URI[x86_64_v2_xarchiver.sha256sum] = "33cd7865d9b511fe5dd3d322efcc8804640eb4681865c9d130014e6f064b77c5"

URI_aarch64_xarchiver = "${EPEL_MIRROR}/aarch64/Packages/x/xarchiver-0.5.4.26-2.el10_2.aarch64.rpm;name=aarch64_xarchiver;unpack=0"
SRC_URI:append = " ${URI_aarch64_xarchiver}"
SRC_URI[aarch64_xarchiver.sha256sum] = "80b14b47f542a5f583eba4c224cf1bdf24886fe313ba26306e063dff665cb843"

RDEPENDS:xarchiver = " \
 bash \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 "
