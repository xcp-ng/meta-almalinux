# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Unidecode"
PV = "1.30"
PR = "27.el10"
PACKAGES = " \
 perl-Text-Unidecode \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Text-Unidecode-1.30-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "911da43e541de509325c005ce9f96dc171c080ccde96d79a9bc791c362f9cf4b"

URI_x86_64_v2_perl-Text-Unidecode = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Text-Unidecode-1.30-27.el10.noarch.rpm;name=x86_64_v2_perl-Text-Unidecode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Unidecode}"
SRC_URI[x86_64_v2_perl-Text-Unidecode.sha256sum] = "8f76f780674c4194d22862c6623ae92319b567e4a3956e64791882dc5fdff9e4"

URI_aarch64_perl-Text-Unidecode = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Text-Unidecode-1.30-27.el10.noarch.rpm;name=aarch64_perl-Text-Unidecode;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Unidecode}"
SRC_URI[aarch64_perl-Text-Unidecode.sha256sum] = "8f76f780674c4194d22862c6623ae92319b567e4a3956e64791882dc5fdff9e4"

RDEPENDS:perl-Text-Unidecode = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
