# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ark"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ark \
 ark-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ark-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3789af2f1f4280f2729878271b127a8afc13fd0dceb42bbe22bfc0b93de88e3f"

URI_x86_64_v2_ark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ark-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ark}"
SRC_URI[x86_64_v2_ark.sha256sum] = "70fba2bd52a552c63e0012e550b1f109a9f9fccefa7d44b3b67cbbced43eb69a"

URI_x86_64_v2_ark-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ark-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ark-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ark-libs}"
SRC_URI[x86_64_v2_ark-libs.sha256sum] = "1e68497efbb6d0e3e6162d050b41cf67ada9a54c25bc540c1f7a8a1765311e9e"

URI_aarch64_ark = "${EPEL_MIRROR}/aarch64/Packages/a/ark-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ark;unpack=0"
SRC_URI:append = " ${URI_aarch64_ark}"
SRC_URI[aarch64_ark.sha256sum] = "c2ec4518f5e7904f0badcf92ced21fb0a90da7ecbf2cabedfd4904ddea49137f"

URI_aarch64_ark-libs = "${EPEL_MIRROR}/aarch64/Packages/a/ark-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ark-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ark-libs}"
SRC_URI[aarch64_ark-libs.sha256sum] = "faf70458c54c16d522c26ae59af6b1bd60fc24b0b6652582d3e8eb4957e7da51"

RDEPENDS:ark = " \
 ark-libs \
 bash \
 bzip2 \
 glibc \
 gzip \
 kf6-breeze-icons \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 unzip \
 "
RDEPENDS:ark-libs = " \
 ark \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kpty \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libarchive \
 libgcc \
 libstdc++ \
 libzip \
 qt6-qtbase \
 qt6-qtbase-gui \
 zlib-ng-compat \
 "
