# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lsvpd"
PV = "1.7.17"
PR = "1.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lsvpd-1.7.17-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca433082ece2ea611a8559f304289e21b9b56bfb351725545bd0f9e921e99f76"

