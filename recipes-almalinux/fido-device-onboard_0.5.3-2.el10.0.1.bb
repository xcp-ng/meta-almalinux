# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fido-device-onboard"
PV = "0.5.3"
PR = "2.el10.0.1"
PACKAGES:x86_64_v2 = " \
 fdo-admin-cli \
 fdo-client \
 fdo-init \
 fdo-manufacturing-server \
 fdo-owner-cli \
 fdo-owner-onboarding-server \
 fdo-rendezvous-server \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fido-device-onboard-0.5.3-2.el10.0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6bba8a1ad86915c6838e598e921de9f8c6cb13c9039b64696fbd4a5568062be"

URI_x86_64_v2_fdo-admin-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-admin-cli-0.5.3-2.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_fdo-admin-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-admin-cli}"
SRC_URI[x86_64_v2_fdo-admin-cli.sha256sum] = "60919b7a9b7e4af39bb0c004d0291deaeaf72375ad45ff1ddd344a889d961068"

URI_x86_64_v2_fdo-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-client-0.5.3-2.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_fdo-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-client}"
SRC_URI[x86_64_v2_fdo-client.sha256sum] = "24ae5d5eac9d7f2e4ae0041e9f1ff5e343a5ab27d7512ae3049da6533cd2efb8"

URI_x86_64_v2_fdo-init = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-init-0.5.3-2.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_fdo-init;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-init}"
SRC_URI[x86_64_v2_fdo-init.sha256sum] = "a281b3d68547fd93faaf8f353c54705aa7f8891d2e13b50a433799c5c2e152c6"

URI_x86_64_v2_fdo-manufacturing-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-manufacturing-server-0.5.3-2.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_fdo-manufacturing-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-manufacturing-server}"
SRC_URI[x86_64_v2_fdo-manufacturing-server.sha256sum] = "c9ceed1f8c663e35533647002dbff9665649581644b8b190d907147fd0219f8a"

URI_x86_64_v2_fdo-owner-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-owner-cli-0.5.3-2.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_fdo-owner-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-owner-cli}"
SRC_URI[x86_64_v2_fdo-owner-cli.sha256sum] = "d6aeea628c3cb0b006e7013b84c180479c459c8b8fefc7cdb4522db50e6b853c"

URI_x86_64_v2_fdo-owner-onboarding-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-owner-onboarding-server-0.5.3-2.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_fdo-owner-onboarding-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-owner-onboarding-server}"
SRC_URI[x86_64_v2_fdo-owner-onboarding-server.sha256sum] = "ac747d2bbcc16f608d05c800a118a709bcfaf910473f5f9c65af7be4c8c74715"

URI_x86_64_v2_fdo-rendezvous-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdo-rendezvous-server-0.5.3-2.el10.0.1.x86_64_v2.rpm;name=x86_64_v2_fdo-rendezvous-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdo-rendezvous-server}"
SRC_URI[x86_64_v2_fdo-rendezvous-server.sha256sum] = "c6e86e349be13ecc3b14cfcabbf64060f119834fa821c7fb962235fdb87579e6"

RDEPENDS:fdo-admin-cli = " \
 bash \
 fdo-client \
 fdo-init \
 fdo-manufacturing-server \
 fdo-owner-cli \
 fdo-owner-onboarding-server \
 fdo-rendezvous-server \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-client = " \
 bash \
 clevis \
 clevis-luks \
 clevis-pin-tpm2 \
 cryptsetup \
 cryptsetup-libs \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-init = " \
 bash \
 dracut \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-manufacturing-server = " \
 bash \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-owner-cli = " \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-owner-onboarding-server = " \
 bash \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
RDEPENDS:fdo-rendezvous-server = " \
 bash \
 glibc \
 libgcc \
 libpq \
 openssl-libs \
 sqlite-libs \
 tpm2-tss \
 "
