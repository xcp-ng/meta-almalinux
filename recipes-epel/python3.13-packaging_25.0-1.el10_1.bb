# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13-packaging"
PV = "25.0"
PR = "1.el10_1"
PACKAGES = " \
 python3.13-packaging \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-packaging-25.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f0f4b6bb0d24d01feb50acd8ff4d9a5012232726203705350d1de0ca158f224"

URI_x86_64_v2_python3.13-packaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-packaging-25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-packaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-packaging}"
SRC_URI[x86_64_v2_python3.13-packaging.sha256sum] = "31524233252b0fcb5a97c80d597e39736285bcd8340be8f2ee5b5ab4b712dc5a"

URI_aarch64_python3.13-packaging = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-packaging-25.0-1.el10_1.noarch.rpm;name=aarch64_python3.13-packaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-packaging}"
SRC_URI[aarch64_python3.13-packaging.sha256sum] = "b4ba80129017aac9bc79718d5b9b81ad36cd6e03494e33224f2dcfc8610aced9"

RDEPENDS:python3.13-packaging = " \
 python3.13 \
 "
