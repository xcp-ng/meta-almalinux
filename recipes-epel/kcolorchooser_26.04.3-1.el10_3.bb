# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcolorchooser"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kcolorchooser \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcolorchooser-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2ad7b6356d3382d8a792e7fc18a23cb9297b2a65a0f6a68f4a75ff936ae3174"

URI_x86_64_v2_kcolorchooser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcolorchooser-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcolorchooser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcolorchooser}"
SRC_URI[x86_64_v2_kcolorchooser.sha256sum] = "69c53489dae04a119e05650c5a514281c6c9927747d738865ffdbe32c687a4f1"

URI_aarch64_kcolorchooser = "${EPEL_MIRROR}/aarch64/Packages/k/kcolorchooser-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kcolorchooser;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcolorchooser}"
SRC_URI[aarch64_kcolorchooser.sha256sum] = "a6c66a2b5c316c36f0417b30aa69f57dd9292cd4850587553c063f4beda07369"

RDEPENDS:kcolorchooser = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
