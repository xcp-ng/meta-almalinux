# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-proto0.25"
PV = "0.25.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-hickory-proto0.25+backtrace-devel \
 rust-hickory-proto0.25+default-devel \
 rust-hickory-proto0.25+futures-io-devel \
 rust-hickory-proto0.25+mdns-devel \
 rust-hickory-proto0.25+no-std-rand-devel \
 rust-hickory-proto0.25+rustls-platform-verifier-devel \
 rust-hickory-proto0.25+serde-devel \
 rust-hickory-proto0.25+socket2-devel \
 rust-hickory-proto0.25+std-devel \
 rust-hickory-proto0.25+testing-devel \
 rust-hickory-proto0.25+text-parsing-devel \
 rust-hickory-proto0.25+tokio-devel \
 rust-hickory-proto0.25+webpki-roots-devel \
 rust-hickory-proto0.25-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-proto0.25-0.25.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e180060b665e12a9d26dd69f901642246e59557220a36ba22eb9191cd47bc9b"

URI_x86_64_v2_rust-hickory-proto0.25+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+backtrace-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+backtrace-devel.sha256sum] = "206890d13319cf80adbef3aab37bf3995b79a13404e9511557f124924bf62e1a"

URI_x86_64_v2_rust-hickory-proto0.25+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+default-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+default-devel.sha256sum] = "22732c5ca62b834d501acb64441498b59eeeefb2ee7975fd63ac19dd24db8549"

URI_x86_64_v2_rust-hickory-proto0.25+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+futures-io-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+futures-io-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+futures-io-devel.sha256sum] = "adfb799e6efa382198dbe7ef0b87ec56319f03fcc43f4fd545b57a1fce40e03c"

URI_x86_64_v2_rust-hickory-proto0.25+mdns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+mdns-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+mdns-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+mdns-devel.sha256sum] = "e1465061fbb5ea4de421ee03934cac4ebe67aa0ca07d1f2c94fb90393e889fa7"

URI_x86_64_v2_rust-hickory-proto0.25+no-std-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+no-std-rand-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+no-std-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+no-std-rand-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+no-std-rand-devel.sha256sum] = "6d137c4822f61a1ca51976c76a340c9b0fe133a00c97ae51c1609b70a77dd601"

URI_x86_64_v2_rust-hickory-proto0.25+rustls-platform-verifier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+rustls-platform-verifier-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+rustls-platform-verifier-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+rustls-platform-verifier-devel.sha256sum] = "d3f6a8f7f90fa52493d2f6e364fa1ac8e675c3e5ad3fba0db574f6c70b6f453a"

URI_x86_64_v2_rust-hickory-proto0.25+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+serde-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+serde-devel.sha256sum] = "a22da99626cebe48f3ccc8fb88eecae2ef67653ec0aa2d758720a912b39f2f8a"

URI_x86_64_v2_rust-hickory-proto0.25+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+socket2-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+socket2-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+socket2-devel.sha256sum] = "63a16c6dcfb6f6ab8ca7170f307d750ffc2215295fe692b8a4148fea8defbb69"

URI_x86_64_v2_rust-hickory-proto0.25+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+std-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+std-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+std-devel.sha256sum] = "d20261b4efa2ce89d15ea5eec61f10a96d6f5cf840920ad12a63f8962639fcad"

URI_x86_64_v2_rust-hickory-proto0.25+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+testing-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+testing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+testing-devel.sha256sum] = "ab3de0734516691addfce00c226d3cee5f0d54a6b794ae26fe14b1d6169071f5"

URI_x86_64_v2_rust-hickory-proto0.25+text-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+text-parsing-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+text-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+text-parsing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+text-parsing-devel.sha256sum] = "5b9c4eed1de0bfe7f6740520bb698a2bc9ff553eb301d20c916197a15e83be56"

URI_x86_64_v2_rust-hickory-proto0.25+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+tokio-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+tokio-devel.sha256sum] = "6c7987a7502c17917d03e83e88ba2c41d7b7072ce90a1ea5529f5b5b84d06022"

URI_x86_64_v2_rust-hickory-proto0.25+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25+webpki-roots-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25+webpki-roots-devel.sha256sum] = "eace471065875fb4827b1275bd32d5266d04174c7f79772b627e8ea044835438"

URI_x86_64_v2_rust-hickory-proto0.25-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto0.25-devel-0.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto0.25-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto0.25-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto0.25-devel.sha256sum] = "b3fcb329064e414e7f1178e7db075fda96c08a39754e06f8418ecf516e48f012"

URI_aarch64_rust-hickory-proto0.25+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+backtrace-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+backtrace-devel.sha256sum] = "c54392b29122375035860b52270a098d79a9964f9d151d3a3fd7ad77c86fdc16"

URI_aarch64_rust-hickory-proto0.25+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+default-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+default-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+default-devel.sha256sum] = "711335b1e8b2238ea585ba98722ebb8c350cc3a0dbb5842e8762c69ff6f6f813"

URI_aarch64_rust-hickory-proto0.25+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+futures-io-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+futures-io-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+futures-io-devel.sha256sum] = "457159f45061d4150b3aeee05051cd1253f0d7afdf4ac609b0544263a1ecece7"

URI_aarch64_rust-hickory-proto0.25+mdns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+mdns-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+mdns-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+mdns-devel.sha256sum] = "57f4d7e18961d3fa241da294cf1a67da320416e2c0158122ff2b6f15e0c2ac90"

URI_aarch64_rust-hickory-proto0.25+no-std-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+no-std-rand-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+no-std-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+no-std-rand-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+no-std-rand-devel.sha256sum] = "a46db2d5fd5cd9254a78e036ef706442a2e8cf47bc3000c8e5cb8d9715d177be"

URI_aarch64_rust-hickory-proto0.25+rustls-platform-verifier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+rustls-platform-verifier-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+rustls-platform-verifier-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+rustls-platform-verifier-devel.sha256sum] = "aaca1472d761f6360cb300182094092dcf2f44d3008a6064bc2cfe866e26565d"

URI_aarch64_rust-hickory-proto0.25+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+serde-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+serde-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+serde-devel.sha256sum] = "efcc7f7068e1b64d9a03262f388b47fd356bd1c43c73f05af68e34862c2dafcc"

URI_aarch64_rust-hickory-proto0.25+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+socket2-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+socket2-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+socket2-devel.sha256sum] = "77c522e71719d60c5d249ad1ca6261e15cc04eb8d9ca320234d85baafd82968a"

URI_aarch64_rust-hickory-proto0.25+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+std-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+std-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+std-devel.sha256sum] = "593afdebd52b9df210123fce7883b3a6550761c91b12ba544760112f9cf9a0a5"

URI_aarch64_rust-hickory-proto0.25+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+testing-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+testing-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+testing-devel.sha256sum] = "efaeaef70083b9a580b52ba7726bbd8218ed6e1c0eddd04c27d3fa41ffdc9a97"

URI_aarch64_rust-hickory-proto0.25+text-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+text-parsing-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+text-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+text-parsing-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+text-parsing-devel.sha256sum] = "e7edcda2614a2ccc2626557c5129b61f20e97cfccb099ec3125858e7475ce522"

URI_aarch64_rust-hickory-proto0.25+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+tokio-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+tokio-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+tokio-devel.sha256sum] = "efadec4c80174428234c28691072201dada5a1a2eb266d12cefbaf6858b94e58"

URI_aarch64_rust-hickory-proto0.25+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25+webpki-roots-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25+webpki-roots-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25+webpki-roots-devel.sha256sum] = "006435a7cfadd6c9d02604872f15c0eff28bce584d9e52a074210b1c060a81f7"

URI_aarch64_rust-hickory-proto0.25-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto0.25-devel-0.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto0.25-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto0.25-devel}"
SRC_URI[aarch64_rust-hickory-proto0.25-devel.sha256sum] = "556d2f6aa0869106186e8ebb144736c84c2d80e69ec34b5fe08aa1bff0943dba"

RDEPENDS:rust-hickory-proto0.25+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-hickory-proto0.25+std-devel \
 rust-hickory-proto0.25-devel \
 "
RDEPENDS:rust-hickory-proto0.25+default-devel = " \
 cargo \
 rust-hickory-proto0.25+std-devel \
 rust-hickory-proto0.25+tokio-devel \
 rust-hickory-proto0.25-devel \
 "
RDEPENDS:rust-hickory-proto0.25+futures-io-devel = " \
 cargo \
 rust-futures-io-devel \
 rust-hickory-proto0.25-devel \
 "
RDEPENDS:rust-hickory-proto0.25+mdns-devel = " \
 cargo \
 rust-hickory-proto0.25+std-devel \
 rust-hickory-proto0.25-devel \
 rust-socket2_0.5+all-devel \
 rust-socket2_0.5+default-devel \
 "
RDEPENDS:rust-hickory-proto0.25+no-std-rand-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-hickory-proto0.25-devel \
 rust-once_cell+critical-section-devel \
 "
RDEPENDS:rust-hickory-proto0.25+rustls-platform-verifier-devel = " \
 cargo \
 rust-hickory-proto0.25+std-devel \
 rust-hickory-proto0.25-devel \
 rust-rustls-platform-verifier0.5+default-devel \
 "
RDEPENDS:rust-hickory-proto0.25+serde-devel = " \
 cargo \
 rust-hickory-proto0.25+std-devel \
 rust-hickory-proto0.25-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-url+serde-devel \
 "
RDEPENDS:rust-hickory-proto0.25+socket2-devel = " \
 cargo \
 rust-hickory-proto0.25-devel \
 rust-socket2_0.5+default-devel \
 "
RDEPENDS:rust-hickory-proto0.25+std-devel = " \
 cargo \
 rust-data-encoding+std-devel \
 rust-futures-channel+std-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util+std-devel \
 rust-hickory-proto0.25-devel \
 rust-ipnet+std-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9+thread_rng-devel \
 rust-ring+default-devel \
 rust-ring+std-devel \
 rust-thiserror+std-devel \
 rust-tracing+std-devel \
 rust-url+std-devel \
 "
RDEPENDS:rust-hickory-proto0.25+testing-devel = " \
 cargo \
 rust-hickory-proto0.25+std-devel \
 rust-hickory-proto0.25-devel \
 "
RDEPENDS:rust-hickory-proto0.25+text-parsing-devel = " \
 cargo \
 rust-hickory-proto0.25+std-devel \
 rust-hickory-proto0.25-devel \
 "
RDEPENDS:rust-hickory-proto0.25+tokio-devel = " \
 cargo \
 rust-hickory-proto0.25+std-devel \
 rust-hickory-proto0.25-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-hickory-proto0.25+webpki-roots-devel = " \
 cargo \
 rust-hickory-proto0.25-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-hickory-proto0.25-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-cfg-if+default-devel \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 rust-enum-as-inner+default-devel \
 rust-futures-channel+alloc-devel \
 rust-futures-channel-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna-devel \
 rust-ipnet-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 rust-rand0.9+alloc-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9-devel \
 rust-thiserror-devel \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 rust-tracing-devel \
 rust-url-devel \
 "
