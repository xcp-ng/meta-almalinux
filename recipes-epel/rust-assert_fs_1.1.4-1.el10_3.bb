# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert_fs"
PV = "1.1.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-assert_fs+color-auto-devel \
 rust-assert_fs+color-devel \
 rust-assert_fs+default-devel \
 rust-assert_fs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert_fs-1.1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a13e8e150c1fd069419d10a9f87e418d45be6b2472f75c91680629ea8aefb6d"

URI_x86_64_v2_rust-assert_fs+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+color-auto-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+color-auto-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+color-auto-devel.sha256sum] = "3e132a537c95893391b79fc50303a152f9cb32f479e1ca4f0a6eceefd0e796a1"

URI_x86_64_v2_rust-assert_fs+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+color-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+color-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+color-devel.sha256sum] = "6b861b11e5a3ed3f7d5db0564aabd63ebf172e20011c3677ba819703a33aab82"

URI_x86_64_v2_rust-assert_fs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+default-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+default-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+default-devel.sha256sum] = "36e216c3463fbb27f5284312a342f2c62c945a634bd79cd9c74f5b0d0fbd2015"

URI_x86_64_v2_rust-assert_fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs-devel}"
SRC_URI[x86_64_v2_rust-assert_fs-devel.sha256sum] = "6f9e84b50cb69f48e47da4b5bcd1ad510311bc769527f6504c7c70692ef33a46"

URI_aarch64_rust-assert_fs+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+color-auto-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-assert_fs+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+color-auto-devel}"
SRC_URI[aarch64_rust-assert_fs+color-auto-devel.sha256sum] = "7717540f32715f42572512705c447595bc768e6532d39c52c134c5fa3c59bffe"

URI_aarch64_rust-assert_fs+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+color-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-assert_fs+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+color-devel}"
SRC_URI[aarch64_rust-assert_fs+color-devel.sha256sum] = "5f3226683390dbc08f8169aa53e5ad0c3614e3362d30a91e6264ebd679ef7692"

URI_aarch64_rust-assert_fs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+default-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-assert_fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+default-devel}"
SRC_URI[aarch64_rust-assert_fs+default-devel.sha256sum] = "17310b16c959c9189b2425326ce2ddc73008e8d0351b36fc8b2b8cab29b051a5"

URI_aarch64_rust-assert_fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-assert_fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs-devel}"
SRC_URI[aarch64_rust-assert_fs-devel.sha256sum] = "e5e3ee340e994233816d28ad03ed169d2f6c3b5fd13b425eef7f76f8c0122b5b"

RDEPENDS:rust-assert_fs+color-auto-devel = " \
 cargo \
 rust-assert_fs+color-devel \
 rust-assert_fs-devel \
 "
RDEPENDS:rust-assert_fs+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-assert_fs-devel \
 rust-predicates+color-devel \
 "
RDEPENDS:rust-assert_fs+default-devel = " \
 cargo \
 rust-assert_fs-devel \
 "
RDEPENDS:rust-assert_fs-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-globwalk+default-devel \
 rust-predicates+diff-devel \
 rust-predicates-core+default-devel \
 rust-predicates-devel \
 rust-predicates-tree+default-devel \
 rust-tempfile-devel \
 "
