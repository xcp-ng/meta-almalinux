# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aes-siv"
PV = "0.7.0"
PR = "6.el10_2"
PACKAGES = " \
 rust-aes-siv+alloc-devel \
 rust-aes-siv+default-devel \
 rust-aes-siv+getrandom-devel \
 rust-aes-siv+heapless-devel \
 rust-aes-siv+pmac-devel \
 rust-aes-siv+std-devel \
 rust-aes-siv+stream-devel \
 rust-aes-siv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aes-siv-0.7.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25bc8f0f02e88310fa19dfb1705164a1d6a9d8b272d16dc728b1b0e42199cf9a"

URI_x86_64_v2_rust-aes-siv+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+alloc-devel-0.7.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+alloc-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+alloc-devel.sha256sum] = "63875be70215a2f5c971e3fe5d5406721bdac263acec1b9c009cc0a4621f2cc6"

URI_x86_64_v2_rust-aes-siv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+default-devel-0.7.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+default-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+default-devel.sha256sum] = "15ae592f1672ed3afed786cadc6445749883068afd3f7fa80037fa75a8063491"

URI_x86_64_v2_rust-aes-siv+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+getrandom-devel-0.7.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+getrandom-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+getrandom-devel.sha256sum] = "0b0510f14a8860dd535138040ca6997d9a49f8716a1c5079d55feaa6554a3fda"

URI_x86_64_v2_rust-aes-siv+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+heapless-devel-0.7.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+heapless-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+heapless-devel.sha256sum] = "89edfba3eea7f54364ab5746d25cdb06db18ac5d23d2735ad92f46a9e3e4dd79"

URI_x86_64_v2_rust-aes-siv+pmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+pmac-devel-0.7.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+pmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+pmac-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+pmac-devel.sha256sum] = "369c3e0c46b44af12eedd9f83bee899532d1b329fe965546c8725c12cc3cd924"

URI_x86_64_v2_rust-aes-siv+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+std-devel-0.7.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+std-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+std-devel.sha256sum] = "ef489a802122b39b40a4d148d261d2ddc03c5b23e6186690c7f34b89cd5cbc68"

URI_x86_64_v2_rust-aes-siv+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+stream-devel-0.7.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+stream-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+stream-devel.sha256sum] = "1f8bdcbab8e1c9749330967809d229b7ebef1187682b18ff5e117efd2773fe5e"

URI_x86_64_v2_rust-aes-siv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv-devel-0.7.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv-devel}"
SRC_URI[x86_64_v2_rust-aes-siv-devel.sha256sum] = "c918a5b615c86389fa5b3b302a23e80d51b6e5be32d4da3c19a2f9f5099fdc97"

URI_aarch64_rust-aes-siv+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+alloc-devel-0.7.0-6.el10_2.noarch.rpm;name=aarch64_rust-aes-siv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+alloc-devel}"
SRC_URI[aarch64_rust-aes-siv+alloc-devel.sha256sum] = "ca94de76aecd3228dbe1763c52c75e1d5011faa9a4ffcbad976df932f5fe53b8"

URI_aarch64_rust-aes-siv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+default-devel-0.7.0-6.el10_2.noarch.rpm;name=aarch64_rust-aes-siv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+default-devel}"
SRC_URI[aarch64_rust-aes-siv+default-devel.sha256sum] = "8eb3992777f72a286e89e839c92e6c1e5a614a8a5b12491178195030a85fba25"

URI_aarch64_rust-aes-siv+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+getrandom-devel-0.7.0-6.el10_2.noarch.rpm;name=aarch64_rust-aes-siv+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+getrandom-devel}"
SRC_URI[aarch64_rust-aes-siv+getrandom-devel.sha256sum] = "eafa9faee65f372e48b99d7e944dca6d48c2701bc95408c39aa52a33204da1eb"

URI_aarch64_rust-aes-siv+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+heapless-devel-0.7.0-6.el10_2.noarch.rpm;name=aarch64_rust-aes-siv+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+heapless-devel}"
SRC_URI[aarch64_rust-aes-siv+heapless-devel.sha256sum] = "83809f230792296716e5805483688a93bc5509564f5eb75267eab5bcdcb94a54"

URI_aarch64_rust-aes-siv+pmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+pmac-devel-0.7.0-6.el10_2.noarch.rpm;name=aarch64_rust-aes-siv+pmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+pmac-devel}"
SRC_URI[aarch64_rust-aes-siv+pmac-devel.sha256sum] = "6d5cf615a091288e953bdee6c9f358eb376206bc26b6d40d9f175ef7951a06a3"

URI_aarch64_rust-aes-siv+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+std-devel-0.7.0-6.el10_2.noarch.rpm;name=aarch64_rust-aes-siv+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+std-devel}"
SRC_URI[aarch64_rust-aes-siv+std-devel.sha256sum] = "b8baafa9dcc6fc6312d9e460e347bd7b3431a4b8a86deb4a0f2d164d5027c160"

URI_aarch64_rust-aes-siv+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+stream-devel-0.7.0-6.el10_2.noarch.rpm;name=aarch64_rust-aes-siv+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+stream-devel}"
SRC_URI[aarch64_rust-aes-siv+stream-devel.sha256sum] = "c09548d9c7042151eb86949b6888ade4ed6bb6f89f92715c0cc1879fc813964c"

URI_aarch64_rust-aes-siv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv-devel-0.7.0-6.el10_2.noarch.rpm;name=aarch64_rust-aes-siv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv-devel}"
SRC_URI[aarch64_rust-aes-siv-devel.sha256sum] = "1c24543bf15cc9bc91a1352d9056d21678d1cae78634e37f0121819cc14feab7"

RDEPENDS:rust-aes-siv+alloc-devel = " \
 cargo \
 rust-aead+alloc-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv+default-devel = " \
 cargo \
 rust-aes-siv+alloc-devel \
 rust-aes-siv+getrandom-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv+getrandom-devel = " \
 cargo \
 rust-aead+getrandom-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv+heapless-devel = " \
 cargo \
 rust-aead+heapless-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv+pmac-devel = " \
 cargo \
 rust-aes-siv-devel \
 rust-pmac+default-devel \
 "
RDEPENDS:rust-aes-siv+std-devel = " \
 cargo \
 rust-aead+std-devel \
 rust-aes-siv+alloc-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv+stream-devel = " \
 cargo \
 rust-aead+stream-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv-devel = " \
 cargo \
 rust \
 rust-aead+default-devel \
 rust-aes+default-devel \
 rust-cipher0.4+default-devel \
 rust-cmac+default-devel \
 rust-ctr+default-devel \
 rust-dbl+default-devel \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 rust-zeroize-devel \
 "
