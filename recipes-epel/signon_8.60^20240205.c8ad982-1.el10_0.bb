# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signon"
PV = "8.60^20240205.c8ad982"
PR = "1.el10_0"
PACKAGES = " \
 signon \
 signon-devel \
 signon-doc \
 signon-qt5 \
 signon-qt5-devel \
 signon-qt6 \
 signon-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/signon-8.60^20240205.c8ad982-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99f17e411643f3011c12e4822c328eb3b8848a110c914a04db51ecf48dd6f30e"

URI_x86_64_v2_signon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-8.60^20240205.c8ad982-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon}"
SRC_URI[x86_64_v2_signon.sha256sum] = "d55a6037ff228123ceae10e78f9fc34c5aeba739138d4edb4815c768a01fcc0b"

URI_x86_64_v2_signon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-devel-8.60^20240205.c8ad982-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-devel}"
SRC_URI[x86_64_v2_signon-devel.sha256sum] = "509a346123cce905b0e0a0418cc71d330570473e604f6931fc1c6ecf7b34d9bc"

URI_x86_64_v2_signon-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-doc-8.60^20240205.c8ad982-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_signon-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-doc}"
SRC_URI[x86_64_v2_signon-doc.sha256sum] = "50bf08a04f8b9a63d74fde4e216e5089109bafce2a191189464072c3d6d393c2"

URI_x86_64_v2_signon-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-qt5-8.60^20240205.c8ad982-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-qt5}"
SRC_URI[x86_64_v2_signon-qt5.sha256sum] = "ac0698bf0b1226fe57e5c3e87a67aa127afd67906826961e97cb8a8e4477530f"

URI_x86_64_v2_signon-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-qt5-devel-8.60^20240205.c8ad982-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-qt5-devel}"
SRC_URI[x86_64_v2_signon-qt5-devel.sha256sum] = "74b82bd19540cf26f6ecd83f5782b578086780755bc13d35c0d0a5cf9014e4a0"

URI_x86_64_v2_signon-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-qt6-8.60^20240205.c8ad982-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-qt6}"
SRC_URI[x86_64_v2_signon-qt6.sha256sum] = "2a61c83f2635c1fc64e2b46012b974a53b8ee5b8a4bf72f489b99ea61bcfdd5c"

URI_x86_64_v2_signon-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-qt6-devel-8.60^20240205.c8ad982-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-qt6-devel}"
SRC_URI[x86_64_v2_signon-qt6-devel.sha256sum] = "35ab4f8efc617c0ca0fa063d1f943b15cf08af49a6df2cf360e4b1dd7a9d77fa"

URI_aarch64_signon = "${EPEL_MIRROR}/aarch64/Packages/s/signon-8.60^20240205.c8ad982-1.el10_0.aarch64.rpm;name=aarch64_signon;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon}"
SRC_URI[aarch64_signon.sha256sum] = "b5efc8565c7ae869042f3c9edda1f2574ef1759e29e458d4e9cefca6fb2cecca"

URI_aarch64_signon-devel = "${EPEL_MIRROR}/aarch64/Packages/s/signon-devel-8.60^20240205.c8ad982-1.el10_0.aarch64.rpm;name=aarch64_signon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-devel}"
SRC_URI[aarch64_signon-devel.sha256sum] = "8c1a665afd9a8bb1c2ce04f6a2fb5428ce35ff1bc4b77d583f32a7e89c1b0661"

URI_aarch64_signon-doc = "${EPEL_MIRROR}/aarch64/Packages/s/signon-doc-8.60^20240205.c8ad982-1.el10_0.noarch.rpm;name=aarch64_signon-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-doc}"
SRC_URI[aarch64_signon-doc.sha256sum] = "2a4d4afc965b2b1f7fc36adc325737acd5143731cf92bbb3db02a77ccb121af1"

URI_aarch64_signon-qt5 = "${EPEL_MIRROR}/aarch64/Packages/s/signon-qt5-8.60^20240205.c8ad982-1.el10_0.aarch64.rpm;name=aarch64_signon-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-qt5}"
SRC_URI[aarch64_signon-qt5.sha256sum] = "71a173e60866237921de0109761d04b5285079d3663312d1ca71ce77f78e7e67"

URI_aarch64_signon-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/s/signon-qt5-devel-8.60^20240205.c8ad982-1.el10_0.aarch64.rpm;name=aarch64_signon-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-qt5-devel}"
SRC_URI[aarch64_signon-qt5-devel.sha256sum] = "dd7f1c09223299157b50be4102e3a46c206b186a39fa8c68bc82997616927e3d"

URI_aarch64_signon-qt6 = "${EPEL_MIRROR}/aarch64/Packages/s/signon-qt6-8.60^20240205.c8ad982-1.el10_0.aarch64.rpm;name=aarch64_signon-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-qt6}"
SRC_URI[aarch64_signon-qt6.sha256sum] = "09967042e9cc0932268266029300cb632882cceaa6d996688f02717e4858043a"

URI_aarch64_signon-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/s/signon-qt6-devel-8.60^20240205.c8ad982-1.el10_0.aarch64.rpm;name=aarch64_signon-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-qt6-devel}"
SRC_URI[aarch64_signon-qt6-devel.sha256sum] = "801d04d06655e73d0b11f8cf64013ea5ce0d1e0e5a626d45680f55ecedbbee5a"

RDEPENDS:signon = " \
 dbus \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:signon-devel = " \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 signon \
 signon-qt6-devel \
 "
RDEPENDS:signon-doc = " \
 "
RDEPENDS:signon-qt5 = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:signon-qt5-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 signon-qt5 \
 "
RDEPENDS:signon-qt6 = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:signon-qt6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 signon-qt6 \
 "
