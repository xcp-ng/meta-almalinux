# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "most"
PV = "5.2.0"
PR = "8.el10_1"
PACKAGES = " \
 most \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/most-5.2.0-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46be1ca1962d772bae72bc240cee07315c0864cd6e58486dc35f77efe37ed278"

URI_x86_64_v2_most = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/most-5.2.0-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_most;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_most}"
SRC_URI[x86_64_v2_most.sha256sum] = "584f6fc66dfaa741e3ce45a6dbf3c050e135d5caf921034d8ddf67ca30d96540"

URI_aarch64_most = "${EPEL_MIRROR}/aarch64/Packages/m/most-5.2.0-8.el10_1.aarch64.rpm;name=aarch64_most;unpack=0"
SRC_URI:append = " ${URI_aarch64_most}"
SRC_URI[aarch64_most.sha256sum] = "2c07f55ab5e987d2377a3775d77a77ffd212edd94f4a6c95b57eb102c2b9fd70"

RDEPENDS:most = " \
 glibc \
 slang \
 "
