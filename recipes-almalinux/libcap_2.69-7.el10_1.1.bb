# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcap"
PV = "2.69"
PR = "7.el10_1.1"
PACKAGES = " \
 libcap \
 libcap-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libcap-2.69-7.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70cc143a9ee381109b39dc2a7599178bdb8cb3e0e10ee58bba45449acbea4693"

URI_x86_64_v2_libcap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcap-2.69-7.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap}"
SRC_URI[x86_64_v2_libcap.sha256sum] = "1380424e384492f37a2cdb5de4712de552689a7c1f63723149ad83cf923fc0eb"

URI_x86_64_v2_libcap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcap-devel-2.69-7.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_libcap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-devel}"
SRC_URI[x86_64_v2_libcap-devel.sha256sum] = "e58974b390b5d4a88dbc0ca91fa7c73e055b3369d8eccf7dcb32232783910100"

URI_aarch64_libcap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcap-2.69-7.el10_1.1.aarch64.rpm;name=aarch64_libcap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap}"
SRC_URI[aarch64_libcap.sha256sum] = "9b18ee742b94347070d73a8b540f5229decc55ed2f86a3579c13b02b7ae4074e"

URI_aarch64_libcap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcap-devel-2.69-7.el10_1.1.aarch64.rpm;name=aarch64_libcap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-devel}"
SRC_URI[aarch64_libcap-devel.sha256sum] = "d9076d94445fb6b5e7a7524e8106725f30b78cde50b702677937fefd4085ed42"

RDEPENDS:libcap = " \
 glibc \
 libgcc \
 pam-libs \
 "
RDEPENDS:libcap-devel = " \
 libcap \
 pkgconf-pkg-config \
 "
