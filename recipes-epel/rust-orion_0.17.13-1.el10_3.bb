# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-orion"
PV = "0.17.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-orion+alloc-devel \
 rust-orion+ct-codecs-devel \
 rust-orion+default-devel \
 rust-orion+experimental-devel \
 rust-orion+getrandom-devel \
 rust-orion+safe_api-devel \
 rust-orion+serde-devel \
 rust-orion+zeroize-devel \
 rust-orion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-orion-0.17.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa57ab1930262e142f6355e8bf95d75c50589fb96263102f670376a8d0155fe4"

URI_x86_64_v2_rust-orion+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+alloc-devel-0.17.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+alloc-devel}"
SRC_URI[x86_64_v2_rust-orion+alloc-devel.sha256sum] = "f9f6006153cc3d78c2404a485492a533689edaac647f76091856db6d02dadbda"

URI_x86_64_v2_rust-orion+ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+ct-codecs-devel-0.17.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-orion+ct-codecs-devel.sha256sum] = "1ee5ace3a4dd6544c08c0418b761ae724c9785dac841387a3c9226cb76e9a582"

URI_x86_64_v2_rust-orion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+default-devel-0.17.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+default-devel}"
SRC_URI[x86_64_v2_rust-orion+default-devel.sha256sum] = "5964abfa1bbf50570bff82f344fd6bbf781fec3b185dc9b1d7fecc5030a7eb21"

URI_x86_64_v2_rust-orion+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+experimental-devel-0.17.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+experimental-devel}"
SRC_URI[x86_64_v2_rust-orion+experimental-devel.sha256sum] = "a0016ad5edd372ab1c0032fca06a4a4ff65fc52fe6836fa2a7eca171d4fa51a0"

URI_x86_64_v2_rust-orion+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+getrandom-devel-0.17.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+getrandom-devel}"
SRC_URI[x86_64_v2_rust-orion+getrandom-devel.sha256sum] = "ba80136a647c5eae25ca7532d6da4d6f6c24d36459825c7fa566b29dfe14ada0"

URI_x86_64_v2_rust-orion+safe_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+safe_api-devel-0.17.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+safe_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+safe_api-devel}"
SRC_URI[x86_64_v2_rust-orion+safe_api-devel.sha256sum] = "d15d5828f0b97d2611ceb4b555c1b84f132427fd8f89511bd3f1961e0f339cdc"

URI_x86_64_v2_rust-orion+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+serde-devel-0.17.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+serde-devel}"
SRC_URI[x86_64_v2_rust-orion+serde-devel.sha256sum] = "da4045d468698af8fce31e3fd39298daeb34b4239fd1025f05ff23a16007eda4"

URI_x86_64_v2_rust-orion+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion+zeroize-devel-0.17.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion+zeroize-devel}"
SRC_URI[x86_64_v2_rust-orion+zeroize-devel.sha256sum] = "06e05283a6af61cf50688456e58f863ecce0cee4bb48ee4e1ecfbe067a285f1e"

URI_x86_64_v2_rust-orion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-orion-devel-0.17.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-orion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-orion-devel}"
SRC_URI[x86_64_v2_rust-orion-devel.sha256sum] = "06877de04d5e36b280c5b6fcf1afb263b51fd3f44279ae58b0d094655062d971"

URI_aarch64_rust-orion+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+alloc-devel-0.17.13-1.el10_3.noarch.rpm;name=aarch64_rust-orion+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+alloc-devel}"
SRC_URI[aarch64_rust-orion+alloc-devel.sha256sum] = "e2ca93218cea52191f355dfdcde344ae15d4f3261d067fbd5c62c6a608188778"

URI_aarch64_rust-orion+ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+ct-codecs-devel-0.17.13-1.el10_3.noarch.rpm;name=aarch64_rust-orion+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+ct-codecs-devel}"
SRC_URI[aarch64_rust-orion+ct-codecs-devel.sha256sum] = "d97c2ded506b263682ac85a49cb43aa967072cc4929dc1232f3c5823530be129"

URI_aarch64_rust-orion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+default-devel-0.17.13-1.el10_3.noarch.rpm;name=aarch64_rust-orion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+default-devel}"
SRC_URI[aarch64_rust-orion+default-devel.sha256sum] = "7865123000680d8228fd909b2215d28331fa655d804a9c24a30b8ca85ac783cb"

URI_aarch64_rust-orion+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+experimental-devel-0.17.13-1.el10_3.noarch.rpm;name=aarch64_rust-orion+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+experimental-devel}"
SRC_URI[aarch64_rust-orion+experimental-devel.sha256sum] = "f40c711fb621f4e7515caf22022ce91e11e43b0e5adbac798faec2ec048c3ed7"

URI_aarch64_rust-orion+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+getrandom-devel-0.17.13-1.el10_3.noarch.rpm;name=aarch64_rust-orion+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+getrandom-devel}"
SRC_URI[aarch64_rust-orion+getrandom-devel.sha256sum] = "497c285a23e80ea1fdcc661ae903d3a292cfc6a34f7835da123b58fb54c68b9c"

URI_aarch64_rust-orion+safe_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+safe_api-devel-0.17.13-1.el10_3.noarch.rpm;name=aarch64_rust-orion+safe_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+safe_api-devel}"
SRC_URI[aarch64_rust-orion+safe_api-devel.sha256sum] = "26f5a98b77ce781da6f6a0e5c8a8a143d1a2b3cc73efd18fea07e25968f1a3b6"

URI_aarch64_rust-orion+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+serde-devel-0.17.13-1.el10_3.noarch.rpm;name=aarch64_rust-orion+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+serde-devel}"
SRC_URI[aarch64_rust-orion+serde-devel.sha256sum] = "6a107ca63f49dfc816bc59659d83bcd77d22616fbc3c9f7eff3ec892c2f85b83"

URI_aarch64_rust-orion+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion+zeroize-devel-0.17.13-1.el10_3.noarch.rpm;name=aarch64_rust-orion+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion+zeroize-devel}"
SRC_URI[aarch64_rust-orion+zeroize-devel.sha256sum] = "23ebb4817fe41d05f062d4a04b70de277097b67523e9f87faf300e71213e83c7"

URI_aarch64_rust-orion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-orion-devel-0.17.13-1.el10_3.noarch.rpm;name=aarch64_rust-orion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-orion-devel}"
SRC_URI[aarch64_rust-orion-devel.sha256sum] = "69b185137fb69ec29d2750d02bbd7a10fb71a3798ef4afc2547994b93b0ccf2a"

RDEPENDS:rust-orion+alloc-devel = " \
 cargo \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+ct-codecs-devel = " \
 cargo \
 rust-ct-codecs+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+default-devel = " \
 cargo \
 rust-orion+safe_api-devel \
 rust-orion+zeroize-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+experimental-devel = " \
 cargo \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-orion-devel \
 "
RDEPENDS:rust-orion+safe_api-devel = " \
 cargo \
 rust-orion+ct-codecs-devel \
 rust-orion+getrandom-devel \
 rust-orion-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-orion+serde-devel = " \
 cargo \
 rust-orion+alloc-devel \
 rust-orion-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-orion+zeroize-devel = " \
 cargo \
 rust-orion-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-orion-devel = " \
 cargo \
 rust \
 rust-fiat-crypto-devel \
 rust-subtle-devel \
 "
