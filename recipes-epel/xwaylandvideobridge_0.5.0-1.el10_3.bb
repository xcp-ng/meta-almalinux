# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xwaylandvideobridge"
PV = "0.5.0"
PR = "1.el10_3"
PACKAGES = " \
 xwaylandvideobridge \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xwaylandvideobridge-0.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9bf26dce29f72b455dd8a3e76ade3ec755abab7b3eb6697bd4653139097c071"

URI_x86_64_v2_xwaylandvideobridge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xwaylandvideobridge-0.5.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xwaylandvideobridge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xwaylandvideobridge}"
SRC_URI[x86_64_v2_xwaylandvideobridge.sha256sum] = "f84c1369f08dc45cb89e920413e563a98465a60250d7da08c80d2d035ae3214f"

URI_aarch64_xwaylandvideobridge = "${EPEL_MIRROR}/aarch64/Packages/x/xwaylandvideobridge-0.5.0-1.el10_3.aarch64.rpm;name=aarch64_xwaylandvideobridge;unpack=0"
SRC_URI:append = " ${URI_aarch64_xwaylandvideobridge}"
SRC_URI[aarch64_xwaylandvideobridge.sha256sum] = "1f7b4f688d7c558bf0df2cf42a6088a2a6e15b17bd546200e060b2d4084405be"

RDEPENDS:xwaylandvideobridge = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kpipewire \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
