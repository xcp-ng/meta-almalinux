# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmbscan"
PV = "1.2.6"
PR = "30.el10_0"
PACKAGES = " \
 nmbscan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nmbscan-1.2.6-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e950e36a47c92de801421516fd727689f6d25b8d818d7f164985817291495b9"

URI_x86_64_v2_nmbscan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nmbscan-1.2.6-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nmbscan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmbscan}"
SRC_URI[x86_64_v2_nmbscan.sha256sum] = "6c7fff4ce502d73f53b021a97a4d1455a2758871fec8103c04f66495a5e63b49"

URI_aarch64_nmbscan = "${EPEL_MIRROR}/aarch64/Packages/n/nmbscan-1.2.6-30.el10_0.noarch.rpm;name=aarch64_nmbscan;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmbscan}"
SRC_URI[aarch64_nmbscan.sha256sum] = "2b2c91b2b800639f942a0ae35f36c9fbe38838272347056036a02d5e8fde27dc"

RDEPENDS:nmbscan = " \
 bash \
 bind-utils \
 iproute \
 iputils \
 samba-client \
 "
