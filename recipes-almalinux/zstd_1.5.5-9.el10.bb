# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zstd"
PV = "1.5.5"
PR = "9.el10"
PACKAGES = " \
 libzstd \
 libzstd-devel \
 zstd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/zstd-1.5.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f012cd03befce17fa354dcb593f92f53fd027c374a8d8b33865b5c6809083e88"

URI_x86_64_v2_libzstd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libzstd-1.5.5-9.el10.x86_64_v2.rpm;name=x86_64_v2_libzstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libzstd}"
SRC_URI[x86_64_v2_libzstd.sha256sum] = "a27ae7025623351b8afaf16c4e3a0e7c31c3777c85960662e1ff7a15da0a3126"

URI_x86_64_v2_libzstd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libzstd-devel-1.5.5-9.el10.x86_64_v2.rpm;name=x86_64_v2_libzstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libzstd-devel}"
SRC_URI[x86_64_v2_libzstd-devel.sha256sum] = "2e0d49b33b42a5c6fb4eec21135ffddd7f00d5168bf3e6286b320148e5a143f8"

URI_x86_64_v2_zstd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/zstd-1.5.5-9.el10.x86_64_v2.rpm;name=x86_64_v2_zstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zstd}"
SRC_URI[x86_64_v2_zstd.sha256sum] = "0203ada9cd01790816fed26d6597c62936d6f036b0ed9ab1262cbc948d9db1ba"

URI_aarch64_libzstd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libzstd-1.5.5-9.el10.aarch64.rpm;name=aarch64_libzstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libzstd}"
SRC_URI[aarch64_libzstd.sha256sum] = "fd9cfcac80f5aa625db43949b15accfd7b9e139e559ab1a7cfb1212191aaf8f1"

URI_aarch64_libzstd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libzstd-devel-1.5.5-9.el10.aarch64.rpm;name=aarch64_libzstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libzstd-devel}"
SRC_URI[aarch64_libzstd-devel.sha256sum] = "77a34d32489f8fec5fb5ee20c8e8ec8f2a5ee92c1122d0f2e874ec8887c2907d"

URI_aarch64_zstd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/zstd-1.5.5-9.el10.aarch64.rpm;name=aarch64_zstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_zstd}"
SRC_URI[aarch64_zstd.sha256sum] = "41c75b0b9faa6c8613d4035f15e5b4eaefcc822ce5e6c86acad38b2d75288356"

RDEPENDS:libzstd = " \
 glibc \
 "
RDEPENDS:libzstd-devel = " \
 libzstd \
 pkgconf-pkg-config \
 "
RDEPENDS:zstd = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 lz4-libs \
 xz-libs \
 zlib-ng-compat \
 "
