# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-workspace"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 libkworkspace6 \
 plasma-lookandfeel-fedora \
 plasma-workspace \
 plasma-workspace-common \
 plasma-workspace-devel \
 plasma-workspace-doc \
 plasma-workspace-libs \
 plasma-workspace-wayland \
 sddm-wayland-plasma \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-workspace-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dd29686d68c37998c8508c84555ce24a4f2e04a750895db606da43700bb51b8"

URI_x86_64_v2_libkworkspace6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkworkspace6-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkworkspace6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkworkspace6}"
SRC_URI[x86_64_v2_libkworkspace6.sha256sum] = "1613879e38501e79e3209caaecbcd3bbe7ade187e9d31789e50ded783c785262"

URI_x86_64_v2_plasma-lookandfeel-fedora = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-lookandfeel-fedora-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-lookandfeel-fedora;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-lookandfeel-fedora}"
SRC_URI[x86_64_v2_plasma-lookandfeel-fedora.sha256sum] = "3ae6ab72313ceb0bc351cbdebf7d88c165d1d9391439bb49adc06a678f1bdb7a"

URI_x86_64_v2_plasma-workspace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace}"
SRC_URI[x86_64_v2_plasma-workspace.sha256sum] = "1b1d30867e659af1fe4501f9b34e1b84e958488f013984e8387c29548e28e9af"

URI_x86_64_v2_plasma-workspace-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-common-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-common}"
SRC_URI[x86_64_v2_plasma-workspace-common.sha256sum] = "bd0cee57e6b77a1bed305c37086e19ecb3c71f930af55c596d1ac0cf0f0d1cdd"

URI_x86_64_v2_plasma-workspace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-devel}"
SRC_URI[x86_64_v2_plasma-workspace-devel.sha256sum] = "ccee8c73482fb9501dffc956304e027910d647618716e39a0d5be5ad59e3e9ee"

URI_x86_64_v2_plasma-workspace-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-doc-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-workspace-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-doc}"
SRC_URI[x86_64_v2_plasma-workspace-doc.sha256sum] = "8c2a0a1161ac3db208d7960f84f97d85bf326c474f7898aeea61bee3f5b8fa13"

URI_x86_64_v2_plasma-workspace-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-libs-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-libs}"
SRC_URI[x86_64_v2_plasma-workspace-libs.sha256sum] = "2987ac6648aa7d4b81ac5d262ae1b4f63a45c3b002ffb0b0fb853fedc9e9b53c"

URI_x86_64_v2_plasma-workspace-wayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-wayland-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-wayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-wayland}"
SRC_URI[x86_64_v2_plasma-workspace-wayland.sha256sum] = "e99a17b2311d37daf8637793d2a7beddb6a554326980524d4c1cacd232e529e9"

URI_x86_64_v2_sddm-wayland-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-wayland-plasma-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-wayland-plasma}"
SRC_URI[x86_64_v2_sddm-wayland-plasma.sha256sum] = "45301ea47ead6674eb6c6ece53a3aff57755e6432a000ea25ea21c76b3c1feac"
RPROVIDES:sddm-wayland-plasma:x86_64_v2 = "virtual/sddm-greeter-displayserver"

URI_aarch64_libkworkspace6 = "${EPEL_MIRROR}/aarch64/Packages/l/libkworkspace6-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_libkworkspace6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkworkspace6}"
SRC_URI[aarch64_libkworkspace6.sha256sum] = "151972d9c71e9350e835c72b548c771254ffa1e37e9ee5c3412fd17164b645a1"

URI_aarch64_plasma-lookandfeel-fedora = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-lookandfeel-fedora-6.3.6-1.el10_0.noarch.rpm;name=aarch64_plasma-lookandfeel-fedora;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-lookandfeel-fedora}"
SRC_URI[aarch64_plasma-lookandfeel-fedora.sha256sum] = "e4d3ac96a6cca1bf1da1cb8265e894efe72314fa6940494dbac4e8d0bb6ed82a"

URI_aarch64_plasma-workspace = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-workspace;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace}"
SRC_URI[aarch64_plasma-workspace.sha256sum] = "c7525120f45e278e29c3e48eb0e4be2fd5e1d4b1c56468224b2d814997b4bf29"

URI_aarch64_plasma-workspace-common = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-common-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-workspace-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-common}"
SRC_URI[aarch64_plasma-workspace-common.sha256sum] = "5a263024f598103755b9ca93d3fdc0b407653301e0e773bc9816bcda243fce2c"

URI_aarch64_plasma-workspace-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-workspace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-devel}"
SRC_URI[aarch64_plasma-workspace-devel.sha256sum] = "23a7458980c498448970f5e341337fc6e6ecec117663a35d95f8a97f2a9ace01"

URI_aarch64_plasma-workspace-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-doc-6.3.6-1.el10_0.noarch.rpm;name=aarch64_plasma-workspace-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-doc}"
SRC_URI[aarch64_plasma-workspace-doc.sha256sum] = "366b60071092b6b599e0a07789299656f161f88b7a7f1e7d5ea02755ee66e935"

URI_aarch64_plasma-workspace-libs = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-libs-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-workspace-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-libs}"
SRC_URI[aarch64_plasma-workspace-libs.sha256sum] = "346e0e160b686aced66cb538aa4800be6211b31603558b63eec02149161ab333"

URI_aarch64_plasma-workspace-wayland = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-wayland-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-workspace-wayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-wayland}"
SRC_URI[aarch64_plasma-workspace-wayland.sha256sum] = "7ab314ecd25a4d56b29caa0035a7e9bacd76090a2856ff575fc11e949a18fc86"

URI_aarch64_sddm-wayland-plasma = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-wayland-plasma-6.3.6-1.el10_0.noarch.rpm;name=aarch64_sddm-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-wayland-plasma}"
SRC_URI[aarch64_sddm-wayland-plasma.sha256sum] = "47accb860ec345bfe3e7c3188e8c01f23802f99fdf35b868de0c125d9e7154d7"
RPROVIDES:sddm-wayland-plasma:aarch64 = "virtual/sddm-greeter-displayserver"

RDEPENDS:libkworkspace6 = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 libXau \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-workspace-common \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
RDEPENDS:plasma-lookandfeel-fedora = " \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 "
RDEPENDS:plasma-workspace = " \
 PackageKit-Qt6 \
 appstream-qt \
 bash \
 dbus \
 dbus-libs \
 dbus-tools \
 fontconfig \
 glibc \
 gnome-menus \
 iso-codes \
 kactivitymanagerd \
 kde-settings-plasma \
 kf6-baloo \
 kf6-baloo-libs \
 kf6-frameworkintegration \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kded \
 kf6-kdoctools \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kparts \
 kf6-kquickcharts \
 kf6-krunner \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 kio-extras \
 kio-fuse \
 kscreenlocker \
 ksystemstats \
 kwayland \
 layer-shell-qt \
 libICE \
 libSM \
 libX11 \
 libXcursor \
 libXfixes \
 libXtst \
 libcanberra \
 libicu \
 libkexiv2-qt6 \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 maliit-keyboard \
 ocean-sound-theme \
 plasma-activities \
 plasma-activities-stats \
 plasma-desktop \
 plasma-lookandfeel-fedora \
 plasma-workspace-common \
 plasma-workspace-libs \
 plasma-workspace-wayland \
 plasma5support \
 policycoreutils \
 polkit-kde \
 powerdevil \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 qt6-qtvirtualkeyboard \
 qt6-qtwayland \
 socat \
 systemd \
 unity-gtk3-module \
 uresourced \
 virtual/coreutils \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 xmessage \
 xprop \
 xrdb \
 zlib-ng-compat \
 "
RDEPENDS:plasma-workspace-common = " \
 "
RDEPENDS:plasma-workspace-devel = " \
 cmake-filesystem \
 libkworkspace6 \
 plasma-workspace-libs \
 "
RDEPENDS:plasma-workspace-doc = " \
 plasma-workspace-common \
 "
RDEPENDS:plasma-workspace-libs = " \
 appstream-qt \
 fontconfig \
 freetype \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kpackage \
 kf6-kparts \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kunitconversion \
 kf6-kuserfeedback \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-networkmanager-qt \
 kf6-prison \
 kf6-solid \
 kwayland \
 libX11 \
 libXcursor \
 libXfixes \
 libXft \
 libcanberra \
 libgcc \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libqalculate \
 libstdc++ \
 libwayland-client \
 libxcb \
 libxcrypt \
 phonon-qt6 \
 plasma-activities \
 plasma-activities-stats \
 plasma-workspace-common \
 plasma5support \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 qt6-qtsvg \
 qt6-qtwayland \
 systemd-libs \
 xcb-util \
 xcb-util-cursor \
 "
RDEPENDS:plasma-workspace-wayland = " \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kwin-wayland \
 libcanberra \
 libkworkspace6 \
 libstdc++ \
 plasma-workspace \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools \
 qt6-qtwayland \
 xdg-desktop-portal-kde \
 xorg-x11-server-Xwayland \
 "
RDEPENDS:sddm-wayland-plasma = " \
 kwin-wayland \
 layer-shell-qt \
 maliit-keyboard \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/sddm-greeter-displayserver"

PROVIDES:append:aarch64 = " rpm/virtual/sddm-greeter-displayserver"
