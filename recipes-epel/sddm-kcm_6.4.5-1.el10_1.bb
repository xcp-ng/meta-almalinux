# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sddm-kcm"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 sddm-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sddm-kcm-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0db23dcda3c9cd1cb399b30938989a1ddb0047405b43e2a09243ed9ad54dd22"

URI_x86_64_v2_sddm-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-kcm-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sddm-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-kcm}"
SRC_URI[x86_64_v2_sddm-kcm.sha256sum] = "11404ef2ef55869035e3ecc18701dab536f1c41dbd5b9ce19683cce688c87321"

URI_aarch64_sddm-kcm = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-kcm-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_sddm-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-kcm}"
SRC_URI[aarch64_sddm-kcm.sha256sum] = "ed65e6ba4f4072f71c2d2dba53d3dd068a74d08933d94a421db04e28a3146fcd"

RDEPENDS:sddm-kcm = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kservice \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 sddm \
 "
