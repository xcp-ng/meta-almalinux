# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stb"
PV = "0^20251025gitf1c79c0"
PR = "1.el10_0"
PACKAGES = " \
 stb-devel \
 stb-doc \
 stb_c_lexer-devel \
 stb_connected_components-devel \
 stb_divide-devel \
 stb_ds-devel \
 stb_dxt-devel \
 stb_easy_font-devel \
 stb_herringbone_wang_tile-devel \
 stb_hexwave-devel \
 stb_image-devel \
 stb_image_resize-devel \
 stb_image_resize2-devel \
 stb_image_write-devel \
 stb_leakcheck-devel \
 stb_perlin-devel \
 stb_rect_pack-devel \
 stb_sprintf-devel \
 stb_textedit-devel \
 stb_tilemap_editor-devel \
 stb_truetype-devel \
 stb_vorbis-devel \
 stb_voxel_render-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stb-0^20251025gitf1c79c0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5daae66f20260967656136635d529975281e8edb14772b442bf74e0dc560c00b"

URI_x86_64_v2_stb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb-devel-0^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb-devel}"
SRC_URI[x86_64_v2_stb-devel.sha256sum] = "359ad55068cf1ee69cf776095d1939a8ffe9dad5617f4f4a110b23d3a5fd8f65"

URI_x86_64_v2_stb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb-doc-0^20251025gitf1c79c0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_stb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb-doc}"
SRC_URI[x86_64_v2_stb-doc.sha256sum] = "95fd582f050ca93e8c18e805a4b7fc2b1db61cb4e8330e0d695af5d5ac65d5ce"

URI_x86_64_v2_stb_c_lexer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_c_lexer-devel-0.12^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_c_lexer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_c_lexer-devel}"
SRC_URI[x86_64_v2_stb_c_lexer-devel.sha256sum] = "3ac2a504fe2017059e66cd651ca2bdb6fba1ef88dbb4d6f8306189458485b991"

URI_x86_64_v2_stb_connected_components-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_connected_components-devel-0.96^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_connected_components-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_connected_components-devel}"
SRC_URI[x86_64_v2_stb_connected_components-devel.sha256sum] = "751761a892fc121091ce9423a342b23df4bf240d0fc8b2fc0411dcdcc8741e37"

URI_x86_64_v2_stb_divide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_divide-devel-0.94^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_divide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_divide-devel}"
SRC_URI[x86_64_v2_stb_divide-devel.sha256sum] = "e05b7fe542bdd11def362bbf747e4d1ab087909846cd09d6252c18dd96c5813a"

URI_x86_64_v2_stb_ds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_ds-devel-0.67^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_ds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_ds-devel}"
SRC_URI[x86_64_v2_stb_ds-devel.sha256sum] = "965f0348c13b4cc6ec9f70158b0d5d2d3a6af471a73841af8b7793a44f9c9441"

URI_x86_64_v2_stb_dxt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_dxt-devel-1.12^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_dxt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_dxt-devel}"
SRC_URI[x86_64_v2_stb_dxt-devel.sha256sum] = "a1137490d29664c65c3f3d0e629de1f9092370d1e7987d7dcb161abaf2393fd0"

URI_x86_64_v2_stb_easy_font-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_easy_font-devel-1.1^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_easy_font-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_easy_font-devel}"
SRC_URI[x86_64_v2_stb_easy_font-devel.sha256sum] = "309365888fe9cf52a71c7bc38fa8da87ba2fd1ed39cf5d6d1729080d0d5ae3b4"

URI_x86_64_v2_stb_herringbone_wang_tile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_herringbone_wang_tile-devel-0.7^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_herringbone_wang_tile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_herringbone_wang_tile-devel}"
SRC_URI[x86_64_v2_stb_herringbone_wang_tile-devel.sha256sum] = "e7300ee66c157df3fb34532d8616f684ff3eb99b9ac098a4067bd37139d60928"

URI_x86_64_v2_stb_hexwave-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_hexwave-devel-0.5^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_hexwave-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_hexwave-devel}"
SRC_URI[x86_64_v2_stb_hexwave-devel.sha256sum] = "8f97b2ec48a58665bd5a937ecc2e4800bb8fb30f7687245eca7c907e293e2c9b"

URI_x86_64_v2_stb_image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image-devel-2.30^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image-devel}"
SRC_URI[x86_64_v2_stb_image-devel.sha256sum] = "d9ed2b5d9a18dccff558c84d82ace030ececf8a279c30a448b7f6a12b3deea3c"

URI_x86_64_v2_stb_image_resize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_resize-devel-0.97^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_resize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_resize-devel}"
SRC_URI[x86_64_v2_stb_image_resize-devel.sha256sum] = "fb17e67beb9ede614dc31097124823c8a0f0b110d9fb98926e411fdd43b4bb6e"

URI_x86_64_v2_stb_image_resize2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_resize2-devel-2.17^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_resize2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_resize2-devel}"
SRC_URI[x86_64_v2_stb_image_resize2-devel.sha256sum] = "4f66493d460df1315c98993c32c71461e5a633a2402d0fe1377c7def1672722a"

URI_x86_64_v2_stb_image_write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_write-devel-1.16^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_write-devel}"
SRC_URI[x86_64_v2_stb_image_write-devel.sha256sum] = "df0a99467fa2eed72dcf30496e1b88eb7ac6fd92ed1984f38c4c5121144e7a17"

URI_x86_64_v2_stb_leakcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_leakcheck-devel-0.6^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_leakcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_leakcheck-devel}"
SRC_URI[x86_64_v2_stb_leakcheck-devel.sha256sum] = "ef321ac802646d00d42712d59eddfc7b5985c02e66085b3fa7d63717ddd8e258"

URI_x86_64_v2_stb_perlin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_perlin-devel-0.5^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_perlin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_perlin-devel}"
SRC_URI[x86_64_v2_stb_perlin-devel.sha256sum] = "09fbbb56e44ff79e0f8a02ea7190662acc02a04293e849e9dfabdfc6d67c972a"

URI_x86_64_v2_stb_rect_pack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_rect_pack-devel-1.1^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_rect_pack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_rect_pack-devel}"
SRC_URI[x86_64_v2_stb_rect_pack-devel.sha256sum] = "b0c4da5f1c4ccfcbd3020a55393253434e66ffb040c3c0649546fa2a97330163"

URI_x86_64_v2_stb_sprintf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_sprintf-devel-1.10^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_sprintf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_sprintf-devel}"
SRC_URI[x86_64_v2_stb_sprintf-devel.sha256sum] = "00aa2a19455f6de24ea63dcff4437940f46652ba3634f51c8d482721c3cfcd8f"

URI_x86_64_v2_stb_textedit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_textedit-devel-1.14^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_textedit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_textedit-devel}"
SRC_URI[x86_64_v2_stb_textedit-devel.sha256sum] = "7e58e315404e55b5e4b27175ba8a4013fb6d0c58c75f3e71886bd4e822a4ab06"

URI_x86_64_v2_stb_tilemap_editor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_tilemap_editor-devel-0.42^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_tilemap_editor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_tilemap_editor-devel}"
SRC_URI[x86_64_v2_stb_tilemap_editor-devel.sha256sum] = "f4a5d889ab603169bd23f12dc2d69428dc07adf74f2fcf2404b196e01af7d8c6"

URI_x86_64_v2_stb_truetype-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_truetype-devel-1.26^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_truetype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_truetype-devel}"
SRC_URI[x86_64_v2_stb_truetype-devel.sha256sum] = "c3664209905e4af591aba7d054e45e957ccc1f375be184d06d19d13fe79b5d00"

URI_x86_64_v2_stb_vorbis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_vorbis-devel-1.22^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_vorbis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_vorbis-devel}"
SRC_URI[x86_64_v2_stb_vorbis-devel.sha256sum] = "4aaabafc271bc0f4bc18fa9db8fe32e1d85fc9bff6e2bb1664b07d589f9f6d58"

URI_x86_64_v2_stb_voxel_render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_voxel_render-devel-0.89^20251025gitf1c79c0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_voxel_render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_voxel_render-devel}"
SRC_URI[x86_64_v2_stb_voxel_render-devel.sha256sum] = "d6943f46a8eeafa95410fce108097c163708c64e724c50a949f863bb9b234c06"

URI_aarch64_stb-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb-devel-0^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb-devel}"
SRC_URI[aarch64_stb-devel.sha256sum] = "a9398389b8e1edcfcc01f70ea11d012e53352dc9c86e387bd57aa4a9773b9c83"

URI_aarch64_stb-doc = "${EPEL_MIRROR}/aarch64/Packages/s/stb-doc-0^20251025gitf1c79c0-1.el10_0.noarch.rpm;name=aarch64_stb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb-doc}"
SRC_URI[aarch64_stb-doc.sha256sum] = "6392b3f68c28c572193540b4762c6e684c31a3d63703de39dae8bbbd2b34273c"

URI_aarch64_stb_c_lexer-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_c_lexer-devel-0.12^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_c_lexer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_c_lexer-devel}"
SRC_URI[aarch64_stb_c_lexer-devel.sha256sum] = "fc082e3a2258818d794b3e35e1e8c1e976db89f01b9dc13179a6f53507e7dd95"

URI_aarch64_stb_connected_components-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_connected_components-devel-0.96^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_connected_components-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_connected_components-devel}"
SRC_URI[aarch64_stb_connected_components-devel.sha256sum] = "d1ba3d34610f2c6beafbf953ac0c37cffc0f2926618f5090e1cfa0020972d1ae"

URI_aarch64_stb_divide-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_divide-devel-0.94^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_divide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_divide-devel}"
SRC_URI[aarch64_stb_divide-devel.sha256sum] = "53ae089709a48c8533f4bc3c6ab26e10c90b85f88d307732eb6d067d3cb9e147"

URI_aarch64_stb_ds-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_ds-devel-0.67^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_ds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_ds-devel}"
SRC_URI[aarch64_stb_ds-devel.sha256sum] = "5e133afb27d9ee2ad20f8829f41c6d993cc274c2cc97bf329d0840e4f7a8111d"

URI_aarch64_stb_dxt-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_dxt-devel-1.12^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_dxt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_dxt-devel}"
SRC_URI[aarch64_stb_dxt-devel.sha256sum] = "9621fca17fb46bef05b977dcf15e6ce0238c5b20adcd580a092b60565f3227f1"

URI_aarch64_stb_easy_font-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_easy_font-devel-1.1^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_easy_font-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_easy_font-devel}"
SRC_URI[aarch64_stb_easy_font-devel.sha256sum] = "a5d902dead302d71b691487e20d6e302197d7c477bc2aabdbbccdf6dc9ce589c"

URI_aarch64_stb_herringbone_wang_tile-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_herringbone_wang_tile-devel-0.7^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_herringbone_wang_tile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_herringbone_wang_tile-devel}"
SRC_URI[aarch64_stb_herringbone_wang_tile-devel.sha256sum] = "f17f08b09e91235120ba90aaf219d38423531ce85beb04a0b354ba4f4d071f55"

URI_aarch64_stb_hexwave-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_hexwave-devel-0.5^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_hexwave-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_hexwave-devel}"
SRC_URI[aarch64_stb_hexwave-devel.sha256sum] = "f4a048dc8316e8e49db4959989bf01b8b4790cbbd890c72fc12a68096fd61244"

URI_aarch64_stb_image-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image-devel-2.30^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image-devel}"
SRC_URI[aarch64_stb_image-devel.sha256sum] = "1ad7993e134a0fe809a3688b3e43196d33be7caf984af548b8248be95ab01184"

URI_aarch64_stb_image_resize-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_resize-devel-0.97^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_image_resize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_resize-devel}"
SRC_URI[aarch64_stb_image_resize-devel.sha256sum] = "79dea6895ed588f3acaf41b8386890866185ad9ee2f652a832ce961771008968"

URI_aarch64_stb_image_resize2-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_resize2-devel-2.17^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_image_resize2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_resize2-devel}"
SRC_URI[aarch64_stb_image_resize2-devel.sha256sum] = "a240bac9642213eb9df2a78188dae67e61d9fa2c408dabc984bccb81d1584e78"

URI_aarch64_stb_image_write-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_write-devel-1.16^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_image_write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_write-devel}"
SRC_URI[aarch64_stb_image_write-devel.sha256sum] = "c395d7817ec798876ec606cbd2b5b1ce9b847d0267d131112d7db2013f27344e"

URI_aarch64_stb_leakcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_leakcheck-devel-0.6^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_leakcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_leakcheck-devel}"
SRC_URI[aarch64_stb_leakcheck-devel.sha256sum] = "777d0bb14da45161040641f942147ba0b81c89bfd458d80ef846a83703883f7d"

URI_aarch64_stb_perlin-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_perlin-devel-0.5^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_perlin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_perlin-devel}"
SRC_URI[aarch64_stb_perlin-devel.sha256sum] = "d7d912a651d596024331404e27b3b625b89f0b37aed21bf09e56375c33605ce3"

URI_aarch64_stb_rect_pack-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_rect_pack-devel-1.1^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_rect_pack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_rect_pack-devel}"
SRC_URI[aarch64_stb_rect_pack-devel.sha256sum] = "35668c31d2630e5b7c3b6c59c8b85037a4ec2216a777de3f7a1a5e966b87e5ff"

URI_aarch64_stb_sprintf-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_sprintf-devel-1.10^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_sprintf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_sprintf-devel}"
SRC_URI[aarch64_stb_sprintf-devel.sha256sum] = "e64bd9ae3eb40a5122099ae4f09403e77942bcb9a595d305103315849452fa61"

URI_aarch64_stb_textedit-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_textedit-devel-1.14^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_textedit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_textedit-devel}"
SRC_URI[aarch64_stb_textedit-devel.sha256sum] = "7a2e4a1808456144f5084a798ac6c937b6a0ea677da9c8e90a1b346c129e1efd"

URI_aarch64_stb_tilemap_editor-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_tilemap_editor-devel-0.42^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_tilemap_editor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_tilemap_editor-devel}"
SRC_URI[aarch64_stb_tilemap_editor-devel.sha256sum] = "7a930133d1d5d67a677be9dc7ae09101f9f4e46bfa74083fb5a507da93bda891"

URI_aarch64_stb_truetype-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_truetype-devel-1.26^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_truetype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_truetype-devel}"
SRC_URI[aarch64_stb_truetype-devel.sha256sum] = "876749e6180f830baa6a39eef5b82ec0739f9b40cae89bdf83e8003b4c50249a"

URI_aarch64_stb_vorbis-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_vorbis-devel-1.22^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_vorbis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_vorbis-devel}"
SRC_URI[aarch64_stb_vorbis-devel.sha256sum] = "a874a6a7a3df475e636dbfaeee952dacc4aca949d6c2cdf87401ca38cb7fc755"

URI_aarch64_stb_voxel_render-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_voxel_render-devel-0.89^20251025gitf1c79c0-1.el10_0.aarch64.rpm;name=aarch64_stb_voxel_render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_voxel_render-devel}"
SRC_URI[aarch64_stb_voxel_render-devel.sha256sum] = "f8ddf0a86fc84dd526d39c0e8053e6528f21fdba804a255099354c1475479dba"

RDEPENDS:stb-devel = " \
 stb_c_lexer-devel \
 stb_connected_components-devel \
 stb_divide-devel \
 stb_ds-devel \
 stb_dxt-devel \
 stb_easy_font-devel \
 stb_herringbone_wang_tile-devel \
 stb_hexwave-devel \
 stb_image-devel \
 stb_image_resize2-devel \
 stb_image_write-devel \
 stb_leakcheck-devel \
 stb_perlin-devel \
 stb_rect_pack-devel \
 stb_sprintf-devel \
 stb_textedit-devel \
 stb_tilemap_editor-devel \
 stb_truetype-devel \
 stb_vorbis-devel \
 stb_voxel_render-devel \
 "
RDEPENDS:stb-doc = " \
 "
RDEPENDS:stb_c_lexer-devel = " \
 "
RDEPENDS:stb_connected_components-devel = " \
 "
RDEPENDS:stb_divide-devel = " \
 "
RDEPENDS:stb_ds-devel = " \
 "
RDEPENDS:stb_dxt-devel = " \
 "
RDEPENDS:stb_easy_font-devel = " \
 "
RDEPENDS:stb_herringbone_wang_tile-devel = " \
 "
RDEPENDS:stb_hexwave-devel = " \
 "
RDEPENDS:stb_image-devel = " \
 "
RDEPENDS:stb_image_resize-devel = " \
 "
RDEPENDS:stb_image_resize2-devel = " \
 "
RDEPENDS:stb_image_write-devel = " \
 "
RDEPENDS:stb_leakcheck-devel = " \
 "
RDEPENDS:stb_perlin-devel = " \
 "
RDEPENDS:stb_rect_pack-devel = " \
 "
RDEPENDS:stb_sprintf-devel = " \
 "
RDEPENDS:stb_textedit-devel = " \
 "
RDEPENDS:stb_tilemap_editor-devel = " \
 "
RDEPENDS:stb_truetype-devel = " \
 "
RDEPENDS:stb_vorbis-devel = " \
 "
RDEPENDS:stb_voxel_render-devel = " \
 "
