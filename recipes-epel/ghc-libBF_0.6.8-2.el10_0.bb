# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-libBF"
PV = "0.6.8"
PR = "2.el10_0"
PACKAGES = " \
 ghc-libBF \
 ghc-libBF-devel \
 ghc-libBF-doc \
 ghc-libBF-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-libBF-0.6.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0776decbf3b7c913fca15efa28626fb9df66f4d2a1368af2403c23025af9ed20"

URI_x86_64_v2_ghc-libBF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libBF-0.6.8-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-libBF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libBF}"
SRC_URI[x86_64_v2_ghc-libBF.sha256sum] = "fd8369f8d420f4cc41492ca55c356b366a5161b8f8f70a864d41f35203d34c7b"

URI_x86_64_v2_ghc-libBF-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libBF-devel-0.6.8-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-libBF-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libBF-devel}"
SRC_URI[x86_64_v2_ghc-libBF-devel.sha256sum] = "99939245e4d58b3b91631ca3b8fecb43ef353a350380444d190f374c35fe07f4"

URI_x86_64_v2_ghc-libBF-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libBF-doc-0.6.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-libBF-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libBF-doc}"
SRC_URI[x86_64_v2_ghc-libBF-doc.sha256sum] = "b45eddf14721b0a2426e4946807a0ea0919e19080dedc8d12e2d6bb511ebdb6c"

URI_x86_64_v2_ghc-libBF-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-libBF-prof-0.6.8-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-libBF-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-libBF-prof}"
SRC_URI[x86_64_v2_ghc-libBF-prof.sha256sum] = "f0f7b5e00fcc0a908536dc7393b07ef98d1006999ff0b521e5ab80bb214e4805"

URI_aarch64_ghc-libBF = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libBF-0.6.8-2.el10_0.aarch64.rpm;name=aarch64_ghc-libBF;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libBF}"
SRC_URI[aarch64_ghc-libBF.sha256sum] = "23353f91be5d1b9db2b84d77877df59bfc9c7ff3d2a13c2c6eda9fc386ecd706"

URI_aarch64_ghc-libBF-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libBF-devel-0.6.8-2.el10_0.aarch64.rpm;name=aarch64_ghc-libBF-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libBF-devel}"
SRC_URI[aarch64_ghc-libBF-devel.sha256sum] = "e962a4cafcf62abde032fd9fd2352ecc7a034417107e02ca4caf67e5c195bdd3"

URI_aarch64_ghc-libBF-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libBF-doc-0.6.8-2.el10_0.noarch.rpm;name=aarch64_ghc-libBF-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libBF-doc}"
SRC_URI[aarch64_ghc-libBF-doc.sha256sum] = "9698d21553e5a43c124f4a4bcc2535d11e924234ece1ee96087f0d282ca64a40"

URI_aarch64_ghc-libBF-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-libBF-prof-0.6.8-2.el10_0.aarch64.rpm;name=aarch64_ghc-libBF-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-libBF-prof}"
SRC_URI[aarch64_ghc-libBF-prof.sha256sum] = "a1f0864a5cf47d26baf186a8ae4bcd16dee6567562c8513b7309fe2f53369ad8"

RDEPENDS:ghc-libBF = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-libBF-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-libBF \
 "
RDEPENDS:ghc-libBF-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-libBF-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-libBF-devel \
 "
