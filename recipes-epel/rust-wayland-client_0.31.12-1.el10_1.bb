# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-client"
PV = "0.31.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-wayland-client+default-devel \
 rust-wayland-client+log-devel \
 rust-wayland-client-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-client-0.31.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16b6f2cb66707441462d9ed15d9e6f877434ee617dd0d2584eb6bc792e509aab"

URI_x86_64_v2_rust-wayland-client+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+default-devel-0.31.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+default-devel.sha256sum] = "b82f0f7099779fe271b2e8f1d127e8df789c4d71ffaab477097b15766d1cf179"

URI_x86_64_v2_rust-wayland-client+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client+log-devel-0.31.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-client+log-devel.sha256sum] = "143d4ec0d4030ec79c78eaba4201755c9e831771be201d8c55fadde1b1c010a9"

URI_x86_64_v2_rust-wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-client-devel-0.31.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-client-devel.sha256sum] = "f660fd76b4ea48a29dddbfb42ad00673be185363184879957ba2d0497bbdf8d5"

URI_aarch64_rust-wayland-client+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+default-devel-0.31.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+default-devel}"
SRC_URI[aarch64_rust-wayland-client+default-devel.sha256sum] = "ccbbf9a932ac8945cb6a2dbf740f716901fd878f3cb12a8a57053a817ddfe0ae"

URI_aarch64_rust-wayland-client+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client+log-devel-0.31.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-client+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client+log-devel}"
SRC_URI[aarch64_rust-wayland-client+log-devel.sha256sum] = "fde3128b1f10376e3a64f3bf01135ba3d529e406616744510afdd5fcf741ac0f"

URI_aarch64_rust-wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-client-devel-0.31.12-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-client-devel.sha256sum] = "672e1ba9dac303c11cae6dcd22ae43dbe397dacc9d8528f6af9bebef20a256d9"

RDEPENDS:rust-wayland-client+default-devel = " \
 cargo \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-client-devel \
 "
RDEPENDS:rust-wayland-client-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
