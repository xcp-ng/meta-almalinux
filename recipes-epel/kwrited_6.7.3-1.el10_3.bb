# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwrited"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kwrited \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwrited-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f46a877d4ad644e7a08d44270a730116333ab9e804a7ca297a014df699cc2948"

URI_x86_64_v2_kwrited = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwrited-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwrited;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwrited}"
SRC_URI[x86_64_v2_kwrited.sha256sum] = "b7f472be5043772e7834530dc0164b6fcbca3aa048195609952b59f6d8efd77e"

URI_aarch64_kwrited = "${EPEL_MIRROR}/aarch64/Packages/k/kwrited-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kwrited;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwrited}"
SRC_URI[aarch64_kwrited.sha256sum] = "d2a883e5ac0edd6ef834912fc3db98e5ff387f5d31ec4ab02cc7bffd2299efd5"

RDEPENDS:kwrited = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-knotifications \
 kf6-kpty \
 libstdc++ \
 qt6-qtbase \
 "
