# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentofu"
PV = "1.10.3"
PR = "1.el10_1"
PACKAGES = " \
 opentofu \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/opentofu-1.10.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e2993b061d5dd3f3188eeb7f538a4c08747e92b22688eaab945bd324dc8f1e91"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentofu-1.10.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opentofu;unpack=0"
SRC_URI[x86_64_v2_opentofu.sha256sum] = "db7c0c0f97a89fca58e01b7b5ad4a277ba48431b718ed73ba386a4f9c471d15f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opentofu-1.10.3-1.el10_1.aarch64.rpm;name=aarch64_opentofu;unpack=0"
SRC_URI[aarch64_opentofu.sha256sum] = "18a3708fe52b6851b991eecbc4e53cefd3c5b0c7c76dddf477c3d92cfcfcde2b"

RDEPENDS:opentofu = " \
 glibc \
 "
