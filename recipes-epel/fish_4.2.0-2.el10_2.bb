# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fish"
PV = "4.2.0"
PR = "2.el10_2"
PACKAGES = " \
 fish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fish-4.2.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23218102da4a2fa21b5057471bcb00469adf5afecdd0c2871bea174583958a70"

URI_x86_64_v2_fish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fish-4.2.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fish}"
SRC_URI[x86_64_v2_fish.sha256sum] = "ffdfb55f776d95b3d855ed94c5c2bb1f9aa3a3eaafccc362985b70de588e4798"

URI_aarch64_fish = "${EPEL_MIRROR}/aarch64/Packages/f/fish-4.2.0-2.el10_2.aarch64.rpm;name=aarch64_fish;unpack=0"
SRC_URI:append = " ${URI_aarch64_fish}"
SRC_URI[aarch64_fish.sha256sum] = "ddda40c2534136892ff95fc6a5525d6421b556107f9ee6370e04d996f7de395b"

RDEPENDS:fish = " \
 bash \
 glibc \
 libgcc \
 ncurses-term \
 pcre2 \
 pcre2-utf32 \
 pkgconf-pkg-config \
 python3 \
 "
