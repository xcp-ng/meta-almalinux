# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgit2_1.9"
PV = "1.9.7"
PR = "1.el10_2"
PACKAGES = " \
 libgit2_1.9 \
 libgit2_1.9-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libgit2_1.9-1.9.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "78b1cbfa168d0a36497d15fba36ff1f3966c65ea2c1f8c1eaeaacb4bbc65a78d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgit2_1.9-1.9.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgit2_1.9;unpack=0"
SRC_URI[x86_64_v2_libgit2_1.9.sha256sum] = "b5d167ac468e0ff84e6ff78d063c2c93cd9054af72fb7089ec74f28cef411575"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgit2_1.9-devel-1.9.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgit2_1.9-devel;unpack=0"
SRC_URI[x86_64_v2_libgit2_1.9-devel.sha256sum] = "3e103012030e9cacb3ed7d67e696ce9a8eaba5a772cc66e0a831443188080c84"
RPROVIDES:libgit2_1.9-devel:append:x86_64_v2 = " virtual/pkgconfig_libgit2_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libgit2_1.9-1.9.7-1.el10_2.aarch64.rpm;name=aarch64_libgit2_1.9;unpack=0"
SRC_URI[aarch64_libgit2_1.9.sha256sum] = "973d14f6c0900dbd24ed2cfc566f9c69c6279acdb40c4da224c25d83933f423c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libgit2_1.9-devel-1.9.7-1.el10_2.aarch64.rpm;name=aarch64_libgit2_1.9-devel;unpack=0"
SRC_URI[aarch64_libgit2_1.9-devel.sha256sum] = "8339007253d62d87a20b206db610e5f7d7ec6f41c9606d35abb60e4559534966"
RPROVIDES:libgit2_1.9-devel:append:aarch64 = " virtual/pkgconfig_libgit2_"

RDEPENDS:libgit2_1.9 = " \
 glibc \
 libgcc \
 libssh2 \
 llhttp \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:libgit2_1.9-devel = " \
 cmake-filesystem \
 libgit2_1.9 \
 libssh2-devel \
 openssl-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
