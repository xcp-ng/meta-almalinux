# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_xsendfile"
PV = "0.12"
PR = "32.el10_2"
PACKAGES = " \
 mod_xsendfile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mod_xsendfile-0.12-32.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "803a6f3bec5803fb858d2511ce6d078077e9d968b22ef11f2c4e214a07490103"

URI_x86_64_v2_mod_xsendfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_xsendfile-0.12-32.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_xsendfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_xsendfile}"
SRC_URI[x86_64_v2_mod_xsendfile.sha256sum] = "5c22914b0ddbb20bb57130392db1192a4cc5083ac2574e99054c40a726a8d51c"

URI_aarch64_mod_xsendfile = "${EPEL_MIRROR}/aarch64/Packages/m/mod_xsendfile-0.12-32.el10_2.aarch64.rpm;name=aarch64_mod_xsendfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_xsendfile}"
SRC_URI[aarch64_mod_xsendfile.sha256sum] = "d156ec0790a5e9ac5359f42930b2fc302909f961f0c52e473e4c67c0e721498a"

RDEPENDS:mod_xsendfile = " \
 glibc \
 httpd-core \
 "
