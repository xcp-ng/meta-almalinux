# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "omping"
PV = "0.0.4"
PR = "34.el10"
PACKAGES = " \
 omping \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/omping-0.0.4-34.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b841578900ea601e90d05cd99207c0cac4e1193fe5d232b3686ca89ca0ec6e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/omping-0.0.4-34.el10.x86_64_v2.rpm;name=x86_64_v2_omping;unpack=0"
SRC_URI[x86_64_v2_omping.sha256sum] = "236b95ebb01cd4600f64b7aff6250f903cac313f906bb85d9f0b509da382b623"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/omping-0.0.4-34.el10.aarch64.rpm;name=aarch64_omping;unpack=0"
SRC_URI[aarch64_omping.sha256sum] = "3184ca442bf59806b0596410eae1fae5b1883376566f466e562f21a7684b7db6"

RDEPENDS:omping = " \
 glibc \
 "
