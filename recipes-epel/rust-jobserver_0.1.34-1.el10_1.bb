# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jobserver"
PV = "0.1.34"
PR = "1.el10_1"
PACKAGES = " \
 rust-jobserver+default-devel \
 rust-jobserver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jobserver-0.1.34-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8444ec85c8f13c2e7f58942ff61da57b53861df6d52e6a0550ff26417e228b80"

URI_x86_64_v2_rust-jobserver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jobserver+default-devel-0.1.34-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jobserver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jobserver+default-devel}"
SRC_URI[x86_64_v2_rust-jobserver+default-devel.sha256sum] = "8f5b160179b2bb9efd3d381276136907d0c4eed8f405dee1944fa60f0016e07e"

URI_x86_64_v2_rust-jobserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jobserver-devel-0.1.34-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jobserver-devel}"
SRC_URI[x86_64_v2_rust-jobserver-devel.sha256sum] = "18587564b7f511ec74eb31675e046af5f9ee750b288e2fcb8561526147f5818c"

URI_aarch64_rust-jobserver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jobserver+default-devel-0.1.34-1.el10_1.noarch.rpm;name=aarch64_rust-jobserver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jobserver+default-devel}"
SRC_URI[aarch64_rust-jobserver+default-devel.sha256sum] = "5067447abbd5b68bb8105d065671ed7338fee1a6ead98e301f5f55439d0b6026"

URI_aarch64_rust-jobserver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jobserver-devel-0.1.34-1.el10_1.noarch.rpm;name=aarch64_rust-jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jobserver-devel}"
SRC_URI[aarch64_rust-jobserver-devel.sha256sum] = "5146401c2a84004e47d960fef5ea06506c583caa96793bdbb408032178b25e0c"

RDEPENDS:rust-jobserver+default-devel = " \
 cargo \
 rust-jobserver-devel \
 "
RDEPENDS:rust-jobserver-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
