# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ident_case"
PV = "1.0.1"
PR = "16.el10_0"
PACKAGES = " \
 rust-ident_case+default-devel \
 rust-ident_case-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ident_case-1.0.1-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00fae47fdfea9d3c47bd5f2922ff90fff164819bbcce1b35b9ff01d8c53a0fa6"

URI_x86_64_v2_rust-ident_case+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ident_case+default-devel-1.0.1-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ident_case+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ident_case+default-devel}"
SRC_URI[x86_64_v2_rust-ident_case+default-devel.sha256sum] = "35ef178d0a9c940b46bfddcbfe5e571742cafa69b0d6a97fa54e83277234f6d0"

URI_x86_64_v2_rust-ident_case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ident_case-devel-1.0.1-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ident_case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ident_case-devel}"
SRC_URI[x86_64_v2_rust-ident_case-devel.sha256sum] = "1856367354659d0fa278159d4ca74862767c96e92c00ba998fdf0ab88051cb32"

URI_aarch64_rust-ident_case+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ident_case+default-devel-1.0.1-16.el10_0.noarch.rpm;name=aarch64_rust-ident_case+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ident_case+default-devel}"
SRC_URI[aarch64_rust-ident_case+default-devel.sha256sum] = "b1ac294496e8df8f275e051e34bee3f9c9cc607939a5a5cbdba8216cd9ea3dec"

URI_aarch64_rust-ident_case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ident_case-devel-1.0.1-16.el10_0.noarch.rpm;name=aarch64_rust-ident_case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ident_case-devel}"
SRC_URI[aarch64_rust-ident_case-devel.sha256sum] = "a8cc8952471be2f266a94dd8831cf5e0a76e037e6b5f0289864c581bb770ae4c"

RDEPENDS:rust-ident_case+default-devel = " \
 cargo \
 rust-ident_case-devel \
 "
RDEPENDS:rust-ident_case-devel = " \
 cargo \
 "
