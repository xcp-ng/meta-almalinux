# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaccounts-integration"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kaccounts-integration-qt6 \
 kaccounts-integration-qt6-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kaccounts-integration-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d2b87156d84ead22f7f77ad1a38352286a46be012b1116df11fec245095209fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-integration-qt6-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-integration-qt6;unpack=0"
SRC_URI[x86_64_v2_kaccounts-integration-qt6.sha256sum] = "fe6ded6d5ba204cf377e93f258d75ac80017f9f99c326d930089b3c00cc254df"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-integration-qt6-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-integration-qt6-devel;unpack=0"
SRC_URI[x86_64_v2_kaccounts-integration-qt6-devel.sha256sum] = "766564b7efe275585f0ec814fd078c5286e0ce6f898489aeb599288bc50a4954"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-integration-qt6-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kaccounts-integration-qt6;unpack=0"
SRC_URI[aarch64_kaccounts-integration-qt6.sha256sum] = "91453ea4b5c0d42d7cad6ebe5e68c83b45d2e281556cfe827f8bdaae20bb555a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-integration-qt6-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kaccounts-integration-qt6-devel;unpack=0"
SRC_URI[aarch64_kaccounts-integration-qt6-devel.sha256sum] = "353e2103a19c8098026470c530fd3854945abafbdcccd67d55f1afca32a1ccab"

RDEPENDS:kaccounts-integration-qt6 = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwallet-libs \
 libaccounts-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 signon-qt6 \
 "
RDEPENDS:kaccounts-integration-qt6-devel = " \
 cmake-filesystem \
 intltool \
 kaccounts-integration-qt6 \
 kf6-kcoreaddons-devel \
 libaccounts-glib-devel \
 libaccounts-qt6-devel \
 qt6-qtbase-devel \
 signon-qt6-devel \
 "
