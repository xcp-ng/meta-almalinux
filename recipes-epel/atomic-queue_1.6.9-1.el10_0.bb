# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "atomic-queue"
PV = "1.6.9"
PR = "1.el10_0"
PACKAGES = " \
 atomic-queue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/atomic-queue-1.6.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1d98073ad545ce566834e99169f752446935063fb13702bb10bdf0d1e3b218e"

URI_x86_64_v2_atomic-queue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atomic-queue-devel-1.6.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atomic-queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atomic-queue-devel}"
SRC_URI[x86_64_v2_atomic-queue-devel.sha256sum] = "9edc6db8fa18c38d63d96668f07a76e6ef0db97f283e52db2690a79eee039965"

URI_aarch64_atomic-queue-devel = "${EPEL_MIRROR}/aarch64/Packages/a/atomic-queue-devel-1.6.9-1.el10_0.aarch64.rpm;name=aarch64_atomic-queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_atomic-queue-devel}"
SRC_URI[aarch64_atomic-queue-devel.sha256sum] = "d78ea4f68364f920507a7072923f3e1561ee4ea128b189721c6633debe035576"

RDEPENDS:atomic-queue-devel = " \
 pkgconf-pkg-config \
 "
