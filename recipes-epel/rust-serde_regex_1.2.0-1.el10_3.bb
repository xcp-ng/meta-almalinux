# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_regex"
PV = "1.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-serde_regex+default-devel \
 rust-serde_regex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_regex-1.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c0253d4b795c32e1e1e34890599ba298f2b6185927a0bf23f6f8d49c0e864d4"

URI_x86_64_v2_rust-serde_regex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_regex+default-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_regex+default-devel}"
SRC_URI[x86_64_v2_rust-serde_regex+default-devel.sha256sum] = "9e4f852676d60b2eb46ee6fbb1646ba3a89218e2ec11911b5509caa4ee254b6b"

URI_x86_64_v2_rust-serde_regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_regex-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_regex-devel}"
SRC_URI[x86_64_v2_rust-serde_regex-devel.sha256sum] = "9e8eaa4dfff0c9a51327ab0dc6e76d3299c175a6a190431884528af59251272f"

URI_aarch64_rust-serde_regex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_regex+default-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-serde_regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_regex+default-devel}"
SRC_URI[aarch64_rust-serde_regex+default-devel.sha256sum] = "66c1d9b2df3e5fc58dfbf102202b81facf9965487debcdef891e0f0a6930c6f2"

URI_aarch64_rust-serde_regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_regex-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-serde_regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_regex-devel}"
SRC_URI[aarch64_rust-serde_regex-devel.sha256sum] = "7a40c813e57b1b63fe228e7882dbeb284ebb3778c77b94adee4a3814f272e7b1"

RDEPENDS:rust-serde_regex+default-devel = " \
 cargo \
 rust-serde_regex-devel \
 "
RDEPENDS:rust-serde_regex-devel = " \
 cargo \
 rust \
 rust-regex+default-devel \
 rust-serde+default-devel \
 "
