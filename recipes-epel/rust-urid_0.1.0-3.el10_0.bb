# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-urid"
PV = "0.1.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-urid+default-devel \
 rust-urid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-urid-0.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7035324f8c1f6105bb5bac9e67188aa90de0f2b5f860edb9b6a86cbbda54aea2"

URI_x86_64_v2_rust-urid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-urid+default-devel-0.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-urid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-urid+default-devel}"
SRC_URI[x86_64_v2_rust-urid+default-devel.sha256sum] = "5cdb85106b72fc88c63a3674f6b59ecfff4b37966402e952695c3b75da1814d7"

URI_x86_64_v2_rust-urid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-urid-devel-0.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-urid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-urid-devel}"
SRC_URI[x86_64_v2_rust-urid-devel.sha256sum] = "c08b07507bbb0974d5e3b9926e0abc6e629adac1a09e94597ed30f233af04b2d"

URI_aarch64_rust-urid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-urid+default-devel-0.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-urid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-urid+default-devel}"
SRC_URI[aarch64_rust-urid+default-devel.sha256sum] = "2f5b5e2b8bd61ee239fc4065d25d35614cd5643204932e60d5096ca89a5d7b0d"

URI_aarch64_rust-urid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-urid-devel-0.1.0-3.el10_0.noarch.rpm;name=aarch64_rust-urid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-urid-devel}"
SRC_URI[aarch64_rust-urid-devel.sha256sum] = "ef338f40c3113044f115e0eb45a7a1b881671b711cdc1610665b4d7c4725fa47"

RDEPENDS:rust-urid+default-devel = " \
 cargo \
 rust-urid-devel \
 "
RDEPENDS:rust-urid-devel = " \
 cargo \
 rust-urid-derive+default-devel \
 "
