# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "udisks2"
PV = "2.10.90"
PR = "6.el10_1.1.alma.2"
PACKAGES = " \
 libudisks2 \
 libudisks2-devel \
 udisks2 \
 udisks2-btrfs \
 udisks2-iscsi \
 udisks2-lsm \
 udisks2-lvm2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/udisks2-2.10.90-6.el10_1.1.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85c547ea105113fd8a21f02ad9cfdfa06f5f330803771059317d28b597aff150"

URI_x86_64_v2_libudisks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libudisks2-2.10.90-6.el10_1.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_libudisks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libudisks2}"
SRC_URI[x86_64_v2_libudisks2.sha256sum] = "8cb70c97100d33238ffc225d059b5a9a8e9ab98b94eacf9be0f51edb6fbfa4ba"

URI_x86_64_v2_libudisks2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libudisks2-devel-2.10.90-6.el10_1.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_libudisks2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libudisks2-devel}"
SRC_URI[x86_64_v2_libudisks2-devel.sha256sum] = "16618423165918095d090e55f47edfae56b3af6debc3bebaaec1553fa738c040"

URI_x86_64_v2_udisks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-2.10.90-6.el10_1.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_udisks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2}"
SRC_URI[x86_64_v2_udisks2.sha256sum] = "8aa3e95994b4676d4b01746fd630c9690782eb53421c601857774781325a0395"

URI_x86_64_v2_udisks2-btrfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-btrfs-2.10.90-6.el10_1.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_udisks2-btrfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-btrfs}"
SRC_URI[x86_64_v2_udisks2-btrfs.sha256sum] = "b87a20db21430722bf6e376c3d894d9bff07c3821d83a908fa7deb1872516b07"

URI_x86_64_v2_udisks2-iscsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-iscsi-2.10.90-6.el10_1.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_udisks2-iscsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-iscsi}"
SRC_URI[x86_64_v2_udisks2-iscsi.sha256sum] = "7931b42d2725498f9b91879d41bca15371986129f8171db865faf08b06b5816f"

URI_x86_64_v2_udisks2-lsm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-lsm-2.10.90-6.el10_1.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_udisks2-lsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-lsm}"
SRC_URI[x86_64_v2_udisks2-lsm.sha256sum] = "ba3ebef93948c9fa53b50227b50bfe43e339335919526a0021d41f639c62db82"

URI_x86_64_v2_udisks2-lvm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-lvm2-2.10.90-6.el10_1.1.alma.2.x86_64_v2.rpm;name=x86_64_v2_udisks2-lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-lvm2}"
SRC_URI[x86_64_v2_udisks2-lvm2.sha256sum] = "c74f0ffe7914dbe1f867f8d0122a97357f47f77e413d356891cb5b82d779d883"

URI_aarch64_libudisks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libudisks2-2.10.90-6.el10_1.1.alma.2.aarch64.rpm;name=aarch64_libudisks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libudisks2}"
SRC_URI[aarch64_libudisks2.sha256sum] = "23df2e9ff9e5fd9b927eefa87619fbfba2e71e13d51ec8331dbc76cb827e945d"

URI_aarch64_libudisks2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libudisks2-devel-2.10.90-6.el10_1.1.alma.2.aarch64.rpm;name=aarch64_libudisks2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libudisks2-devel}"
SRC_URI[aarch64_libudisks2-devel.sha256sum] = "9c85d70dc3f67383b4dca25f5c69ae974a95b2debbbe4f240fef4b77970fc8cd"

URI_aarch64_udisks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-2.10.90-6.el10_1.1.alma.2.aarch64.rpm;name=aarch64_udisks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2}"
SRC_URI[aarch64_udisks2.sha256sum] = "1d43122b2d09b8acb80b55add6d1cbdfd748bb8891b741a299088aaa7dfcd2d5"

URI_aarch64_udisks2-btrfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-btrfs-2.10.90-6.el10_1.1.alma.2.aarch64.rpm;name=aarch64_udisks2-btrfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-btrfs}"
SRC_URI[aarch64_udisks2-btrfs.sha256sum] = "aa9a7f5616e5cc39105864bb73296a1406f27293dcf269abda69ae2c62fcb6b9"

URI_aarch64_udisks2-iscsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-iscsi-2.10.90-6.el10_1.1.alma.2.aarch64.rpm;name=aarch64_udisks2-iscsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-iscsi}"
SRC_URI[aarch64_udisks2-iscsi.sha256sum] = "7791c5f2a3ea1b839051357f87b75835cc29a139f4753d8ffe434814decd9578"

URI_aarch64_udisks2-lsm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-lsm-2.10.90-6.el10_1.1.alma.2.aarch64.rpm;name=aarch64_udisks2-lsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-lsm}"
SRC_URI[aarch64_udisks2-lsm.sha256sum] = "33f8422fbd524c64bd91f83c551c510dc080c0d9881fb714be01b7faf2534aa3"

URI_aarch64_udisks2-lvm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-lvm2-2.10.90-6.el10_1.1.alma.2.aarch64.rpm;name=aarch64_udisks2-lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-lvm2}"
SRC_URI[aarch64_udisks2-lvm2.sha256sum] = "7236bef351b71be30eee77d3855ed80db179c11bc8e1021884d69b40f35d6c75"

RDEPENDS:libudisks2 = " \
 glib2 \
 glibc \
 "
RDEPENDS:libudisks2-devel = " \
 glib2-devel \
 libudisks2 \
 libudisks2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:udisks2 = " \
 bash \
 dbus \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-crypto \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-mdraid \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-smart \
 libblockdev-swap \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit \
 polkit-libs \
 systemd-libs \
 systemd-udev \
 util-linux \
 "
RDEPENDS:udisks2-btrfs = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-btrfs \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-lsm = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-utils \
 libconfig \
 libgcc \
 libgudev \
 libmount \
 libstoragemgmt \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-lvm2 = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-lvm \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 lvm2 \
 polkit-libs \
 systemd-libs \
 "
