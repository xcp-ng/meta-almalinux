# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xine-lib"
PV = "1.2.13"
PR = "17.el10_0"
PACKAGES = " \
 xine-lib \
 xine-lib-devel \
 xine-lib-extras \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xine-lib-1.2.13-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9240f1e31f02a8540b2dc792e513261c894b9647fa420b547223f78196173b6f"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - xine-lib: libavcodec.so.61()(64bit)
# - xine-lib: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - xine-lib: libavformat.so.61()(64bit)
# - xine-lib: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - xine-lib: libavutil.so.59()(64bit)
# - xine-lib: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - xine-lib: libpostproc.so.58()(64bit)
# - xine-lib: libpostproc.so.58(LIBPOSTPROC_58)(64bit)

URI_x86_64_v2_xine-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xine-lib-1.2.13-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xine-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xine-lib}"
SRC_URI[x86_64_v2_xine-lib.sha256sum] = "7d75e3d0a1a855d3c843f20add5c85570c4bd74166f1f0bc36c63f2806512e3d"

URI_x86_64_v2_xine-lib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xine-lib-devel-1.2.13-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xine-lib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xine-lib-devel}"
SRC_URI[x86_64_v2_xine-lib-devel.sha256sum] = "678f6aa6cd44b9335e0f91c35023925b8df07506695ecc165427f033fff82505"

URI_x86_64_v2_xine-lib-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xine-lib-extras-1.2.13-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xine-lib-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xine-lib-extras}"
SRC_URI[x86_64_v2_xine-lib-extras.sha256sum] = "c6fbd5f43fd15e5427d59023fe6284b245b6c59e645c2a55a115dce8530efee9"

URI_aarch64_xine-lib = "${EPEL_MIRROR}/aarch64/Packages/x/xine-lib-1.2.13-17.el10_0.aarch64.rpm;name=aarch64_xine-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_xine-lib}"
SRC_URI[aarch64_xine-lib.sha256sum] = "d9ebaf9fb3a31a942b269b179e7ae38be9855861a792d7586b1d328bfe204ec4"

URI_aarch64_xine-lib-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xine-lib-devel-1.2.13-17.el10_0.aarch64.rpm;name=aarch64_xine-lib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xine-lib-devel}"
SRC_URI[aarch64_xine-lib-devel.sha256sum] = "94db32fbb8cc362feabd55cdf9157fd440b7ad977feb477531cc5aaf0f74fbd0"

URI_aarch64_xine-lib-extras = "${EPEL_MIRROR}/aarch64/Packages/x/xine-lib-extras-1.2.13-17.el10_0.aarch64.rpm;name=aarch64_xine-lib-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_xine-lib-extras}"
SRC_URI[aarch64_xine-lib-extras.sha256sum] = "761eb1bb52aaf9a20b41f976146179e8f05820680f21dc1b3ca15eb519f4b857"

RDEPENDS:xine-lib:x86_64_v2 = " \
 alsa-lib \
 flac-libs \
 fontconfig \
 freetype \
 glibc \
 gnutls \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXinerama \
 libXv \
 liba52 \
 libaom \
 libbluray \
 libcdio \
 libdav1d \
 libdca \
 libdvdnav \
 libdvdread \
 libgcc \
 libgcrypt \
 libglvnd-egl \
 libglvnd-glx \
 libjpeg-turbo \
 libmad \
 libmng \
 libmodplug \
 libmpcdec \
 libnfs \
 libogg \
 libpng \
 libssh2 \
 libtheora \
 libv4l \
 libva \
 libvdpau \
 libvmaf \
 libvorbis \
 libvpx \
 libwayland-client \
 libwayland-egl \
 libxcb \
 libxdg-basedir \
 mesa-libGLU \
 openssl-libs \
 pulseaudio-libs \
 speex \
 vcdimager-libs \
 wavpack \
 zlib-ng-compat \
"
RDEPENDS:xine-lib:aarch64 = " \
 alsa-lib \
 flac-libs \
 fontconfig \
 freetype \
 glibc \
 gnutls \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXinerama \
 libXv \
 liba52 \
 libaom \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbluray \
 libcdio \
 libdav1d \
 libdca \
 libdvdnav \
 libdvdread \
 libgcc \
 libgcrypt \
 libglvnd-egl \
 libglvnd-glx \
 libjpeg-turbo \
 libmad \
 libmng \
 libmodplug \
 libmpcdec \
 libnfs \
 libogg \
 libpng \
 libpostproc-free \
 libssh2 \
 libtheora \
 libv4l \
 libva \
 libvdpau \
 libvorbis \
 libvpx \
 libwayland-client \
 libwayland-egl \
 libxcb \
 libxdg-basedir \
 mesa-libGLU \
 openssl-libs \
 pulseaudio-libs \
 speex \
 vcdimager-libs \
 wavpack \
 zlib-ng-compat \
"
RDEPENDS:xine-lib-devel = " \
 bash \
 glibc \
 libxdg-basedir-devel \
 pkgconf-pkg-config \
 xine-lib \
 zlib-ng-compat-devel \
 "
RDEPENDS:xine-lib-extras = " \
 ImageMagick-libs \
 aalib-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXinerama \
 libcaca \
 libsmbclient \
 libxdg-basedir \
 pipewire-jack-audio-connection-kit-libs \
 sdl12-compat \
 xine-lib \
 zlib-ng-compat \
 "
