# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "subscription-manager"
PV = "1.30.15"
PR = "1.el10.alma.1"
PACKAGES = " \
 libdnf-plugin-subscription-manager \
 python3-cloud-what \
 python3-subscription-manager-rhsm \
 subscription-manager \
 subscription-manager-plugin-ostree \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/subscription-manager-1.30.15-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfc5a4f3816e35e1ece3c6c72a703e5faf67bb9c63caab825205a73d08ea1dfa"

URI_x86_64_v2_libdnf-plugin-subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdnf-plugin-subscription-manager-1.30.15-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf-plugin-subscription-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnf-plugin-subscription-manager}"
SRC_URI[x86_64_v2_libdnf-plugin-subscription-manager.sha256sum] = "3f41e59e41b190df54f945b0cacafb7c79452e6571a3d528f2028da34200a457"

URI_x86_64_v2_python3-cloud-what = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-cloud-what-1.30.15-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-cloud-what;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cloud-what}"
SRC_URI[x86_64_v2_python3-cloud-what.sha256sum] = "a441b44360a17d6e73f97284c736e3fb6ff0c1186b675e0f5e6b4639dcb363b2"

URI_x86_64_v2_python3-subscription-manager-rhsm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-subscription-manager-rhsm-1.30.15-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-subscription-manager-rhsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-subscription-manager-rhsm}"
SRC_URI[x86_64_v2_python3-subscription-manager-rhsm.sha256sum] = "ae3bb42c2fc559b6296f26022c30053b07025527a4f007857bf4dc2f0807ef30"

URI_x86_64_v2_subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/subscription-manager-1.30.15-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_subscription-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subscription-manager}"
SRC_URI[x86_64_v2_subscription-manager.sha256sum] = "e98dbc52ca2156fc6afb6bc7ff3d992fcc0927052b2b2fffc54eb0139c4d026c"

URI_x86_64_v2_subscription-manager-plugin-ostree = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/subscription-manager-plugin-ostree-1.30.15-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_subscription-manager-plugin-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subscription-manager-plugin-ostree}"
SRC_URI[x86_64_v2_subscription-manager-plugin-ostree.sha256sum] = "ba5c873bd03318482da71b4759f5b754af1191b679b9d8ab21d72da6c9f3d445"

URI_aarch64_libdnf-plugin-subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdnf-plugin-subscription-manager-1.30.15-1.el10.alma.1.aarch64.rpm;name=aarch64_libdnf-plugin-subscription-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnf-plugin-subscription-manager}"
SRC_URI[aarch64_libdnf-plugin-subscription-manager.sha256sum] = "b0bf9a43928a71548af05f88220912a38fe8dd5d0febeb8dd2993b020d428e49"

URI_aarch64_python3-cloud-what = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-cloud-what-1.30.15-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-cloud-what;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cloud-what}"
SRC_URI[aarch64_python3-cloud-what.sha256sum] = "8dc0726b42a82b455828291c48c6f9e54e0cb330e1252ac0fc5deea828ddf9d0"

URI_aarch64_python3-subscription-manager-rhsm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-subscription-manager-rhsm-1.30.15-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-subscription-manager-rhsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-subscription-manager-rhsm}"
SRC_URI[aarch64_python3-subscription-manager-rhsm.sha256sum] = "59d7fbd2ed8ae9ec3bb4d801a64a33f3a4176b1801e398e0a0fcefe966e26386"

URI_aarch64_subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/subscription-manager-1.30.15-1.el10.alma.1.aarch64.rpm;name=aarch64_subscription-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_subscription-manager}"
SRC_URI[aarch64_subscription-manager.sha256sum] = "e0df0143d71d65399ea9de7c91c0c270198d4f8d1d944e0775f2046d64e16c66"

URI_aarch64_subscription-manager-plugin-ostree = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/subscription-manager-plugin-ostree-1.30.15-1.el10.alma.1.aarch64.rpm;name=aarch64_subscription-manager-plugin-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_subscription-manager-plugin-ostree}"
SRC_URI[aarch64_subscription-manager-plugin-ostree.sha256sum] = "ad86f357490f4d032d2dd1c34587f7f5e80a4ed7af2344bc2ce8363aea88b495"

RDEPENDS:libdnf-plugin-subscription-manager = " \
 glib2 \
 glibc \
 json-c \
 libdnf \
 librepo \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-cloud-what = " \
 dmidecode \
 python3 \
 python3-requests \
 "
RDEPENDS:python3-subscription-manager-rhsm = " \
 glibc \
 openssl-libs \
 python3 \
 python3-cloud-what \
 python3-dateutil \
 python3-iniparse \
 python3-rpm \
 subscription-manager-rhsm-certificates \
 "
RDEPENDS:subscription-manager = " \
 bash \
 dmidecode \
 findutils \
 glib2 \
 glibc \
 iproute \
 libdnf-plugin-subscription-manager \
 python3 \
 python3-cloud-what \
 python3-dateutil \
 python3-dbus \
 python3-decorator \
 python3-dnf \
 python3-dnf-plugins-core \
 python3-gobject-base \
 python3-iniparse \
 python3-inotify \
 python3-librepo \
 python3-subscription-manager-rhsm \
 subscription-manager-rhsm-certificates \
 systemd \
 virt-what \
 "
RDEPENDS:subscription-manager-plugin-ostree = " \
 python3 \
 python3-gobject-base \
 python3-iniparse \
 subscription-manager \
 "
