# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-coreutils"
PV = "0.7.0"
PR = "10.el10_3"
PACKAGES = " \
 rust-coreutils+arch-devel \
 rust-coreutils+b2sum-devel \
 rust-coreutils+base32-devel \
 rust-coreutils+base64-devel \
 rust-coreutils+basename-devel \
 rust-coreutils+basenc-devel \
 rust-coreutils+cat-devel \
 rust-coreutils+chcon-devel \
 rust-coreutils+chgrp-devel \
 rust-coreutils+chmod-devel \
 rust-coreutils+chown-devel \
 rust-coreutils+chroot-devel \
 rust-coreutils+cksum-devel \
 rust-coreutils+comm-devel \
 rust-coreutils+cp-devel \
 rust-coreutils+csplit-devel \
 rust-coreutils+cut-devel \
 rust-coreutils+date-devel \
 rust-coreutils+dd-devel \
 rust-coreutils+default-devel \
 rust-coreutils+df-devel \
 rust-coreutils+dir-devel \
 rust-coreutils+dircolors-devel \
 rust-coreutils+dirname-devel \
 rust-coreutils+du-devel \
 rust-coreutils+echo-devel \
 rust-coreutils+env-devel \
 rust-coreutils+expand-devel \
 rust-coreutils+expensive_tests-devel \
 rust-coreutils+expr-devel \
 rust-coreutils+factor-devel \
 rust-coreutils+false-devel \
 rust-coreutils+feat_Tier1-devel \
 rust-coreutils+feat_acl-devel \
 rust-coreutils+feat_common_core-devel \
 rust-coreutils+feat_external_libstdbuf-devel \
 rust-coreutils+feat_os_macos-devel \
 rust-coreutils+feat_os_unix-devel \
 rust-coreutils+feat_os_unix_android-devel \
 rust-coreutils+feat_os_unix_fuchsia-devel \
 rust-coreutils+feat_os_unix_gnueabihf-devel \
 rust-coreutils+feat_os_unix_musl-devel \
 rust-coreutils+feat_os_unix_redox-devel \
 rust-coreutils+feat_os_windows-devel \
 rust-coreutils+feat_os_windows_legacy-devel \
 rust-coreutils+feat_require_selinux-devel \
 rust-coreutils+feat_require_unix-devel \
 rust-coreutils+feat_require_unix_core-devel \
 rust-coreutils+feat_require_unix_hostid-devel \
 rust-coreutils+feat_require_unix_musl-devel \
 rust-coreutils+feat_require_unix_utmpx-devel \
 rust-coreutils+feat_selinux-devel \
 rust-coreutils+feat_smack-devel \
 rust-coreutils+feat_systemd_logind-devel \
 rust-coreutils+feat_wasm-devel \
 rust-coreutils+fmt-devel \
 rust-coreutils+fold-devel \
 rust-coreutils+groups-devel \
 rust-coreutils+head-devel \
 rust-coreutils+hostid-devel \
 rust-coreutils+hostname-devel \
 rust-coreutils+id-devel \
 rust-coreutils+install-devel \
 rust-coreutils+join-devel \
 rust-coreutils+kill-devel \
 rust-coreutils+link-devel \
 rust-coreutils+ln-devel \
 rust-coreutils+logname-devel \
 rust-coreutils+ls-devel \
 rust-coreutils+macos-devel \
 rust-coreutils+md5sum-devel \
 rust-coreutils+mkdir-devel \
 rust-coreutils+mkfifo-devel \
 rust-coreutils+mknod-devel \
 rust-coreutils+mktemp-devel \
 rust-coreutils+more-devel \
 rust-coreutils+mv-devel \
 rust-coreutils+nice-devel \
 rust-coreutils+nl-devel \
 rust-coreutils+nohup-devel \
 rust-coreutils+nproc-devel \
 rust-coreutils+numfmt-devel \
 rust-coreutils+od-devel \
 rust-coreutils+paste-devel \
 rust-coreutils+pathchk-devel \
 rust-coreutils+pinky-devel \
 rust-coreutils+pr-devel \
 rust-coreutils+printenv-devel \
 rust-coreutils+printf-devel \
 rust-coreutils+ptx-devel \
 rust-coreutils+pwd-devel \
 rust-coreutils+readlink-devel \
 rust-coreutils+realpath-devel \
 rust-coreutils+rm-devel \
 rust-coreutils+rmdir-devel \
 rust-coreutils+runcon-devel \
 rust-coreutils+selinux-devel \
 rust-coreutils+seq-devel \
 rust-coreutils+sha1sum-devel \
 rust-coreutils+sha224sum-devel \
 rust-coreutils+sha256sum-devel \
 rust-coreutils+sha384sum-devel \
 rust-coreutils+sha512sum-devel \
 rust-coreutils+shred-devel \
 rust-coreutils+shuf-devel \
 rust-coreutils+sleep-devel \
 rust-coreutils+sort-devel \
 rust-coreutils+split-devel \
 rust-coreutils+stat-devel \
 rust-coreutils+stdbuf-devel \
 rust-coreutils+stty-devel \
 rust-coreutils+sum-devel \
 rust-coreutils+sync-devel \
 rust-coreutils+tac-devel \
 rust-coreutils+tail-devel \
 rust-coreutils+tee-devel \
 rust-coreutils+test-devel \
 rust-coreutils+test_risky_names-devel \
 rust-coreutils+timeout-devel \
 rust-coreutils+touch-devel \
 rust-coreutils+tr-devel \
 rust-coreutils+true-devel \
 rust-coreutils+truncate-devel \
 rust-coreutils+tsort-devel \
 rust-coreutils+tty-devel \
 rust-coreutils+uname-devel \
 rust-coreutils+unexpand-devel \
 rust-coreutils+uniq-devel \
 rust-coreutils+unix-devel \
 rust-coreutils+unlink-devel \
 rust-coreutils+uptime-devel \
 rust-coreutils+users-devel \
 rust-coreutils+uu_test-devel \
 rust-coreutils+uudoc-devel \
 rust-coreutils+vdir-devel \
 rust-coreutils+wc-devel \
 rust-coreutils+who-devel \
 rust-coreutils+whoami-devel \
 rust-coreutils+windows-devel \
 rust-coreutils+yes-devel \
 rust-coreutils-devel \
 uutils-coreutils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-coreutils-0.7.0-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71e3b0493382995836a85b2fa83d849261ab29db624de515dee1baa2cab8e4c1"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-coreutils+uudoc-devel: (crate(zip) >= 8.0.0 with crate(zip) < 9.0.0~)
# - rust-coreutils+uudoc-devel: (crate(zip/deflate) >= 8.0.0 with crate(zip/deflate) < 9.0.0~)

URI_x86_64_v2_rust-coreutils+arch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+arch-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+arch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+arch-devel}"
SRC_URI[x86_64_v2_rust-coreutils+arch-devel.sha256sum] = "4e4c415c8a04d9b031e07e4d62279338355ae39d42ebe9f324d7e95f15b22de5"

URI_x86_64_v2_rust-coreutils+b2sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+b2sum-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+b2sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+b2sum-devel}"
SRC_URI[x86_64_v2_rust-coreutils+b2sum-devel.sha256sum] = "c15910b64cf50a1223aed7cf226856265eb5d3309110627e1ec5f0f664cbb3e7"

URI_x86_64_v2_rust-coreutils+base32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+base32-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+base32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+base32-devel}"
SRC_URI[x86_64_v2_rust-coreutils+base32-devel.sha256sum] = "bb1aa8ceed7a0679317bfb9521c2a94b1d13f6c3f875a3acbe0989f0480352c4"

URI_x86_64_v2_rust-coreutils+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+base64-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+base64-devel}"
SRC_URI[x86_64_v2_rust-coreutils+base64-devel.sha256sum] = "98caada95fc6a100ee6361c452a19ff626c2be6208df9794a8de69df132bd41e"

URI_x86_64_v2_rust-coreutils+basename-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+basename-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+basename-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+basename-devel}"
SRC_URI[x86_64_v2_rust-coreutils+basename-devel.sha256sum] = "7318e0f80c861371be734f1f8a0e6538e689f1d317df1c7e2691b70c1de49048"

URI_x86_64_v2_rust-coreutils+basenc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+basenc-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+basenc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+basenc-devel}"
SRC_URI[x86_64_v2_rust-coreutils+basenc-devel.sha256sum] = "095b08560314eeba7eea5b26b961a74675450b730fc248f63d0ee2a1e88285cf"

URI_x86_64_v2_rust-coreutils+cat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+cat-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+cat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+cat-devel}"
SRC_URI[x86_64_v2_rust-coreutils+cat-devel.sha256sum] = "ce7c98c5511e3fa8448cef71629ae2a435e571154dd05fc14000da713f306d02"

URI_x86_64_v2_rust-coreutils+chcon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+chcon-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+chcon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+chcon-devel}"
SRC_URI[x86_64_v2_rust-coreutils+chcon-devel.sha256sum] = "2cb66862f85f4b2b9902559c87c0ef57507ff91032d70cde01d05b019af084fe"

URI_x86_64_v2_rust-coreutils+chgrp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+chgrp-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+chgrp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+chgrp-devel}"
SRC_URI[x86_64_v2_rust-coreutils+chgrp-devel.sha256sum] = "8df18ccacad9568b95e2ff460b12dfc078eb225ba1ea44b6bcc9edc2c89b66f1"

URI_x86_64_v2_rust-coreutils+chmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+chmod-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+chmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+chmod-devel}"
SRC_URI[x86_64_v2_rust-coreutils+chmod-devel.sha256sum] = "0b1ce81dd2001457c264927652bef5d7e5011328158b3c6a04d9a95a1b7c0f0e"

URI_x86_64_v2_rust-coreutils+chown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+chown-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+chown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+chown-devel}"
SRC_URI[x86_64_v2_rust-coreutils+chown-devel.sha256sum] = "5db8d59f981f5e797d98d7f2f954f97ee49dd506bce78c3b0ef599575deed94a"

URI_x86_64_v2_rust-coreutils+chroot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+chroot-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+chroot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+chroot-devel}"
SRC_URI[x86_64_v2_rust-coreutils+chroot-devel.sha256sum] = "510bb540e13052dbf4e2484564899f11751396abe561818f934c1fd5cf01f0f6"

URI_x86_64_v2_rust-coreutils+cksum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+cksum-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+cksum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+cksum-devel}"
SRC_URI[x86_64_v2_rust-coreutils+cksum-devel.sha256sum] = "cc592bd209c2cf123abea12c9d974cb7e18724f43a200b1676cb278fd54593d6"

URI_x86_64_v2_rust-coreutils+comm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+comm-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+comm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+comm-devel}"
SRC_URI[x86_64_v2_rust-coreutils+comm-devel.sha256sum] = "ee2f1b8eebe092f67b9b46903c8edb735104077802e865754106b0291205325e"

URI_x86_64_v2_rust-coreutils+cp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+cp-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+cp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+cp-devel}"
SRC_URI[x86_64_v2_rust-coreutils+cp-devel.sha256sum] = "222457669de343f2e1b49a39f1ea968b96cec60dd2138e02d6d9a0645ff83f84"

URI_x86_64_v2_rust-coreutils+csplit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+csplit-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+csplit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+csplit-devel}"
SRC_URI[x86_64_v2_rust-coreutils+csplit-devel.sha256sum] = "2968f93a936bfa92f2d9a46d9b1bebca34ecbe66dfd5701b7221e42e4c87a17f"

URI_x86_64_v2_rust-coreutils+cut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+cut-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+cut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+cut-devel}"
SRC_URI[x86_64_v2_rust-coreutils+cut-devel.sha256sum] = "530d6621197db24638743f66dbc810e8dff2ddbaf207e8f5636a622ac9728d7d"

URI_x86_64_v2_rust-coreutils+date-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+date-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+date-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+date-devel}"
SRC_URI[x86_64_v2_rust-coreutils+date-devel.sha256sum] = "0345ea40ac91c4cd125d63644765b397956caae4d99f7e7acaf110ae4ce50116"

URI_x86_64_v2_rust-coreutils+dd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+dd-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+dd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+dd-devel}"
SRC_URI[x86_64_v2_rust-coreutils+dd-devel.sha256sum] = "17e7344915418c51031373517e8e691cf1b3359dc4389ef68469641063035db3"

URI_x86_64_v2_rust-coreutils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+default-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+default-devel}"
SRC_URI[x86_64_v2_rust-coreutils+default-devel.sha256sum] = "902ea2913f001292bed6e43e4bc7be650ac1df807d1364ea40c0c8f3b92ad4bf"

URI_x86_64_v2_rust-coreutils+df-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+df-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+df-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+df-devel}"
SRC_URI[x86_64_v2_rust-coreutils+df-devel.sha256sum] = "21ca5b6ff9ef6bb675d157cfd5ebded24a8dc8fbafafe48f35fb64359c1915c1"

URI_x86_64_v2_rust-coreutils+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+dir-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+dir-devel}"
SRC_URI[x86_64_v2_rust-coreutils+dir-devel.sha256sum] = "3a2e716a9651888479a7952b6f55d27939da1a032d8e905d40d0f0aa723bbfee"

URI_x86_64_v2_rust-coreutils+dircolors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+dircolors-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+dircolors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+dircolors-devel}"
SRC_URI[x86_64_v2_rust-coreutils+dircolors-devel.sha256sum] = "c110e234f65e1542203c3c71c3b105019d267e85f6ad155ab4028958477989db"

URI_x86_64_v2_rust-coreutils+dirname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+dirname-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+dirname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+dirname-devel}"
SRC_URI[x86_64_v2_rust-coreutils+dirname-devel.sha256sum] = "59909a169d3053eae9fa7d6f9d81fc5d3259122c7506bc4b1da5e9465ec21dad"

URI_x86_64_v2_rust-coreutils+du-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+du-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+du-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+du-devel}"
SRC_URI[x86_64_v2_rust-coreutils+du-devel.sha256sum] = "262ce5b58fa82fd3c7edb1b5f488f47a5b3edd0e3cd969f69871b80e09226ada"

URI_x86_64_v2_rust-coreutils+echo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+echo-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+echo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+echo-devel}"
SRC_URI[x86_64_v2_rust-coreutils+echo-devel.sha256sum] = "b3942345ddde154c0107b07647a8d5a60c61e7f5f4e16b1751c75233ab40766c"

URI_x86_64_v2_rust-coreutils+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+env-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+env-devel}"
SRC_URI[x86_64_v2_rust-coreutils+env-devel.sha256sum] = "69c065b14b3f6212f90dcb7168e454f97468677bd9991677c224be1a46a9be0e"

URI_x86_64_v2_rust-coreutils+expand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+expand-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+expand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+expand-devel}"
SRC_URI[x86_64_v2_rust-coreutils+expand-devel.sha256sum] = "19ed6594d44b41821df18120f47ac6a221d671e7f6b1e81322ff2428b4d90838"

URI_x86_64_v2_rust-coreutils+expensive_tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+expensive_tests-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+expensive_tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+expensive_tests-devel}"
SRC_URI[x86_64_v2_rust-coreutils+expensive_tests-devel.sha256sum] = "444463cddaab3115199cbd5d9c0622451b56ace0a64cb35dc1b086f8adfadd90"

URI_x86_64_v2_rust-coreutils+expr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+expr-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+expr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+expr-devel}"
SRC_URI[x86_64_v2_rust-coreutils+expr-devel.sha256sum] = "984e812f79fa4578757e583c7050af8c710fb7d6e56a3a6e5ced0ba2fab5247b"

URI_x86_64_v2_rust-coreutils+factor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+factor-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+factor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+factor-devel}"
SRC_URI[x86_64_v2_rust-coreutils+factor-devel.sha256sum] = "28ccc93f7f33f691faa58221ff579c50561b12a2cf5c3cc08b9dfe409560140e"

URI_x86_64_v2_rust-coreutils+false-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+false-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+false-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+false-devel}"
SRC_URI[x86_64_v2_rust-coreutils+false-devel.sha256sum] = "d9c908c8e98a0473887bb345703c4bfcbf40a16945b65f5db74574c8d71977c2"

URI_x86_64_v2_rust-coreutils+feat_Tier1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_Tier1-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_Tier1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_Tier1-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_Tier1-devel.sha256sum] = "91a38ad8f3598153cf658dc0d6d49e14face2877ae52c415b67b32ab0b7b3594"

URI_x86_64_v2_rust-coreutils+feat_acl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_acl-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_acl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_acl-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_acl-devel.sha256sum] = "959d46cbc083e4e840f3262a546509bc855a068d4465c42c8c92ae4ea583d1a4"

URI_x86_64_v2_rust-coreutils+feat_common_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_common_core-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_common_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_common_core-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_common_core-devel.sha256sum] = "3faf3cfbccaea7ad0a9529face06d2dbaf2e4f0892b612a4aa8a59bd6f665cdf"

URI_x86_64_v2_rust-coreutils+feat_external_libstdbuf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_external_libstdbuf-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_external_libstdbuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_external_libstdbuf-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_external_libstdbuf-devel.sha256sum] = "a69a6cbee402f50622736b198440321a40a2fe2e227056a0c64f83eb7769a5a5"

URI_x86_64_v2_rust-coreutils+feat_os_macos-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_os_macos-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_os_macos-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_os_macos-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_os_macos-devel.sha256sum] = "5b20b7f4a794c59c5c09a818c905b94e70b6b9bb5ebd3f0cddb466f982612ec4"

URI_x86_64_v2_rust-coreutils+feat_os_unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_os_unix-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_os_unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_os_unix-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_os_unix-devel.sha256sum] = "a5f0b9a1e8ed50af57476ea50dc4246b1a8f86c49f1db5885f87974b02ace510"

URI_x86_64_v2_rust-coreutils+feat_os_unix_android-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_os_unix_android-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_os_unix_android-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_os_unix_android-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_os_unix_android-devel.sha256sum] = "8fcffb82732f519a7d03224fa41f0580b356119cc1e2854e00e89ea96d741725"

URI_x86_64_v2_rust-coreutils+feat_os_unix_fuchsia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_os_unix_fuchsia-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_os_unix_fuchsia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_os_unix_fuchsia-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_os_unix_fuchsia-devel.sha256sum] = "1230d840362194137550076878609901d0ddced89a1b43a6e37c07f7ac6558c1"

URI_x86_64_v2_rust-coreutils+feat_os_unix_gnueabihf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_os_unix_gnueabihf-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_os_unix_gnueabihf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_os_unix_gnueabihf-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_os_unix_gnueabihf-devel.sha256sum] = "762a40f1f23b5d2114b1e8466a136ac14870864f9f572d2ea712d18d7237914d"

URI_x86_64_v2_rust-coreutils+feat_os_unix_musl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_os_unix_musl-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_os_unix_musl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_os_unix_musl-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_os_unix_musl-devel.sha256sum] = "221ac625e2ed123cdca2bc6755c6e31092a91ead1b7714d5536a2c71b4ba0e3b"

URI_x86_64_v2_rust-coreutils+feat_os_unix_redox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_os_unix_redox-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_os_unix_redox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_os_unix_redox-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_os_unix_redox-devel.sha256sum] = "88bcf751939b3fccf558eff2df18ccc7d13e31700040026ccc06dcfa62ee93f5"

URI_x86_64_v2_rust-coreutils+feat_os_windows-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_os_windows-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_os_windows-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_os_windows-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_os_windows-devel.sha256sum] = "1d4f7440988e8784bdb138235211e186cdf416f38a1416d9df38a31f4c805f17"

URI_x86_64_v2_rust-coreutils+feat_os_windows_legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_os_windows_legacy-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_os_windows_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_os_windows_legacy-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_os_windows_legacy-devel.sha256sum] = "a4e4ee6f5fe5ac9fb7499cd27777d0d0eb5064bf1ee674b828925b6e1c87c059"

URI_x86_64_v2_rust-coreutils+feat_require_selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_require_selinux-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_require_selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_require_selinux-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_require_selinux-devel.sha256sum] = "0e612f9291b232d0ea274f1bce98d22e49f0cfdfd4cc9b334268221de6afbf3f"

URI_x86_64_v2_rust-coreutils+feat_require_unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_require_unix-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_require_unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_require_unix-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_require_unix-devel.sha256sum] = "4d04fe40fec0777c4354790811877aeac8964ba2d82e95394205cdd08be7c72d"

URI_x86_64_v2_rust-coreutils+feat_require_unix_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_require_unix_core-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_require_unix_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_require_unix_core-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_require_unix_core-devel.sha256sum] = "bb0e67b5ac15bd72c4084ec4ab6642f28c77217b86249c292696cc65fe41fb81"

URI_x86_64_v2_rust-coreutils+feat_require_unix_hostid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_require_unix_hostid-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_require_unix_hostid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_require_unix_hostid-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_require_unix_hostid-devel.sha256sum] = "8d94d4ff64f9ba31420d4031b9d0c4cd23a2eaef032e18b59a6abeb77d33ef58"

URI_x86_64_v2_rust-coreutils+feat_require_unix_musl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_require_unix_musl-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_require_unix_musl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_require_unix_musl-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_require_unix_musl-devel.sha256sum] = "14754d9b30ca2dde710c26c3788c3ee740e0c6fbd6510dba6c219de8e916ba1a"

URI_x86_64_v2_rust-coreutils+feat_require_unix_utmpx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_require_unix_utmpx-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_require_unix_utmpx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_require_unix_utmpx-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_require_unix_utmpx-devel.sha256sum] = "b6b9a714898a954c78cc18fedde683a26f8cf7a9875c0223f9b0d1a77fdcaf11"

URI_x86_64_v2_rust-coreutils+feat_selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_selinux-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_selinux-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_selinux-devel.sha256sum] = "a6fff053f83edf31910cb27ca0d00176864204488dddc323a6b12aa5437abc15"

URI_x86_64_v2_rust-coreutils+feat_smack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_smack-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_smack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_smack-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_smack-devel.sha256sum] = "47bf21623cb21393ee6098b18ac102e25a346c674b1f890b4790bc26b4240b08"

URI_x86_64_v2_rust-coreutils+feat_systemd_logind-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_systemd_logind-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_systemd_logind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_systemd_logind-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_systemd_logind-devel.sha256sum] = "e469756f556009200f803899afd300e888670bbc93a18dbcbc90cb4a1e7f8b21"

URI_x86_64_v2_rust-coreutils+feat_wasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+feat_wasm-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+feat_wasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+feat_wasm-devel}"
SRC_URI[x86_64_v2_rust-coreutils+feat_wasm-devel.sha256sum] = "bf619813249ccc1d3cf76572c2beb6da009b0f73dd8dfdb4094ca281775ab807"

URI_x86_64_v2_rust-coreutils+fmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+fmt-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+fmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+fmt-devel}"
SRC_URI[x86_64_v2_rust-coreutils+fmt-devel.sha256sum] = "a4150fe9bf4c769518be29a4b8ced87f70484f4002405beec725a59ca0b422d1"

URI_x86_64_v2_rust-coreutils+fold-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+fold-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+fold-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+fold-devel}"
SRC_URI[x86_64_v2_rust-coreutils+fold-devel.sha256sum] = "a2b8d48073577e0e25b284c5215275247eb3b7acc56dfed176a81ddd4b51cfb9"

URI_x86_64_v2_rust-coreutils+groups-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+groups-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+groups-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+groups-devel}"
SRC_URI[x86_64_v2_rust-coreutils+groups-devel.sha256sum] = "16348d83008e8d326cddf3153633c01ddf6d0b59b05735aa85b21f46948ca57a"

URI_x86_64_v2_rust-coreutils+head-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+head-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+head-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+head-devel}"
SRC_URI[x86_64_v2_rust-coreutils+head-devel.sha256sum] = "8cd0da5d6192a31b7eb64823bfb6b4031aebf7ef8fbff442cef3fdc0ba4d3bc5"

URI_x86_64_v2_rust-coreutils+hostid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+hostid-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+hostid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+hostid-devel}"
SRC_URI[x86_64_v2_rust-coreutils+hostid-devel.sha256sum] = "ee3ec00d7f5e6cd9ae44ae757216b3bd87f0ea33734db6e16252e0a64bcd4031"

URI_x86_64_v2_rust-coreutils+hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+hostname-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+hostname-devel}"
SRC_URI[x86_64_v2_rust-coreutils+hostname-devel.sha256sum] = "281c6bfd1fc8578a26423de70d832310a2e663b3e05e435e622d228f2b47f2bf"

URI_x86_64_v2_rust-coreutils+id-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+id-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+id-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+id-devel}"
SRC_URI[x86_64_v2_rust-coreutils+id-devel.sha256sum] = "56603c4f52ac3448b9922527946ad1e7f0a4cb69c7146f5d05649bf99b8a00c1"

URI_x86_64_v2_rust-coreutils+install-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+install-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+install-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+install-devel}"
SRC_URI[x86_64_v2_rust-coreutils+install-devel.sha256sum] = "e8c5e88303bd7101702e52ced74beb8018706549fe12d60317e79897ef66dc79"

URI_x86_64_v2_rust-coreutils+join-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+join-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+join-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+join-devel}"
SRC_URI[x86_64_v2_rust-coreutils+join-devel.sha256sum] = "412bdb28c56ef2c3353e9c0a263d24803b0b88d1e80cd4077163f5e51a7b76de"

URI_x86_64_v2_rust-coreutils+kill-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+kill-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+kill-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+kill-devel}"
SRC_URI[x86_64_v2_rust-coreutils+kill-devel.sha256sum] = "dd7252558b207b14e8a5d81d164fb20cdd39942eac389c6eee25b7ef0c85c143"

URI_x86_64_v2_rust-coreutils+link-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+link-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+link-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+link-devel}"
SRC_URI[x86_64_v2_rust-coreutils+link-devel.sha256sum] = "cc58bca9e3f69603f1aa09bfa900934182771f1a6bafb638a468c0061b9d758e"

URI_x86_64_v2_rust-coreutils+ln-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+ln-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+ln-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+ln-devel}"
SRC_URI[x86_64_v2_rust-coreutils+ln-devel.sha256sum] = "f40e931383ed025fbcca4cd588687fc9351ca699f745d395f663dd062ab6f388"

URI_x86_64_v2_rust-coreutils+logname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+logname-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+logname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+logname-devel}"
SRC_URI[x86_64_v2_rust-coreutils+logname-devel.sha256sum] = "facf71e425a49b890ca2d96d92c06baed4c9eab4e8c22787705c839cb00738b7"

URI_x86_64_v2_rust-coreutils+ls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+ls-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+ls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+ls-devel}"
SRC_URI[x86_64_v2_rust-coreutils+ls-devel.sha256sum] = "25052e78f7b6d0f8d67483cb1e49be72b8949b8f54cad74ed891c825c92e9876"

URI_x86_64_v2_rust-coreutils+macos-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+macos-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+macos-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+macos-devel}"
SRC_URI[x86_64_v2_rust-coreutils+macos-devel.sha256sum] = "9914aa696ea048147c3334b75ba130ae16b34bd0577ac6b9df8ddf0a834df1ec"

URI_x86_64_v2_rust-coreutils+md5sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+md5sum-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+md5sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+md5sum-devel}"
SRC_URI[x86_64_v2_rust-coreutils+md5sum-devel.sha256sum] = "6ffebec8d467d955aa2d92930fcd95c78a2a1111db7398c4a7cd7e07b7ed5ed4"

URI_x86_64_v2_rust-coreutils+mkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+mkdir-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+mkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+mkdir-devel}"
SRC_URI[x86_64_v2_rust-coreutils+mkdir-devel.sha256sum] = "184779421a48ac3c29d088e835e7177845aafa10db2767b61026043776ffbb9b"

URI_x86_64_v2_rust-coreutils+mkfifo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+mkfifo-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+mkfifo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+mkfifo-devel}"
SRC_URI[x86_64_v2_rust-coreutils+mkfifo-devel.sha256sum] = "1002b788090e31dc39bf7f809e38bb33c6fa58eb2cd91a1fa74c819e28be50c2"

URI_x86_64_v2_rust-coreutils+mknod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+mknod-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+mknod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+mknod-devel}"
SRC_URI[x86_64_v2_rust-coreutils+mknod-devel.sha256sum] = "8064cae3ebc5bdc61142d2fecc5c6cfbf40b2a53865508bab9b7c754b70fbcb1"

URI_x86_64_v2_rust-coreutils+mktemp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+mktemp-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+mktemp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+mktemp-devel}"
SRC_URI[x86_64_v2_rust-coreutils+mktemp-devel.sha256sum] = "770a7d2ede72440a7f4040af142c8a6bf75b504aa3e8c7eb56cf60273ca4ee9f"

URI_x86_64_v2_rust-coreutils+more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+more-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+more-devel}"
SRC_URI[x86_64_v2_rust-coreutils+more-devel.sha256sum] = "98c05375af5988059b25a60dacad4ac2b948c9f9a126cb5a5782d5ca5ffb7c5b"

URI_x86_64_v2_rust-coreutils+mv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+mv-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+mv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+mv-devel}"
SRC_URI[x86_64_v2_rust-coreutils+mv-devel.sha256sum] = "ad68acf0fb435d65724370237a45938b269e0cb0cdcb9c30819a6ff378719f5e"

URI_x86_64_v2_rust-coreutils+nice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+nice-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+nice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+nice-devel}"
SRC_URI[x86_64_v2_rust-coreutils+nice-devel.sha256sum] = "368edfea7dca5f880b46986ba65a0a74ba0ea2c2365609a72d2e9b81c17e9952"

URI_x86_64_v2_rust-coreutils+nl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+nl-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+nl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+nl-devel}"
SRC_URI[x86_64_v2_rust-coreutils+nl-devel.sha256sum] = "121e3ed1b6395a832c2549a6aa7d61274fa5af8df8d876807bafbe7bdb9b06a5"

URI_x86_64_v2_rust-coreutils+nohup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+nohup-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+nohup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+nohup-devel}"
SRC_URI[x86_64_v2_rust-coreutils+nohup-devel.sha256sum] = "538dce4b204d32e2e990b8ef3711d3906a85a63c47e75bcd6e21afe688ddd387"

URI_x86_64_v2_rust-coreutils+nproc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+nproc-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+nproc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+nproc-devel}"
SRC_URI[x86_64_v2_rust-coreutils+nproc-devel.sha256sum] = "e0ff94468662e0f4f9b01433162a2da0763e83b0663675a4f774cf5a4b86e561"

URI_x86_64_v2_rust-coreutils+numfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+numfmt-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+numfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+numfmt-devel}"
SRC_URI[x86_64_v2_rust-coreutils+numfmt-devel.sha256sum] = "a9605dbbee5e7c00fe1cb70070f65eb47460bec348a22c1b0029cb6743d375b1"

URI_x86_64_v2_rust-coreutils+od-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+od-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+od-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+od-devel}"
SRC_URI[x86_64_v2_rust-coreutils+od-devel.sha256sum] = "0452772e02de1c46216f828a67851aef0a1318efadf1b2946bfcbee9cbd5e9d1"

URI_x86_64_v2_rust-coreutils+paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+paste-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+paste-devel}"
SRC_URI[x86_64_v2_rust-coreutils+paste-devel.sha256sum] = "c3cf9ec3140a9139a3c70843679cfed6f7b53e2c4a4f93e3eb06b1a27d154325"

URI_x86_64_v2_rust-coreutils+pathchk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+pathchk-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+pathchk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+pathchk-devel}"
SRC_URI[x86_64_v2_rust-coreutils+pathchk-devel.sha256sum] = "034d197c177368d889a665830c76add27db55602bc66a1b3488aa5c37938ff4a"

URI_x86_64_v2_rust-coreutils+pinky-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+pinky-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+pinky-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+pinky-devel}"
SRC_URI[x86_64_v2_rust-coreutils+pinky-devel.sha256sum] = "2d01151eba48ee7173c2dbc4151e4ae95e623d26e78ba79927145e882510304b"

URI_x86_64_v2_rust-coreutils+pr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+pr-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+pr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+pr-devel}"
SRC_URI[x86_64_v2_rust-coreutils+pr-devel.sha256sum] = "6c94fb84e5c6986bd61cd555db46a6d190f73a843fc58b232b377355535539c0"

URI_x86_64_v2_rust-coreutils+printenv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+printenv-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+printenv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+printenv-devel}"
SRC_URI[x86_64_v2_rust-coreutils+printenv-devel.sha256sum] = "2609b01d046d7426e1ec1cc393aab34d44ab935809f53c33b21cbf814ce32248"

URI_x86_64_v2_rust-coreutils+printf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+printf-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+printf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+printf-devel}"
SRC_URI[x86_64_v2_rust-coreutils+printf-devel.sha256sum] = "a396da1e4070830576ec2c5c991716bc3bb2ae1f48fb78483faf83a95804588d"

URI_x86_64_v2_rust-coreutils+ptx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+ptx-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+ptx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+ptx-devel}"
SRC_URI[x86_64_v2_rust-coreutils+ptx-devel.sha256sum] = "31fb16b701e32cef815b349bd7db7a6430cc60d717f948823dede391d2d9127c"

URI_x86_64_v2_rust-coreutils+pwd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+pwd-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+pwd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+pwd-devel}"
SRC_URI[x86_64_v2_rust-coreutils+pwd-devel.sha256sum] = "83b2e3557f77118b4403a3447e520e9e49fbcc94262a7c4bcb3d10ee7d216ff7"

URI_x86_64_v2_rust-coreutils+readlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+readlink-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+readlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+readlink-devel}"
SRC_URI[x86_64_v2_rust-coreutils+readlink-devel.sha256sum] = "a28ea4657bd8a0a882e8829ba941c6b7f65d3aff82ce65a3a94f92ee0da7255e"

URI_x86_64_v2_rust-coreutils+realpath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+realpath-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+realpath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+realpath-devel}"
SRC_URI[x86_64_v2_rust-coreutils+realpath-devel.sha256sum] = "c1fa61fe9821cf8977ead5ed6f7f37c41fa338d1a5fec3b1a274bddf29492be3"

URI_x86_64_v2_rust-coreutils+rm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+rm-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+rm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+rm-devel}"
SRC_URI[x86_64_v2_rust-coreutils+rm-devel.sha256sum] = "c06076853796b473a7bd2193c3481bca83d1d18bdaaccdd6197c2bb2c0f7c53b"

URI_x86_64_v2_rust-coreutils+rmdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+rmdir-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+rmdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+rmdir-devel}"
SRC_URI[x86_64_v2_rust-coreutils+rmdir-devel.sha256sum] = "862ab3e25fcaf4f01d69b84553800b5d754d1971730fe1437b726a84ba5f77ec"

URI_x86_64_v2_rust-coreutils+runcon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+runcon-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+runcon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+runcon-devel}"
SRC_URI[x86_64_v2_rust-coreutils+runcon-devel.sha256sum] = "30631b66aede03be6293eecf0a4c32048e90806bca834ad4aeefd6ccc9ec4a86"

URI_x86_64_v2_rust-coreutils+selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+selinux-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+selinux-devel}"
SRC_URI[x86_64_v2_rust-coreutils+selinux-devel.sha256sum] = "0011664b834f8a0f59eb23e571123fef30c1a9aaac72c00de6d1418f945972e3"

URI_x86_64_v2_rust-coreutils+seq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+seq-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+seq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+seq-devel}"
SRC_URI[x86_64_v2_rust-coreutils+seq-devel.sha256sum] = "590fb66b3cf3ebfa1b2ed115f6989a1a1e025274ab34171d4d62eac113e9f86d"

URI_x86_64_v2_rust-coreutils+sha1sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+sha1sum-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+sha1sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+sha1sum-devel}"
SRC_URI[x86_64_v2_rust-coreutils+sha1sum-devel.sha256sum] = "6bb143dc58f854597b1a242783bbeeb0202d865dbfba55677647320e8bd93d05"

URI_x86_64_v2_rust-coreutils+sha224sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+sha224sum-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+sha224sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+sha224sum-devel}"
SRC_URI[x86_64_v2_rust-coreutils+sha224sum-devel.sha256sum] = "a9854bb5fc8a6ef3480b899d353a210153681328b73b3e4541640a46bff62cfb"

URI_x86_64_v2_rust-coreutils+sha256sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+sha256sum-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+sha256sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+sha256sum-devel}"
SRC_URI[x86_64_v2_rust-coreutils+sha256sum-devel.sha256sum] = "4c8b3a213cf1f9f37094b2ba78f81b94e2c8dad0be6ab001497850d541e2291f"

URI_x86_64_v2_rust-coreutils+sha384sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+sha384sum-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+sha384sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+sha384sum-devel}"
SRC_URI[x86_64_v2_rust-coreutils+sha384sum-devel.sha256sum] = "ccc2996ca5f8c51bcdbc219bc57e69d638e16ceaa6b52eaa4c5e6f573a9a7e90"

URI_x86_64_v2_rust-coreutils+sha512sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+sha512sum-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+sha512sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+sha512sum-devel}"
SRC_URI[x86_64_v2_rust-coreutils+sha512sum-devel.sha256sum] = "de71e7a7948ff1a94b8e2077aa89b36e17a301e3179919643127ae6c94ce799e"

URI_x86_64_v2_rust-coreutils+shred-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+shred-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+shred-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+shred-devel}"
SRC_URI[x86_64_v2_rust-coreutils+shred-devel.sha256sum] = "6e7bf823b965ae73afeb705faf57c080f80e64a12bb4ca5988b2ec2c790d599b"

URI_x86_64_v2_rust-coreutils+shuf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+shuf-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+shuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+shuf-devel}"
SRC_URI[x86_64_v2_rust-coreutils+shuf-devel.sha256sum] = "6f040fe4b82f12edda6d617156177682549cbffca76f0db86f2e7f4e7076e0fc"

URI_x86_64_v2_rust-coreutils+sleep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+sleep-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+sleep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+sleep-devel}"
SRC_URI[x86_64_v2_rust-coreutils+sleep-devel.sha256sum] = "053f7e024213262831c8a0a3939c41b952822a4def24d489f204fee39fbbb55f"

URI_x86_64_v2_rust-coreutils+sort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+sort-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+sort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+sort-devel}"
SRC_URI[x86_64_v2_rust-coreutils+sort-devel.sha256sum] = "c3e664353d1312a16c3ee9ca4c6af2a42256c02df8be2a7e062876482a0a90c1"

URI_x86_64_v2_rust-coreutils+split-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+split-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+split-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+split-devel}"
SRC_URI[x86_64_v2_rust-coreutils+split-devel.sha256sum] = "de478849f0ec69403ec73ccdbb8ded03effb03500d082480e63a87e15239539d"

URI_x86_64_v2_rust-coreutils+stat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+stat-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+stat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+stat-devel}"
SRC_URI[x86_64_v2_rust-coreutils+stat-devel.sha256sum] = "492018a2579b9d286317a058127a45cb8d13b8743a386fcf429510656828e776"

URI_x86_64_v2_rust-coreutils+stdbuf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+stdbuf-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+stdbuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+stdbuf-devel}"
SRC_URI[x86_64_v2_rust-coreutils+stdbuf-devel.sha256sum] = "1735ecb55df2e874d3e4bc1952dedfa8ca1ac38aafd12168bd72fe07d03813f2"

URI_x86_64_v2_rust-coreutils+stty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+stty-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+stty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+stty-devel}"
SRC_URI[x86_64_v2_rust-coreutils+stty-devel.sha256sum] = "531c12334645a9c2cb9ad07f079fbfe7715580916a56509bf87903acbae42eec"

URI_x86_64_v2_rust-coreutils+sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+sum-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+sum-devel}"
SRC_URI[x86_64_v2_rust-coreutils+sum-devel.sha256sum] = "7fdb82223c316e5c0a27cf5b0e7ff9858da3760fd110569ecf9451ba1ef21b41"

URI_x86_64_v2_rust-coreutils+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+sync-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+sync-devel}"
SRC_URI[x86_64_v2_rust-coreutils+sync-devel.sha256sum] = "d530e97332015d3f3df6f3404392b26c1be5b603c44f1a0b80586755773ad7b8"

URI_x86_64_v2_rust-coreutils+tac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+tac-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+tac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+tac-devel}"
SRC_URI[x86_64_v2_rust-coreutils+tac-devel.sha256sum] = "241fb91c092a340e340842414bd79423d9cc0631df21f070520365119720ba11"

URI_x86_64_v2_rust-coreutils+tail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+tail-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+tail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+tail-devel}"
SRC_URI[x86_64_v2_rust-coreutils+tail-devel.sha256sum] = "3dbabe1c0e86142b09e953fd130866fae7f43d0b74c8da20d88589224b25a5f0"

URI_x86_64_v2_rust-coreutils+tee-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+tee-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+tee-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+tee-devel}"
SRC_URI[x86_64_v2_rust-coreutils+tee-devel.sha256sum] = "ade24540c510741f4c32c736c76f8ef464d855cb3b69a3387c6a168895c01c46"

URI_x86_64_v2_rust-coreutils+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+test-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+test-devel}"
SRC_URI[x86_64_v2_rust-coreutils+test-devel.sha256sum] = "37f79427c7d36e08cb7ea618ec787a03df15bd19342f15b783462c6f52239007"

URI_x86_64_v2_rust-coreutils+test_risky_names-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+test_risky_names-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+test_risky_names-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+test_risky_names-devel}"
SRC_URI[x86_64_v2_rust-coreutils+test_risky_names-devel.sha256sum] = "247a967659ee73e0e66d377ee007fc50ee8abbb957b2e58a9dea0ce96f4d4b6d"

URI_x86_64_v2_rust-coreutils+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+timeout-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+timeout-devel}"
SRC_URI[x86_64_v2_rust-coreutils+timeout-devel.sha256sum] = "b0e98786550517122a32922cbcd415f96ce8c29a5b9f51add74ae23bf1f3efbe"

URI_x86_64_v2_rust-coreutils+touch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+touch-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+touch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+touch-devel}"
SRC_URI[x86_64_v2_rust-coreutils+touch-devel.sha256sum] = "5fb1b8efb97d19ee075b50147fffc11102cd426d812cc459f87bbd6313ac7c84"

URI_x86_64_v2_rust-coreutils+tr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+tr-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+tr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+tr-devel}"
SRC_URI[x86_64_v2_rust-coreutils+tr-devel.sha256sum] = "732743c2fa5f49780e096241f03f880f618b15a3163632a084c73b97ed6ac180"

URI_x86_64_v2_rust-coreutils+true-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+true-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+true-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+true-devel}"
SRC_URI[x86_64_v2_rust-coreutils+true-devel.sha256sum] = "399f1ee8539e562c08315a8b8c6835554f907f3878747c8baeada654959d8e9f"

URI_x86_64_v2_rust-coreutils+truncate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+truncate-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+truncate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+truncate-devel}"
SRC_URI[x86_64_v2_rust-coreutils+truncate-devel.sha256sum] = "fb489515e1f5ac73005d98df854dfdf9f8948baa2391b3c1fe8a2225a8eb3dc7"

URI_x86_64_v2_rust-coreutils+tsort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+tsort-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+tsort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+tsort-devel}"
SRC_URI[x86_64_v2_rust-coreutils+tsort-devel.sha256sum] = "0b09d9869fdb278ba377027488f4882124ea74cf919ec678975d540647d212d2"

URI_x86_64_v2_rust-coreutils+tty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+tty-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+tty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+tty-devel}"
SRC_URI[x86_64_v2_rust-coreutils+tty-devel.sha256sum] = "e48f7f06e081032ac5cb75fd864db30cd1f4002db5abe272a6bd149ae6fba7f6"

URI_x86_64_v2_rust-coreutils+uname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+uname-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+uname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+uname-devel}"
SRC_URI[x86_64_v2_rust-coreutils+uname-devel.sha256sum] = "f960fead3dac2fc44fbf55351f445a5b01a9efed4d234fc439ce4096d8478198"

URI_x86_64_v2_rust-coreutils+unexpand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+unexpand-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+unexpand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+unexpand-devel}"
SRC_URI[x86_64_v2_rust-coreutils+unexpand-devel.sha256sum] = "b23b14422091df7fc5d4588f5cf9ea55c529beaab09a772c2d1125db2417881a"

URI_x86_64_v2_rust-coreutils+uniq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+uniq-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+uniq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+uniq-devel}"
SRC_URI[x86_64_v2_rust-coreutils+uniq-devel.sha256sum] = "9aaddfe2dbc8f2cca3a726ae2585466b0bbd3b2808045f17b56cde6b56cfd4ff"

URI_x86_64_v2_rust-coreutils+unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+unix-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+unix-devel}"
SRC_URI[x86_64_v2_rust-coreutils+unix-devel.sha256sum] = "2e42f6113c90f7c4a4168e1beba39785c7c2f5160b85dac267af780e90d8c1ec"

URI_x86_64_v2_rust-coreutils+unlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+unlink-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+unlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+unlink-devel}"
SRC_URI[x86_64_v2_rust-coreutils+unlink-devel.sha256sum] = "b7ca0353d60263f7ce58232f61e4a4889900ce44537df26dfe5422771fb57015"

URI_x86_64_v2_rust-coreutils+uptime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+uptime-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+uptime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+uptime-devel}"
SRC_URI[x86_64_v2_rust-coreutils+uptime-devel.sha256sum] = "9506f564dad89cb1b3ec687f3997cc45ec1569a4159a701314be7f7aa9af2b0e"

URI_x86_64_v2_rust-coreutils+users-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+users-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+users-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+users-devel}"
SRC_URI[x86_64_v2_rust-coreutils+users-devel.sha256sum] = "dd9e883f0e183aaaae46439b312f4aa6aabc084c45dbf511df2e8f21e14368b1"

URI_x86_64_v2_rust-coreutils+uu_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+uu_test-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+uu_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+uu_test-devel}"
SRC_URI[x86_64_v2_rust-coreutils+uu_test-devel.sha256sum] = "73587ba1d0e42be8604ca16cad0a4b724fc7becef2315ba83210af34af9bf000"

URI_x86_64_v2_rust-coreutils+uudoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+uudoc-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+uudoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+uudoc-devel}"
SRC_URI[x86_64_v2_rust-coreutils+uudoc-devel.sha256sum] = "4bd7a9df227dd35eafd0d81c9955ddf39ac03cedc31652a834b977174bdc1c36"

URI_x86_64_v2_rust-coreutils+vdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+vdir-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+vdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+vdir-devel}"
SRC_URI[x86_64_v2_rust-coreutils+vdir-devel.sha256sum] = "f6e97db0f80ff077e0d10d41a1439ee1756c6fb98458cfb4dc1b8af5a9080f03"

URI_x86_64_v2_rust-coreutils+wc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+wc-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+wc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+wc-devel}"
SRC_URI[x86_64_v2_rust-coreutils+wc-devel.sha256sum] = "29cac7f9b2810e13c2676e44dce64346af0bc1d8a2d0d067c1bd49f6e64ab0fc"

URI_x86_64_v2_rust-coreutils+who-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+who-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+who-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+who-devel}"
SRC_URI[x86_64_v2_rust-coreutils+who-devel.sha256sum] = "359e824e117906ef93d863703b1d9907c8fc68604edb556a7a42becbfc7821fb"

URI_x86_64_v2_rust-coreutils+whoami-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+whoami-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+whoami-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+whoami-devel}"
SRC_URI[x86_64_v2_rust-coreutils+whoami-devel.sha256sum] = "36a752a46651fee17af07da85e039bfe5bc193052c5992e5cc85b0db2285161a"

URI_x86_64_v2_rust-coreutils+windows-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+windows-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+windows-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+windows-devel}"
SRC_URI[x86_64_v2_rust-coreutils+windows-devel.sha256sum] = "d40cfafeebd988aa56864acc3989aa28c1171dcd82aec63101c6d6fdf40a885e"

URI_x86_64_v2_rust-coreutils+yes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils+yes-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils+yes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils+yes-devel}"
SRC_URI[x86_64_v2_rust-coreutils+yes-devel.sha256sum] = "5b9f4ab54caa39b96bdb1a0d64ae8fe06096032a21fb7738cff4d5cf45d882c5"

URI_x86_64_v2_rust-coreutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-coreutils-devel-0.7.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-coreutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-coreutils-devel}"
SRC_URI[x86_64_v2_rust-coreutils-devel.sha256sum] = "c19949a5e38181b6dc02903ffa2b9bf6cb57edd714fefd9c63ebf916bb5c2b4d"

URI_x86_64_v2_uutils-coreutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uutils-coreutils-0.7.0-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uutils-coreutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uutils-coreutils}"
SRC_URI[x86_64_v2_uutils-coreutils.sha256sum] = "640c0333b9129628058c124230adf6784394e7e87d05cdf8b528882457a3aa63"

URI_aarch64_rust-coreutils+arch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+arch-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+arch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+arch-devel}"
SRC_URI[aarch64_rust-coreutils+arch-devel.sha256sum] = "e55325e15142244d1d9ac7e4d157b53bc4f61734cedfc0e6404422978948c22f"

URI_aarch64_rust-coreutils+b2sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+b2sum-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+b2sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+b2sum-devel}"
SRC_URI[aarch64_rust-coreutils+b2sum-devel.sha256sum] = "19478626c7060aa4d0cc13b8ba05251f14faa528111035f82dc3c669b3ea3c57"

URI_aarch64_rust-coreutils+base32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+base32-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+base32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+base32-devel}"
SRC_URI[aarch64_rust-coreutils+base32-devel.sha256sum] = "906232352dde61477db9160d482e18409f85d86ef7300264c6e81787ab648bf7"

URI_aarch64_rust-coreutils+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+base64-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+base64-devel}"
SRC_URI[aarch64_rust-coreutils+base64-devel.sha256sum] = "b09420dc515153bfbd8e33379125a2b5956eb603554dab8728269fdc09411385"

URI_aarch64_rust-coreutils+basename-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+basename-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+basename-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+basename-devel}"
SRC_URI[aarch64_rust-coreutils+basename-devel.sha256sum] = "f31b824b598e7aed15ce8f175cb704f6c266c7234b5598f32bdba6faa01a9a61"

URI_aarch64_rust-coreutils+basenc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+basenc-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+basenc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+basenc-devel}"
SRC_URI[aarch64_rust-coreutils+basenc-devel.sha256sum] = "040b0dc7c4d384e708579a0a63ec1fe12e0405ffa49f05a78b64055132eead21"

URI_aarch64_rust-coreutils+cat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+cat-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+cat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+cat-devel}"
SRC_URI[aarch64_rust-coreutils+cat-devel.sha256sum] = "f61a057b8c7b6754e44a37d9c122f1c472af123602de8456c24d54abbb08a2c3"

URI_aarch64_rust-coreutils+chcon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+chcon-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+chcon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+chcon-devel}"
SRC_URI[aarch64_rust-coreutils+chcon-devel.sha256sum] = "e6613c4f529e6aa7d5d316cd11790cec9d069d97a008e6f1d7f6c062d5ac47c5"

URI_aarch64_rust-coreutils+chgrp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+chgrp-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+chgrp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+chgrp-devel}"
SRC_URI[aarch64_rust-coreutils+chgrp-devel.sha256sum] = "9d9b218bb0ed58e84fbde1c6f4be63d4e15e17bf36dce630c04d5e4bdb282a52"

URI_aarch64_rust-coreutils+chmod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+chmod-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+chmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+chmod-devel}"
SRC_URI[aarch64_rust-coreutils+chmod-devel.sha256sum] = "e52b592561c839778c9b78945ed336d22e7e808134895c988bf16e301be12be8"

URI_aarch64_rust-coreutils+chown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+chown-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+chown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+chown-devel}"
SRC_URI[aarch64_rust-coreutils+chown-devel.sha256sum] = "e53ad99626d8511bced50b2dc41ae88995f71104a8c471371edc3f610bad54c2"

URI_aarch64_rust-coreutils+chroot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+chroot-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+chroot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+chroot-devel}"
SRC_URI[aarch64_rust-coreutils+chroot-devel.sha256sum] = "af18f887d48cbea525c1daff67ccc0fd717f865111af4f6594bcca4ed862945a"

URI_aarch64_rust-coreutils+cksum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+cksum-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+cksum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+cksum-devel}"
SRC_URI[aarch64_rust-coreutils+cksum-devel.sha256sum] = "917c65f9e69321526c89b8a5742fb76a4f0449ae90e2a1318a211d08cf7a508c"

URI_aarch64_rust-coreutils+comm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+comm-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+comm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+comm-devel}"
SRC_URI[aarch64_rust-coreutils+comm-devel.sha256sum] = "e0ff2234e8b1914c1a2aea3c05a51e206817ca808f2549477d4a525017c1a51e"

URI_aarch64_rust-coreutils+cp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+cp-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+cp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+cp-devel}"
SRC_URI[aarch64_rust-coreutils+cp-devel.sha256sum] = "6407782db0376055f7bceabbbde8d90215bd005e16306a2533b60c869139d4e3"

URI_aarch64_rust-coreutils+csplit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+csplit-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+csplit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+csplit-devel}"
SRC_URI[aarch64_rust-coreutils+csplit-devel.sha256sum] = "e50bfec2030edb189aa4ab0fe1dc705a657fea5e4dd48b645e0de6d00699d292"

URI_aarch64_rust-coreutils+cut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+cut-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+cut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+cut-devel}"
SRC_URI[aarch64_rust-coreutils+cut-devel.sha256sum] = "39aeb83bed55989042f51b2757dcf10601af53aab2688373be9b5e4da7860588"

URI_aarch64_rust-coreutils+date-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+date-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+date-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+date-devel}"
SRC_URI[aarch64_rust-coreutils+date-devel.sha256sum] = "6fcc07e1b87b45bc626f9721e8908a0506ff5255a3d8b6a95010dc80f5d31435"

URI_aarch64_rust-coreutils+dd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+dd-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+dd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+dd-devel}"
SRC_URI[aarch64_rust-coreutils+dd-devel.sha256sum] = "6f73c54e7475509ef67df01f3b733dfbdda4373339f53c732c3a0bbe61f1808e"

URI_aarch64_rust-coreutils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+default-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+default-devel}"
SRC_URI[aarch64_rust-coreutils+default-devel.sha256sum] = "da1acdf90a34e0f5e393d20a9a21665fb6d2e48769d9e7a4a52559ecb585fb42"

URI_aarch64_rust-coreutils+df-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+df-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+df-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+df-devel}"
SRC_URI[aarch64_rust-coreutils+df-devel.sha256sum] = "17145257bb322ee734f1f194e3a263f9b2ab726874283b4308f9654b0b8e52b1"

URI_aarch64_rust-coreutils+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+dir-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+dir-devel}"
SRC_URI[aarch64_rust-coreutils+dir-devel.sha256sum] = "323a81f002dbca70f1c05e11f9e821167278569a045725446f036be489c6af4c"

URI_aarch64_rust-coreutils+dircolors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+dircolors-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+dircolors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+dircolors-devel}"
SRC_URI[aarch64_rust-coreutils+dircolors-devel.sha256sum] = "ebcbf051929ee753d72f5aa73f8964d01d2e28299024dbc69c84f8ea9ac04c4a"

URI_aarch64_rust-coreutils+dirname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+dirname-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+dirname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+dirname-devel}"
SRC_URI[aarch64_rust-coreutils+dirname-devel.sha256sum] = "0798487578cd5efab1fa17d24ff6edac413dc9401d8dcd1ec9578c2a49e75ef9"

URI_aarch64_rust-coreutils+du-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+du-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+du-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+du-devel}"
SRC_URI[aarch64_rust-coreutils+du-devel.sha256sum] = "d9b469b1729a4ddc7fbb02ee88e1953e6b7be3ab2cb15b1c265158135029dd4e"

URI_aarch64_rust-coreutils+echo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+echo-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+echo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+echo-devel}"
SRC_URI[aarch64_rust-coreutils+echo-devel.sha256sum] = "cd2506ea0d3e7b5e14470840a3bafd4ce6dbf4bee16fbe61bf73c702bd1795b0"

URI_aarch64_rust-coreutils+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+env-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+env-devel}"
SRC_URI[aarch64_rust-coreutils+env-devel.sha256sum] = "6695edf80cfe5a4d1e5e414b5a530c398a85826a25fcd7b82f791315ab7892e0"

URI_aarch64_rust-coreutils+expand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+expand-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+expand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+expand-devel}"
SRC_URI[aarch64_rust-coreutils+expand-devel.sha256sum] = "3457c8c602d717e0e83fba539a0702c178ba1d8f3db2a34e7841c0ade159313f"

URI_aarch64_rust-coreutils+expensive_tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+expensive_tests-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+expensive_tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+expensive_tests-devel}"
SRC_URI[aarch64_rust-coreutils+expensive_tests-devel.sha256sum] = "bcc88a31bd8f3a7b8dfc86acc0b8e85e6168799a057234c6defdcdd12e3ecbf0"

URI_aarch64_rust-coreutils+expr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+expr-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+expr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+expr-devel}"
SRC_URI[aarch64_rust-coreutils+expr-devel.sha256sum] = "9b6be2e2914916626b8c531d339d574748cad965c7e92f03903657270f81c1fd"

URI_aarch64_rust-coreutils+factor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+factor-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+factor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+factor-devel}"
SRC_URI[aarch64_rust-coreutils+factor-devel.sha256sum] = "011947b6ad89a24ecb22ff5b3894b40f2f10098c2e56bfa4fe5204c335605b60"

URI_aarch64_rust-coreutils+false-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+false-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+false-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+false-devel}"
SRC_URI[aarch64_rust-coreutils+false-devel.sha256sum] = "573cdc6e9dfa1d0c641addc1364b0d1170f42009581b97b8fce13ef544f5b7ab"

URI_aarch64_rust-coreutils+feat_Tier1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_Tier1-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_Tier1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_Tier1-devel}"
SRC_URI[aarch64_rust-coreutils+feat_Tier1-devel.sha256sum] = "caa4fe584ee6a5a5ed4683c5df0673e6f886499fc512c3ccf3e0c507f6a2f084"

URI_aarch64_rust-coreutils+feat_acl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_acl-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_acl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_acl-devel}"
SRC_URI[aarch64_rust-coreutils+feat_acl-devel.sha256sum] = "cf464a08c0fbc566fde9da43ad3a7c5f07a356026bf295d37afa3424a7a4f44d"

URI_aarch64_rust-coreutils+feat_common_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_common_core-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_common_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_common_core-devel}"
SRC_URI[aarch64_rust-coreutils+feat_common_core-devel.sha256sum] = "738f06cf90cae371e5653e7214b58566da48a439575ae8c5f488c07605aa3485"

URI_aarch64_rust-coreutils+feat_external_libstdbuf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_external_libstdbuf-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_external_libstdbuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_external_libstdbuf-devel}"
SRC_URI[aarch64_rust-coreutils+feat_external_libstdbuf-devel.sha256sum] = "a70798b9000f60ab3328cfa4718cc4d3f2b39afffaf035fc77585a03fa01aea2"

URI_aarch64_rust-coreutils+feat_os_macos-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_os_macos-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_os_macos-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_os_macos-devel}"
SRC_URI[aarch64_rust-coreutils+feat_os_macos-devel.sha256sum] = "05cede5d3686bf5871fbbab6660df60f5d4b1bab28b5457625aa13d2ea84bd84"

URI_aarch64_rust-coreutils+feat_os_unix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_os_unix-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_os_unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_os_unix-devel}"
SRC_URI[aarch64_rust-coreutils+feat_os_unix-devel.sha256sum] = "c81b4567fc381b89a176dc7850ba11852ecb2bf61800c069de3a1bf99cde42ae"

URI_aarch64_rust-coreutils+feat_os_unix_android-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_os_unix_android-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_os_unix_android-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_os_unix_android-devel}"
SRC_URI[aarch64_rust-coreutils+feat_os_unix_android-devel.sha256sum] = "75cfcb7dcb502f656036134f153803943b9a4362be0564c1e31d822b661af634"

URI_aarch64_rust-coreutils+feat_os_unix_fuchsia-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_os_unix_fuchsia-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_os_unix_fuchsia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_os_unix_fuchsia-devel}"
SRC_URI[aarch64_rust-coreutils+feat_os_unix_fuchsia-devel.sha256sum] = "4283f2b997475e2b4a15547e90d73edfe6d219111c064afb21cb19f2947b4b15"

URI_aarch64_rust-coreutils+feat_os_unix_gnueabihf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_os_unix_gnueabihf-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_os_unix_gnueabihf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_os_unix_gnueabihf-devel}"
SRC_URI[aarch64_rust-coreutils+feat_os_unix_gnueabihf-devel.sha256sum] = "059ec351111439d1466dbc325311a820bdae9e6fffee371f7af2ccba412656dc"

URI_aarch64_rust-coreutils+feat_os_unix_musl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_os_unix_musl-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_os_unix_musl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_os_unix_musl-devel}"
SRC_URI[aarch64_rust-coreutils+feat_os_unix_musl-devel.sha256sum] = "b0131f067db5168612644717d7b812a7e01a27889b4663d6ded335461093a5aa"

URI_aarch64_rust-coreutils+feat_os_unix_redox-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_os_unix_redox-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_os_unix_redox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_os_unix_redox-devel}"
SRC_URI[aarch64_rust-coreutils+feat_os_unix_redox-devel.sha256sum] = "e3cf934acd3a5db5175feb23d4cfea0c906f21e6f840c6e7462c68197f72875f"

URI_aarch64_rust-coreutils+feat_os_windows-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_os_windows-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_os_windows-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_os_windows-devel}"
SRC_URI[aarch64_rust-coreutils+feat_os_windows-devel.sha256sum] = "d73ec6c80d2e98a22323e3b30f57c9646bc4ede1fb470e766ffc9edaf88d1dde"

URI_aarch64_rust-coreutils+feat_os_windows_legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_os_windows_legacy-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_os_windows_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_os_windows_legacy-devel}"
SRC_URI[aarch64_rust-coreutils+feat_os_windows_legacy-devel.sha256sum] = "99dc280c0405ca23f989a6679c168cb177c150d0544a3b3df9ecd5522467a9cc"

URI_aarch64_rust-coreutils+feat_require_selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_require_selinux-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_require_selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_require_selinux-devel}"
SRC_URI[aarch64_rust-coreutils+feat_require_selinux-devel.sha256sum] = "2a5a9daff5bac8f78fc51be4175b33a4bf461dc9868702ef953e13911c4b6795"

URI_aarch64_rust-coreutils+feat_require_unix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_require_unix-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_require_unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_require_unix-devel}"
SRC_URI[aarch64_rust-coreutils+feat_require_unix-devel.sha256sum] = "68da8252945e8a02d73f5bdf41055c54c5d3f6a3f7910d8e5041f1eeac8ab738"

URI_aarch64_rust-coreutils+feat_require_unix_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_require_unix_core-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_require_unix_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_require_unix_core-devel}"
SRC_URI[aarch64_rust-coreutils+feat_require_unix_core-devel.sha256sum] = "df8dd6374e0c685072730208b9e15a65fc6e8e7511bfc9b63ca6b5013875045a"

URI_aarch64_rust-coreutils+feat_require_unix_hostid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_require_unix_hostid-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_require_unix_hostid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_require_unix_hostid-devel}"
SRC_URI[aarch64_rust-coreutils+feat_require_unix_hostid-devel.sha256sum] = "995e9c1c6ea9c815f78aaac1d45b1bd0cba20fb29cdba0b23f12244bac2a592d"

URI_aarch64_rust-coreutils+feat_require_unix_musl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_require_unix_musl-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_require_unix_musl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_require_unix_musl-devel}"
SRC_URI[aarch64_rust-coreutils+feat_require_unix_musl-devel.sha256sum] = "77ab16e8ad5e2cf8b1ff2e0c96db3e1cfef3369c12b8d8b78dac03ab28102991"

URI_aarch64_rust-coreutils+feat_require_unix_utmpx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_require_unix_utmpx-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_require_unix_utmpx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_require_unix_utmpx-devel}"
SRC_URI[aarch64_rust-coreutils+feat_require_unix_utmpx-devel.sha256sum] = "aa066a2b2faa4f593be013790d3b39f0c7ccf7059ed57ccb96b6eeebc71f02c2"

URI_aarch64_rust-coreutils+feat_selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_selinux-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_selinux-devel}"
SRC_URI[aarch64_rust-coreutils+feat_selinux-devel.sha256sum] = "8e12db5867d5790ef283f23c1129806acd60924f02569fde0ecf78e2466242e9"

URI_aarch64_rust-coreutils+feat_smack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_smack-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_smack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_smack-devel}"
SRC_URI[aarch64_rust-coreutils+feat_smack-devel.sha256sum] = "a14824663e6951bb824b970e714fbb2e8e3e71c6d3418b3243e8421a5f1f2f8c"

URI_aarch64_rust-coreutils+feat_systemd_logind-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_systemd_logind-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_systemd_logind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_systemd_logind-devel}"
SRC_URI[aarch64_rust-coreutils+feat_systemd_logind-devel.sha256sum] = "14566b5d9daa6b54a8accc52d04ad87c6c1386406fcb0eba4b555de2d5dcff9e"

URI_aarch64_rust-coreutils+feat_wasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+feat_wasm-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+feat_wasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+feat_wasm-devel}"
SRC_URI[aarch64_rust-coreutils+feat_wasm-devel.sha256sum] = "debeb759999c0551b594d9917c93eb986848473491285349b7feac552713dc62"

URI_aarch64_rust-coreutils+fmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+fmt-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+fmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+fmt-devel}"
SRC_URI[aarch64_rust-coreutils+fmt-devel.sha256sum] = "c23f46fb30e363684c44f1c8a830ef4a1092bccefea98baff535bd9fe7c68e47"

URI_aarch64_rust-coreutils+fold-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+fold-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+fold-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+fold-devel}"
SRC_URI[aarch64_rust-coreutils+fold-devel.sha256sum] = "0fa43ba00e54bd2e7e86254099bae80d9e45011863fce6ce763a2e0b63e6d519"

URI_aarch64_rust-coreutils+groups-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+groups-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+groups-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+groups-devel}"
SRC_URI[aarch64_rust-coreutils+groups-devel.sha256sum] = "8c1907ecfa584020e99448ba21d70836affd589de8557765b8c40bab85ec5eec"

URI_aarch64_rust-coreutils+head-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+head-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+head-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+head-devel}"
SRC_URI[aarch64_rust-coreutils+head-devel.sha256sum] = "d5972c202b804bc3ee4de6d5aecbbb28843fe1526d544b8a3938cbc530cac834"

URI_aarch64_rust-coreutils+hostid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+hostid-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+hostid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+hostid-devel}"
SRC_URI[aarch64_rust-coreutils+hostid-devel.sha256sum] = "a855aca4f910f8195b506169cfded8bfa3d3115cb3df97bfcc11c74b2448cde8"

URI_aarch64_rust-coreutils+hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+hostname-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+hostname-devel}"
SRC_URI[aarch64_rust-coreutils+hostname-devel.sha256sum] = "52d3fcdabcab92d9f73b6647903016366bb7037ceecf3b44164db4b6a2765e66"

URI_aarch64_rust-coreutils+id-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+id-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+id-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+id-devel}"
SRC_URI[aarch64_rust-coreutils+id-devel.sha256sum] = "a60f4e657a1915de7539c6d6cb622e754dfaba406f7228dced15f26214408f89"

URI_aarch64_rust-coreutils+install-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+install-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+install-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+install-devel}"
SRC_URI[aarch64_rust-coreutils+install-devel.sha256sum] = "04ec42a085fcafef9a8cd5fcc82aca6c42c1facebdedce0ba3a7e180f202301c"

URI_aarch64_rust-coreutils+join-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+join-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+join-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+join-devel}"
SRC_URI[aarch64_rust-coreutils+join-devel.sha256sum] = "3bc04e0399f60dd995f4f69c954631b487595b94c558d74367d5f9c01d80f320"

URI_aarch64_rust-coreutils+kill-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+kill-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+kill-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+kill-devel}"
SRC_URI[aarch64_rust-coreutils+kill-devel.sha256sum] = "440843bef1157f935239e9266bba2cefd9da0ea16aa23594679e28a0a27cdcce"

URI_aarch64_rust-coreutils+link-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+link-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+link-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+link-devel}"
SRC_URI[aarch64_rust-coreutils+link-devel.sha256sum] = "4386a2f9b9d912d420618a53259f29774f258e78c4ecfe6e6246cfc8ef6367d1"

URI_aarch64_rust-coreutils+ln-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+ln-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+ln-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+ln-devel}"
SRC_URI[aarch64_rust-coreutils+ln-devel.sha256sum] = "c5736ce25d3fbb8059de5c64de1a80f1d68004be4762adb851be4868a24ee204"

URI_aarch64_rust-coreutils+logname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+logname-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+logname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+logname-devel}"
SRC_URI[aarch64_rust-coreutils+logname-devel.sha256sum] = "b785cbbb101773b7c1b0538eab1296c96f09fd5dc0300fa4ff95ccdb3982596e"

URI_aarch64_rust-coreutils+ls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+ls-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+ls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+ls-devel}"
SRC_URI[aarch64_rust-coreutils+ls-devel.sha256sum] = "8362a713725befadbd66745cdb63dda1f7db1e291ea21b96957ddda8a4615622"

URI_aarch64_rust-coreutils+macos-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+macos-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+macos-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+macos-devel}"
SRC_URI[aarch64_rust-coreutils+macos-devel.sha256sum] = "20dbee7da07544b4e391d8e6f2bc89592cc5848486e1b4b1c0ef6c8ce1ad53a5"

URI_aarch64_rust-coreutils+md5sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+md5sum-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+md5sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+md5sum-devel}"
SRC_URI[aarch64_rust-coreutils+md5sum-devel.sha256sum] = "77337ede123b1d7721901bf6da65302d1f34e19f48b2d43c5a2d851f1900bc99"

URI_aarch64_rust-coreutils+mkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+mkdir-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+mkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+mkdir-devel}"
SRC_URI[aarch64_rust-coreutils+mkdir-devel.sha256sum] = "326ebfb7b41a6d3ef27be48968283f1ce636e49aafa1ecef383480df3e430038"

URI_aarch64_rust-coreutils+mkfifo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+mkfifo-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+mkfifo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+mkfifo-devel}"
SRC_URI[aarch64_rust-coreutils+mkfifo-devel.sha256sum] = "b3536e3c5631db5c475922ed4fb78a96d27f5fba93ecdded1c8f59d8ef0a184d"

URI_aarch64_rust-coreutils+mknod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+mknod-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+mknod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+mknod-devel}"
SRC_URI[aarch64_rust-coreutils+mknod-devel.sha256sum] = "f2277ad8ffd193eace6d8cfb46e1dce5435c1b53c1a7955a6e9b47c676857be4"

URI_aarch64_rust-coreutils+mktemp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+mktemp-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+mktemp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+mktemp-devel}"
SRC_URI[aarch64_rust-coreutils+mktemp-devel.sha256sum] = "846517ff68e44ad3473877522756fcd42d02db998c61642d6a9b116b80b96415"

URI_aarch64_rust-coreutils+more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+more-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+more-devel}"
SRC_URI[aarch64_rust-coreutils+more-devel.sha256sum] = "204ccbfe9df5b61c3169eb74161f4d4484defc6642e58a5ffcbeabc72e40634c"

URI_aarch64_rust-coreutils+mv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+mv-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+mv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+mv-devel}"
SRC_URI[aarch64_rust-coreutils+mv-devel.sha256sum] = "2242c1e876685d148fd2dccb71f69609ee2c701b4ac729ef92b19cb1eae3bc93"

URI_aarch64_rust-coreutils+nice-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+nice-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+nice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+nice-devel}"
SRC_URI[aarch64_rust-coreutils+nice-devel.sha256sum] = "4b5f929d96e3e57663f4d1b4ef872fa100c992521455f370c076de8044407daa"

URI_aarch64_rust-coreutils+nl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+nl-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+nl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+nl-devel}"
SRC_URI[aarch64_rust-coreutils+nl-devel.sha256sum] = "877644ac4490bae94fe0248046252a9cfe55cb08026d5b39af6d55b1c907c82c"

URI_aarch64_rust-coreutils+nohup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+nohup-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+nohup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+nohup-devel}"
SRC_URI[aarch64_rust-coreutils+nohup-devel.sha256sum] = "ff2d3c15db5d8535ade346a3fb7d957c8ca876904c7b6c4f14ab1ddeb6735d73"

URI_aarch64_rust-coreutils+nproc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+nproc-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+nproc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+nproc-devel}"
SRC_URI[aarch64_rust-coreutils+nproc-devel.sha256sum] = "c08942859550786830f5e9883f5ee2e136c7d294015021c590f608fcbd72f187"

URI_aarch64_rust-coreutils+numfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+numfmt-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+numfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+numfmt-devel}"
SRC_URI[aarch64_rust-coreutils+numfmt-devel.sha256sum] = "707edd5774af72162415a3fcad512a414ce4ce8c453c43a0b05aaebb1f51f1b6"

URI_aarch64_rust-coreutils+od-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+od-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+od-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+od-devel}"
SRC_URI[aarch64_rust-coreutils+od-devel.sha256sum] = "43397ea74e6f0a49c9bf7c64060edfa8dad8c3b6bd5503dddb76441cc3800bb9"

URI_aarch64_rust-coreutils+paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+paste-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+paste-devel}"
SRC_URI[aarch64_rust-coreutils+paste-devel.sha256sum] = "67a4c3f55af840dab78507a302eacf3fc6fac138850ecf7d74d64e2b6e6687a0"

URI_aarch64_rust-coreutils+pathchk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+pathchk-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+pathchk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+pathchk-devel}"
SRC_URI[aarch64_rust-coreutils+pathchk-devel.sha256sum] = "709df35d94a780356ae029a592d17d427b8e6199b036716d066982596e12ca99"

URI_aarch64_rust-coreutils+pinky-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+pinky-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+pinky-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+pinky-devel}"
SRC_URI[aarch64_rust-coreutils+pinky-devel.sha256sum] = "e4b96bd17c399ace5828f223d231e42bba1adb6b25eaa2df273f585865869e3a"

URI_aarch64_rust-coreutils+pr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+pr-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+pr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+pr-devel}"
SRC_URI[aarch64_rust-coreutils+pr-devel.sha256sum] = "7906897209055f6be3ec4a7c529ae2e6656b60bf2cc3d8de6fbc59f0191668e6"

URI_aarch64_rust-coreutils+printenv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+printenv-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+printenv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+printenv-devel}"
SRC_URI[aarch64_rust-coreutils+printenv-devel.sha256sum] = "9d4dd8677d0ecfa3e4726c2ff65c47b96e4ac8459519bd537276e1ea65b11f4a"

URI_aarch64_rust-coreutils+printf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+printf-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+printf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+printf-devel}"
SRC_URI[aarch64_rust-coreutils+printf-devel.sha256sum] = "cbd8311c075914f4173abb69915e7b85d1fcc4d9c608b0a2066e817212ac64de"

URI_aarch64_rust-coreutils+ptx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+ptx-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+ptx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+ptx-devel}"
SRC_URI[aarch64_rust-coreutils+ptx-devel.sha256sum] = "68d8e664faeb178fbef4d8341a0fe32629cfb67793b8bbe862103b367d90b40a"

URI_aarch64_rust-coreutils+pwd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+pwd-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+pwd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+pwd-devel}"
SRC_URI[aarch64_rust-coreutils+pwd-devel.sha256sum] = "6c940fbfbe47ef2c6c9e94daecba05caa581b239d9a561395e33ed6824ff1c2d"

URI_aarch64_rust-coreutils+readlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+readlink-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+readlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+readlink-devel}"
SRC_URI[aarch64_rust-coreutils+readlink-devel.sha256sum] = "5f7f225785a6e80e370535f63d5188f51fcfa2a452c4f06004311a2aad4fc6d5"

URI_aarch64_rust-coreutils+realpath-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+realpath-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+realpath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+realpath-devel}"
SRC_URI[aarch64_rust-coreutils+realpath-devel.sha256sum] = "76e2c68312ce64defb7512612f131b42904150fe839ab7185bff56654a466f7b"

URI_aarch64_rust-coreutils+rm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+rm-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+rm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+rm-devel}"
SRC_URI[aarch64_rust-coreutils+rm-devel.sha256sum] = "3e970aeb37a6d0eb17701be45fa5091c0f39ded6f112eb327564c063165056a1"

URI_aarch64_rust-coreutils+rmdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+rmdir-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+rmdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+rmdir-devel}"
SRC_URI[aarch64_rust-coreutils+rmdir-devel.sha256sum] = "e8f4561e43025c6ef3f561b7e5f0655d2e990b77bc4e5036f611470a9f93b80e"

URI_aarch64_rust-coreutils+runcon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+runcon-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+runcon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+runcon-devel}"
SRC_URI[aarch64_rust-coreutils+runcon-devel.sha256sum] = "b5213dcd9cb65a72e3d707512edde7368fac62bb83adea00cc52bf6944703a13"

URI_aarch64_rust-coreutils+selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+selinux-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+selinux-devel}"
SRC_URI[aarch64_rust-coreutils+selinux-devel.sha256sum] = "e10e77b4be2d9e49f1845783b322e60caeb75354a5334b6b37e382e9b1bdc7bd"

URI_aarch64_rust-coreutils+seq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+seq-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+seq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+seq-devel}"
SRC_URI[aarch64_rust-coreutils+seq-devel.sha256sum] = "c1686f9a7f24a2b647dc3034de0a8839f19d3fb578a96db7d0f42b4537029399"

URI_aarch64_rust-coreutils+sha1sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+sha1sum-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+sha1sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+sha1sum-devel}"
SRC_URI[aarch64_rust-coreutils+sha1sum-devel.sha256sum] = "69fa363de6a465379de0d485d1a1c220860c6d2632278dfcdb3da0be23beeb1e"

URI_aarch64_rust-coreutils+sha224sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+sha224sum-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+sha224sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+sha224sum-devel}"
SRC_URI[aarch64_rust-coreutils+sha224sum-devel.sha256sum] = "2b359aaee2b9723ab62c33063f8a847dfc9472d32465591c16dd5f4b8381c1cb"

URI_aarch64_rust-coreutils+sha256sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+sha256sum-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+sha256sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+sha256sum-devel}"
SRC_URI[aarch64_rust-coreutils+sha256sum-devel.sha256sum] = "1b9f3236e5759dbb5c26edd0f52f66ed40158d880d0b3d5cbd223d27c30f0bb5"

URI_aarch64_rust-coreutils+sha384sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+sha384sum-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+sha384sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+sha384sum-devel}"
SRC_URI[aarch64_rust-coreutils+sha384sum-devel.sha256sum] = "e39678d870173340d14979fb001146c471667e76e9e3d3e169d241acf454f2ae"

URI_aarch64_rust-coreutils+sha512sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+sha512sum-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+sha512sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+sha512sum-devel}"
SRC_URI[aarch64_rust-coreutils+sha512sum-devel.sha256sum] = "63f7e726896bb35a0283afb4a5273933b43681248702ebe16ca1e0e8b588a196"

URI_aarch64_rust-coreutils+shred-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+shred-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+shred-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+shred-devel}"
SRC_URI[aarch64_rust-coreutils+shred-devel.sha256sum] = "d78dce313e00b91dfd96e65d83cb36a0458036ce6a6847684ee9fcb560c4edfb"

URI_aarch64_rust-coreutils+shuf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+shuf-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+shuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+shuf-devel}"
SRC_URI[aarch64_rust-coreutils+shuf-devel.sha256sum] = "3017753af3f398a4c9d4ead83c12c079483909e3c46c51262ccfb2307df75484"

URI_aarch64_rust-coreutils+sleep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+sleep-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+sleep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+sleep-devel}"
SRC_URI[aarch64_rust-coreutils+sleep-devel.sha256sum] = "b2b717ca1f9098cf3b477cc82f59b6163bb363fb5a3e2c976858fcb5c86cacec"

URI_aarch64_rust-coreutils+sort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+sort-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+sort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+sort-devel}"
SRC_URI[aarch64_rust-coreutils+sort-devel.sha256sum] = "d501fa19e99454f2a006948f5ebb5a1f97781c2f8d6254ab39eb43e6dac00957"

URI_aarch64_rust-coreutils+split-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+split-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+split-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+split-devel}"
SRC_URI[aarch64_rust-coreutils+split-devel.sha256sum] = "26e5048bcbeff8c28a341f4c150257e2611c5e45ffa940548912c10448bbe27d"

URI_aarch64_rust-coreutils+stat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+stat-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+stat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+stat-devel}"
SRC_URI[aarch64_rust-coreutils+stat-devel.sha256sum] = "a0e7d24c95d9b944b6e6a44db2435610dd170b0f2ad03bb5f5678007c7fc78d8"

URI_aarch64_rust-coreutils+stdbuf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+stdbuf-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+stdbuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+stdbuf-devel}"
SRC_URI[aarch64_rust-coreutils+stdbuf-devel.sha256sum] = "b18264646318dfad1b3137b48a197de41480ce6d4b9eaf610df540d0a64ae8e8"

URI_aarch64_rust-coreutils+stty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+stty-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+stty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+stty-devel}"
SRC_URI[aarch64_rust-coreutils+stty-devel.sha256sum] = "6425d53b17ecb154f231b48f91d9105536e277eb37e6bc5e66b71457efec6a41"

URI_aarch64_rust-coreutils+sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+sum-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+sum-devel}"
SRC_URI[aarch64_rust-coreutils+sum-devel.sha256sum] = "9b4144fc4df9b9e61ed868772e03e354269abd82a8d9f9cdf04c452c5488b49d"

URI_aarch64_rust-coreutils+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+sync-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+sync-devel}"
SRC_URI[aarch64_rust-coreutils+sync-devel.sha256sum] = "cd53c838a998a61cf55785d128684485fd42a5b8f11c635b879eea5e8d2bf0eb"

URI_aarch64_rust-coreutils+tac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+tac-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+tac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+tac-devel}"
SRC_URI[aarch64_rust-coreutils+tac-devel.sha256sum] = "bc50253b6da57a457291d6bbef90f16a499f87aed06541191f4471cc531df842"

URI_aarch64_rust-coreutils+tail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+tail-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+tail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+tail-devel}"
SRC_URI[aarch64_rust-coreutils+tail-devel.sha256sum] = "010f6e529873ad0a4ff7f40305e009f07f7c5efe77fa625c45b3719e183c41da"

URI_aarch64_rust-coreutils+tee-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+tee-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+tee-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+tee-devel}"
SRC_URI[aarch64_rust-coreutils+tee-devel.sha256sum] = "b5ddc3ce2549826fb2e5c26d9e7d2ebe7a80924f6b9e1fceceb4184da55ce720"

URI_aarch64_rust-coreutils+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+test-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+test-devel}"
SRC_URI[aarch64_rust-coreutils+test-devel.sha256sum] = "cd0f318d21fa8851cf413b72371c49377a737005560117903f56231f8b94aed9"

URI_aarch64_rust-coreutils+test_risky_names-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+test_risky_names-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+test_risky_names-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+test_risky_names-devel}"
SRC_URI[aarch64_rust-coreutils+test_risky_names-devel.sha256sum] = "8ecf8135c686a9e34a6e84569d420a35ab73ba06b90663ff3881ab45e0c91c5f"

URI_aarch64_rust-coreutils+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+timeout-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+timeout-devel}"
SRC_URI[aarch64_rust-coreutils+timeout-devel.sha256sum] = "c65bb030891becb7ef3fdbc3b9b6854790d273e62bc4a9146aa68074eaccd6b7"

URI_aarch64_rust-coreutils+touch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+touch-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+touch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+touch-devel}"
SRC_URI[aarch64_rust-coreutils+touch-devel.sha256sum] = "5875743961364343d7f5c2790f741b2c73fe196b4ea0bd125d32b999e8aba891"

URI_aarch64_rust-coreutils+tr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+tr-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+tr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+tr-devel}"
SRC_URI[aarch64_rust-coreutils+tr-devel.sha256sum] = "6661271d4f6b42859c7a981254c9326fb1373b6e874d7777b9a90de3be3338c5"

URI_aarch64_rust-coreutils+true-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+true-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+true-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+true-devel}"
SRC_URI[aarch64_rust-coreutils+true-devel.sha256sum] = "ae16bb5c8352897bd338a9839b30617f4b1a0f35fb18a9d0d7e89c2f6e7757c2"

URI_aarch64_rust-coreutils+truncate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+truncate-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+truncate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+truncate-devel}"
SRC_URI[aarch64_rust-coreutils+truncate-devel.sha256sum] = "e8eb3f8601609b71a98af1cefd8fdcc02b1f57c82a321bf070c0e285d28d9b0b"

URI_aarch64_rust-coreutils+tsort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+tsort-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+tsort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+tsort-devel}"
SRC_URI[aarch64_rust-coreutils+tsort-devel.sha256sum] = "5b5e09a9742dbb544ec2d741d47ee2a2cdd0ec0a705919945cd42a102fdeab19"

URI_aarch64_rust-coreutils+tty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+tty-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+tty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+tty-devel}"
SRC_URI[aarch64_rust-coreutils+tty-devel.sha256sum] = "aac997a538f5f1270684a81c61d99fd3b3b2374e84ec83bc6002b417bcf6c115"

URI_aarch64_rust-coreutils+uname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+uname-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+uname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+uname-devel}"
SRC_URI[aarch64_rust-coreutils+uname-devel.sha256sum] = "138db16e4730e655b281035cbe617fc5e0837010f843198a3290a8e5ee2306e3"

URI_aarch64_rust-coreutils+unexpand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+unexpand-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+unexpand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+unexpand-devel}"
SRC_URI[aarch64_rust-coreutils+unexpand-devel.sha256sum] = "18a4b2439842899c90a3c70089b427fa72e843ba2980e4dac7f03bbc43031c31"

URI_aarch64_rust-coreutils+uniq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+uniq-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+uniq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+uniq-devel}"
SRC_URI[aarch64_rust-coreutils+uniq-devel.sha256sum] = "68d52896dabde9813900a75b848a274d7531dbdefb0f552ade779c3e00f29f45"

URI_aarch64_rust-coreutils+unix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+unix-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+unix-devel}"
SRC_URI[aarch64_rust-coreutils+unix-devel.sha256sum] = "8dab501dea7825ce15ccea17feb95383b56e3d1d948c686b6491f2c87f31db06"

URI_aarch64_rust-coreutils+unlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+unlink-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+unlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+unlink-devel}"
SRC_URI[aarch64_rust-coreutils+unlink-devel.sha256sum] = "dd7cdc3d4ad7d5ef10ea52b07ee6229283fd943aa6b879934e022ee027882ca0"

URI_aarch64_rust-coreutils+uptime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+uptime-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+uptime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+uptime-devel}"
SRC_URI[aarch64_rust-coreutils+uptime-devel.sha256sum] = "046f9a362f26c8f7bb75253276e86008b9a16cf85612eb6ebff2d0c0abb2c0fe"

URI_aarch64_rust-coreutils+users-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+users-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+users-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+users-devel}"
SRC_URI[aarch64_rust-coreutils+users-devel.sha256sum] = "9da6ab52e2b53ff50af901d0124e34a762151a960f862d9c0042b773efe15ffc"

URI_aarch64_rust-coreutils+uu_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+uu_test-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+uu_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+uu_test-devel}"
SRC_URI[aarch64_rust-coreutils+uu_test-devel.sha256sum] = "fc4dc4b5f69cf7248969bea271f631a224fc481e158a0022f5f8e1bc67315302"

URI_aarch64_rust-coreutils+uudoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+uudoc-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+uudoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+uudoc-devel}"
SRC_URI[aarch64_rust-coreutils+uudoc-devel.sha256sum] = "1ccf92136bd24f9e825ce8c66698527b80c3fbb010ed821b7e15f4e4b4e8add5"

URI_aarch64_rust-coreutils+vdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+vdir-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+vdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+vdir-devel}"
SRC_URI[aarch64_rust-coreutils+vdir-devel.sha256sum] = "9bb31511f68da3aec2c2174c56f9110ced9b258cf42c67ea42c8a10e73c0488b"

URI_aarch64_rust-coreutils+wc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+wc-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+wc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+wc-devel}"
SRC_URI[aarch64_rust-coreutils+wc-devel.sha256sum] = "9b3ef407be11712d63d1f493633b60d6afafb8c4a43bcba2e660f1b49057eb36"

URI_aarch64_rust-coreutils+who-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+who-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+who-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+who-devel}"
SRC_URI[aarch64_rust-coreutils+who-devel.sha256sum] = "9ff2dfd2f555c4f20e6c6def1d8a8d670adea30ec8b54441f0677c9f4ea1f022"

URI_aarch64_rust-coreutils+whoami-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+whoami-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+whoami-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+whoami-devel}"
SRC_URI[aarch64_rust-coreutils+whoami-devel.sha256sum] = "943d45200962ebd4614836854ddf84924c78715ef4ad3a25f033548e317ee861"

URI_aarch64_rust-coreutils+windows-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+windows-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+windows-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+windows-devel}"
SRC_URI[aarch64_rust-coreutils+windows-devel.sha256sum] = "b0d5a65b72bcbfdc655e9f7877c875d9442c43106cd21b81b50b363107294ba1"

URI_aarch64_rust-coreutils+yes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils+yes-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils+yes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils+yes-devel}"
SRC_URI[aarch64_rust-coreutils+yes-devel.sha256sum] = "978cef5075ce85f12d98e3af20d705d54b93a8d6359378448591468f3d3e3977"

URI_aarch64_rust-coreutils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-coreutils-devel-0.7.0-10.el10_3.noarch.rpm;name=aarch64_rust-coreutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-coreutils-devel}"
SRC_URI[aarch64_rust-coreutils-devel.sha256sum] = "fd199a0a4ef471aea142585c93b4858cfef17f443ebbc3ae7a40c4d3e11a75e9"

URI_aarch64_uutils-coreutils = "${EPEL_MIRROR}/aarch64/Packages/u/uutils-coreutils-0.7.0-10.el10_3.aarch64.rpm;name=aarch64_uutils-coreutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_uutils-coreutils}"
SRC_URI[aarch64_uutils-coreutils.sha256sum] = "fd432b2bf3ba0c5aadae7fe92e01419439e355c55d5e464fce6886bbd1aef6ea"

RDEPENDS:rust-coreutils+arch-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_arch+default-devel \
 "
RDEPENDS:rust-coreutils+b2sum-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_b2sum+default-devel \
 "
RDEPENDS:rust-coreutils+base32-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_base32+default-devel \
 "
RDEPENDS:rust-coreutils+base64-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_base64+default-devel \
 "
RDEPENDS:rust-coreutils+basename-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_basename+default-devel \
 "
RDEPENDS:rust-coreutils+basenc-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_basenc+default-devel \
 "
RDEPENDS:rust-coreutils+cat-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_cat+default-devel \
 "
RDEPENDS:rust-coreutils+chcon-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_chcon+default-devel \
 "
RDEPENDS:rust-coreutils+chgrp-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_chgrp+default-devel \
 "
RDEPENDS:rust-coreutils+chmod-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_chmod+default-devel \
 "
RDEPENDS:rust-coreutils+chown-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_chown+default-devel \
 "
RDEPENDS:rust-coreutils+chroot-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_chroot+default-devel \
 "
RDEPENDS:rust-coreutils+cksum-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_cksum+default-devel \
 "
RDEPENDS:rust-coreutils+comm-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_comm+default-devel \
 "
RDEPENDS:rust-coreutils+cp-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_cp+default-devel \
 "
RDEPENDS:rust-coreutils+csplit-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_csplit+default-devel \
 "
RDEPENDS:rust-coreutils+cut-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_cut+default-devel \
 "
RDEPENDS:rust-coreutils+date-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_date+default-devel \
 "
RDEPENDS:rust-coreutils+dd-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_dd+default-devel \
 "
RDEPENDS:rust-coreutils+default-devel = " \
 cargo \
 rust-coreutils+feat_common_core-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+df-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_df+default-devel \
 "
RDEPENDS:rust-coreutils+dir-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_dir+default-devel \
 "
RDEPENDS:rust-coreutils+dircolors-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_dircolors+default-devel \
 "
RDEPENDS:rust-coreutils+dirname-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_dirname+default-devel \
 "
RDEPENDS:rust-coreutils+du-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_du+default-devel \
 "
RDEPENDS:rust-coreutils+echo-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_echo+default-devel \
 "
RDEPENDS:rust-coreutils+env-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_env+default-devel \
 "
RDEPENDS:rust-coreutils+expand-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_expand+default-devel \
 "
RDEPENDS:rust-coreutils+expensive_tests-devel = " \
 cargo \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+expr-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_expr+default-devel \
 "
RDEPENDS:rust-coreutils+factor-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_factor+default-devel \
 "
RDEPENDS:rust-coreutils+false-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_false+default-devel \
 "
RDEPENDS:rust-coreutils+feat_Tier1-devel = " \
 cargo \
 rust-coreutils+arch-devel \
 rust-coreutils+feat_common_core-devel \
 rust-coreutils+hostname-devel \
 rust-coreutils+nproc-devel \
 rust-coreutils+sync-devel \
 rust-coreutils+uname-devel \
 rust-coreutils+whoami-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_acl-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_cp+default-devel \
 rust-uu_cp+feat_acl-devel \
 "
RDEPENDS:rust-coreutils+feat_common_core-devel = " \
 cargo \
 rust-coreutils+b2sum-devel \
 rust-coreutils+base32-devel \
 rust-coreutils+base64-devel \
 rust-coreutils+basename-devel \
 rust-coreutils+basenc-devel \
 rust-coreutils+cat-devel \
 rust-coreutils+cksum-devel \
 rust-coreutils+comm-devel \
 rust-coreutils+cp-devel \
 rust-coreutils+csplit-devel \
 rust-coreutils+cut-devel \
 rust-coreutils+date-devel \
 rust-coreutils+dd-devel \
 rust-coreutils+df-devel \
 rust-coreutils+dir-devel \
 rust-coreutils+dircolors-devel \
 rust-coreutils+dirname-devel \
 rust-coreutils+du-devel \
 rust-coreutils+echo-devel \
 rust-coreutils+env-devel \
 rust-coreutils+expand-devel \
 rust-coreutils+expr-devel \
 rust-coreutils+factor-devel \
 rust-coreutils+false-devel \
 rust-coreutils+fmt-devel \
 rust-coreutils+fold-devel \
 rust-coreutils+head-devel \
 rust-coreutils+join-devel \
 rust-coreutils+link-devel \
 rust-coreutils+ln-devel \
 rust-coreutils+ls-devel \
 rust-coreutils+md5sum-devel \
 rust-coreutils+mkdir-devel \
 rust-coreutils+mktemp-devel \
 rust-coreutils+more-devel \
 rust-coreutils+mv-devel \
 rust-coreutils+nl-devel \
 rust-coreutils+numfmt-devel \
 rust-coreutils+od-devel \
 rust-coreutils+paste-devel \
 rust-coreutils+pr-devel \
 rust-coreutils+printenv-devel \
 rust-coreutils+printf-devel \
 rust-coreutils+ptx-devel \
 rust-coreutils+pwd-devel \
 rust-coreutils+readlink-devel \
 rust-coreutils+realpath-devel \
 rust-coreutils+rm-devel \
 rust-coreutils+rmdir-devel \
 rust-coreutils+seq-devel \
 rust-coreutils+sha1sum-devel \
 rust-coreutils+sha224sum-devel \
 rust-coreutils+sha256sum-devel \
 rust-coreutils+sha384sum-devel \
 rust-coreutils+sha512sum-devel \
 rust-coreutils+shred-devel \
 rust-coreutils+shuf-devel \
 rust-coreutils+sleep-devel \
 rust-coreutils+sort-devel \
 rust-coreutils+split-devel \
 rust-coreutils+sum-devel \
 rust-coreutils+tac-devel \
 rust-coreutils+tail-devel \
 rust-coreutils+tee-devel \
 rust-coreutils+test-devel \
 rust-coreutils+touch-devel \
 rust-coreutils+tr-devel \
 rust-coreutils+true-devel \
 rust-coreutils+truncate-devel \
 rust-coreutils+tsort-devel \
 rust-coreutils+unexpand-devel \
 rust-coreutils+uniq-devel \
 rust-coreutils+unlink-devel \
 rust-coreutils+vdir-devel \
 rust-coreutils+wc-devel \
 rust-coreutils+yes-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_external_libstdbuf-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_stdbuf+default-devel \
 rust-uu_stdbuf+feat_external_libstdbuf-devel \
 "
RDEPENDS:rust-coreutils+feat_os_macos-devel = " \
 cargo \
 rust-coreutils+feat_os_unix-devel \
 rust-coreutils+feat_require_unix_hostid-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_os_unix-devel = " \
 cargo \
 rust-coreutils+feat_Tier1-devel \
 rust-coreutils+feat_require_unix-devel \
 rust-coreutils+feat_require_unix_hostid-devel \
 rust-coreutils+feat_require_unix_utmpx-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_os_unix_android-devel = " \
 cargo \
 rust-coreutils+feat_Tier1-devel \
 rust-coreutils+feat_require_unix-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_os_unix_fuchsia-devel = " \
 cargo \
 rust-coreutils+chgrp-devel \
 rust-coreutils+chmod-devel \
 rust-coreutils+chown-devel \
 rust-coreutils+du-devel \
 rust-coreutils+feat_common_core-devel \
 rust-coreutils+groups-devel \
 rust-coreutils+hostid-devel \
 rust-coreutils+install-devel \
 rust-coreutils+logname-devel \
 rust-coreutils+mkfifo-devel \
 rust-coreutils+mknod-devel \
 rust-coreutils+nice-devel \
 rust-coreutils+pathchk-devel \
 rust-coreutils+tty-devel \
 rust-coreutils+uname-devel \
 rust-coreutils+unlink-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_os_unix_gnueabihf-devel = " \
 cargo \
 rust-coreutils+feat_Tier1-devel \
 rust-coreutils+feat_require_unix-devel \
 rust-coreutils+feat_require_unix_hostid-devel \
 rust-coreutils+feat_require_unix_utmpx-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_os_unix_musl-devel = " \
 cargo \
 rust-coreutils+feat_Tier1-devel \
 rust-coreutils+feat_require_unix_hostid-devel \
 rust-coreutils+feat_require_unix_musl-devel \
 rust-coreutils+feat_require_unix_utmpx-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_os_unix_redox-devel = " \
 cargo \
 rust-coreutils+chmod-devel \
 rust-coreutils+feat_common_core-devel \
 rust-coreutils+stat-devel \
 rust-coreutils+uname-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_os_windows-devel = " \
 cargo \
 rust-coreutils+feat_Tier1-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_os_windows_legacy-devel = " \
 cargo \
 rust-coreutils+arch-devel \
 rust-coreutils+feat_common_core-devel \
 rust-coreutils+nproc-devel \
 rust-coreutils+sync-devel \
 rust-coreutils+whoami-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_require_selinux-devel = " \
 cargo \
 rust-coreutils+chcon-devel \
 rust-coreutils+runcon-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_require_unix-devel = " \
 cargo \
 rust-coreutils+feat_require_unix_core-devel \
 rust-coreutils+stdbuf-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_require_unix_core-devel = " \
 cargo \
 rust-coreutils+chgrp-devel \
 rust-coreutils+chmod-devel \
 rust-coreutils+chown-devel \
 rust-coreutils+chroot-devel \
 rust-coreutils+groups-devel \
 rust-coreutils+id-devel \
 rust-coreutils+install-devel \
 rust-coreutils+kill-devel \
 rust-coreutils+logname-devel \
 rust-coreutils+mkfifo-devel \
 rust-coreutils+mknod-devel \
 rust-coreutils+nice-devel \
 rust-coreutils+nohup-devel \
 rust-coreutils+pathchk-devel \
 rust-coreutils+stat-devel \
 rust-coreutils+stty-devel \
 rust-coreutils+timeout-devel \
 rust-coreutils+tty-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_require_unix_hostid-devel = " \
 cargo \
 rust-coreutils+hostid-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_require_unix_musl-devel = " \
 cargo \
 rust-coreutils+feat_require_unix_core-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_require_unix_utmpx-devel = " \
 cargo \
 rust-coreutils+pinky-devel \
 rust-coreutils+uptime-devel \
 rust-coreutils+users-devel \
 rust-coreutils+who-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+feat_selinux-devel = " \
 cargo \
 rust-coreutils+feat_require_selinux-devel \
 rust-coreutils+selinux-devel \
 rust-coreutils-devel \
 rust-uu_cp+default-devel \
 rust-uu_cp+selinux-devel \
 rust-uu_id+default-devel \
 rust-uu_id+selinux-devel \
 rust-uu_install+default-devel \
 rust-uu_install+selinux-devel \
 rust-uu_ls+default-devel \
 rust-uu_ls+selinux-devel \
 rust-uu_mkdir+default-devel \
 rust-uu_mkdir+selinux-devel \
 rust-uu_mkfifo+default-devel \
 rust-uu_mkfifo+selinux-devel \
 rust-uu_mknod+default-devel \
 rust-uu_mknod+selinux-devel \
 rust-uu_stat+default-devel \
 rust-uu_stat+selinux-devel \
 "
RDEPENDS:rust-coreutils+feat_smack-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_id+default-devel \
 rust-uu_id+smack-devel \
 rust-uu_ls+default-devel \
 rust-uu_ls+smack-devel \
 rust-uu_mkdir+default-devel \
 rust-uu_mkdir+smack-devel \
 rust-uu_mkfifo+default-devel \
 rust-uu_mkfifo+smack-devel \
 rust-uu_mknod+default-devel \
 rust-uu_mknod+smack-devel \
 "
RDEPENDS:rust-coreutils+feat_systemd_logind-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_pinky+default-devel \
 rust-uu_pinky+feat_systemd_logind-devel \
 rust-uu_uptime+default-devel \
 rust-uu_uptime+feat_systemd_logind-devel \
 rust-uu_users+default-devel \
 rust-uu_users+feat_systemd_logind-devel \
 rust-uu_who+default-devel \
 rust-uu_who+feat_systemd_logind-devel \
 rust-uucore+feat_systemd_logind-devel \
 "
RDEPENDS:rust-coreutils+feat_wasm-devel = " \
 cargo \
 rust-coreutils+arch-devel \
 rust-coreutils+b2sum-devel \
 rust-coreutils+base32-devel \
 rust-coreutils+base64-devel \
 rust-coreutils+basename-devel \
 rust-coreutils+basenc-devel \
 rust-coreutils+cksum-devel \
 rust-coreutils+cut-devel \
 rust-coreutils+date-devel \
 rust-coreutils+dircolors-devel \
 rust-coreutils+dirname-devel \
 rust-coreutils+echo-devel \
 rust-coreutils+expand-devel \
 rust-coreutils+factor-devel \
 rust-coreutils+false-devel \
 rust-coreutils+fmt-devel \
 rust-coreutils+fold-devel \
 rust-coreutils+join-devel \
 rust-coreutils+link-devel \
 rust-coreutils+md5sum-devel \
 rust-coreutils+nl-devel \
 rust-coreutils+numfmt-devel \
 rust-coreutils+od-devel \
 rust-coreutils+paste-devel \
 rust-coreutils+pr-devel \
 rust-coreutils+printenv-devel \
 rust-coreutils+printf-devel \
 rust-coreutils+ptx-devel \
 rust-coreutils+pwd-devel \
 rust-coreutils+seq-devel \
 rust-coreutils+sha1sum-devel \
 rust-coreutils+sha224sum-devel \
 rust-coreutils+sha256sum-devel \
 rust-coreutils+sha384sum-devel \
 rust-coreutils+sha512sum-devel \
 rust-coreutils+shred-devel \
 rust-coreutils+shuf-devel \
 rust-coreutils+sleep-devel \
 rust-coreutils+sum-devel \
 rust-coreutils+tee-devel \
 rust-coreutils+true-devel \
 rust-coreutils+truncate-devel \
 rust-coreutils+uname-devel \
 rust-coreutils+unexpand-devel \
 rust-coreutils+uniq-devel \
 rust-coreutils+unlink-devel \
 rust-coreutils+wc-devel \
 rust-coreutils+yes-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+fmt-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_fmt+default-devel \
 "
RDEPENDS:rust-coreutils+fold-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_fold+default-devel \
 "
RDEPENDS:rust-coreutils+groups-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_groups+default-devel \
 "
RDEPENDS:rust-coreutils+head-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_head+default-devel \
 "
RDEPENDS:rust-coreutils+hostid-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_hostid+default-devel \
 "
RDEPENDS:rust-coreutils+hostname-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_hostname+default-devel \
 "
RDEPENDS:rust-coreutils+id-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_id+default-devel \
 "
RDEPENDS:rust-coreutils+install-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_install+default-devel \
 "
RDEPENDS:rust-coreutils+join-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_join+default-devel \
 "
RDEPENDS:rust-coreutils+kill-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_kill+default-devel \
 "
RDEPENDS:rust-coreutils+link-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_link+default-devel \
 "
RDEPENDS:rust-coreutils+ln-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_ln+default-devel \
 "
RDEPENDS:rust-coreutils+logname-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_logname+default-devel \
 "
RDEPENDS:rust-coreutils+ls-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_ls+default-devel \
 "
RDEPENDS:rust-coreutils+macos-devel = " \
 cargo \
 rust-coreutils+feat_os_macos-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+md5sum-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_md5sum+default-devel \
 "
RDEPENDS:rust-coreutils+mkdir-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_mkdir+default-devel \
 "
RDEPENDS:rust-coreutils+mkfifo-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_mkfifo+default-devel \
 "
RDEPENDS:rust-coreutils+mknod-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_mknod+default-devel \
 "
RDEPENDS:rust-coreutils+mktemp-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_mktemp+default-devel \
 "
RDEPENDS:rust-coreutils+more-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_more+default-devel \
 "
RDEPENDS:rust-coreutils+mv-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_mv+default-devel \
 "
RDEPENDS:rust-coreutils+nice-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_nice+default-devel \
 "
RDEPENDS:rust-coreutils+nl-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_nl+default-devel \
 "
RDEPENDS:rust-coreutils+nohup-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_nohup+default-devel \
 "
RDEPENDS:rust-coreutils+nproc-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_nproc+default-devel \
 "
RDEPENDS:rust-coreutils+numfmt-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_numfmt+default-devel \
 "
RDEPENDS:rust-coreutils+od-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_od+default-devel \
 "
RDEPENDS:rust-coreutils+paste-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_paste+default-devel \
 "
RDEPENDS:rust-coreutils+pathchk-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_pathchk+default-devel \
 "
RDEPENDS:rust-coreutils+pinky-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_pinky+default-devel \
 "
RDEPENDS:rust-coreutils+pr-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_pr+default-devel \
 "
RDEPENDS:rust-coreutils+printenv-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_printenv+default-devel \
 "
RDEPENDS:rust-coreutils+printf-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_printf+default-devel \
 "
RDEPENDS:rust-coreutils+ptx-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_ptx+default-devel \
 "
RDEPENDS:rust-coreutils+pwd-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_pwd+default-devel \
 "
RDEPENDS:rust-coreutils+readlink-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_readlink+default-devel \
 "
RDEPENDS:rust-coreutils+realpath-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_realpath+default-devel \
 "
RDEPENDS:rust-coreutils+rm-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_rm+default-devel \
 "
RDEPENDS:rust-coreutils+rmdir-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_rmdir+default-devel \
 "
RDEPENDS:rust-coreutils+runcon-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_runcon+default-devel \
 "
RDEPENDS:rust-coreutils+selinux-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-selinux+default-devel \
 "
RDEPENDS:rust-coreutils+seq-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_seq+default-devel \
 "
RDEPENDS:rust-coreutils+sha1sum-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_sha1sum+default-devel \
 "
RDEPENDS:rust-coreutils+sha224sum-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_sha224sum+default-devel \
 "
RDEPENDS:rust-coreutils+sha256sum-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_sha256sum+default-devel \
 "
RDEPENDS:rust-coreutils+sha384sum-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_sha384sum+default-devel \
 "
RDEPENDS:rust-coreutils+sha512sum-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_sha512sum+default-devel \
 "
RDEPENDS:rust-coreutils+shred-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_shred+default-devel \
 "
RDEPENDS:rust-coreutils+shuf-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_shuf+default-devel \
 "
RDEPENDS:rust-coreutils+sleep-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_sleep+default-devel \
 "
RDEPENDS:rust-coreutils+sort-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_sort+default-devel \
 "
RDEPENDS:rust-coreutils+split-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_split+default-devel \
 "
RDEPENDS:rust-coreutils+stat-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_stat+default-devel \
 "
RDEPENDS:rust-coreutils+stdbuf-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_stdbuf+default-devel \
 "
RDEPENDS:rust-coreutils+stty-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_stty+default-devel \
 "
RDEPENDS:rust-coreutils+sum-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_sum+default-devel \
 "
RDEPENDS:rust-coreutils+sync-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_sync+default-devel \
 "
RDEPENDS:rust-coreutils+tac-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_tac+default-devel \
 "
RDEPENDS:rust-coreutils+tail-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_tail+default-devel \
 "
RDEPENDS:rust-coreutils+tee-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_tee+default-devel \
 "
RDEPENDS:rust-coreutils+test-devel = " \
 cargo \
 rust-coreutils+uu_test-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+test_risky_names-devel = " \
 cargo \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+timeout-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_timeout+default-devel \
 "
RDEPENDS:rust-coreutils+touch-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_touch+default-devel \
 "
RDEPENDS:rust-coreutils+tr-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_tr+default-devel \
 "
RDEPENDS:rust-coreutils+true-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_true+default-devel \
 "
RDEPENDS:rust-coreutils+truncate-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_truncate+default-devel \
 "
RDEPENDS:rust-coreutils+tsort-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_tsort+default-devel \
 "
RDEPENDS:rust-coreutils+tty-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_tty+default-devel \
 "
RDEPENDS:rust-coreutils+uname-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_uname+default-devel \
 "
RDEPENDS:rust-coreutils+unexpand-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_unexpand+default-devel \
 "
RDEPENDS:rust-coreutils+uniq-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_uniq+default-devel \
 "
RDEPENDS:rust-coreutils+unix-devel = " \
 cargo \
 rust-coreutils+feat_os_unix-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+unlink-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_unlink+default-devel \
 "
RDEPENDS:rust-coreutils+uptime-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_uptime+default-devel \
 "
RDEPENDS:rust-coreutils+users-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_users+default-devel \
 "
RDEPENDS:rust-coreutils+uu_test-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_test+default-devel \
 "
RDEPENDS:rust-coreutils+uudoc-devel:x86_64_v2 = " \
 cargo \
 rust-clap_complete+default-devel \
 rust-clap_mangen+default-devel \
 rust-coreutils-devel \
 rust-fluent-syntax+default-devel \
"
RDEPENDS:rust-coreutils+uudoc-devel:aarch64 = " \
 cargo \
 rust-clap_complete+default-devel \
 rust-clap_mangen+default-devel \
 rust-coreutils-devel \
 rust-fluent-syntax+default-devel \
 rust-zip+deflate-devel \
 rust-zip-devel \
"
RDEPENDS:rust-coreutils+vdir-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_vdir+default-devel \
 "
RDEPENDS:rust-coreutils+wc-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_wc+default-devel \
 "
RDEPENDS:rust-coreutils+who-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_who+default-devel \
 "
RDEPENDS:rust-coreutils+whoami-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_whoami+default-devel \
 "
RDEPENDS:rust-coreutils+windows-devel = " \
 cargo \
 rust-coreutils+feat_os_windows-devel \
 rust-coreutils-devel \
 "
RDEPENDS:rust-coreutils+yes-devel = " \
 cargo \
 rust-coreutils-devel \
 rust-uu_yes+default-devel \
 "
RDEPENDS:rust-coreutils-devel = " \
 bash \
 cargo \
 python3 \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-itertools0.14+default-devel \
 rust-phf+default-devel \
 rust-phf_codegen+default-devel \
 rust-textwrap+default-devel \
 rust-textwrap+terminal_size-devel \
 rust-uucore+default-devel \
 "
RDEPENDS:uutils-coreutils = " \
 glibc \
 libacl \
 libgcc \
 libselinux \
 oniguruma \
 systemd-libs \
 "
