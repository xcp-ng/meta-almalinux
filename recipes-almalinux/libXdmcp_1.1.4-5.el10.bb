# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXdmcp"
PV = "1.1.4"
PR = "5.el10"
PACKAGES = " \
 libXdmcp \
 libXdmcp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXdmcp-1.1.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2edcc987e0893db6862872ee5e115f52c242d2649630909e9110865b208383da"

URI_x86_64_v2_libXdmcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXdmcp-1.1.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_libXdmcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXdmcp}"
SRC_URI[x86_64_v2_libXdmcp.sha256sum] = "4ecea5792827c4512c99ae88173ae8e750aa36d4937ca776d80c12236411f68d"

URI_x86_64_v2_libXdmcp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libXdmcp-devel-1.1.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_libXdmcp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXdmcp-devel}"
SRC_URI[x86_64_v2_libXdmcp-devel.sha256sum] = "a0cac1564b710e100d6319c9d8c9fd7fc090a21ad21e591a04f59a252c85962a"

URI_aarch64_libXdmcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXdmcp-1.1.4-5.el10.aarch64.rpm;name=aarch64_libXdmcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXdmcp}"
SRC_URI[aarch64_libXdmcp.sha256sum] = "61d17122fec6cebbd1adaa63ff5e0e0aea72d6277e1c37ec913e09c134c8e044"

URI_aarch64_libXdmcp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libXdmcp-devel-1.1.4-5.el10.aarch64.rpm;name=aarch64_libXdmcp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXdmcp-devel}"
SRC_URI[aarch64_libXdmcp-devel.sha256sum] = "bad3004698633e5a95c7479d5d449aa12e21b9ff9d28a3ef24331f0317efcecf"

RDEPENDS:libXdmcp = " \
 glibc \
 "
RDEPENDS:libXdmcp-devel = " \
 libXdmcp \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
