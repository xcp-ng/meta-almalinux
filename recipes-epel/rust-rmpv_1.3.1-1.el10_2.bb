# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rmpv"
PV = "1.3.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-rmpv+default-devel \
 rust-rmpv+serde-devel \
 rust-rmpv+serde_bytes-devel \
 rust-rmpv+with-serde-devel \
 rust-rmpv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rmpv-1.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f43fb7bf0643fc09c8f7420135f0d56f02c84cbed2059988d50133131e62e7b"

URI_x86_64_v2_rust-rmpv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+default-devel-1.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+default-devel}"
SRC_URI[x86_64_v2_rust-rmpv+default-devel.sha256sum] = "22e49ffb18d8d1436339ac553c39f7f20261533eec6411c0689520e09d67d1fd"

URI_x86_64_v2_rust-rmpv+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+serde-devel-1.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+serde-devel}"
SRC_URI[x86_64_v2_rust-rmpv+serde-devel.sha256sum] = "05c3d3ef7b0c02d9b8c567eb77c099eb0d10c5b4f97f2b8f4394b991bc11a3b9"

URI_x86_64_v2_rust-rmpv+serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+serde_bytes-devel-1.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-rmpv+serde_bytes-devel.sha256sum] = "354a61b3eda3cd9196aad6f03354d75ced6abb852386f7febd154e63f075aa38"

URI_x86_64_v2_rust-rmpv+with-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv+with-serde-devel-1.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv+with-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv+with-serde-devel}"
SRC_URI[x86_64_v2_rust-rmpv+with-serde-devel.sha256sum] = "029407fac92247a0f297885f7bfe96df2bf2fb9370edc815462019f7db8d37a3"

URI_x86_64_v2_rust-rmpv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmpv-devel-1.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmpv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmpv-devel}"
SRC_URI[x86_64_v2_rust-rmpv-devel.sha256sum] = "8636d7a52f335487c01c1789108fafae0c8b69c264851bde848d12f64c128fa9"

URI_aarch64_rust-rmpv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+default-devel-1.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rmpv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+default-devel}"
SRC_URI[aarch64_rust-rmpv+default-devel.sha256sum] = "368334b1e0d84930cd45754da52b70186476ce4246d4fecee92b0f14eff93a76"

URI_aarch64_rust-rmpv+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+serde-devel-1.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rmpv+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+serde-devel}"
SRC_URI[aarch64_rust-rmpv+serde-devel.sha256sum] = "f86b57e2c12e3f6e2b460a0b659ebffcbb34802c36f8a387af16b751066565a4"

URI_aarch64_rust-rmpv+serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+serde_bytes-devel-1.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rmpv+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+serde_bytes-devel}"
SRC_URI[aarch64_rust-rmpv+serde_bytes-devel.sha256sum] = "2332523fae2ed238fae6ae1807976aca41f11e15feae6a8a84384d4334d6fa45"

URI_aarch64_rust-rmpv+with-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv+with-serde-devel-1.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rmpv+with-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv+with-serde-devel}"
SRC_URI[aarch64_rust-rmpv+with-serde-devel.sha256sum] = "80f2a3dc0be3a1473d37a1a4be623b07f54ea6d64fa0a4f119cda96f005bc0df"

URI_aarch64_rust-rmpv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmpv-devel-1.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rmpv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmpv-devel}"
SRC_URI[aarch64_rust-rmpv-devel.sha256sum] = "a7851d715cbb441822b1ee56487eefaa6cc61766238f506b0ffdeb23b08e5084"

RDEPENDS:rust-rmpv+default-devel = " \
 cargo \
 rust-rmpv-devel \
 "
RDEPENDS:rust-rmpv+serde-devel = " \
 cargo \
 rust-rmpv-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-rmpv+serde_bytes-devel = " \
 cargo \
 rust-rmpv-devel \
 rust-serde_bytes+default-devel \
 "
RDEPENDS:rust-rmpv+with-serde-devel = " \
 cargo \
 rust-rmpv+serde-devel \
 rust-rmpv+serde_bytes-devel \
 rust-rmpv-devel \
 "
RDEPENDS:rust-rmpv-devel = " \
 cargo \
 rust \
 rust-rmp+default-devel \
 "
