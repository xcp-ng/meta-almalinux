# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-rtsp-server"
PV = "1.24.11"
PR = "1.el10"
PACKAGES = " \
 gstreamer1-rtsp-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-rtsp-server-1.24.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41e389fa71118d387e0ad6d53445935e35d36c9a441f168d93a7681d7128c035"

URI_x86_64_v2_gstreamer1-rtsp-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-rtsp-server-1.24.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-rtsp-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-rtsp-server}"
SRC_URI[x86_64_v2_gstreamer1-rtsp-server.sha256sum] = "8283c2a1533c9a2dfff91ac1c23c7aaca863f5d5b9a2ea9f15cb2e315c98b165"

URI_aarch64_gstreamer1-rtsp-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-rtsp-server-1.24.11-1.el10.aarch64.rpm;name=aarch64_gstreamer1-rtsp-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-rtsp-server}"
SRC_URI[aarch64_gstreamer1-rtsp-server.sha256sum] = "aa57a9e0ae5ca7bb00e22ff19be5195c4bbddb617a25f652a67ac82e04aaad5f"

RDEPENDS:gstreamer1-rtsp-server = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 "
