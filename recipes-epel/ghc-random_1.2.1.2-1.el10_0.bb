# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-random"
PV = "1.2.1.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-random \
 ghc-random-devel \
 ghc-random-doc \
 ghc-random-prof \
 ghc-splitmix \
 ghc-splitmix-devel \
 ghc-splitmix-doc \
 ghc-splitmix-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-random-1.2.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2a306ee56dada25c08e20c625d1be82f619be8670884d2eb240fc5c2b4ffec3"

URI_x86_64_v2_ghc-random = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-random-1.2.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-random;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-random}"
SRC_URI[x86_64_v2_ghc-random.sha256sum] = "0c41e7e80782067d6c04591890a804225ed11a34d61f559d463465a76befbe3e"

URI_x86_64_v2_ghc-random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-random-devel-1.2.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-random-devel}"
SRC_URI[x86_64_v2_ghc-random-devel.sha256sum] = "6caa10d5df09f035c13142e6263f78355dcd3501ca745ad555eef2defa250564"

URI_x86_64_v2_ghc-random-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-random-doc-1.2.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-random-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-random-doc}"
SRC_URI[x86_64_v2_ghc-random-doc.sha256sum] = "0516407c59d2bc7ef8a0f74dc3dfb60805de4ed589b42eab644521ec6e2525b2"

URI_x86_64_v2_ghc-random-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-random-prof-1.2.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-random-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-random-prof}"
SRC_URI[x86_64_v2_ghc-random-prof.sha256sum] = "fe664257c6b89ea59fb4947fccb3eb4435d967bcac55746e6c715cca37d4d492"

URI_x86_64_v2_ghc-splitmix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-splitmix-0.1.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-splitmix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-splitmix}"
SRC_URI[x86_64_v2_ghc-splitmix.sha256sum] = "967abce7c6c466d4df61b17dc28be8772b0ce6155f406c2146aecd913f30502d"

URI_x86_64_v2_ghc-splitmix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-splitmix-devel-0.1.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-splitmix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-splitmix-devel}"
SRC_URI[x86_64_v2_ghc-splitmix-devel.sha256sum] = "028995fbf0ee36776898ecc98f9be9a5255c4065a0c562ebcdedf92bebe38a15"

URI_x86_64_v2_ghc-splitmix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-splitmix-doc-0.1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-splitmix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-splitmix-doc}"
SRC_URI[x86_64_v2_ghc-splitmix-doc.sha256sum] = "1e525307e6cf022dbe294da77a2baec2ba7cf0f0eee300c8df94614fc2b22839"

URI_x86_64_v2_ghc-splitmix-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-splitmix-prof-0.1.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-splitmix-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-splitmix-prof}"
SRC_URI[x86_64_v2_ghc-splitmix-prof.sha256sum] = "bb6dfc664b67a681732fc94c5fe50679f319a3c9fbe77a124a7dee47a1e63db7"

URI_aarch64_ghc-random = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-random-1.2.1.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-random;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-random}"
SRC_URI[aarch64_ghc-random.sha256sum] = "472a8da76d1c248b54a61b98c144e272d7a0cb791b552fae3f1632aacee68ada"

URI_aarch64_ghc-random-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-random-devel-1.2.1.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-random-devel}"
SRC_URI[aarch64_ghc-random-devel.sha256sum] = "64771b80b970f5440e9df831f6f3ba23a0901f1424cdf64d7f45b63c1fff4d29"

URI_aarch64_ghc-random-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-random-doc-1.2.1.2-1.el10_0.noarch.rpm;name=aarch64_ghc-random-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-random-doc}"
SRC_URI[aarch64_ghc-random-doc.sha256sum] = "b05db657dd98fee462198741ea85019547b0f2f25f263729f524518d96a58a2c"

URI_aarch64_ghc-random-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-random-prof-1.2.1.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-random-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-random-prof}"
SRC_URI[aarch64_ghc-random-prof.sha256sum] = "4c9d8770fc8d4a26c5ccd3716a5eba3c4a14b0f413249883e206abcfcc171294"

URI_aarch64_ghc-splitmix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-splitmix-0.1.0.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-splitmix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-splitmix}"
SRC_URI[aarch64_ghc-splitmix.sha256sum] = "729cedb12806eb640a9b4e72eec0c9e98fb495c3e0d3e2fac0c63e57f047a3ab"

URI_aarch64_ghc-splitmix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-splitmix-devel-0.1.0.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-splitmix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-splitmix-devel}"
SRC_URI[aarch64_ghc-splitmix-devel.sha256sum] = "85983c9f908e3a5c77217ba71cad9c9997e4ceec13c4de526ff76fba93a66b30"

URI_aarch64_ghc-splitmix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-splitmix-doc-0.1.0.5-1.el10_0.noarch.rpm;name=aarch64_ghc-splitmix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-splitmix-doc}"
SRC_URI[aarch64_ghc-splitmix-doc.sha256sum] = "2e35a7e045e46bfffbf1e7cb226266a619d83d6ba220d70301c146d134ad6510"

URI_aarch64_ghc-splitmix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-splitmix-prof-0.1.0.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-splitmix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-splitmix-prof}"
SRC_URI[aarch64_ghc-splitmix-prof.sha256sum] = "e85d1ed954e268d2d2c0cf3228efa396b93bc7b21e6401a62a7ee7a02ef37fc8"

RDEPENDS:ghc-random = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-splitmix \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-random-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-mtl-devel \
 ghc-random \
 ghc-splitmix-devel \
 "
RDEPENDS:ghc-random-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-random-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-mtl-prof \
 ghc-random-devel \
 ghc-splitmix-prof \
 "
RDEPENDS:ghc-splitmix = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-splitmix-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-splitmix \
 "
RDEPENDS:ghc-splitmix-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-splitmix-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-splitmix-devel \
 "
