# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsolv"
PV = "0.7.33"
PR = "6.el10.alma.4"
PACKAGES = " \
 libsolv \
 libsolv-devel \
 libsolv-tools \
 libsolv-tools-base \
 python3-solv \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsolv-0.7.33-6.el10.alma.4.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "529672727818dbfd8fdfad2aee85e72fd386e443d17ec124b3f71a540a7187ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsolv-0.7.33-6.el10.alma.4.x86_64_v2.rpm;name=x86_64_v2_libsolv;unpack=0"
SRC_URI[x86_64_v2_libsolv.sha256sum] = "47de14f7e5ff69b1cb82ba290e0f866ef58aa394dd9bc7c7230ab9c30f4cda98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-devel-0.7.33-6.el10.alma.4.x86_64_v2.rpm;name=x86_64_v2_libsolv-devel;unpack=0"
SRC_URI[x86_64_v2_libsolv-devel.sha256sum] = "4c86806945bb7355a904751019462f49beaaeab904cb8d2097836ab9a6e5bd24"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-tools-0.7.33-6.el10.alma.4.x86_64_v2.rpm;name=x86_64_v2_libsolv-tools;unpack=0"
SRC_URI[x86_64_v2_libsolv-tools.sha256sum] = "8fc65220c6bccb24bdc77e2d9093921f5f1d58f06566abf226fca27f0838bc3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-tools-base-0.7.33-6.el10.alma.4.x86_64_v2.rpm;name=x86_64_v2_libsolv-tools-base;unpack=0"
SRC_URI[x86_64_v2_libsolv-tools-base.sha256sum] = "9d3f770ecd2f17409e9f4948f084c6fcf326bcff4ea93f8e66804af60a6ea1ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-solv-0.7.33-6.el10.alma.4.x86_64_v2.rpm;name=x86_64_v2_python3-solv;unpack=0"
SRC_URI[x86_64_v2_python3-solv.sha256sum] = "4a5b349d9beefa7465e580371c5672ea8ef734d0ce7df7e1acfdc03a0e9e49ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsolv-0.7.33-6.el10.alma.4.aarch64.rpm;name=aarch64_libsolv;unpack=0"
SRC_URI[aarch64_libsolv.sha256sum] = "896efcc7c9c2157407e34fbc05bbeae28611c01fac87c72f10dc8a903956d59f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-devel-0.7.33-6.el10.alma.4.aarch64.rpm;name=aarch64_libsolv-devel;unpack=0"
SRC_URI[aarch64_libsolv-devel.sha256sum] = "28d91e14209d1a87971b188a100cb0cc2660c518ce09a4a866aee84cf8c8874e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-tools-0.7.33-6.el10.alma.4.aarch64.rpm;name=aarch64_libsolv-tools;unpack=0"
SRC_URI[aarch64_libsolv-tools.sha256sum] = "f01c7fc0b9e7987527266b78850174eb5da5a804ffdf53f3a866a7575546cfb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-tools-base-0.7.33-6.el10.alma.4.aarch64.rpm;name=aarch64_libsolv-tools-base;unpack=0"
SRC_URI[aarch64_libsolv-tools-base.sha256sum] = "df8a79c93d41b0d30dd69d2fd4686073f0fadb7ac04a8ec8e364ac746c3bfc06"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-solv-0.7.33-6.el10.alma.4.aarch64.rpm;name=aarch64_python3-solv;unpack=0"
SRC_URI[aarch64_python3-solv.sha256sum] = "3adf91b3c2dc835c9b9e56483d9bf745d7dec831054080e1b4b8a65ab68962d4"

RDEPENDS:libsolv = " \
 bzip2-libs \
 glibc \
 libxml2 \
 libzstd \
 openssl-libs \
 rpm-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libsolv-devel = " \
 libsolv \
 libsolv-devel \
 pkgconf-pkg-config \
 rpm-devel \
 "
RDEPENDS:libsolv-tools = " \
 glibc \
 libsolv \
 libsolv-tools-base \
 "
RDEPENDS:libsolv-tools-base = " \
 glibc \
 libsolv \
 rpm-libs \
 "
RDEPENDS:python3-solv = " \
 glibc \
 libsolv \
 python3 \
 "
