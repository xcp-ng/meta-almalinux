# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "adcli"
PV = "0.9.2"
PR = "9.el10"
PACKAGES = " \
 adcli \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/adcli-0.9.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6de52db5750c2ba8433a30adbc259d7866fb12e8a8d4e1ea33f59205d3f5e660"

URI_x86_64_v2_adcli = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/adcli-0.9.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_adcli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adcli}"
SRC_URI[x86_64_v2_adcli.sha256sum] = "779bbb8f582bf6779cb1a76eb8c65521cd54b1e016a08739f779d6f594407060"

URI_aarch64_adcli = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/adcli-0.9.2-9.el10.aarch64.rpm;name=aarch64_adcli;unpack=0"
SRC_URI:append = " ${URI_aarch64_adcli}"
SRC_URI[aarch64_adcli.sha256sum] = "af57f095a5728f0db0739bcc11b6d16e63241afd1c71225d32b1ee924f960ea2"

RDEPENDS:adcli = " \
 cyrus-sasl-gssapi \
 glibc \
 krb5-libs \
 openldap \
 "
