# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rle-decode-fast"
PV = "1.0.3"
PR = "7.el10_0"
PACKAGES = " \
 rust-rle-decode-fast+default-devel \
 rust-rle-decode-fast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rle-decode-fast-1.0.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b584491b6c21afa25facdd347e593267c50a56f918c72047290b9f1d2b9c5ef9"

URI_x86_64_v2_rust-rle-decode-fast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rle-decode-fast+default-devel-1.0.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rle-decode-fast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rle-decode-fast+default-devel}"
SRC_URI[x86_64_v2_rust-rle-decode-fast+default-devel.sha256sum] = "cf5f9cb758240c6e8459eb98cd30dea59d5b717362854b62c4ad2827c23875cc"

URI_x86_64_v2_rust-rle-decode-fast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rle-decode-fast-devel-1.0.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rle-decode-fast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rle-decode-fast-devel}"
SRC_URI[x86_64_v2_rust-rle-decode-fast-devel.sha256sum] = "3997c1006bf236f4cb57aa6097ca1c2acc9b3837d8bea8f62b87f57ed7eb437a"

URI_aarch64_rust-rle-decode-fast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rle-decode-fast+default-devel-1.0.3-7.el10_0.noarch.rpm;name=aarch64_rust-rle-decode-fast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rle-decode-fast+default-devel}"
SRC_URI[aarch64_rust-rle-decode-fast+default-devel.sha256sum] = "ba3c546a46c620884dd0ca16a7de3aa48181547c05915ccc081bd19b1035122c"

URI_aarch64_rust-rle-decode-fast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rle-decode-fast-devel-1.0.3-7.el10_0.noarch.rpm;name=aarch64_rust-rle-decode-fast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rle-decode-fast-devel}"
SRC_URI[aarch64_rust-rle-decode-fast-devel.sha256sum] = "41f8a52eaaa41bcb7ea2bfd8dae44c3b230b19a46437a6332fb21a9e28c9339c"

RDEPENDS:rust-rle-decode-fast+default-devel = " \
 cargo \
 rust-rle-decode-fast-devel \
 "
RDEPENDS:rust-rle-decode-fast-devel = " \
 cargo \
 "
