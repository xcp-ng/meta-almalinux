# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-log"
PV = "0.4.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-log+default-devel \
 rust-log+kv-devel \
 rust-log+max_level_debug-devel \
 rust-log+max_level_error-devel \
 rust-log+max_level_info-devel \
 rust-log+max_level_off-devel \
 rust-log+max_level_trace-devel \
 rust-log+max_level_warn-devel \
 rust-log+release_max_level_debug-devel \
 rust-log+release_max_level_error-devel \
 rust-log+release_max_level_info-devel \
 rust-log+release_max_level_off-devel \
 rust-log+release_max_level_trace-devel \
 rust-log+release_max_level_warn-devel \
 rust-log+serde-devel \
 rust-log+serde_core-devel \
 rust-log+std-devel \
 rust-log-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-log-0.4.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1cfe33c797f08a415fa05abb2864241ba7c78a9b5c17ab0614a50ae26550ff4"

URI_x86_64_v2_rust-log+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+default-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+default-devel}"
SRC_URI[x86_64_v2_rust-log+default-devel.sha256sum] = "bdd361302e0c524c2cd4cb14038a69feb3bb371f81079df74c6d0eb6dbecaa35"

URI_x86_64_v2_rust-log+kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+kv-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+kv-devel}"
SRC_URI[x86_64_v2_rust-log+kv-devel.sha256sum] = "5e38f877052167277de43e5f9af3dc1e71b49d7076cc29d73acc2113d4fc5ed0"

URI_x86_64_v2_rust-log+max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_debug-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_debug-devel.sha256sum] = "afee3619cdb1e75cbac0a0e03b1c79c07e9dcb6294079aedafd23088e605ba52"

URI_x86_64_v2_rust-log+max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_error-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_error-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_error-devel.sha256sum] = "6e43be7e7d65cfcc1b8fc3c164937e7627e65c5465b7ba0418073fb3f4b3f663"

URI_x86_64_v2_rust-log+max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_info-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_info-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_info-devel.sha256sum] = "6be060f7067b3f9ac9ba7e75e98470c8664a8c9e10d37732af95afd598f6a28a"

URI_x86_64_v2_rust-log+max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_off-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_off-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_off-devel.sha256sum] = "9659d8f3d67202b9930a3272d2b44e59fab7e2476d0eb8611faeee1397c70ebd"

URI_x86_64_v2_rust-log+max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_trace-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_trace-devel.sha256sum] = "171a192a6e1fc9b0f3381d8b869375315131b64156f72153e3be8ae5a643a939"

URI_x86_64_v2_rust-log+max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_warn-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_warn-devel.sha256sum] = "21d02307ad1099eb84a4f76ea082f51860b2ca86a9abce8c3e89619c8b3ef947"

URI_x86_64_v2_rust-log+release_max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_debug-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_debug-devel.sha256sum] = "275d1714ff1cd9dbdfe3035e903430638c7457ea44058df154770f7bccbc1118"

URI_x86_64_v2_rust-log+release_max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_error-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_error-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_error-devel.sha256sum] = "af6135d1f1995778f99ce65fc5ade02231810f55ae07267d72a15f415660a5d2"

URI_x86_64_v2_rust-log+release_max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_info-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_info-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_info-devel.sha256sum] = "062f7d4b026bc5c8c6bf59569da10e7ae8ffc789d443763133fcc5fdedc5d252"

URI_x86_64_v2_rust-log+release_max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_off-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_off-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_off-devel.sha256sum] = "ec3d63346fbe378b885647916a3a90d84a24b5a761ce2c3fae1c3725b5cfffbe"

URI_x86_64_v2_rust-log+release_max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_trace-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_trace-devel.sha256sum] = "4ccb1249acb6ba5beb9fdbb623077fcf152fe098075d82dc042f1c660ef5396d"

URI_x86_64_v2_rust-log+release_max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_warn-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_warn-devel.sha256sum] = "77249317bfe051f7d7dde15b53ddb46444837e4cbbbb8499b2201d90efafc96b"

URI_x86_64_v2_rust-log+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+serde-devel}"
SRC_URI[x86_64_v2_rust-log+serde-devel.sha256sum] = "94dbd911b2fab3d9381f64a2ecd184d0e89ea925facf13a529a5f9149a517637"

URI_x86_64_v2_rust-log+serde_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde_core-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+serde_core-devel}"
SRC_URI[x86_64_v2_rust-log+serde_core-devel.sha256sum] = "ab2f9ba487917e9e7f9c71acee321d33e8c4bfd0413511c77c40c61782b2f94a"

URI_x86_64_v2_rust-log+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+std-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+std-devel}"
SRC_URI[x86_64_v2_rust-log+std-devel.sha256sum] = "2624cb98f68a1be3db06090648bef8e8387ce97bc94217c4911fae3e24880b0f"

URI_x86_64_v2_rust-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log-devel-0.4.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log-devel}"
SRC_URI[x86_64_v2_rust-log-devel.sha256sum] = "5a95cd042cd1f4642cc56f295d6cbbffafe73c4d5b41230590ea52adc01ac8c8"

URI_aarch64_rust-log+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+default-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+default-devel}"
SRC_URI[aarch64_rust-log+default-devel.sha256sum] = "7107309748b87d11edc8933117ca119b3add3ca6662407a274903721f4bbbeef"

URI_aarch64_rust-log+kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+kv-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+kv-devel}"
SRC_URI[aarch64_rust-log+kv-devel.sha256sum] = "bf2100ff7d2a7d5eb4aad3072aee6a28ec5c672a5638d29d784b41476737ce4e"

URI_aarch64_rust-log+max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_debug-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_debug-devel}"
SRC_URI[aarch64_rust-log+max_level_debug-devel.sha256sum] = "e50ffe22c403914ca3430d25234d9683129a542ef3013facc1d738a877baee59"

URI_aarch64_rust-log+max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_error-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_error-devel}"
SRC_URI[aarch64_rust-log+max_level_error-devel.sha256sum] = "0fab9a55b0d1b3744dec1718f7f978b569d476f98a8b62444f6d5e7f0cac1c03"

URI_aarch64_rust-log+max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_info-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_info-devel}"
SRC_URI[aarch64_rust-log+max_level_info-devel.sha256sum] = "2840ab4564523722ff41b702194ab874d4e8d9109bf33037d69ab4744e02412d"

URI_aarch64_rust-log+max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_off-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_off-devel}"
SRC_URI[aarch64_rust-log+max_level_off-devel.sha256sum] = "e1c6803f1a31ec46086a78db2f67c915b37d3268775984a3809a3cfebcd64627"

URI_aarch64_rust-log+max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_trace-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_trace-devel}"
SRC_URI[aarch64_rust-log+max_level_trace-devel.sha256sum] = "98ec8f56a6d74c4cf573b7c8bba874feb5f732c483c7fb412e46efb746fb74b2"

URI_aarch64_rust-log+max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_warn-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_warn-devel}"
SRC_URI[aarch64_rust-log+max_level_warn-devel.sha256sum] = "dff37bec5f9c65d99167c5c58027d5c8a6be20a8a1db76d2ce3545b2d3f17593"

URI_aarch64_rust-log+release_max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_debug-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_debug-devel}"
SRC_URI[aarch64_rust-log+release_max_level_debug-devel.sha256sum] = "7833746e502fb4d57bc1bde4be4a671aadfe6f6dc77ebcdbbd0c69ceb823afb2"

URI_aarch64_rust-log+release_max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_error-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_error-devel}"
SRC_URI[aarch64_rust-log+release_max_level_error-devel.sha256sum] = "820e4349c220f938758798317684813f08b73885b1556a060992b9cc75a53946"

URI_aarch64_rust-log+release_max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_info-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_info-devel}"
SRC_URI[aarch64_rust-log+release_max_level_info-devel.sha256sum] = "af0c45e8505b3cb400fc0f1059c858a22318ebdd163100d0469695af7b4f96a6"

URI_aarch64_rust-log+release_max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_off-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_off-devel}"
SRC_URI[aarch64_rust-log+release_max_level_off-devel.sha256sum] = "9d595cf584a165e0f09a9eba6dd9b7acdd662cd08758ef8d2e8a75ef16af0d31"

URI_aarch64_rust-log+release_max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_trace-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_trace-devel}"
SRC_URI[aarch64_rust-log+release_max_level_trace-devel.sha256sum] = "f9282d1436b3d26ad7de5418082a4a5d1709778f7b41a6020bd6ad1d9c50bfe0"

URI_aarch64_rust-log+release_max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_warn-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_warn-devel}"
SRC_URI[aarch64_rust-log+release_max_level_warn-devel.sha256sum] = "c2af30ffe3cc3b2dd2ae451ec405dbcbcad9d4201aec255ba8a0e2249a1f8953"

URI_aarch64_rust-log+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+serde-devel}"
SRC_URI[aarch64_rust-log+serde-devel.sha256sum] = "f1371606b7aba713a0c051f9cd252e60c4fc1662938827de705c10e8448b1960"

URI_aarch64_rust-log+serde_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde_core-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+serde_core-devel}"
SRC_URI[aarch64_rust-log+serde_core-devel.sha256sum] = "ef8dfe2c5532f82bac48c047ba3ddbc8b2f1e5e34945c402b9f33fc1a4dfb88a"

URI_aarch64_rust-log+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+std-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+std-devel}"
SRC_URI[aarch64_rust-log+std-devel.sha256sum] = "fd83081c870be54f5f7fdd2ecade11bb8f10d86abc678a5b05f9c3a8987d4ae1"

URI_aarch64_rust-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log-devel-0.4.33-1.el10_3.noarch.rpm;name=aarch64_rust-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log-devel}"
SRC_URI[aarch64_rust-log-devel.sha256sum] = "175d7e034e7d62bb5db4cb46dbf8585c9c9905194430fe08565be3f5a809ab05"

RDEPENDS:rust-log+default-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+kv-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde-devel = " \
 cargo \
 rust-log+serde_core-devel \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde_core-devel = " \
 cargo \
 rust-log-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-log+std-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log-devel = " \
 cargo \
 rust \
 "
