# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch-ascii"
PV = "2.27.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-onefetch-ascii+default-devel \
 rust-onefetch-ascii-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-ascii-2.27.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ead21049e3bab9bc4cbb253db15f79a480144a8f02c19f147faab87649494da"

URI_x86_64_v2_rust-onefetch-ascii+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-ascii+default-devel-2.27.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-ascii+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-ascii+default-devel}"
SRC_URI[x86_64_v2_rust-onefetch-ascii+default-devel.sha256sum] = "d28db9bfcb685a049c69128dd0b8e6f41a37789feb949b7ab9eed40dda2dab66"

URI_x86_64_v2_rust-onefetch-ascii-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-ascii-devel-2.27.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-ascii-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-ascii-devel}"
SRC_URI[x86_64_v2_rust-onefetch-ascii-devel.sha256sum] = "545770e7fd5678746038527a2b365e6da3d38837043ce297543886ed57d53510"

URI_aarch64_rust-onefetch-ascii+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-ascii+default-devel-2.27.1-1.el10_3.noarch.rpm;name=aarch64_rust-onefetch-ascii+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-ascii+default-devel}"
SRC_URI[aarch64_rust-onefetch-ascii+default-devel.sha256sum] = "231cc8c92203a4e7f61f5ff267aa234633ed459429282294f841044364cffb45"

URI_aarch64_rust-onefetch-ascii-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-ascii-devel-2.27.1-1.el10_3.noarch.rpm;name=aarch64_rust-onefetch-ascii-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-ascii-devel}"
SRC_URI[aarch64_rust-onefetch-ascii-devel.sha256sum] = "f0532210d86abf38cf9397d4cb5ca9426cffaa150b17f1eef0b388aac522e1e3"

RDEPENDS:rust-onefetch-ascii+default-devel = " \
 cargo \
 rust-onefetch-ascii-devel \
 "
RDEPENDS:rust-onefetch-ascii-devel = " \
 cargo \
 rust-owo-colors+default-devel \
 "
