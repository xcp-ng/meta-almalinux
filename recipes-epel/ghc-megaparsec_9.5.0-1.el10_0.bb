# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-megaparsec"
PV = "9.5.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-megaparsec \
 ghc-megaparsec-devel \
 ghc-megaparsec-doc \
 ghc-megaparsec-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-megaparsec-9.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4a0f014bdbc3157a930d1b1827ba0f06b0867547da1caf639a6da48279d432a"

URI_x86_64_v2_ghc-megaparsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-megaparsec-9.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-megaparsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-megaparsec}"
SRC_URI[x86_64_v2_ghc-megaparsec.sha256sum] = "8954aced995677f83d60f7003d249b9bcf4a666e7617399f87a9ce09a53e4a53"

URI_x86_64_v2_ghc-megaparsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-megaparsec-devel-9.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-megaparsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-megaparsec-devel}"
SRC_URI[x86_64_v2_ghc-megaparsec-devel.sha256sum] = "c039d6ea2d9b26063e0771c62d6e8ff126a91b741f606d78e9efd8b26ebc865e"

URI_x86_64_v2_ghc-megaparsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-megaparsec-doc-9.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-megaparsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-megaparsec-doc}"
SRC_URI[x86_64_v2_ghc-megaparsec-doc.sha256sum] = "9417524ce4f4a7d9fbf929bdd2db92b7f04790b4efa36d0b80f248653ad2eac8"

URI_x86_64_v2_ghc-megaparsec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-megaparsec-prof-9.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-megaparsec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-megaparsec-prof}"
SRC_URI[x86_64_v2_ghc-megaparsec-prof.sha256sum] = "ccc6914b352eb36f07c46873a983e62423f85e1bd53f186d8845958766573b5c"

URI_aarch64_ghc-megaparsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-megaparsec-9.5.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-megaparsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-megaparsec}"
SRC_URI[aarch64_ghc-megaparsec.sha256sum] = "36eab277e8c0abeafa15e2921532ea98fe7aef5a0d2711552d73f8fb4cad090a"

URI_aarch64_ghc-megaparsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-megaparsec-devel-9.5.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-megaparsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-megaparsec-devel}"
SRC_URI[aarch64_ghc-megaparsec-devel.sha256sum] = "4e99c8fce3e196863bacca8f11c70a803e106d8a19dd3236284b9487651838ef"

URI_aarch64_ghc-megaparsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-megaparsec-doc-9.5.0-1.el10_0.noarch.rpm;name=aarch64_ghc-megaparsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-megaparsec-doc}"
SRC_URI[aarch64_ghc-megaparsec-doc.sha256sum] = "3a8b1f99f0ad9aa64451b47ee4772399400346a6f5f8ed2b5aa73bd980f74226"

URI_aarch64_ghc-megaparsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-megaparsec-prof-9.5.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-megaparsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-megaparsec-prof}"
SRC_URI[aarch64_ghc-megaparsec-prof.sha256sum] = "ffa9467fa1e75e9494e334e25fb076a70152f0ffd237eed90b616a743d7f3cd0"

RDEPENDS:ghc-megaparsec = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-megaparsec-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-megaparsec \
 ghc-mtl-devel \
 ghc-parser-combinators-devel \
 ghc-scientific-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-megaparsec-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-megaparsec-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-megaparsec-devel \
 ghc-mtl-prof \
 ghc-parser-combinators-prof \
 ghc-scientific-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
