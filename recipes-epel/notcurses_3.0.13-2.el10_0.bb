# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "notcurses"
PV = "3.0.13"
PR = "2.el10_0"
PACKAGES = " \
 notcurses \
 notcurses-devel \
 notcurses-static \
 notcurses-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/notcurses-3.0.13-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bd4f94217e88e7a708ab509a9ae4011aac727fe3e7df3b7dca068464a7b35de"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - notcurses: libavcodec.so.61()(64bit)
# - notcurses: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - notcurses: libavdevice.so.61()(64bit)
# - notcurses: libavdevice.so.61(LIBAVDEVICE_61)(64bit)
# - notcurses: libavformat.so.61()(64bit)
# - notcurses: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - notcurses: libavutil.so.59()(64bit)
# - notcurses: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - notcurses: libswscale.so.8()(64bit)
# - notcurses: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_notcurses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notcurses-3.0.13-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notcurses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notcurses}"
SRC_URI[x86_64_v2_notcurses.sha256sum] = "533d0ba76992f84ecd3b700a3705d23cbbbef2a265bb5cb7dd5686b93a992a19"

URI_x86_64_v2_notcurses-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notcurses-devel-3.0.13-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notcurses-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notcurses-devel}"
SRC_URI[x86_64_v2_notcurses-devel.sha256sum] = "9f46ab1e20454535db2eaa2fd9724343e351b27d839fbe5a8f273dd2e75c7a87"

URI_x86_64_v2_notcurses-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notcurses-static-3.0.13-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notcurses-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notcurses-static}"
SRC_URI[x86_64_v2_notcurses-static.sha256sum] = "9fdc2974916df9ee146e24ffb149b27cfec4df718578319cb7797734ad580b55"

URI_x86_64_v2_notcurses-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notcurses-utils-3.0.13-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notcurses-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notcurses-utils}"
SRC_URI[x86_64_v2_notcurses-utils.sha256sum] = "1f437f29e5816331d55fb04566bac0060179f92698eaee3f214d63354cf54e67"

URI_aarch64_notcurses = "${EPEL_MIRROR}/aarch64/Packages/n/notcurses-3.0.13-2.el10_0.aarch64.rpm;name=aarch64_notcurses;unpack=0"
SRC_URI:append = " ${URI_aarch64_notcurses}"
SRC_URI[aarch64_notcurses.sha256sum] = "a50db8692370fc44b322d83c9182f5a72f54930dca189fc16ebf63c9f4045302"

URI_aarch64_notcurses-devel = "${EPEL_MIRROR}/aarch64/Packages/n/notcurses-devel-3.0.13-2.el10_0.aarch64.rpm;name=aarch64_notcurses-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_notcurses-devel}"
SRC_URI[aarch64_notcurses-devel.sha256sum] = "bd1e41e84b7bd2525d6bfd8f5a8c41f9c81545a481b1c70d196ebd42847b3f52"

URI_aarch64_notcurses-static = "${EPEL_MIRROR}/aarch64/Packages/n/notcurses-static-3.0.13-2.el10_0.aarch64.rpm;name=aarch64_notcurses-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_notcurses-static}"
SRC_URI[aarch64_notcurses-static.sha256sum] = "3690de36f32263c2ff72b64c5eb22710bc6268889e0e041f1a476e894162ba2f"

URI_aarch64_notcurses-utils = "${EPEL_MIRROR}/aarch64/Packages/n/notcurses-utils-3.0.13-2.el10_0.aarch64.rpm;name=aarch64_notcurses-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_notcurses-utils}"
SRC_URI[aarch64_notcurses-utils.sha256sum] = "1851d75aad1473a6deeaea53220931214fd71760051248ee1897f91b37c86eb1"

RDEPENDS:notcurses:x86_64_v2 = " \
 glibc \
 libdeflate \
 libgcc \
 libstdc++ \
 libunistring \
 ncurses-libs \
"
RDEPENDS:notcurses:aarch64 = " \
 glibc \
 libavcodec-free \
 libavdevice-free \
 libavformat-free \
 libavutil-free \
 libdeflate \
 libgcc \
 libstdc++ \
 libswscale-free \
 libunistring \
 ncurses-libs \
"
RDEPENDS:notcurses-devel = " \
 cmake-filesystem \
 ncurses-devel \
 notcurses \
 notcurses-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:notcurses-static = " \
 notcurses \
 "
RDEPENDS:notcurses-utils = " \
 glibc \
 libdeflate \
 libgcc \
 libstdc++ \
 libunistring \
 ncurses-libs \
 notcurses \
 "
