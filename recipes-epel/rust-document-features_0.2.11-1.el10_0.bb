# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-document-features"
PV = "0.2.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-document-features+default-devel \
 rust-document-features+self-test-devel \
 rust-document-features-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-document-features-0.2.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59a2d28bde60e33d687bf256a9005c6121511830244aef095adc729394cd5f31"

URI_x86_64_v2_rust-document-features+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-document-features+default-devel-0.2.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-document-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-document-features+default-devel}"
SRC_URI[x86_64_v2_rust-document-features+default-devel.sha256sum] = "3c5b6a1d53541bfc30f37962de08bc7b5c2be304e90b533569ada880ed73f95c"

URI_x86_64_v2_rust-document-features+self-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-document-features+self-test-devel-0.2.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-document-features+self-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-document-features+self-test-devel}"
SRC_URI[x86_64_v2_rust-document-features+self-test-devel.sha256sum] = "ace994dadc91415a160ba29bf5d923f1ca51c6956b3ac9c1c11f45ee0d81487e"

URI_x86_64_v2_rust-document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-document-features-devel-0.2.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-document-features-devel}"
SRC_URI[x86_64_v2_rust-document-features-devel.sha256sum] = "9d24268a27fd5019c286f4ac5942a1e93863a987130b91e01d3a8fee6dffc1f2"

URI_aarch64_rust-document-features+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-document-features+default-devel-0.2.11-1.el10_0.noarch.rpm;name=aarch64_rust-document-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-document-features+default-devel}"
SRC_URI[aarch64_rust-document-features+default-devel.sha256sum] = "8f8c23239f00ebd7fba6fb820ef79df278105027609b18631c4416281cff3d68"

URI_aarch64_rust-document-features+self-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-document-features+self-test-devel-0.2.11-1.el10_0.noarch.rpm;name=aarch64_rust-document-features+self-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-document-features+self-test-devel}"
SRC_URI[aarch64_rust-document-features+self-test-devel.sha256sum] = "aa6dda905fafae87a6638a4bfabcb0c2ccdeb2ec5dc9317fdb373f04dd8c1242"

URI_aarch64_rust-document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-document-features-devel-0.2.11-1.el10_0.noarch.rpm;name=aarch64_rust-document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-document-features-devel}"
SRC_URI[aarch64_rust-document-features-devel.sha256sum] = "3fcb500117622f5407fd9cb511be46b9b23c7dea39994ba807f148853862ba00"

RDEPENDS:rust-document-features+default-devel = " \
 cargo \
 rust-document-features-devel \
 "
RDEPENDS:rust-document-features+self-test-devel = " \
 cargo \
 rust-document-features-devel \
 "
RDEPENDS:rust-document-features-devel = " \
 cargo \
 rust-litrs-devel \
 "
