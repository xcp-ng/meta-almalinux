# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "poxml"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 poxml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/poxml-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ed28fc006e995b17e8d2780daafcd0820c12d2d81abb71a528fdd9d89daf6cd"

URI_x86_64_v2_poxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/poxml-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_poxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poxml}"
SRC_URI[x86_64_v2_poxml.sha256sum] = "d3bae7dfa07d45d0affda964a3b6d1bcf45a608ac29915ade57243191dd8aae6"

URI_aarch64_poxml = "${EPEL_MIRROR}/aarch64/Packages/p/poxml-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_poxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_poxml}"
SRC_URI[aarch64_poxml.sha256sum] = "0df3a0988dc9ab646fb92e2a5696a7335504c47961d79c5b034d232170592e1a"

RDEPENDS:poxml = " \
 gettext-libs \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
