# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unbound"
PV = "1.26.1"
PR = "2.el10"
PACKAGES = " \
 python3-unbound \
 unbound \
 unbound-anchor \
 unbound-devel \
 unbound-dracut \
 unbound-libs \
 unbound-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/unbound-1.26.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "64b567ddc822eba23399d0c2dfc28bcfe17bd3c5732eb9d2620f0824ed18fcb7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-unbound-1.26.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-unbound;unpack=0"
SRC_URI[x86_64_v2_python3-unbound.sha256sum] = "c0abc95564a250c53dfc1393951b51877689ba6207461c84b902c096f87d1c29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/unbound-1.26.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_unbound;unpack=0"
SRC_URI[x86_64_v2_unbound.sha256sum] = "04b59d311a4db96955e2177f8c65b858f4759252015f80041a5afd53e81abe87"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/unbound-anchor-1.26.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_unbound-anchor;unpack=0"
SRC_URI[x86_64_v2_unbound-anchor.sha256sum] = "eef3cb7c30bc8c73c9d7185ae12995c9fdd2ce89690e88c1df4c35ec63b9c81a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/unbound-devel-1.26.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_unbound-devel;unpack=0"
SRC_URI[x86_64_v2_unbound-devel.sha256sum] = "40039e086f0c98bdbd1fe5950815534b547ecde0cf8dc3db53092cb8c73ce114"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/unbound-dracut-1.26.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_unbound-dracut;unpack=0"
SRC_URI[x86_64_v2_unbound-dracut.sha256sum] = "7fb49265340a6431fda52645eae1d44f541aba6c7443a679ad31ecd9ce575906"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/unbound-libs-1.26.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_unbound-libs;unpack=0"
SRC_URI[x86_64_v2_unbound-libs.sha256sum] = "14e34efe40ee46c7737fb5006e3d33980fab3b5880fb163444fcda51e572d018"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-utils-1.26.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_unbound-utils;unpack=0"
SRC_URI[x86_64_v2_unbound-utils.sha256sum] = "858c2d5ea13d24a551ea96de143fe0d7943e04574e4fb126c8b549425e036f54"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-unbound-1.26.1-2.el10.aarch64.rpm;name=aarch64_python3-unbound;unpack=0"
SRC_URI[aarch64_python3-unbound.sha256sum] = "4cbb9c683e43502299996aa2aba69e09af6c09f7a8aede4f33d395735be4db88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/unbound-1.26.1-2.el10.aarch64.rpm;name=aarch64_unbound;unpack=0"
SRC_URI[aarch64_unbound.sha256sum] = "091a002e62c586cfdecbbb9f48fe031a8b58f4a9d2e21d90584389afa57a071a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/unbound-anchor-1.26.1-2.el10.aarch64.rpm;name=aarch64_unbound-anchor;unpack=0"
SRC_URI[aarch64_unbound-anchor.sha256sum] = "757b996fdaa8587fbe919f3b19bda0447263d647059b088f8b47e2385768a240"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/unbound-devel-1.26.1-2.el10.aarch64.rpm;name=aarch64_unbound-devel;unpack=0"
SRC_URI[aarch64_unbound-devel.sha256sum] = "78687e105415166b74791288b4944a8508a2c7bfc3119ce41455bb74ba5e2e74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/unbound-dracut-1.26.1-2.el10.aarch64.rpm;name=aarch64_unbound-dracut;unpack=0"
SRC_URI[aarch64_unbound-dracut.sha256sum] = "f5d121eac296488e70979509cedbf10aef1a6d73761d910c351a5b9134facf20"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/unbound-libs-1.26.1-2.el10.aarch64.rpm;name=aarch64_unbound-libs;unpack=0"
SRC_URI[aarch64_unbound-libs.sha256sum] = "c5bfb33259fe23d1d76676408af5e67239363bf3dd956d0ae35d35b1d14cc373"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-utils-1.26.1-2.el10.aarch64.rpm;name=aarch64_unbound-utils;unpack=0"
SRC_URI[aarch64_unbound-utils.sha256sum] = "00837915ad57886606ffebab5222e1d7a6e8b95ed099e389b101cfeaa111952b"

RDEPENDS:python3-unbound = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3 \
 python3-libs \
 systemd-libs \
 unbound-libs \
 "
RDEPENDS:unbound = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl \
 openssl-libs \
 protobuf-c \
 python3-libs \
 systemd-libs \
 unbound-anchor \
 unbound-libs \
 "
RDEPENDS:unbound-anchor = " \
 bash \
 expat \
 glibc \
 openssl-libs \
 unbound-libs \
 "
RDEPENDS:unbound-devel = " \
 libevent-devel \
 openssl-devel \
 pkgconf-pkg-config \
 python3-devel \
 unbound-libs \
 "
RDEPENDS:unbound-dracut = " \
 bash \
 dracut \
 unbound \
 "
RDEPENDS:unbound-libs = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3-libs \
 shadow-utils \
 systemd-libs \
 "
RDEPENDS:unbound-utils = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 python3-libs \
 unbound-libs \
 "
