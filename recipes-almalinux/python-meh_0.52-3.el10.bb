# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-meh"
PV = "0.52"
PR = "3.el10"
PACKAGES = " \
 python3-meh \
 python3-meh-gui \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-meh-0.52-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "276a2bc62673c2a800452558335ec456be1ebd272af95a1d9bd16b45de557ea0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-meh-0.52-3.el10.noarch.rpm;name=x86_64_v2_python3-meh;unpack=0"
SRC_URI[x86_64_v2_python3-meh.sha256sum] = "a8ae45cac2058fcc29943409a0703caf165e5f7f8224ccfd0fe01be83d3356bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-meh-gui-0.52-3.el10.noarch.rpm;name=x86_64_v2_python3-meh-gui;unpack=0"
SRC_URI[x86_64_v2_python3-meh-gui.sha256sum] = "c1bbfa97f256c25b2f2715d5201b7a19cc13f0264877ac318f7c20a27f6cec48"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-meh-0.52-3.el10.noarch.rpm;name=aarch64_python3-meh;unpack=0"
SRC_URI[aarch64_python3-meh.sha256sum] = "a8ae45cac2058fcc29943409a0703caf165e5f7f8224ccfd0fe01be83d3356bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-meh-gui-0.52-3.el10.noarch.rpm;name=aarch64_python3-meh-gui;unpack=0"
SRC_URI[aarch64_python3-meh-gui.sha256sum] = "c1bbfa97f256c25b2f2715d5201b7a19cc13f0264877ac318f7c20a27f6cec48"

RDEPENDS:python3-meh = " \
 python3 \
 python3-dbus \
 python3-rpm \
 "
RDEPENDS:python3-meh-gui = " \
 gtk3 \
 python3 \
 python3-gobject \
 python3-meh \
 "
