# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lxc"
PV = "6.0.6"
PR = "1.el10_2"
PACKAGES = " \
 lxc \
 lxc-devel \
 lxc-doc \
 lxc-libs \
 lxc-templates \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lxc-6.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43cb2bd1a4086ffd244364f774023c547643940c20469c0e6d9d1dd7a4a51e08"

URI_x86_64_v2_lxc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-6.0.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc}"
SRC_URI[x86_64_v2_lxc.sha256sum] = "d7da77d79cd49321e48d84514c074bc24d4ad014eb5f237408568c090ad875e6"

URI_x86_64_v2_lxc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-devel-6.0.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-devel}"
SRC_URI[x86_64_v2_lxc-devel.sha256sum] = "9cfd7cbb2afd555d77558d53291b34973e25215acb7f9452d68dc932f209e1af"

URI_x86_64_v2_lxc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-doc-6.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lxc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-doc}"
SRC_URI[x86_64_v2_lxc-doc.sha256sum] = "c8ebad6447d3135e04872506a22e4dedbbb859ec1643ffc636f20b90367d4939"

URI_x86_64_v2_lxc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-libs-6.0.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-libs}"
SRC_URI[x86_64_v2_lxc-libs.sha256sum] = "0c79b4b22a2a40d3b36ae79984cbe29a0eea3f85194fc89311c48a1711252f53"

URI_x86_64_v2_lxc-templates = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-templates-6.0.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-templates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-templates}"
SRC_URI[x86_64_v2_lxc-templates.sha256sum] = "f254ed72b931d452ff72ec59d7dc425487a18c279de154056ae9b13763b8cc73"

URI_aarch64_lxc = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-6.0.6-1.el10_2.aarch64.rpm;name=aarch64_lxc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc}"
SRC_URI[aarch64_lxc.sha256sum] = "dda63911c3ab9f3fe14925cc5b7701fb3bd1c987654c99e5b9ceb0dfcee48f0c"

URI_aarch64_lxc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-devel-6.0.6-1.el10_2.aarch64.rpm;name=aarch64_lxc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-devel}"
SRC_URI[aarch64_lxc-devel.sha256sum] = "00f05b1ee408ecf0c2b78fb7de55d6a1169dad6b289fb6d89f4fd7480f4661aa"

URI_aarch64_lxc-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-doc-6.0.6-1.el10_2.noarch.rpm;name=aarch64_lxc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-doc}"
SRC_URI[aarch64_lxc-doc.sha256sum] = "77f85076bb8c5aa7dc92759c206aba1854771a0803cd8e6ac7e1dee5af44777d"

URI_aarch64_lxc-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-libs-6.0.6-1.el10_2.aarch64.rpm;name=aarch64_lxc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-libs}"
SRC_URI[aarch64_lxc-libs.sha256sum] = "1dbec05807bc71a29b5aa8535c71f78a09670afd5e146957f0ff1118a1c46ea0"

URI_aarch64_lxc-templates = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-templates-6.0.6-1.el10_2.aarch64.rpm;name=aarch64_lxc-templates;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-templates}"
SRC_URI[aarch64_lxc-templates.sha256sum] = "ee6aab8f3970b3f8c0e256e57baacaa987a401de37091c35ee73b3fa66cfc5e2"

RDEPENDS:lxc = " \
 bash \
 dbus-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 lxc-libs \
 lxcfs \
 openssl \
 openssl-libs \
 rsync \
 "
RDEPENDS:lxc-devel = " \
 dbus-devel \
 libcap-devel \
 libseccomp-devel \
 libselinux-devel \
 lxc-libs \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:lxc-doc = " \
 "
RDEPENDS:lxc-libs = " \
 bash \
 dbus-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 pam-libs \
 rsync \
 systemd \
 "
RDEPENDS:lxc-templates = " \
 bash \
 lxc-libs \
 wget \
 "
