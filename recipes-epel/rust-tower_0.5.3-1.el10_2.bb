# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower"
PV = "0.5.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-tower+balance-devel \
 rust-tower+buffer-devel \
 rust-tower+default-devel \
 rust-tower+discover-devel \
 rust-tower+filter-devel \
 rust-tower+full-devel \
 rust-tower+futures-core-devel \
 rust-tower+futures-util-devel \
 rust-tower+hdrhistogram-devel \
 rust-tower+hedge-devel \
 rust-tower+indexmap-devel \
 rust-tower+limit-devel \
 rust-tower+load-devel \
 rust-tower+load-shed-devel \
 rust-tower+log-devel \
 rust-tower+make-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower+ready-cache-devel \
 rust-tower+reconnect-devel \
 rust-tower+retry-devel \
 rust-tower+slab-devel \
 rust-tower+spawn-ready-devel \
 rust-tower+steer-devel \
 rust-tower+sync_wrapper-devel \
 rust-tower+timeout-devel \
 rust-tower+tokio-devel \
 rust-tower+tokio-stream-devel \
 rust-tower+tokio-util-devel \
 rust-tower+tracing-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tower-0.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a1fb5cee157352a573a5da5a32548bc346c6412ea7af397226ccc620d107f811"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+balance-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+balance-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+balance-devel.sha256sum] = "85757c920ca9caa64be56ceb0ccca811efbd1eaa76d59fd842405bfe16928c4c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+buffer-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+buffer-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+buffer-devel.sha256sum] = "d9b0c28b583ec59d71ca15eef9d99449e01b8a915eda708faaac7f55ec56f4cb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+default-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+default-devel.sha256sum] = "1b807c12dfed692abb8017fcde242b85a389a05946b51a39dc41b4868f1f730f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+discover-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+discover-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+discover-devel.sha256sum] = "f35aa614b257c97b07dd0537d38bcea8f0f5c8c93afb34aebc9593e392d759a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+filter-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+filter-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+filter-devel.sha256sum] = "bd310cfec4b05269e163c014f810f97bbbf4f72a75a893b8dbf5b2d61b6593f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+full-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+full-devel.sha256sum] = "875230424d2410c72eaa45a9a45f023848335dd16785214b98ed17abc5ff34f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+futures-core-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+futures-core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+futures-core-devel.sha256sum] = "b2bd8af0233244597962fc09f502371b53d47c27bbab44a0615b4d10ae356f58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+futures-util-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+futures-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+futures-util-devel.sha256sum] = "05d4127495d9aec938680774805158af5b34a2b7e9d2a0446d724d27da36a5ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+hdrhistogram-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+hdrhistogram-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+hdrhistogram-devel.sha256sum] = "ac0bdcbcaa822f401ca4456e7437a33cbddd5dab6a2f9a05be5657667633502d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+hedge-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+hedge-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+hedge-devel.sha256sum] = "ebf55104c68d9392080da73f16678aad58a82cc2ea9bcaa28f94fedf21d45474"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+indexmap-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+indexmap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+indexmap-devel.sha256sum] = "0e6b88c692bfe41b5774d21f611a7113b797b879e33f3e89dc0a3b842e55c680"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+limit-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+limit-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+limit-devel.sha256sum] = "c83a872e022c39a1dcf32b443888701b8ce43360ec23d843ed2f988a82153e01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+load-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+load-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+load-devel.sha256sum] = "9d8f26d66368f93b5aad76f5ffdd1889a8e829a669e26b43a8bc970231755e6b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+load-shed-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+load-shed-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+load-shed-devel.sha256sum] = "52d979b5e0c50cc9332a65bc2531da10ea977266e826420e4af136ebad07685c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+log-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+log-devel.sha256sum] = "1de549980f3d336427cbe3232fc67d4a0dfe1701f90b345059c91003226a9983"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+make-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+make-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+make-devel.sha256sum] = "4701bcc68fb6a280d50c6593bf79300935ea5f6a108389eb5dfa6851bc830889"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+pin-project-lite-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+pin-project-lite-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+pin-project-lite-devel.sha256sum] = "519857926f3623890c3356e50bfbc1f080b4f54a85f3ef932efc4f1cc4bdcdd5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+ready-cache-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+ready-cache-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+ready-cache-devel.sha256sum] = "aff1c3b66194b32b1af4f471fc0464112d4223e58f69334574abf2552b802d74"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+reconnect-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+reconnect-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+reconnect-devel.sha256sum] = "61deff28f9b0b76a9e2fd889673926d0a738f65b2886e6aaeaddcbddc5e0104a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+retry-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+retry-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+retry-devel.sha256sum] = "807e4d8412f435572e5ecb11b30d5d34a069dff578bae29b5c76f5d90370e934"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+slab-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+slab-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+slab-devel.sha256sum] = "96c02a0785ae74e978ba20860be032b99a1859c8ccdadb6d97947b9e18b9fab7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+spawn-ready-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+spawn-ready-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+spawn-ready-devel.sha256sum] = "12d90191b136a04802d30e9179a6a8cbf23ed8e63f87234a59486fe803ae3d8f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+steer-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+steer-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+steer-devel.sha256sum] = "04e58a0d73081fdc1a0a37bd71c5267fc3e341163721f0a92719504408852a05"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+sync_wrapper-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+sync_wrapper-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+sync_wrapper-devel.sha256sum] = "15b8e8643354fdaba66784c1d156f29b260c5b076fbce7830ead693e6884ab3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+timeout-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+timeout-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+timeout-devel.sha256sum] = "871186e620dfd96378d623fe6ae6cf40fd4b1093993c5c2dc4feb6ccdf8d36cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+tokio-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+tokio-devel.sha256sum] = "8e223cdbcca248b9aad9e2200b3b6e27bde02a8e3a7a5ef9b0c0f76983853cbb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+tokio-stream-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+tokio-stream-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+tokio-stream-devel.sha256sum] = "dff7279eeb1861ec69ff959f575defe0b8133badd0ebf9e1049cf404266b7f07"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+tokio-util-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+tokio-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+tokio-util-devel.sha256sum] = "09699b151a9c79c2b10746265335e0fb7c05b0cc820c5b8800b6bb89ab65ed94"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+tracing-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+tracing-devel.sha256sum] = "751e16a513fd88f06f98b3a34d0f81de205d2f263ec48f51b28a3a2835a5ddbb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower+util-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower+util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower+util-devel.sha256sum] = "6751265663c08394ec2937155ca4e114e299e418edaf0927458afc2100c65af0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-devel.sha256sum] = "69c41260f68ddc32136e5f3ab0fdd301ab6aedbff966089c5d9c9db0312dd01b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+balance-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+balance-devel;unpack=0"
SRC_URI[aarch64_rust-tower+balance-devel.sha256sum] = "593cd0d3ddcb0eb946389f4bdce1caf5d32cab8146185a11a5a12f3293623a3b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+buffer-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+buffer-devel;unpack=0"
SRC_URI[aarch64_rust-tower+buffer-devel.sha256sum] = "68db71f4a5e4341457400a068555d50482982691cf506b67f4ea8d435ed4ffff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+default-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+default-devel;unpack=0"
SRC_URI[aarch64_rust-tower+default-devel.sha256sum] = "6895985bc9bb4344140a03db48e11cbf63acf4216379881ecbefbd03f8f42033"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+discover-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+discover-devel;unpack=0"
SRC_URI[aarch64_rust-tower+discover-devel.sha256sum] = "1fed6d5bebc7c8915d1f3795dad8620bafb70512255af300ad073925beafb317"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+filter-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+filter-devel;unpack=0"
SRC_URI[aarch64_rust-tower+filter-devel.sha256sum] = "a6b3024af48283460ce16189a99a3d82155aa66ca8092a41253ede4468ee9d88"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+full-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+full-devel;unpack=0"
SRC_URI[aarch64_rust-tower+full-devel.sha256sum] = "7a8a6d95abe750a043200f49a530e59267d112ccde26428d90e82424ad70ed8c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+futures-core-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+futures-core-devel;unpack=0"
SRC_URI[aarch64_rust-tower+futures-core-devel.sha256sum] = "739a62f7fffebee5b47f3732da33e4a3d57bfffe3fa1af987cd4dd10a31f1932"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+futures-util-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+futures-util-devel;unpack=0"
SRC_URI[aarch64_rust-tower+futures-util-devel.sha256sum] = "fc3e1f737a57bc0256792c32c00a23d83cdf7bbb21ae88d9a413f64050c8d0a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+hdrhistogram-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+hdrhistogram-devel;unpack=0"
SRC_URI[aarch64_rust-tower+hdrhistogram-devel.sha256sum] = "3b8f3920fc4ad1b07f41be53ca019fa4502c64b704a41bebda65a8f2fe95c98f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+hedge-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+hedge-devel;unpack=0"
SRC_URI[aarch64_rust-tower+hedge-devel.sha256sum] = "1891bee7ce0431b5c87cbc7294e1c828d0a756e0dec5ddf27f6310d0a7e8dbe7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+indexmap-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+indexmap-devel;unpack=0"
SRC_URI[aarch64_rust-tower+indexmap-devel.sha256sum] = "690809ee420a27e28d3c1567c04406c932e2b93ea486f5a7a2e73e50a039be93"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+limit-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+limit-devel;unpack=0"
SRC_URI[aarch64_rust-tower+limit-devel.sha256sum] = "2f3f3521fae2447bb07740769a7b64294795f5e91ee07c1e5435ba6e695b32dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+load-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+load-devel;unpack=0"
SRC_URI[aarch64_rust-tower+load-devel.sha256sum] = "a2a530431e9723c7326ab2554646fffcefa48becd04525a180d122b445339e42"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+load-shed-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+load-shed-devel;unpack=0"
SRC_URI[aarch64_rust-tower+load-shed-devel.sha256sum] = "978bfb43cef1cd9ed9ae0c34901636cc2ba79a1075e99ddd8c91b2433d8a0625"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+log-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+log-devel;unpack=0"
SRC_URI[aarch64_rust-tower+log-devel.sha256sum] = "65cf2847e2714429835f4dddf872610c8d8aad72d2e19dd348d90c5e754313ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+make-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+make-devel;unpack=0"
SRC_URI[aarch64_rust-tower+make-devel.sha256sum] = "80b7bba4b9e6cc40f15af5086ccada00e4192fa6956dc76f27618ba3d9ab1536"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+pin-project-lite-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+pin-project-lite-devel;unpack=0"
SRC_URI[aarch64_rust-tower+pin-project-lite-devel.sha256sum] = "583aabaebab984aebe650b1e393b62204fbf2ae0229a216fdfd8d619466ac379"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+ready-cache-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+ready-cache-devel;unpack=0"
SRC_URI[aarch64_rust-tower+ready-cache-devel.sha256sum] = "214fccfc0c62947e02d1707a59bc30e331db365869b2ed688530a4a0678c908c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+reconnect-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+reconnect-devel;unpack=0"
SRC_URI[aarch64_rust-tower+reconnect-devel.sha256sum] = "50e6ce0277fadb18ac28415ad50c5d5da5a221da80d2fd41fbe1ce607c42bdf1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+retry-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+retry-devel;unpack=0"
SRC_URI[aarch64_rust-tower+retry-devel.sha256sum] = "8f2be8f7acd2e19b8776585d91bd795fa418bff530e9590cf853c03ad9a4d3eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+slab-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+slab-devel;unpack=0"
SRC_URI[aarch64_rust-tower+slab-devel.sha256sum] = "b92a12edba23fe556950ce89e97cf8b687f1bd0dc4d4a19d60bb626daf4bb968"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+spawn-ready-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+spawn-ready-devel;unpack=0"
SRC_URI[aarch64_rust-tower+spawn-ready-devel.sha256sum] = "c324e4a95bb22d167dabdc7f38d9a3fda8219d561c274697d0bb7ffb7a30f78e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+steer-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+steer-devel;unpack=0"
SRC_URI[aarch64_rust-tower+steer-devel.sha256sum] = "47667f267b98871506c17008e57b03a7e33479b1a77d81319d7bf659e84c12a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+sync_wrapper-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+sync_wrapper-devel;unpack=0"
SRC_URI[aarch64_rust-tower+sync_wrapper-devel.sha256sum] = "454dddc46106b33fea7daee07313c1e6320ff990e25ec1a3095128047bffd787"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+timeout-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+timeout-devel;unpack=0"
SRC_URI[aarch64_rust-tower+timeout-devel.sha256sum] = "307974198806eccab499990237d3d3a3cbcae03b0629eeffa37eb10a1bacf64d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+tokio-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-tower+tokio-devel.sha256sum] = "ea4498cfefce7553f812c6852873cb0debbcaaf06122d3c9658d5a6d870099b0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+tokio-stream-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+tokio-stream-devel;unpack=0"
SRC_URI[aarch64_rust-tower+tokio-stream-devel.sha256sum] = "ef69dbbebe69e1f5fe4de98536a41cf86b3c07a9f2cc8cb978e8fffdc046989a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+tokio-util-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+tokio-util-devel;unpack=0"
SRC_URI[aarch64_rust-tower+tokio-util-devel.sha256sum] = "0b2bbcf53e1083dad0af46d1caf783a8203b6e731879c7c52c26ae0f5e5cb995"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+tracing-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-tower+tracing-devel.sha256sum] = "8b5255dc17d8c74940eb4d00a931fd8e8b189d4990e0d0e267370c92b861de9c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower+util-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower+util-devel;unpack=0"
SRC_URI[aarch64_rust-tower+util-devel.sha256sum] = "b7b4a8aac1fab5b0d672491c8f51dab25c6108a5dd20774d228807bdc396690f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-tower-devel;unpack=0"
SRC_URI[aarch64_rust-tower-devel.sha256sum] = "09ab3851eefc99b0c8ee6f0397d1294ac87414daf2862ba57de2498ea912cbd6"

RDEPENDS:rust-tower+balance-devel = " \
 cargo \
 rust-tower+discover-devel \
 rust-tower+load-devel \
 rust-tower+make-devel \
 rust-tower+ready-cache-devel \
 rust-tower+slab-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+buffer-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower+tokio-util-devel \
 rust-tower+tracing-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+default-devel = " \
 cargo \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+discover-devel = " \
 cargo \
 rust-tower+futures-core-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+filter-devel = " \
 cargo \
 rust-tower+futures-util-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+full-devel = " \
 cargo \
 rust-tower+balance-devel \
 rust-tower+buffer-devel \
 rust-tower+discover-devel \
 rust-tower+filter-devel \
 rust-tower+hedge-devel \
 rust-tower+limit-devel \
 rust-tower+load-devel \
 rust-tower+load-shed-devel \
 rust-tower+make-devel \
 rust-tower+ready-cache-devel \
 rust-tower+reconnect-devel \
 rust-tower+retry-devel \
 rust-tower+spawn-ready-devel \
 rust-tower+steer-devel \
 rust-tower+timeout-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+futures-core-devel = " \
 cargo \
 rust-futures-core+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+futures-util-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+hdrhistogram-devel = " \
 cargo \
 rust-hdrhistogram-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+hedge-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+time-devel \
 rust-tower+filter-devel \
 rust-tower+futures-util-devel \
 rust-tower+hdrhistogram-devel \
 rust-tower+tracing-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+limit-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower+tokio-util-devel \
 rust-tower+tracing-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+load-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+time-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower+tracing-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+load-shed-devel = " \
 cargo \
 rust-tower+pin-project-lite-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+log-devel = " \
 cargo \
 rust-tower-devel \
 rust-tracing+log-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tower+make-devel = " \
 cargo \
 rust-tower+pin-project-lite-devel \
 rust-tower+tokio-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+pin-project-lite-devel = " \
 cargo \
 rust-pin-project-lite+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+ready-cache-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tower+futures-core-devel \
 rust-tower+futures-util-devel \
 rust-tower+indexmap-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower+tracing-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+reconnect-devel = " \
 cargo \
 rust-tower+make-devel \
 rust-tower+tracing-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+retry-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+time-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+slab-devel = " \
 cargo \
 rust-slab+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+spawn-ready-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tower+futures-util-devel \
 rust-tower+tracing-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+steer-devel = " \
 cargo \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+sync_wrapper-devel = " \
 cargo \
 rust-sync_wrapper+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+timeout-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+time-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+tokio-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+tokio-stream-devel = " \
 cargo \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+tokio-util-devel = " \
 cargo \
 rust-tokio-util-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower+tracing-devel = " \
 cargo \
 rust-tower-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tower+util-devel = " \
 cargo \
 rust-tower+futures-core-devel \
 rust-tower+futures-util-devel \
 rust-tower+pin-project-lite-devel \
 rust-tower+sync_wrapper-devel \
 rust-tower-devel \
 "
RDEPENDS:rust-tower-devel = " \
 cargo \
 rust \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
