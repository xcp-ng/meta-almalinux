# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-simplejson"
PV = "3.19.2"
PR = "1.el10_0"
PACKAGES = " \
 python-simplejson-doc \
 python3-simplejson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-simplejson-3.19.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91b31022cc485b4e916d4c220e321dfd80ae07f806fe19f7f1e886b67a9c7a44"

URI_x86_64_v2_python-simplejson-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-simplejson-doc-3.19.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-simplejson-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-simplejson-doc}"
SRC_URI[x86_64_v2_python-simplejson-doc.sha256sum] = "bd128ca933dc1518223a554fdccbc5060d6955a1d4195ac7b58144ab86581940"

URI_x86_64_v2_python3-simplejson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-simplejson-3.19.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-simplejson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-simplejson}"
SRC_URI[x86_64_v2_python3-simplejson.sha256sum] = "088c257af121e2a261544d2d5b3828d247b8c9b5a65b8335b3fbeed7a997d03a"

URI_aarch64_python-simplejson-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-simplejson-doc-3.19.2-1.el10_0.aarch64.rpm;name=aarch64_python-simplejson-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-simplejson-doc}"
SRC_URI[aarch64_python-simplejson-doc.sha256sum] = "1e92520758ba12703262104804a66f73df49de3dee4fa21224aa98676719c3e0"

URI_aarch64_python3-simplejson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-simplejson-3.19.2-1.el10_0.aarch64.rpm;name=aarch64_python3-simplejson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-simplejson}"
SRC_URI[aarch64_python3-simplejson.sha256sum] = "1a730b67c25d03ea9cc7452322e155b35bdb91c09c2143ce8ab7dc10fac786ae"

RDEPENDS:python-simplejson-doc = " \
 "
RDEPENDS:python3-simplejson = " \
 glibc \
 python3 \
 "
