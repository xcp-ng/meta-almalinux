# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktrip"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 ktrip \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ktrip-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2225ef0943033eacd7e1519dc2c8febe4b649b051486ef294addcf1b0f5e1ff0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktrip-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktrip;unpack=0"
SRC_URI[x86_64_v2_ktrip.sha256sum] = "9d6ebe79a4137688ddd1a99fa5ad409e957135f547493bcae4951a4aeb17f73b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktrip-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ktrip;unpack=0"
SRC_URI[aarch64_ktrip.sha256sum] = "bef0f577c2281a59cbb0915d4e434bcfbd6d1f422b68627e79b32f5e745f6c83"

RDEPENDS:ktrip = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kpublictransport \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
