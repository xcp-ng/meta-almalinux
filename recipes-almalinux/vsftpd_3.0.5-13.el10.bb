# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vsftpd"
PV = "3.0.5"
PR = "13.el10"
PACKAGES = " \
 vsftpd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vsftpd-3.0.5-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "01a149baae43f3f52cb8a7ccbe5c18240a997d2814a532c15138339da5c5bc7f"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - vsftpd: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vsftpd-3.0.5-13.el10.x86_64_v2.rpm;name=x86_64_v2_vsftpd;unpack=0"
SRC_URI[x86_64_v2_vsftpd.sha256sum] = "25f06df38f4336718eb4021c1b06715426ad0fc7b2929f1e8ee54c53d8b5ec1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vsftpd-3.0.5-13.el10.aarch64.rpm;name=aarch64_vsftpd;unpack=0"
SRC_URI[aarch64_vsftpd.sha256sum] = "5c5110032d1fd101dbeb4f03203361497e6783284091a0389eaf8d21008abaa1"

RDEPENDS:vsftpd:x86_64_v2 = " \
 bash \
 glibc \
 libcap \
 logrotate \
 openssl-libs \
 pam-libs \
"
RDEPENDS:vsftpd:aarch64 = " \
 bash \
 glibc \
 logrotate \
 openssl-libs \
 pam-libs \
"
