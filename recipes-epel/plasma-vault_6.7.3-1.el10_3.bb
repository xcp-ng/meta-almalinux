# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-vault"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-vault \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-vault-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc3e38a2ca4db53265fe18eef8dbe151deb30e5a925892c0e9e36460dcf28c73"

URI_x86_64_v2_plasma-vault = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-vault-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-vault;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-vault}"
SRC_URI[x86_64_v2_plasma-vault.sha256sum] = "6ee8a8b003a2640bd0f1b2b377f6658887da4a0fcda22261783c27475b5c1935"

URI_aarch64_plasma-vault = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-vault-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-vault;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-vault}"
SRC_URI[aarch64_plasma-vault.sha256sum] = "bfb5896ee4d6aa486269d993ed561b8bc583fcff2d755768da98b6e340bb8469"

RDEPENDS:plasma-vault = " \
 glibc \
 gocryptfs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libgcc \
 libksysguard \
 libplasma \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
