# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper-rustls"
PV = "0.27.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-hyper-rustls+default-devel \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+http2-devel \
 rust-hyper-rustls+log-devel \
 rust-hyper-rustls+logging-devel \
 rust-hyper-rustls+native-tokio-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+rustls-native-certs-devel \
 rust-hyper-rustls+rustls-platform-verifier-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls+webpki-roots-devel \
 rust-hyper-rustls+webpki-tokio-devel \
 rust-hyper-rustls-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-rustls-0.27.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d372e6df612f576522bfd7014dac27d41df9576bf41ecea6d5e0e648959102d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+default-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+default-devel.sha256sum] = "2a9da7fdc09d27eb85fe316ea3ec6f5e7085c613fab8c3e810ae1f4554d466e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+http1-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+http1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+http1-devel.sha256sum] = "69e56faa7749d47e8a65507a7f116ff6baa8479447352a31db407b92ee1a6b25"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+http2-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+http2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+http2-devel.sha256sum] = "b1c8aa22a64e37773b2a633beb36850a26a6802d3d2f47de3173d30c31a61705"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+log-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+log-devel.sha256sum] = "3a272bc63b05137fcd42d706e409a941782685f1656b094fc58f16b09f862b83"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+logging-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+logging-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+logging-devel.sha256sum] = "c218ba5ded6f6a1a86199708d82dfb3e3d7d59435ff6c0e8dc7d19d8df6f24fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+native-tokio-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+native-tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+native-tokio-devel.sha256sum] = "11d4357c3e521907230456cd2bf9eef0ebecd26641f16457407809159de04f5b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+ring-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+ring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+ring-devel.sha256sum] = "c97f2c7099a098edc650436cc42e673d0c870bcf67606c0aad3dd9b848b3c1e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+rustls-native-certs-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+rustls-native-certs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+rustls-native-certs-devel.sha256sum] = "9d319a4b688be9b678e4f5a3441f4f9d8f720303f36de1efe09bcf58f1751121"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+rustls-platform-verifier-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+rustls-platform-verifier-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+rustls-platform-verifier-devel.sha256sum] = "b64690e8828f5fcfae1cedcd61e2c7cc88ce76ca8e9d08ed6cd5d6d0a8bf9656"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+tls12-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+tls12-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+tls12-devel.sha256sum] = "2edfb6171873d4bfa60498f0b27c0cb96bcbb10706364cd5da07eaef274742e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+webpki-roots-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+webpki-roots-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+webpki-roots-devel.sha256sum] = "56c07494ceee5e88178d09a3b305d8d59c774e5cf2e45318e2b48c6d548e214e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+webpki-tokio-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+webpki-tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls+webpki-tokio-devel.sha256sum] = "6b8607ae1571c31f9131bbf6e6915d82598e9e88c90bcbe18f3467b5d348456c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls-devel-0.27.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-rustls-devel.sha256sum] = "1c0f735a85ef92497900e0862dcfefff65d27f91f69389c42a9440e05cad21e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+default-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+default-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+default-devel.sha256sum] = "ae1fcbd2ac8e079ccaa441f2cd971cb38ff18bd3f900b58b98842309595c0d0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+http1-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+http1-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+http1-devel.sha256sum] = "fc13a201085430eef49973069241214654ef63fce099cda843ab48eeae87203f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+http2-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+http2-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+http2-devel.sha256sum] = "6555def0857e6aea1722db1c565516c91e2d3caf648ca1c5cba8f2fc3176419a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+log-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+log-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+log-devel.sha256sum] = "557971a61f7c47382a29086717c3344ebce4b5a6c7347f6eedcd9297132106ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+logging-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+logging-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+logging-devel.sha256sum] = "35951f4a89582a3b10ba17c66a337beb87f32adf9b502ba2a4ba3d3234db0aab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+native-tokio-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+native-tokio-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+native-tokio-devel.sha256sum] = "6c5d6cb3c51dd298182ff90d007cc2a1833019bbc19c868382ac11113793c76d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+ring-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+ring-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+ring-devel.sha256sum] = "4aaee7b7cef13a553b2e884ca8b98c6926e149297b0198eb26c6fed2f757c002"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+rustls-native-certs-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+rustls-native-certs-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+rustls-native-certs-devel.sha256sum] = "1c2e063b01ac115020af124f480460d4e10aa5b90e4dfcb0fe0a9c30442d1189"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+rustls-platform-verifier-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+rustls-platform-verifier-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+rustls-platform-verifier-devel.sha256sum] = "1e7567ef6f443c62a42618301cae556ba00870e586911cfa089e4c209b7981f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+tls12-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+tls12-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+tls12-devel.sha256sum] = "a21c1c1fda68c3e12df841c5141915a2411fdaa31d8351daf43f01b53d5c1ca0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+webpki-roots-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+webpki-roots-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+webpki-roots-devel.sha256sum] = "999421807f32ad4a3e4b7922d17775707926b86645fa162f8a6337a0b74981e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+webpki-tokio-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls+webpki-tokio-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls+webpki-tokio-devel.sha256sum] = "a6c737a2d8553c819052802322bbaa67fcc65ca4621b7ef32cafebe99a3bc766"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls-devel-0.27.10-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-rustls-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-rustls-devel.sha256sum] = "db3a3b37c94907f87d13a7213fc5484bf32ae20494cf8157a382492d8d95931f"

RDEPENDS:rust-hyper-rustls+default-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+logging-devel \
 rust-hyper-rustls+native-tokio-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 "
RDEPENDS:rust-hyper-rustls+http1-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-hyper-util+http1-devel \
 "
RDEPENDS:rust-hyper-rustls+http2-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-hyper-util+http2-devel \
 "
RDEPENDS:rust-hyper-rustls+log-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-hyper-rustls+logging-devel = " \
 cargo \
 rust-hyper-rustls+log-devel \
 rust-hyper-rustls-devel \
 rust-rustls+logging-devel \
 rust-tokio-rustls+logging-devel \
 "
RDEPENDS:rust-hyper-rustls+native-tokio-devel = " \
 cargo \
 rust-hyper-rustls+rustls-native-certs-devel \
 rust-hyper-rustls-devel \
 "
RDEPENDS:rust-hyper-rustls+ring-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-rustls+ring-devel \
 "
RDEPENDS:rust-hyper-rustls+rustls-native-certs-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-rustls-native-certs+default-devel \
 "
RDEPENDS:rust-hyper-rustls+rustls-platform-verifier-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-rustls-platform-verifier+default-devel \
 "
RDEPENDS:rust-hyper-rustls+tls12-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-rustls+tls12-devel \
 rust-tokio-rustls+tls12-devel \
 "
RDEPENDS:rust-hyper-rustls+webpki-roots-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-hyper-rustls+webpki-tokio-devel = " \
 cargo \
 rust-hyper-rustls+webpki-roots-devel \
 rust-hyper-rustls-devel \
 "
RDEPENDS:rust-hyper-rustls-devel = " \
 cargo \
 rust \
 rust-http+default-devel \
 rust-hyper-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-rustls-devel \
 rust-tokio+default-devel \
 rust-tokio-rustls-devel \
 rust-tower-service+default-devel \
 "
