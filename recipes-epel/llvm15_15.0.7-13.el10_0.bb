# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm15"
PV = "15.0.7"
PR = "13.el10_0"
PACKAGES = " \
 llvm15 \
 llvm15-devel \
 llvm15-doc \
 llvm15-libs \
 llvm15-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/llvm15-15.0.7-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0db470a7c2d45487870673b841951aba7d4b929cd67007e0f286c524f30c7da"

URI_x86_64_v2_llvm15 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm15-15.0.7-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm15;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm15}"
SRC_URI[x86_64_v2_llvm15.sha256sum] = "06a07f2268370c1c7a70cae539c1a63cfa321418099ba6a685178a6445d3ab6c"

URI_x86_64_v2_llvm15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm15-devel-15.0.7-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm15-devel}"
SRC_URI[x86_64_v2_llvm15-devel.sha256sum] = "0fb69b0ab0be9ab495c1fa8acffb0bd57231d6b87719560c0b167730d5626ee5"

URI_x86_64_v2_llvm15-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm15-doc-15.0.7-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_llvm15-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm15-doc}"
SRC_URI[x86_64_v2_llvm15-doc.sha256sum] = "e91f000542ab9364ab72d24f8ea5dfaa20c3cc968a38381b2acc0666662764ba"

URI_x86_64_v2_llvm15-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm15-libs-15.0.7-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm15-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm15-libs}"
SRC_URI[x86_64_v2_llvm15-libs.sha256sum] = "ecd7a87f79603e0e9245bd051b759bf5cc33192019e64f2a77278c85af20e662"

URI_x86_64_v2_llvm15-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm15-static-15.0.7-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm15-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm15-static}"
SRC_URI[x86_64_v2_llvm15-static.sha256sum] = "4cc849314f7894260ed474c5cf444c6f614bab6a2cc8e54e82972fa9efbd0e0b"

URI_aarch64_llvm15 = "${EPEL_MIRROR}/aarch64/Packages/l/llvm15-15.0.7-13.el10_0.aarch64.rpm;name=aarch64_llvm15;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm15}"
SRC_URI[aarch64_llvm15.sha256sum] = "14695b21facde6b0efdcc241958aadd54cf78407d3f0411891e84c08f823e146"

URI_aarch64_llvm15-devel = "${EPEL_MIRROR}/aarch64/Packages/l/llvm15-devel-15.0.7-13.el10_0.aarch64.rpm;name=aarch64_llvm15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm15-devel}"
SRC_URI[aarch64_llvm15-devel.sha256sum] = "f661bf928056cf6adb7a914b0477058afd460891068189a9d62a854afab64f75"

URI_aarch64_llvm15-doc = "${EPEL_MIRROR}/aarch64/Packages/l/llvm15-doc-15.0.7-13.el10_0.noarch.rpm;name=aarch64_llvm15-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm15-doc}"
SRC_URI[aarch64_llvm15-doc.sha256sum] = "c8330c5b8b8fbd2f223ccdcb7a408c79cd8e36531873431ace11caa4fdee2649"

URI_aarch64_llvm15-libs = "${EPEL_MIRROR}/aarch64/Packages/l/llvm15-libs-15.0.7-13.el10_0.aarch64.rpm;name=aarch64_llvm15-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm15-libs}"
SRC_URI[aarch64_llvm15-libs.sha256sum] = "65b49f1c3ccb73a10f05bd61f24d6f69430454ae8e0d623314acc4f2be380d7d"

URI_aarch64_llvm15-static = "${EPEL_MIRROR}/aarch64/Packages/l/llvm15-static-15.0.7-13.el10_0.aarch64.rpm;name=aarch64_llvm15-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm15-static}"
SRC_URI[aarch64_llvm15-static.sha256sum] = "656bc82ba4dd9fb25a09cd94b6d3079d3eec10dc8b6708c6e9be41d1da25363b"

RDEPENDS:llvm15 = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm15-libs \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:llvm15-devel = " \
 alternatives \
 bash \
 libedit-devel \
 llvm15 \
 llvm15-libs \
 llvm15-static \
 "
RDEPENDS:llvm15-doc = " \
 llvm15 \
 "
RDEPENDS:llvm15-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:llvm15-static = " \
 "
