# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setroubleshoot"
PV = "3.3.35"
PR = "1.el10"
PACKAGES = " \
 setroubleshoot \
 setroubleshoot-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/setroubleshoot-3.3.35-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cad939cd16d258416f1dd563b9b69ab513d8e4bf4a950f47cedfd6b691825eb5"

URI_x86_64_v2_setroubleshoot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setroubleshoot-3.3.35-1.el10.x86_64_v2.rpm;name=x86_64_v2_setroubleshoot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setroubleshoot}"
SRC_URI[x86_64_v2_setroubleshoot.sha256sum] = "abb03344a6b37acc408dc2ac78fb82d72599849084428ef549d06ea7ce071672"

URI_x86_64_v2_setroubleshoot-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setroubleshoot-server-3.3.35-1.el10.x86_64_v2.rpm;name=x86_64_v2_setroubleshoot-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setroubleshoot-server}"
SRC_URI[x86_64_v2_setroubleshoot-server.sha256sum] = "3e173175bc9694bde11a5a86a31b059a4859d12b5c923924dbbc2710e3d35333"

URI_aarch64_setroubleshoot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setroubleshoot-3.3.35-1.el10.aarch64.rpm;name=aarch64_setroubleshoot;unpack=0"
SRC_URI:append = " ${URI_aarch64_setroubleshoot}"
SRC_URI[aarch64_setroubleshoot.sha256sum] = "fcca74dc7d2b169b36b0a68e8054eb71fdc9bb1e96a045f7172e705a2da69f58"

URI_aarch64_setroubleshoot-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setroubleshoot-server-3.3.35-1.el10.aarch64.rpm;name=aarch64_setroubleshoot-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_setroubleshoot-server}"
SRC_URI[aarch64_setroubleshoot-server.sha256sum] = "f3ad8057ba00856807f8afb4533d997cf8a261d24eee193a6cccfcc29dbcee65"

RDEPENDS:setroubleshoot = " \
 dbus \
 desktop-file-utils \
 gtk3 \
 libnotify \
 python3 \
 python3-dasbus \
 python3-gobject \
 setroubleshoot-server \
 xdg-utils \
 "
RDEPENDS:setroubleshoot-server = " \
 audit \
 audit-libs \
 bash \
 dbus \
 dbus-libs \
 glibc \
 initscripts-service \
 libcap-ng \
 libselinux \
 policycoreutils-python-utils \
 polkit \
 python3 \
 python3-audit \
 python3-dasbus \
 python3-dbus \
 python3-gobject-base \
 python3-libselinux \
 python3-libxml2 \
 python3-rpm \
 python3-six \
 python3-systemd \
 setroubleshoot-plugins \
 "
