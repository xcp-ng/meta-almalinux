# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-equator-macro"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-equator-macro+default-devel \
 rust-equator-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-equator-macro-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8c1e72ec9b800cc20deb95aaa7dc831ad1526ab21238da13ad9eee167f72e05"

URI_x86_64_v2_rust-equator-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equator-macro+default-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equator-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equator-macro+default-devel}"
SRC_URI[x86_64_v2_rust-equator-macro+default-devel.sha256sum] = "2b7cc00f9674eea1db0f0bceafa25e6688febaa423bf6f92862438db6fc9fded"

URI_x86_64_v2_rust-equator-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equator-macro-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equator-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equator-macro-devel}"
SRC_URI[x86_64_v2_rust-equator-macro-devel.sha256sum] = "b556f57084d2053d82bd56ae97d4428dda965701af373af0804a2aab4a33d37e"

URI_aarch64_rust-equator-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equator-macro+default-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-equator-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equator-macro+default-devel}"
SRC_URI[aarch64_rust-equator-macro+default-devel.sha256sum] = "66a3e8e61a50dfa8e81c0e42c86ba1bad2ac0994c698045f00bbedd48c0ff241"

URI_aarch64_rust-equator-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equator-macro-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-equator-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equator-macro-devel}"
SRC_URI[aarch64_rust-equator-macro-devel.sha256sum] = "10a2b2028f13b63013058d2a5d31091d8bbde8798ff33da3709ba51283d2feff"

RDEPENDS:rust-equator-macro+default-devel = " \
 cargo \
 rust-equator-macro-devel \
 "
RDEPENDS:rust-equator-macro-devel = " \
 cargo \
 "
