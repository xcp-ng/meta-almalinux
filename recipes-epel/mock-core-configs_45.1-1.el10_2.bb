# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mock-core-configs"
PV = "45.1"
PR = "1.el10_2"
PACKAGES = " \
 mock-core-configs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mock-core-configs-45.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1f92b90aa2af7c1c9f1987e6f2b4cdb8e17b74ad26fe93140a1c4d7013c074c"

URI_x86_64_v2_mock-core-configs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-core-configs-45.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mock-core-configs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-core-configs}"
SRC_URI[x86_64_v2_mock-core-configs.sha256sum] = "5206534df14306971af9c811ffb48e0a9cd1e3c80156403c114b80d3b3129539"

URI_aarch64_mock-core-configs = "${EPEL_MIRROR}/aarch64/Packages/m/mock-core-configs-45.1-1.el10_2.noarch.rpm;name=aarch64_mock-core-configs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-core-configs}"
SRC_URI[aarch64_mock-core-configs.sha256sum] = "e46b699c0ce0d9320ff34b595900fdd41b23c28e4909b1c5ec510b3228166f27"

RDEPENDS:mock-core-configs = " \
 almalinux-release \
 bash \
 distribution-gpg-keys \
 mock \
 mock-filesystem \
 python3 \
 virtual/coreutils \
 virtual/python3-libdnf5_or__python3-dnf_and_python3-hawkey_ \
 "
