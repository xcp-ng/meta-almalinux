# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crash-gcore-command"
PV = "1.6.4"
PR = "9.el10"
PACKAGES = " \
 crash-gcore-command \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crash-gcore-command-1.6.4-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8575ebb1f8120aa4acc82711834b1c8b6f570e1f9d0fcfd152c572f4e8583b1e"

URI_x86_64_v2_crash-gcore-command = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crash-gcore-command-1.6.4-9.el10.x86_64_v2.rpm;name=x86_64_v2_crash-gcore-command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crash-gcore-command}"
SRC_URI[x86_64_v2_crash-gcore-command.sha256sum] = "d6f7b55e3f2e566eb7357bc94bd36373328079fc0e4994cbb0b8331a4f8e2fb4"

URI_aarch64_crash-gcore-command = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crash-gcore-command-1.6.4-9.el10.aarch64.rpm;name=aarch64_crash-gcore-command;unpack=0"
SRC_URI:append = " ${URI_aarch64_crash-gcore-command}"
SRC_URI[aarch64_crash-gcore-command.sha256sum] = "4c6c1faa85f2648f3c66384cb473b9cfd58e0629d70a6d311ae49d72e0674d4a"

RDEPENDS:crash-gcore-command = " \
 crash \
 glibc \
 "
