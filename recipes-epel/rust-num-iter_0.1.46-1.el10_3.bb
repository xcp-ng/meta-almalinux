# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-iter"
PV = "0.1.46"
PR = "1.el10_3"
PACKAGES = " \
 rust-num-iter+default-devel \
 rust-num-iter+i128-devel \
 rust-num-iter+std-devel \
 rust-num-iter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-iter-0.1.46-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30cd792014b3bc6bd05de165404c293b7857fd59761da132cfc669ead5c124ef"

URI_x86_64_v2_rust-num-iter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter+default-devel-0.1.46-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter+default-devel}"
SRC_URI[x86_64_v2_rust-num-iter+default-devel.sha256sum] = "65cd0e037c74a56cfef181fe12e3e9341b1d0118d2b4ded684d235b81a6e7c8c"

URI_x86_64_v2_rust-num-iter+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter+i128-devel-0.1.46-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter+i128-devel}"
SRC_URI[x86_64_v2_rust-num-iter+i128-devel.sha256sum] = "8419405e02ba4a5a9e5579ae566c6bf6a710b41c0d951ded536eaf55493a8a57"

URI_x86_64_v2_rust-num-iter+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter+std-devel-0.1.46-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter+std-devel}"
SRC_URI[x86_64_v2_rust-num-iter+std-devel.sha256sum] = "2cc90e64a16374dc45aff0461f09946ffde96164fca7492398db79773af8fc1d"

URI_x86_64_v2_rust-num-iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-iter-devel-0.1.46-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-iter-devel}"
SRC_URI[x86_64_v2_rust-num-iter-devel.sha256sum] = "cf5f37d65c6143dc931bbb7981b5ae28ff5051002f03a944ce9fb4f5dd748d81"

URI_aarch64_rust-num-iter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter+default-devel-0.1.46-1.el10_3.noarch.rpm;name=aarch64_rust-num-iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter+default-devel}"
SRC_URI[aarch64_rust-num-iter+default-devel.sha256sum] = "4ad87e927c2901fe4a72dd6638261d83bb0a9b5ee0739cc1edeb7178f71995e6"

URI_aarch64_rust-num-iter+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter+i128-devel-0.1.46-1.el10_3.noarch.rpm;name=aarch64_rust-num-iter+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter+i128-devel}"
SRC_URI[aarch64_rust-num-iter+i128-devel.sha256sum] = "45d96b22212852efddcbbb1a257c4fa324c9735cdf728cebe4ca6995e8d0e3f0"

URI_aarch64_rust-num-iter+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter+std-devel-0.1.46-1.el10_3.noarch.rpm;name=aarch64_rust-num-iter+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter+std-devel}"
SRC_URI[aarch64_rust-num-iter+std-devel.sha256sum] = "bdfce5e08ae0b10aa7c5245c0052f79dd7de721856b299609051b6136cc1b87d"

URI_aarch64_rust-num-iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-iter-devel-0.1.46-1.el10_3.noarch.rpm;name=aarch64_rust-num-iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-iter-devel}"
SRC_URI[aarch64_rust-num-iter-devel.sha256sum] = "fdb0574b535b32ead011c3812ece412e4fbf41a4940e5a1ff66437f1b7744083"

RDEPENDS:rust-num-iter+default-devel = " \
 cargo \
 rust-num-iter+std-devel \
 rust-num-iter-devel \
 "
RDEPENDS:rust-num-iter+i128-devel = " \
 cargo \
 rust-num-iter-devel \
 "
RDEPENDS:rust-num-iter+std-devel = " \
 cargo \
 rust-num-integer+std-devel \
 rust-num-iter-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-iter-devel = " \
 cargo \
 rust \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
