# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipv6toolkit"
PV = "2.2"
PR = "2.el10_0"
PACKAGES = " \
 ipv6toolkit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ipv6toolkit-2.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de296b309d9ce2d257dad6c49a9bc06198800c808ffc11d5adb8b97734e98724"

URI_x86_64_v2_ipv6toolkit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ipv6toolkit-2.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ipv6toolkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipv6toolkit}"
SRC_URI[x86_64_v2_ipv6toolkit.sha256sum] = "ec4b065a4d715db12cabada0fa17dd1ceddbea7246ca8ad20fbbab790838532d"

URI_aarch64_ipv6toolkit = "${EPEL_MIRROR}/aarch64/Packages/i/ipv6toolkit-2.2-2.el10_0.aarch64.rpm;name=aarch64_ipv6toolkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipv6toolkit}"
SRC_URI[aarch64_ipv6toolkit.sha256sum] = "13d74d212e871e13e9a72083304d6152e82c991068d03e0b5678bdc4fa383f85"

RDEPENDS:ipv6toolkit = " \
 curl \
 glibc \
 libpcap \
 perl-Crypt-X509 \
 perl-IPC-Open3 \
 perl-MIME-Base64 \
 perl-Net-DNS \
 perl-Net-IP \
 perl-Socket \
 perl-constant \
 perl-interpreter \
 "
