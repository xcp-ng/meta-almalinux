# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_info"
PV = "3.12.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-os_info+default-devel \
 rust-os_info+serde-devel \
 rust-os_info-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_info-3.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a327b1f9beb9b27cb7705c703ee3f55c17fa63b28812a29221e8a3a570efe4ba"

URI_x86_64_v2_rust-os_info+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info+default-devel-3.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info+default-devel}"
SRC_URI[x86_64_v2_rust-os_info+default-devel.sha256sum] = "62fdac69778057f13b461b1dfe559564baec8623420f6aaa983b65e954ebab19"

URI_x86_64_v2_rust-os_info+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info+serde-devel-3.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info+serde-devel}"
SRC_URI[x86_64_v2_rust-os_info+serde-devel.sha256sum] = "6f4bb391b79528656266fbcbdea86b4f7597834076f620f55fbabb8acc01200c"

URI_x86_64_v2_rust-os_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info-devel-3.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info-devel}"
SRC_URI[x86_64_v2_rust-os_info-devel.sha256sum] = "11da0e6ff7af33f1e47a925f0e0ff40b7119b99a81f7919b02b79dd7ad8aff06"

URI_aarch64_rust-os_info+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info+default-devel-3.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-os_info+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info+default-devel}"
SRC_URI[aarch64_rust-os_info+default-devel.sha256sum] = "172cd9d8fadbd91502d5aab06d3ebec90db5126dee625ad37793ac217e58311a"

URI_aarch64_rust-os_info+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info+serde-devel-3.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-os_info+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info+serde-devel}"
SRC_URI[aarch64_rust-os_info+serde-devel.sha256sum] = "776633637cda6429803662a3a3362a63b921a05491d3e1557c0f6b64868b8655"

URI_aarch64_rust-os_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info-devel-3.12.0-1.el10_1.noarch.rpm;name=aarch64_rust-os_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info-devel}"
SRC_URI[aarch64_rust-os_info-devel.sha256sum] = "3d01ec818aaf8ae78313bbe0a90985827bf157def0a6c3ab6a672d3c54c79fcb"

RDEPENDS:rust-os_info+default-devel = " \
 cargo \
 rust-os_info+serde-devel \
 rust-os_info-devel \
 "
RDEPENDS:rust-os_info+serde-devel = " \
 cargo \
 rust-os_info-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-os_info-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 "
