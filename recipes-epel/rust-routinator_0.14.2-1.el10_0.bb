# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-routinator"
PV = "0.14.2"
PR = "1.el10_0"
PACKAGES = " \
 routinator \
 rust-routinator+arbitrary-devel \
 rust-routinator+default-devel \
 rust-routinator+native-tls-devel \
 rust-routinator+rta-devel \
 rust-routinator+socks-devel \
 rust-routinator+ui-devel \
 rust-routinator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-routinator-0.14.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3da7661b31d7ba798e52b380246bf89dc177b7f567a1658ec854b1ff003195a7"

URI_x86_64_v2_routinator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/routinator-0.14.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_routinator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_routinator}"
SRC_URI[x86_64_v2_routinator.sha256sum] = "1bc71916120afb6e4c6f964af696518be5f41f760e6a29a6dfaaf8fefaf12e25"

URI_x86_64_v2_rust-routinator+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+arbitrary-devel-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-routinator+arbitrary-devel.sha256sum] = "958266af26171f9eaf68d3914450ce146bc65618b23ae105299d598ca224e9fc"

URI_x86_64_v2_rust-routinator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+default-devel-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+default-devel}"
SRC_URI[x86_64_v2_rust-routinator+default-devel.sha256sum] = "671498a02fc3ad5d3777fb223c21013b3273c042cb53b5c9059cd42290d542a4"

URI_x86_64_v2_rust-routinator+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+native-tls-devel-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+native-tls-devel}"
SRC_URI[x86_64_v2_rust-routinator+native-tls-devel.sha256sum] = "e25ab5487ff515017b7f7cea133b0b6c028bdff87d504992b75c9ebce76317f9"

URI_x86_64_v2_rust-routinator+rta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+rta-devel-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+rta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+rta-devel}"
SRC_URI[x86_64_v2_rust-routinator+rta-devel.sha256sum] = "f98e26c29bf44aa23fa88f084df4f8f6e7160eee7968c66bda94dbbe675a439f"

URI_x86_64_v2_rust-routinator+socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+socks-devel-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+socks-devel}"
SRC_URI[x86_64_v2_rust-routinator+socks-devel.sha256sum] = "78419596084b334f88d3537058ebab8e8694f89a3fb73e50afda8fe4728f5d06"

URI_x86_64_v2_rust-routinator+ui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+ui-devel-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+ui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+ui-devel}"
SRC_URI[x86_64_v2_rust-routinator+ui-devel.sha256sum] = "61725fe9d629abc94a44d22cf8dcc1b9cf1eb3aa7521281fffaf9dd2429d68d5"

URI_x86_64_v2_rust-routinator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator-devel-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator-devel}"
SRC_URI[x86_64_v2_rust-routinator-devel.sha256sum] = "a58bf9ffd3e1a19063c776beeabb0f55cb90db4ee736f15c402f21c2f6ff1e94"

URI_aarch64_routinator = "${EPEL_MIRROR}/aarch64/Packages/r/routinator-0.14.2-1.el10_0.aarch64.rpm;name=aarch64_routinator;unpack=0"
SRC_URI:append = " ${URI_aarch64_routinator}"
SRC_URI[aarch64_routinator.sha256sum] = "514a4dfb5c200f12dc490b4f339255aa599741ee9033e6784b4105deb037a09c"

URI_aarch64_rust-routinator+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+arbitrary-devel-0.14.2-1.el10_0.noarch.rpm;name=aarch64_rust-routinator+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+arbitrary-devel}"
SRC_URI[aarch64_rust-routinator+arbitrary-devel.sha256sum] = "d06fc668a3d1e3e15405d57dd04a631415d4dbfe6f322a598471c3274aa2d3a5"

URI_aarch64_rust-routinator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+default-devel-0.14.2-1.el10_0.noarch.rpm;name=aarch64_rust-routinator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+default-devel}"
SRC_URI[aarch64_rust-routinator+default-devel.sha256sum] = "db9e4a601009de596ff9e4a066cf9740c74a5e45cd34783db5d66b48e6e1e3aa"

URI_aarch64_rust-routinator+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+native-tls-devel-0.14.2-1.el10_0.noarch.rpm;name=aarch64_rust-routinator+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+native-tls-devel}"
SRC_URI[aarch64_rust-routinator+native-tls-devel.sha256sum] = "c76f4c52f34bb6be78157867f01a233cc599285657e2569e46b98d0dcbef49b4"

URI_aarch64_rust-routinator+rta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+rta-devel-0.14.2-1.el10_0.noarch.rpm;name=aarch64_rust-routinator+rta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+rta-devel}"
SRC_URI[aarch64_rust-routinator+rta-devel.sha256sum] = "c00c685ca4063612466c18a6b348e780f6ebbe017cd22a041b80ef45e3282344"

URI_aarch64_rust-routinator+socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+socks-devel-0.14.2-1.el10_0.noarch.rpm;name=aarch64_rust-routinator+socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+socks-devel}"
SRC_URI[aarch64_rust-routinator+socks-devel.sha256sum] = "aee0629cf242c20da86eafb61838ae0684456182f865c74bb7fb121e26e5daf3"

URI_aarch64_rust-routinator+ui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+ui-devel-0.14.2-1.el10_0.noarch.rpm;name=aarch64_rust-routinator+ui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+ui-devel}"
SRC_URI[aarch64_rust-routinator+ui-devel.sha256sum] = "25b8242b980c8f592ba63650a6d5ed420ce4f44faac3b89d309aaee9b3f97717"

URI_aarch64_rust-routinator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator-devel-0.14.2-1.el10_0.noarch.rpm;name=aarch64_rust-routinator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator-devel}"
SRC_URI[aarch64_rust-routinator-devel.sha256sum] = "f8bf450b532eb038aa2b0eb9a13ee49e32c297bfd13b932dd3b1134dcdd60e01"

RDEPENDS:routinator = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-routinator+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono+arbitrary-devel \
 rust-routinator-devel \
 rust-rpki+arbitrary-devel \
 "
RDEPENDS:rust-routinator+default-devel = " \
 cargo \
 rust-routinator+socks-devel \
 rust-routinator+ui-devel \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+native-tls-devel = " \
 cargo \
 rust-reqwest+native-tls-devel \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+rta-devel = " \
 cargo \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+socks-devel = " \
 cargo \
 rust-reqwest+socks-devel \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+ui-devel = " \
 cargo \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator-devel = " \
 bash \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-chrono+default-devel \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+wrap_help-devel \
 rust-crossbeam-queue+default-devel \
 rust-dirs+default-devel \
 rust-form_urlencoded+default-devel \
 rust-futures+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+default-devel \
 rust-hyper+server-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-devel \
 rust-listenfd+default-devel \
 rust-log+default-devel \
 rust-nix0.27+default-devel \
 rust-nix0.27+fs-devel \
 rust-nix0.27+mman-devel \
 rust-nix0.27+net-devel \
 rust-nix0.27+process-devel \
 rust-nix0.27+socket-devel \
 rust-nix0.27+user-devel \
 rust-pin-project-lite+default-devel \
 rust-rand0.8+default-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest-devel \
 rust-ring+default-devel \
 rust-rpki+default-devel \
 rust-rpki+repository-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-devel \
 rust-rpki+slurm-devel \
 rust-rustls-pemfile+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-siphasher+default-devel \
 rust-syslog+default-devel \
 rust-tempfile+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+sync-devel \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 rust-toml_edit+default-devel \
 rust-uuid+default-devel \
 "
