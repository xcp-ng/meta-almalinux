# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-seancfoley-ipaddress"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-seancfoley-ipaddress-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-seancfoley-ipaddress-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "698ae3f00a4366c3d7ad8fc09e3e54133a1ca68d91f1013862a4c52f5e6ef095"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-seancfoley-ipaddress-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-seancfoley-ipaddress-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-seancfoley-ipaddress-devel.sha256sum] = "a2bf8b041fddb795fb177fc6f38444153f241e408991e666bd71d8309b205030"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-seancfoley-ipaddress-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-seancfoley-ipaddress-devel;unpack=0"
SRC_URI[aarch64_golang-github-seancfoley-ipaddress-devel.sha256sum] = "c5e2ac354fb2b7992210c83be05496ab4d128d3086f83f690529091bd93a193f"

RDEPENDS:golang-github-seancfoley-ipaddress-devel = " \
 go-filesystem \
 golang-github-seancfoley-bintree-devel \
 "
