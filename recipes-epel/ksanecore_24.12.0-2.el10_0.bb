# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksanecore"
PV = "24.12.0"
PR = "2.el10_0"
PACKAGES = " \
 ksanecore \
 ksanecore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksanecore-24.12.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e0e674d8d46a7ec5a09381db0521d85e31cf03835dd14b36046d2624bf0a62e"

URI_x86_64_v2_ksanecore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksanecore-24.12.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksanecore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksanecore}"
SRC_URI[x86_64_v2_ksanecore.sha256sum] = "9027c8f9ca9f7347a0ac19c6737db8abb60c07bd8c9ee7ae2a68c144e7114dbb"

URI_x86_64_v2_ksanecore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksanecore-devel-24.12.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksanecore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksanecore-devel}"
SRC_URI[x86_64_v2_ksanecore-devel.sha256sum] = "cb240f8aadce0cc9ac1ef5712067c6f1cfdfc051e7040d7fefba37948c629a27"

URI_aarch64_ksanecore = "${EPEL_MIRROR}/aarch64/Packages/k/ksanecore-24.12.0-2.el10_0.aarch64.rpm;name=aarch64_ksanecore;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksanecore}"
SRC_URI[aarch64_ksanecore.sha256sum] = "f800a049fb63530590080b148959c2c43f8bee784bb98443b9a90529958318ec"

URI_aarch64_ksanecore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ksanecore-devel-24.12.0-2.el10_0.aarch64.rpm;name=aarch64_ksanecore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksanecore-devel}"
SRC_URI[aarch64_ksanecore-devel.sha256sum] = "0cd266dbcf7729450cbcb515276c5ca0d2c6ecf65765abb792dfc543eba3d744"

RDEPENDS:ksanecore = " \
 glibc \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 sane-backends-libs \
 "
RDEPENDS:ksanecore-devel = " \
 cmake-filesystem \
 ksanecore \
 qt6-qtbase-devel \
 "
