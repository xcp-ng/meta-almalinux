# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parallel-Pipes"
PV = "0.201"
PR = "1.el10_0"
PACKAGES = " \
 perl-Parallel-Pipes \
 perl-Parallel-Pipes-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Parallel-Pipes-0.201-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e94d22bb9db12f99596758e34d7d2472e89dc46dca914c4c6f97d95c983854e"

URI_x86_64_v2_perl-Parallel-Pipes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parallel-Pipes-0.201-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parallel-Pipes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parallel-Pipes}"
SRC_URI[x86_64_v2_perl-Parallel-Pipes.sha256sum] = "ce4251458f109f6049a048e96674d22a8f8c16c77cc0e82d68f86d2861915b6c"

URI_x86_64_v2_perl-Parallel-Pipes-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parallel-Pipes-tests-0.201-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parallel-Pipes-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parallel-Pipes-tests}"
SRC_URI[x86_64_v2_perl-Parallel-Pipes-tests.sha256sum] = "d2a7bf13ab61aaec64f69bf3a2392708f4fc83469714a44154ee221015439925"

URI_aarch64_perl-Parallel-Pipes = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Parallel-Pipes-0.201-1.el10_0.noarch.rpm;name=aarch64_perl-Parallel-Pipes;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parallel-Pipes}"
SRC_URI[aarch64_perl-Parallel-Pipes.sha256sum] = "c9543ba5d4b5634485a73d0cca9447be21c4c33fab6cc4c5fda40c5eeb2c474a"

URI_aarch64_perl-Parallel-Pipes-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Parallel-Pipes-tests-0.201-1.el10_0.noarch.rpm;name=aarch64_perl-Parallel-Pipes-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parallel-Pipes-tests}"
SRC_URI[aarch64_perl-Parallel-Pipes-tests.sha256sum] = "8ec5e0cb76abecde6ab3c1106be04d906edb5fe49c0114bc78cf6ad8c40422ce"

RDEPENDS:perl-Parallel-Pipes = " \
 perl-Carp \
 perl-IO \
 perl-Parallel-Pipes \
 perl-Storable \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Parallel-Pipes-tests = " \
 bash \
 perl-File-Temp \
 perl-Parallel-Pipes \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 "
