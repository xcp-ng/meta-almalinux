# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "devscripts"
PV = "2.25.5"
PR = "1.el10_1"
PACKAGES = " \
 devscripts \
 devscripts-checkbashisms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/devscripts-2.25.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75820f17d6e72e5ebee5323bf9a2076f3c1946ceea0574d65529a811c8802673"

URI_x86_64_v2_devscripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/devscripts-2.25.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_devscripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_devscripts}"
SRC_URI[x86_64_v2_devscripts.sha256sum] = "b5990d20cae6c8144f6b29b080bc3a24856c4bf4f13aa66b37456c1510381ce1"

URI_x86_64_v2_devscripts-checkbashisms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/devscripts-checkbashisms-2.25.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_devscripts-checkbashisms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_devscripts-checkbashisms}"
SRC_URI[x86_64_v2_devscripts-checkbashisms.sha256sum] = "55cad1fdb076013aee7dd92419d9b4f32d8c3dfdf718c2cb3e8892c60f119380"

URI_aarch64_devscripts = "${EPEL_MIRROR}/aarch64/Packages/d/devscripts-2.25.5-1.el10_1.noarch.rpm;name=aarch64_devscripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_devscripts}"
SRC_URI[aarch64_devscripts.sha256sum] = "43309e4db2fc63af3f91035f62be978f650855233754f176996475ed85daee90"

URI_aarch64_devscripts-checkbashisms = "${EPEL_MIRROR}/aarch64/Packages/d/devscripts-checkbashisms-2.25.5-1.el10_1.noarch.rpm;name=aarch64_devscripts-checkbashisms;unpack=0"
SRC_URI:append = " ${URI_aarch64_devscripts-checkbashisms}"
SRC_URI[aarch64_devscripts-checkbashisms.sha256sum] = "6a5352f753071f89261b9fc3bbce22d0d5bc96678eaa550db638b0377049ace8"

RDEPENDS:devscripts = " \
 bash \
 devscripts \
 devscripts-checkbashisms \
 dpkg-dev \
 dpkg-perl \
 perl-Carp \
 perl-DB_File \
 perl-Data-Dumper \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Encode-Locale \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-DirList \
 perl-File-Find \
 perl-File-HomeDir \
 perl-File-Path \
 perl-File-Temp \
 perl-File-Touch \
 perl-File-Which \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Git-Wrapper \
 perl-GitLab-API-v4 \
 perl-HTTP-Message \
 perl-HTTP-Tiny \
 perl-IO \
 perl-IPC-Open3 \
 perl-IPC-Run \
 perl-JSON \
 perl-JSON-PP \
 perl-List-Compare \
 perl-MIME-Base64 \
 perl-Moo \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Scalar-List-Utils \
 perl-String-ShellQuote \
 perl-Symbol \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-Text-Tabs+Wrap \
 perl-Time-Piece \
 perl-Try-Tiny \
 perl-URI \
 perl-autodie \
 perl-base \
 perl-constant \
 perl-filetest \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 perl-open \
 perl-podlators \
 perl-sigtrap \
 perl-vars \
 python3 \
 sensible-utils \
 virtual//usr/bin/man \
 "
RDEPENDS:devscripts-checkbashisms = " \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
