# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordermap"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ordermap+arbitrary-devel \
 rust-ordermap+default-devel \
 rust-ordermap+quickcheck-devel \
 rust-ordermap+rayon-devel \
 rust-ordermap+serde-devel \
 rust-ordermap+std-devel \
 rust-ordermap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordermap-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cab0359af0195c03dafed5a05353666b152231b441f3b3e548367d8f9f57b1d"

URI_x86_64_v2_rust-ordermap+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+arbitrary-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-ordermap+arbitrary-devel.sha256sum] = "a082100f1bdf6a627bc152af641dd29fb05fbe7ce3a3478c0ac0ebca2dec042e"

URI_x86_64_v2_rust-ordermap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+default-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+default-devel}"
SRC_URI[x86_64_v2_rust-ordermap+default-devel.sha256sum] = "5315966039aa55fece517e395015e800fd34e99f7a43674e96ab05dd348aa56d"

URI_x86_64_v2_rust-ordermap+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+quickcheck-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-ordermap+quickcheck-devel.sha256sum] = "b16ed8f86b3ca385af9b2edde9d30c6c51a156592da06ca6c9d2ac99994cb537"

URI_x86_64_v2_rust-ordermap+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+rayon-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+rayon-devel}"
SRC_URI[x86_64_v2_rust-ordermap+rayon-devel.sha256sum] = "01c1bd17216123eaedda75e2adc08477ee09bc222fd94d313863314fd5ee4ced"

URI_x86_64_v2_rust-ordermap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+serde-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+serde-devel}"
SRC_URI[x86_64_v2_rust-ordermap+serde-devel.sha256sum] = "86a65ffb74d4aea3ec1b8dca4a6cdc5943a7e9cd6ed837cb7f6d37f442f6f9f8"

URI_x86_64_v2_rust-ordermap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+std-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+std-devel}"
SRC_URI[x86_64_v2_rust-ordermap+std-devel.sha256sum] = "270f73370c609180960abe20c31721987d7aaff6af3403d9a740a9da01ca0f26"

URI_x86_64_v2_rust-ordermap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap-devel}"
SRC_URI[x86_64_v2_rust-ordermap-devel.sha256sum] = "62ae7b3bf4b05c0341a0aadd761a438f8b899b2ca310a1e4480c7be70ec6ed7b"

URI_aarch64_rust-ordermap+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+arbitrary-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ordermap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+arbitrary-devel}"
SRC_URI[aarch64_rust-ordermap+arbitrary-devel.sha256sum] = "80cae26bcb4803561f19282bbe473766bf265dca896ce2e4584145c9de9860db"

URI_aarch64_rust-ordermap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+default-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ordermap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+default-devel}"
SRC_URI[aarch64_rust-ordermap+default-devel.sha256sum] = "c7cbcc72c8dbe87c77c5e8f93f5550e6a05b57396078c89e929a8f129e890b5d"

URI_aarch64_rust-ordermap+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+quickcheck-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ordermap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+quickcheck-devel}"
SRC_URI[aarch64_rust-ordermap+quickcheck-devel.sha256sum] = "183102ba683540a96681de0fe26bf05417519bad309f457411519e49539e0261"

URI_aarch64_rust-ordermap+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+rayon-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ordermap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+rayon-devel}"
SRC_URI[aarch64_rust-ordermap+rayon-devel.sha256sum] = "85a5b015cfd3c17e9815b7a619a995dddc12369836e8be994c06211123808392"

URI_aarch64_rust-ordermap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+serde-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ordermap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+serde-devel}"
SRC_URI[aarch64_rust-ordermap+serde-devel.sha256sum] = "f40371ec532d4e9dda141721ec0c12a548467b75744aeb724b020c73892e06f5"

URI_aarch64_rust-ordermap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+std-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ordermap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+std-devel}"
SRC_URI[aarch64_rust-ordermap+std-devel.sha256sum] = "00eb0d8159265a38e5fef010a85b175aeadb1e19247e3dd90081d7c1e1fcb99a"

URI_aarch64_rust-ordermap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ordermap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap-devel}"
SRC_URI[aarch64_rust-ordermap-devel.sha256sum] = "ff5493915d5d68e9cc56c3e37e1ff0f4b1e95cc5f84f558a075fd1ae3e0e7283"

RDEPENDS:rust-ordermap+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-indexmap+arbitrary-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap+default-devel = " \
 cargo \
 rust-ordermap+std-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap+quickcheck-devel = " \
 cargo \
 rust-indexmap+quickcheck-devel \
 rust-ordermap-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-ordermap+rayon-devel = " \
 cargo \
 rust-indexmap+rayon-devel \
 rust-ordermap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-ordermap+serde-devel = " \
 cargo \
 rust-indexmap+serde-devel \
 rust-ordermap-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-ordermap+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap-devel = " \
 cargo \
 rust \
 rust-indexmap-devel \
 "
