# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "holland"
PV = "1.3.1"
PR = "2.el10_1"
PACKAGES = " \
 holland \
 holland-command \
 holland-common \
 holland-commvault \
 holland-lvm \
 holland-mariabackup \
 holland-mariadb-dump \
 holland-mongodump \
 holland-mysql \
 holland-mysqldump \
 holland-mysqllvm \
 holland-mysqlsh \
 holland-pg_basebackup \
 holland-pgdump \
 holland-xtrabackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/holland-1.3.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba2b46bb4b387a6a9bf43896f28842cb6f719c196eeb9e7c1678398eaddef389"

URI_x86_64_v2_holland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland}"
SRC_URI[x86_64_v2_holland.sha256sum] = "1372154a6ff834c5b2ebce0fdbfda2ee437f683c1c34a40cfcddb422fd26e0e7"

URI_x86_64_v2_holland-command = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-command-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-command}"
SRC_URI[x86_64_v2_holland-command.sha256sum] = "cc38dc08a0529b87c62e8e1b2485deb4f38a4b11ba7e5f56a0b05ac59cb79560"

URI_x86_64_v2_holland-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-common-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-common}"
SRC_URI[x86_64_v2_holland-common.sha256sum] = "4cc44c6888fd9c674cedc8f3f27a9500bd33518ce74998682fd13a75859a4d6e"

URI_x86_64_v2_holland-commvault = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-commvault-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-commvault;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-commvault}"
SRC_URI[x86_64_v2_holland-commvault.sha256sum] = "1f62c7ccff328d9a139edc158dc3e1b40b7d0e00c73283ef3c514ed305ad1a96"

URI_x86_64_v2_holland-lvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-lvm-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-lvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-lvm}"
SRC_URI[x86_64_v2_holland-lvm.sha256sum] = "94f9433111a10879efe721814beb4be9f3c24df2e94e264096c4e722391ef562"

URI_x86_64_v2_holland-mariabackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mariabackup-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mariabackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mariabackup}"
SRC_URI[x86_64_v2_holland-mariabackup.sha256sum] = "c85e187d340d818b758477999be7a69a02aad18c39ab2c19101ba0d5236e83a4"

URI_x86_64_v2_holland-mariadb-dump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mariadb-dump-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mariadb-dump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mariadb-dump}"
SRC_URI[x86_64_v2_holland-mariadb-dump.sha256sum] = "d412cb63c9324fbfd000bafa90390bff1ee19ebf416ffafab2f3c22413b9023e"

URI_x86_64_v2_holland-mongodump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mongodump-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mongodump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mongodump}"
SRC_URI[x86_64_v2_holland-mongodump.sha256sum] = "71781f29d9b0c17256c1bbedf41b0f7ca1ec6c93b398a5bd450418d8072a9e38"

URI_x86_64_v2_holland-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysql-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysql}"
SRC_URI[x86_64_v2_holland-mysql.sha256sum] = "d7a6dfd47ae406a73280fa66aaa7ff3442381bcb9da845f519e16cfd0baeac74"

URI_x86_64_v2_holland-mysqldump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysqldump-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysqldump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysqldump}"
SRC_URI[x86_64_v2_holland-mysqldump.sha256sum] = "bffb4acb925bad88c3968e415cbe6e72265a4882e39073d37211b02138e8aad2"

URI_x86_64_v2_holland-mysqllvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysqllvm-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysqllvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysqllvm}"
SRC_URI[x86_64_v2_holland-mysqllvm.sha256sum] = "e85184bcf0817c628357538c67f750836be53814bdff2af1c1407950d8b436ef"

URI_x86_64_v2_holland-mysqlsh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysqlsh-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysqlsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysqlsh}"
SRC_URI[x86_64_v2_holland-mysqlsh.sha256sum] = "d0b7d29915cf47419cfc8ef445a6efa6f8ab910f10f7164a7e85526417020818"

URI_x86_64_v2_holland-pg_basebackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-pg_basebackup-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-pg_basebackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-pg_basebackup}"
SRC_URI[x86_64_v2_holland-pg_basebackup.sha256sum] = "304de4557b80dd7188fe2288707ec1263adbcd2cf876b9a30bbb00ce587b7662"

URI_x86_64_v2_holland-pgdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-pgdump-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-pgdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-pgdump}"
SRC_URI[x86_64_v2_holland-pgdump.sha256sum] = "120363e47c84e7082262f7a177afc6a79d1b20653bbf84bf448e2c3dbe78a04e"

URI_x86_64_v2_holland-xtrabackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-xtrabackup-1.3.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_holland-xtrabackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-xtrabackup}"
SRC_URI[x86_64_v2_holland-xtrabackup.sha256sum] = "1d0160675979acfd93a1358aa6158fa9093103226375a739351a3e5e0fcc1c7a"

URI_aarch64_holland = "${EPEL_MIRROR}/aarch64/Packages/h/holland-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland}"
SRC_URI[aarch64_holland.sha256sum] = "29dd2fec59df2f4bd53632b7dfd1d0c86c1e4213937e91371cee7315a8a2492b"

URI_aarch64_holland-command = "${EPEL_MIRROR}/aarch64/Packages/h/holland-command-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-command;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-command}"
SRC_URI[aarch64_holland-command.sha256sum] = "d98f203906449fe3925402c5c035b176c83d1ad5972249b1a01315413d9678ad"

URI_aarch64_holland-common = "${EPEL_MIRROR}/aarch64/Packages/h/holland-common-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-common}"
SRC_URI[aarch64_holland-common.sha256sum] = "9b0fadb31a9699e7e9483e590a3aee27a81b5e7a6f4c4316ed54f08cf1a8b11a"

URI_aarch64_holland-commvault = "${EPEL_MIRROR}/aarch64/Packages/h/holland-commvault-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-commvault;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-commvault}"
SRC_URI[aarch64_holland-commvault.sha256sum] = "015818a417b8d50ac3ee00edac2c3ac25e1d074277f420b484d95cc277726cea"

URI_aarch64_holland-lvm = "${EPEL_MIRROR}/aarch64/Packages/h/holland-lvm-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-lvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-lvm}"
SRC_URI[aarch64_holland-lvm.sha256sum] = "e594175e8c2f8bf7908dfab4de849a7cd44404ab30709155ef330c35f0085ebe"

URI_aarch64_holland-mariabackup = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mariabackup-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-mariabackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mariabackup}"
SRC_URI[aarch64_holland-mariabackup.sha256sum] = "99890d63bbd8d7d7890436fdd9e8dc9fdc8ce884f7fdcab2cdc4ce448043c10f"

URI_aarch64_holland-mariadb-dump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mariadb-dump-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-mariadb-dump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mariadb-dump}"
SRC_URI[aarch64_holland-mariadb-dump.sha256sum] = "2b9171c9d53159284154f43d634039ea9d369e7dc9272f1df6bb060cef7e8169"

URI_aarch64_holland-mongodump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mongodump-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-mongodump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mongodump}"
SRC_URI[aarch64_holland-mongodump.sha256sum] = "80c9904d8b2a201c6b1486de78f7917717a1e202b3c91ee9dcf75d3eb64c1612"

URI_aarch64_holland-mysql = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysql-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysql}"
SRC_URI[aarch64_holland-mysql.sha256sum] = "5c57a6b39aa598792ceb0918c39c85dfe716783ec68634d8c854c6a00a6fb813"

URI_aarch64_holland-mysqldump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysqldump-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-mysqldump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysqldump}"
SRC_URI[aarch64_holland-mysqldump.sha256sum] = "b0f33bb4a98f45e56da3da16f2f22305e8f07d1632ddfea6aab2317c13c09696"

URI_aarch64_holland-mysqllvm = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysqllvm-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-mysqllvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysqllvm}"
SRC_URI[aarch64_holland-mysqllvm.sha256sum] = "c9eb977daef2fc961468be66486e3a36668775926b4a952ce1b834d90a09e4e6"

URI_aarch64_holland-mysqlsh = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysqlsh-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-mysqlsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysqlsh}"
SRC_URI[aarch64_holland-mysqlsh.sha256sum] = "f48a0e1859ede7b8fa883976b45fb8dfd2250cb958c80fdbe514fc9e85ca2bd5"

URI_aarch64_holland-pg_basebackup = "${EPEL_MIRROR}/aarch64/Packages/h/holland-pg_basebackup-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-pg_basebackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-pg_basebackup}"
SRC_URI[aarch64_holland-pg_basebackup.sha256sum] = "e4422b883b50f5d5e0e448c098074606a9153defde91112c8bdb7a8a94234cfd"

URI_aarch64_holland-pgdump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-pgdump-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-pgdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-pgdump}"
SRC_URI[aarch64_holland-pgdump.sha256sum] = "f9f953e3b41a9b11a041271362e208ab024fe47123e5d8207225358c2978acc3"

URI_aarch64_holland-xtrabackup = "${EPEL_MIRROR}/aarch64/Packages/h/holland-xtrabackup-1.3.1-2.el10_1.noarch.rpm;name=aarch64_holland-xtrabackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-xtrabackup}"
SRC_URI[aarch64_holland-xtrabackup.sha256sum] = "039b9ab8aa396965ba7c5551134e8b510ed02b6d52217fe044a998c08db91994"

RDEPENDS:holland = " \
 logrotate \
 python3 \
 python3-configobj \
 python3-setuptools \
 python3-six \
 "
RDEPENDS:holland-command = " \
 holland-common \
 python3 \
 "
RDEPENDS:holland-common = " \
 holland \
 python3 \
 "
RDEPENDS:holland-commvault = " \
 holland \
 python3 \
 python3-pid \
 tar \
 "
RDEPENDS:holland-lvm = " \
 holland \
 python3 \
 "
RDEPENDS:holland-mariabackup = " \
 holland-common \
 holland-mysql \
 mariadb-backup \
 python3 \
 "
RDEPENDS:holland-mariadb-dump = " \
 holland-common \
 holland-mysql \
 mariadb \
 python3 \
 "
RDEPENDS:holland-mongodump = " \
 holland-common \
 python3 \
 python3-pymongo \
 "
RDEPENDS:holland-mysql = " \
 holland-common \
 python3 \
 python3-PyMySQL \
 python3-mysqlclient \
 "
RDEPENDS:holland-mysqldump = " \
 holland-mysql \
 python3 \
 virtual//usr/bin/mysqldump \
 "
RDEPENDS:holland-mysqllvm = " \
 holland-lvm \
 holland-mysql \
 lvm2 \
 python3 \
 tar \
 "
RDEPENDS:holland-mysqlsh = " \
 holland-common \
 holland-mysql \
 python3 \
 "
RDEPENDS:holland-pg_basebackup = " \
 holland-common \
 python3 \
 python3-psycopg2 \
 "
RDEPENDS:holland-pgdump = " \
 holland-common \
 python3 \
 python3-psycopg2 \
 "
RDEPENDS:holland-xtrabackup = " \
 holland-common \
 holland-mysql \
 python3 \
 python3-mysqlclient \
 "
