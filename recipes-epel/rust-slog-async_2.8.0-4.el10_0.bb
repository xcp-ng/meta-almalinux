# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slog-async"
PV = "2.8.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-slog-async+default-devel \
 rust-slog-async+dynamic-keys-devel \
 rust-slog-async+nested-values-devel \
 rust-slog-async-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slog-async-2.8.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8ad1f2652a917b3fdd9724bbf42f3683efd64abe28ddb6d4f56e71d9cc3ff12"

URI_x86_64_v2_rust-slog-async+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-async+default-devel-2.8.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-async+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-async+default-devel}"
SRC_URI[x86_64_v2_rust-slog-async+default-devel.sha256sum] = "6e80b8cd79571bf4c376d4993770b547c3999ccfad0e5ca93b2b0901077191a6"

URI_x86_64_v2_rust-slog-async+dynamic-keys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-async+dynamic-keys-devel-2.8.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-async+dynamic-keys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-async+dynamic-keys-devel}"
SRC_URI[x86_64_v2_rust-slog-async+dynamic-keys-devel.sha256sum] = "212bb8fcc4ec4f1925555a69815cd6610148f83fd4aa5809b3a95c18939dcad9"

URI_x86_64_v2_rust-slog-async+nested-values-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-async+nested-values-devel-2.8.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-async+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-async+nested-values-devel}"
SRC_URI[x86_64_v2_rust-slog-async+nested-values-devel.sha256sum] = "e42ac8e492833fffcc667492f22bc1a91f98e05a268801ab667ca7e262d1ddbe"

URI_x86_64_v2_rust-slog-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-async-devel-2.8.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-async-devel}"
SRC_URI[x86_64_v2_rust-slog-async-devel.sha256sum] = "2de07e822948fd5fef19477b26acf1c76547226ec75fd6549a11b6f52c118c0b"

URI_aarch64_rust-slog-async+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-async+default-devel-2.8.0-4.el10_0.noarch.rpm;name=aarch64_rust-slog-async+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-async+default-devel}"
SRC_URI[aarch64_rust-slog-async+default-devel.sha256sum] = "14034d134ef06757305a50c903c560042041470cdf16aab536020f69a546957a"

URI_aarch64_rust-slog-async+dynamic-keys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-async+dynamic-keys-devel-2.8.0-4.el10_0.noarch.rpm;name=aarch64_rust-slog-async+dynamic-keys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-async+dynamic-keys-devel}"
SRC_URI[aarch64_rust-slog-async+dynamic-keys-devel.sha256sum] = "85926ed8e8b8caecfba3d1a824030619aed4b968ac560865dd1940c39958878c"

URI_aarch64_rust-slog-async+nested-values-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-async+nested-values-devel-2.8.0-4.el10_0.noarch.rpm;name=aarch64_rust-slog-async+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-async+nested-values-devel}"
SRC_URI[aarch64_rust-slog-async+nested-values-devel.sha256sum] = "45e15dcef3f32f490ed35627ac64181c713078637a4b187bf882150849295c02"

URI_aarch64_rust-slog-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-async-devel-2.8.0-4.el10_0.noarch.rpm;name=aarch64_rust-slog-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-async-devel}"
SRC_URI[aarch64_rust-slog-async-devel.sha256sum] = "321febef1786b127162e3d45a4042231615b8028854222d882b0df8395f05f19"

RDEPENDS:rust-slog-async+default-devel = " \
 cargo \
 rust-slog-async-devel \
 "
RDEPENDS:rust-slog-async+dynamic-keys-devel = " \
 cargo \
 rust-slog+dynamic-keys-devel \
 rust-slog-async-devel \
 "
RDEPENDS:rust-slog-async+nested-values-devel = " \
 cargo \
 rust-slog+nested-values-devel \
 rust-slog-async-devel \
 "
RDEPENDS:rust-slog-async-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-slog+default-devel \
 rust-take_mut+default-devel \
 rust-thread_local+default-devel \
 "
