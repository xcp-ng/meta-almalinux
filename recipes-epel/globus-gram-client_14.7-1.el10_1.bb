# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-client"
PV = "14.7"
PR = "1.el10_1"
PACKAGES = " \
 globus-gram-client \
 globus-gram-client-devel \
 globus-gram-client-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-client-14.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11a5d80d3ed77771129be225b7a93d4573e2d61d5d0501a9158d9b2dbe8feca9"

URI_x86_64_v2_globus-gram-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-client-14.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-client}"
SRC_URI[x86_64_v2_globus-gram-client.sha256sum] = "4e6e3264fe20f7b129537f2aeeda823035115e4c082cbc86ba062390df351145"

URI_x86_64_v2_globus-gram-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-client-devel-14.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-client-devel}"
SRC_URI[x86_64_v2_globus-gram-client-devel.sha256sum] = "20c8078f0aec8145586481a4d879d1dd91e5fe9787011d12277977a006be671f"

URI_x86_64_v2_globus-gram-client-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-client-doc-14.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-client-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-client-doc}"
SRC_URI[x86_64_v2_globus-gram-client-doc.sha256sum] = "72d26e283f663fc097b342351566eb360ba23eb3ce307849375cad9f24d21852"

URI_aarch64_globus-gram-client = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-client-14.7-1.el10_1.aarch64.rpm;name=aarch64_globus-gram-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-client}"
SRC_URI[aarch64_globus-gram-client.sha256sum] = "5f914aa495870b484671c142de2588ee8cb0e83201ad0da1529d79acd11954e4"

URI_aarch64_globus-gram-client-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-client-devel-14.7-1.el10_1.aarch64.rpm;name=aarch64_globus-gram-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-client-devel}"
SRC_URI[aarch64_globus-gram-client-devel.sha256sum] = "3b858634395f9f81aede9ae4e5e1f97d11e02e8e69ec15b89a6243b2243397e4"

URI_aarch64_globus-gram-client-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-client-doc-14.7-1.el10_1.noarch.rpm;name=aarch64_globus-gram-client-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-client-doc}"
SRC_URI[aarch64_globus-gram-client-doc.sha256sum] = "cc591c7d74849ea994e6b34950a2e4a3b735ed9f65d620ace7a4451adda29493"

RDEPENDS:globus-gram-client = " \
 glibc \
 globus-common \
 globus-gram-protocol \
 globus-gss-assist \
 globus-io \
 globus-rsl \
 "
RDEPENDS:globus-gram-client-devel = " \
 globus-common-devel \
 globus-gram-client \
 globus-gram-protocol-devel \
 globus-gss-assist-devel \
 globus-io-devel \
 globus-rsl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gram-client-doc = " \
 "
