# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kplotting"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kplotting \
 kf6-kplotting-devel \
 kf6-kplotting-doc \
 kf6-kplotting-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kplotting-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ce7f0cb3c56b575c50a07e720ea37c15e3de4cc00e8436b09e57462c00e29a1c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kplotting;unpack=0"
SRC_URI[x86_64_v2_kf6-kplotting.sha256sum] = "31c8d014b0bcc04dbbae9bf2b5292fa40f13f776f6c8c8963a79b603ac2494d7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kplotting-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kplotting-devel.sha256sum] = "adf0c55aa1dfd0fab514a136614f091bf66859d4da21051920bd5838418d966c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kplotting-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kplotting-doc.sha256sum] = "d73ee0a5e44b9feb1af1cf8b16befabec084ddecd2a3f811312fe6f020241d42"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kplotting-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kplotting-html.sha256sum] = "4243796689616485b8eeae0abb4aa3e96e465174beb33d7cf9bfd7b7f7f3f8af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kplotting;unpack=0"
SRC_URI[aarch64_kf6-kplotting.sha256sum] = "3d6d9d79de9bf92783d23770d2f75fdac407457a31c0fb3b5f2f1db81c3a02c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kplotting-devel;unpack=0"
SRC_URI[aarch64_kf6-kplotting-devel.sha256sum] = "583818b76b0c7489248ff3aaf218a54998b00a8ff5bf75c3e3024dcb5eeb4cfd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kplotting-doc;unpack=0"
SRC_URI[aarch64_kf6-kplotting-doc.sha256sum] = "02f3592bbe73a3183b5b47373dd62c55751064c9e4c8ad54a93cd2732f623699"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kplotting-html;unpack=0"
SRC_URI[aarch64_kf6-kplotting-html.sha256sum] = "1b691452fdbf047f5b3201025f7e378b3e90787ea380b542da096d9b96c4b597"

RDEPENDS:kf6-kplotting = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kplotting-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kplotting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kplotting-doc = " \
 "
RDEPENDS:kf6-kplotting-html = " \
 "
