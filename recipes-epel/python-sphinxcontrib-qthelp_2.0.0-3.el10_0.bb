# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinxcontrib-qthelp"
PV = "2.0.0"
PR = "3.el10_0"
PACKAGES = " \
 python3-sphinxcontrib-qthelp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinxcontrib-qthelp-2.0.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "347e8140c08ed2f43601aa92c06b56203bb02484dcf02db70a9e67b053b70c05"

URI_x86_64_v2_python3-sphinxcontrib-qthelp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinxcontrib-qthelp-2.0.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinxcontrib-qthelp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinxcontrib-qthelp}"
SRC_URI[x86_64_v2_python3-sphinxcontrib-qthelp.sha256sum] = "300fe073c2048f729b7ba448c226080e6ccedca21402b8ce570380d4502566e4"

URI_aarch64_python3-sphinxcontrib-qthelp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinxcontrib-qthelp-2.0.0-3.el10_0.noarch.rpm;name=aarch64_python3-sphinxcontrib-qthelp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinxcontrib-qthelp}"
SRC_URI[aarch64_python3-sphinxcontrib-qthelp.sha256sum] = "6a7ffe3ca1796a921db5f4c84192e305bd4229b1bae59193cd4eef2c3b82eb27"

RDEPENDS:python3-sphinxcontrib-qthelp = " \
 python3 \
 "
