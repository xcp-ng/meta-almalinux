# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knewstuff"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-knewstuff \
 kf6-knewstuff-devel \
 kf6-knewstuff-doc \
 kf6-knewstuff-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-knewstuff-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "083bd40d5f64e0fe6492ab0a1989a8a11cf1d5f661672e82cc59b22c3b271686"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knewstuff;unpack=0"
SRC_URI[x86_64_v2_kf6-knewstuff.sha256sum] = "071d2cc37b2245109c802dfc2bb222184565ef7a9842a0e316fb4e836613931c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knewstuff-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-knewstuff-devel.sha256sum] = "f7f1039bb762eda12024d42230a2401056e4a446b965ab4720827e121e4deca9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knewstuff-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-knewstuff-doc.sha256sum] = "faeeb5889b7161a1147563992658f9440925ca895787873db7905581e798d0ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knewstuff-html;unpack=0"
SRC_URI[x86_64_v2_kf6-knewstuff-html.sha256sum] = "622e771fcfb403e8837be63e0de94ec0eae714af2fc62e5682a0a71acd012007"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knewstuff;unpack=0"
SRC_URI[aarch64_kf6-knewstuff.sha256sum] = "297f898871521b86411b6bb615bca615883aaedf00bd9e4a7af58cfff4811730"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knewstuff-devel;unpack=0"
SRC_URI[aarch64_kf6-knewstuff-devel.sha256sum] = "f3b1a75ee636bc0e3afbcd5d9aab3552e4044b879696c7b6f4d5a280ef461ac6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knewstuff-doc;unpack=0"
SRC_URI[aarch64_kf6-knewstuff-doc.sha256sum] = "61fc8e1c4764f2a31ea14e6b1279014fc753dd4482d1e70197a8a2f92fd1d9c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knewstuff-html;unpack=0"
SRC_URI[aarch64_kf6-knewstuff-html.sha256sum] = "fcb79483d604e2fc618f899b6bb802f0988250dda71701676b67f86a678b1a38"

RDEPENDS:kf6-knewstuff = " \
 glibc \
 kf6-attica \
 kf6-filesystem \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kwidgetsaddons \
 kf6-syndication \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-knewstuff-devel = " \
 cmake-filesystem \
 glibc \
 kf6-attica-devel \
 kf6-knewstuff \
 kf6-kservice-devel \
 kf6-kxmlgui-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-knewstuff-doc = " \
 "
RDEPENDS:kf6-knewstuff-html = " \
 "
