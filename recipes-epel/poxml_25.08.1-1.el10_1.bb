# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "poxml"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 poxml \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/poxml-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0854b5abd04627b2696598780d860bbfa9383b1b75f9a7b7bf7a92aa7ef187dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/poxml-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_poxml;unpack=0"
SRC_URI[x86_64_v2_poxml.sha256sum] = "7e4d6c0ace0ba45ca1964e51e8c4fa07b6f3d0fcf3492d0bcc87580b41d45133"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/poxml-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_poxml;unpack=0"
SRC_URI[aarch64_poxml.sha256sum] = "cac3fc7a8af20d9b4d4a53ffe8d9c7d6e72de4ac887ebdb6d143e57883c47e34"

RDEPENDS:poxml = " \
 gettext-libs \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
