# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libuv"
PE = "1"
PV = "1.52.1"
PR = "1.el10"
PACKAGES = " \
 libuv \
 libuv-devel \
 libuv-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libuv-1.52.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c16ec74bfd2618cfd9df99ab1ca3c25164ab8da6a2ceddf0a5db8652eaa797f"

URI_x86_64_v2_libuv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuv-1.52.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libuv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuv}"
SRC_URI[x86_64_v2_libuv.sha256sum] = "69756ddc135756b0ce8a3d1fc74356c18c63010b64392a923ef3be459333dfee"

URI_x86_64_v2_libuv-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuv-devel-1.52.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libuv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuv-devel}"
SRC_URI[x86_64_v2_libuv-devel.sha256sum] = "8972e90e1f99c0426ca90c07d1de80d5195d112c4817eaf0bd0b8b22c8b7269c"

URI_x86_64_v2_libuv-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuv-static-1.52.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libuv-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuv-static}"
SRC_URI[x86_64_v2_libuv-static.sha256sum] = "87b10e766e9d1ec802211a638d478b5362eb9287251b65e2112d1e832da0b5fe"

URI_aarch64_libuv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuv-1.52.1-1.el10.aarch64.rpm;name=aarch64_libuv;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuv}"
SRC_URI[aarch64_libuv.sha256sum] = "72ae45309c2dac5b9a1c3cdba5665786b64523e87fde46caf146519368e589ee"

URI_aarch64_libuv-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuv-devel-1.52.1-1.el10.aarch64.rpm;name=aarch64_libuv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuv-devel}"
SRC_URI[aarch64_libuv-devel.sha256sum] = "02d6572dac3d33d7ec6b906971fdb19554431f6cd26199939ae9577dbdbc713d"

URI_aarch64_libuv-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuv-static-1.52.1-1.el10.aarch64.rpm;name=aarch64_libuv-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuv-static}"
SRC_URI[aarch64_libuv-static.sha256sum] = "f39919824f7570836993e9fa0ee7ccbf56bb07d72f8b469d03aaaccebbecb99b"

RDEPENDS:libuv = " \
 glibc \
 "
RDEPENDS:libuv-devel = " \
 cmake-filesystem \
 libuv \
 libuv-static \
 pkgconf-pkg-config \
 "
RDEPENDS:libuv-static = " \
 libuv-devel \
 pkgconf-pkg-config \
 "
