# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ghash"
PV = "0.5.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-ghash+default-devel \
 rust-ghash+std-devel \
 rust-ghash+zeroize-devel \
 rust-ghash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ghash-0.5.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5c8dbcb610d559067067889be06da6738a1c96a860975a1718491bcd4b7d238"

URI_x86_64_v2_rust-ghash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ghash+default-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ghash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ghash+default-devel}"
SRC_URI[x86_64_v2_rust-ghash+default-devel.sha256sum] = "720018de20bf3ae978fe3d4919accbd6359a4d82da6a0791a4aa9b6c70336e15"

URI_x86_64_v2_rust-ghash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ghash+std-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ghash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ghash+std-devel}"
SRC_URI[x86_64_v2_rust-ghash+std-devel.sha256sum] = "053ec1f68b3f33ecb4026959e05893de39fcda96975f0d77f1c7fcdd4851a022"

URI_x86_64_v2_rust-ghash+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ghash+zeroize-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ghash+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ghash+zeroize-devel}"
SRC_URI[x86_64_v2_rust-ghash+zeroize-devel.sha256sum] = "e7a00e64bc126383f8bb1540a301eb6fb16fa8a20a70e3eda975eab277493a76"

URI_x86_64_v2_rust-ghash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ghash-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ghash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ghash-devel}"
SRC_URI[x86_64_v2_rust-ghash-devel.sha256sum] = "01fe1669a41076ea8b95f98c427c1c10445dc1ccf1328390c7f30a48cd79649a"

URI_aarch64_rust-ghash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ghash+default-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_rust-ghash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ghash+default-devel}"
SRC_URI[aarch64_rust-ghash+default-devel.sha256sum] = "0f94d519455e5adee226f44b2384a3a7bd3f8b9e2f5e4e6125cdcb4c0e10e027"

URI_aarch64_rust-ghash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ghash+std-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_rust-ghash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ghash+std-devel}"
SRC_URI[aarch64_rust-ghash+std-devel.sha256sum] = "6a24ff80885c2fb18fec74ef0fa0c5cde6b2bc91063c69676259aa1961be0d5c"

URI_aarch64_rust-ghash+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ghash+zeroize-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_rust-ghash+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ghash+zeroize-devel}"
SRC_URI[aarch64_rust-ghash+zeroize-devel.sha256sum] = "212c16cc29aa0042e2f6ef2beeb9d49899ba23faec7248768dfce6249468df02"

URI_aarch64_rust-ghash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ghash-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_rust-ghash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ghash-devel}"
SRC_URI[aarch64_rust-ghash-devel.sha256sum] = "0b74f2b83806453d145632600f3692800090d3d74a309847daa6420b09f28f6b"

RDEPENDS:rust-ghash+default-devel = " \
 cargo \
 rust-ghash-devel \
 "
RDEPENDS:rust-ghash+std-devel = " \
 cargo \
 rust-ghash-devel \
 rust-polyval+std-devel \
 "
RDEPENDS:rust-ghash+zeroize-devel = " \
 cargo \
 rust-ghash-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-ghash-devel = " \
 cargo \
 rust \
 rust-opaque-debug+default-devel \
 rust-polyval+default-devel \
 "
