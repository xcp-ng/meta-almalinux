# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-coreos-installer"
PV = "0.23.0"
PR = "1.el10"
PACKAGES = " \
 coreos-installer \
 coreos-installer-bootinfra \
 coreos-installer-dracut \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-coreos-installer-0.23.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a18c3212dabd7a73905e39c0c6275a75a9343af7541afddbb56d888a4cef75a"

URI_x86_64_v2_coreos-installer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/coreos-installer-0.23.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_coreos-installer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreos-installer}"
SRC_URI[x86_64_v2_coreos-installer.sha256sum] = "623f7247ba17001ec2096af62c65e1fca7e2c665dbe4c37790026493fac82107"

URI_x86_64_v2_coreos-installer-bootinfra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/coreos-installer-bootinfra-0.23.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_coreos-installer-bootinfra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreos-installer-bootinfra}"
SRC_URI[x86_64_v2_coreos-installer-bootinfra.sha256sum] = "1e391bc75c28d192227e03d96cd48d3b0878772ee31d851051a159c656e52fd6"

URI_x86_64_v2_coreos-installer-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/coreos-installer-dracut-0.23.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_coreos-installer-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreos-installer-dracut}"
SRC_URI[x86_64_v2_coreos-installer-dracut.sha256sum] = "ff50855acf532934a623c3555b7ba5db6882a7fa54e7de773255e14667ad7d80"

URI_aarch64_coreos-installer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/coreos-installer-0.23.0-1.el10.aarch64.rpm;name=aarch64_coreos-installer;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreos-installer}"
SRC_URI[aarch64_coreos-installer.sha256sum] = "9a551dea3c0f6059bd335e88757ed287ec42112f8c4710bba33ac8f45260e0d5"

URI_aarch64_coreos-installer-bootinfra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/coreos-installer-bootinfra-0.23.0-1.el10.aarch64.rpm;name=aarch64_coreos-installer-bootinfra;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreos-installer-bootinfra}"
SRC_URI[aarch64_coreos-installer-bootinfra.sha256sum] = "63359ac8dd142bb4821e23cfc2994a22621fa4ce51870d25ae32cfec08221b7a"

URI_aarch64_coreos-installer-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/coreos-installer-dracut-0.23.0-1.el10.aarch64.rpm;name=aarch64_coreos-installer-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreos-installer-dracut}"
SRC_URI[aarch64_coreos-installer-dracut.sha256sum] = "b560f3604cf429c3a3fdb737d5e9cf7be1ff225aefba4d763e29f93cd461c552"

RDEPENDS:coreos-installer = " \
 glibc \
 gnupg2 \
 kpartx \
 libgcc \
 libzstd \
 openssl-libs \
 systemd-udev \
 util-linux \
 xz-libs \
 "
RDEPENDS:coreos-installer-bootinfra = " \
 bash \
 coreos-installer \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 xz-libs \
 "
RDEPENDS:coreos-installer-dracut = " \
 bash \
 coreos-installer \
 "
