# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sos"
PV = "4.11.0"
PR = "1.el10_2"
PACKAGES = " \
 sos \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sos-4.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a9366af7bf8212975bf16fb9f921ccdfa3eea06c1e77c54a27d2c753528f44a"

URI_x86_64_v2_sos = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sos-4.11.0-1.el10_2.noarch.rpm;name=x86_64_v2_sos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sos}"
SRC_URI[x86_64_v2_sos.sha256sum] = "cd5180e020d9d4236dfee6fdc767f104348e1748bf3128c4ca8f4c44b34f133d"

URI_aarch64_sos = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sos-4.11.0-1.el10_2.noarch.rpm;name=aarch64_sos;unpack=0"
SRC_URI:append = " ${URI_aarch64_sos}"
SRC_URI[aarch64_sos.sha256sum] = "cd5180e020d9d4236dfee6fdc767f104348e1748bf3128c4ca8f4c44b34f133d"

RDEPENDS:sos = " \
 python3 \
 python3-packaging \
 python3-pexpect \
 python3-pyyaml \
 python3-requests \
 python3-setuptools \
 "
