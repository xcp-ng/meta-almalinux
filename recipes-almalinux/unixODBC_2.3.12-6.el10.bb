# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unixODBC"
PV = "2.3.12"
PR = "6.el10"
PACKAGES = " \
 unixODBC \
 unixODBC-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/unixODBC-2.3.12-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cc704cf42ee1d5ad81836472a3c779da6964a954b405cb94b13b3e647da85756"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unixODBC-2.3.12-6.el10.x86_64_v2.rpm;name=x86_64_v2_unixODBC;unpack=0"
SRC_URI[x86_64_v2_unixODBC.sha256sum] = "abf51730446d7c489df84ce8e4999213b5de66a2a1af48b7093c4a92355e7f44"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/unixODBC-devel-2.3.12-6.el10.x86_64_v2.rpm;name=x86_64_v2_unixODBC-devel;unpack=0"
SRC_URI[x86_64_v2_unixODBC-devel.sha256sum] = "a11d2be9a1133863e22e342e85fc5fa2c55ab90bc2412ada5be6f911d16d2d56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unixODBC-2.3.12-6.el10.aarch64.rpm;name=aarch64_unixODBC;unpack=0"
SRC_URI[aarch64_unixODBC.sha256sum] = "8ef5bd03107e52b0088b51730b631326df2e7be1cc18e68805e6fbb832e28f70"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/unixODBC-devel-2.3.12-6.el10.aarch64.rpm;name=aarch64_unixODBC-devel;unpack=0"
SRC_URI[aarch64_unixODBC-devel.sha256sum] = "0b69edfa686ac55bf0a690b018f91e66f8a12537d063e97944c642aa6a28954f"

RDEPENDS:unixODBC = " \
 glibc \
 libtool-ltdl \
 readline \
 "
RDEPENDS:unixODBC-devel = " \
 pkgconf-pkg-config \
 unixODBC \
 unixODBC-devel \
 "
