# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "man-pages"
PV = "6.06"
PR = "13.el10"
PACKAGES = " \
 man-pages \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/man-pages-6.06-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6396cfe4ccc129d4e96763545e69444bf2e72189ae276be5fcf5cbfce8678b7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/man-pages-6.06-13.el10.noarch.rpm;name=x86_64_v2_man-pages;unpack=0"
SRC_URI[x86_64_v2_man-pages.sha256sum] = "967c974dda907085424129b1ef8f6abeb0cc47f0d947c020df371d4a8b8c11b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/man-pages-6.06-13.el10.noarch.rpm;name=aarch64_man-pages;unpack=0"
SRC_URI[aarch64_man-pages.sha256sum] = "967c974dda907085424129b1ef8f6abeb0cc47f0d947c020df371d4a8b8c11b3"

RDEPENDS:man-pages = " \
 alternatives \
 bash \
 "
