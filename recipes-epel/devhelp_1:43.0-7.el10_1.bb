# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "devhelp"
PE = "1"
PV = "43.0"
PR = "7.el10_1"
PACKAGES = " \
 devhelp \
 devhelp-devel \
 devhelp-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/devhelp-43.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f18b625410e9dfce87b5af59cd8e7ba6f265c8cdcedf59ccbdf421ba9bab48f7"

URI_x86_64_v2_devhelp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/devhelp-43.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_devhelp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_devhelp}"
SRC_URI[x86_64_v2_devhelp.sha256sum] = "581b580e3fb71a679a73fc2fc063783ba574c449c924d36fe08cd4aaf93b3fcc"

URI_x86_64_v2_devhelp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/devhelp-devel-43.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_devhelp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_devhelp-devel}"
SRC_URI[x86_64_v2_devhelp-devel.sha256sum] = "0f5bd861737d91afea940a5a733c3b4597ad530c26235a7b032e5a1812cc203d"

URI_x86_64_v2_devhelp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/devhelp-libs-43.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_devhelp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_devhelp-libs}"
SRC_URI[x86_64_v2_devhelp-libs.sha256sum] = "7bb48cffa060080ade286106917476e776a8bbfa58c8619b35a157125d538220"

URI_aarch64_devhelp = "${EPEL_MIRROR}/aarch64/Packages/d/devhelp-43.0-7.el10_1.aarch64.rpm;name=aarch64_devhelp;unpack=0"
SRC_URI:append = " ${URI_aarch64_devhelp}"
SRC_URI[aarch64_devhelp.sha256sum] = "d53f6cee87f3ae1cd670b958a9142c0a03416b4791be63269e617355c2d8c3df"

URI_aarch64_devhelp-devel = "${EPEL_MIRROR}/aarch64/Packages/d/devhelp-devel-43.0-7.el10_1.aarch64.rpm;name=aarch64_devhelp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_devhelp-devel}"
SRC_URI[aarch64_devhelp-devel.sha256sum] = "ed3ee5762010f89c16601d2d47350fa353f3d6d887206ab305cd12ef1170fc11"

URI_aarch64_devhelp-libs = "${EPEL_MIRROR}/aarch64/Packages/d/devhelp-libs-43.0-7.el10_1.aarch64.rpm;name=aarch64_devhelp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_devhelp-libs}"
SRC_URI[aarch64_devhelp-libs.sha256sum] = "f16556efb813634e46ab4953e2d1920dabcde70883999cf4a98e874cf644d25d"

RDEPENDS:devhelp = " \
 devhelp-libs \
 glib2 \
 glibc \
 gtk3 \
 pango \
 webkit2gtk4.1 \
 "
RDEPENDS:devhelp-devel = " \
 devhelp \
 devhelp-libs \
 glib2-devel \
 gsettings-desktop-schemas-devel \
 gtk3-devel \
 pkgconf-pkg-config \
 webkit2gtk4.1-devel \
 "
RDEPENDS:devhelp-libs = " \
 glib2 \
 glibc \
 gtk3 \
 pango \
 webkit2gtk4.1 \
 "
