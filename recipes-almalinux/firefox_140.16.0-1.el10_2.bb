# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firefox"
PV = "140.16.0"
PR = "1.el10_2"
PACKAGES = " \
 firefox \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/firefox-140.16.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8b7dcd232b8fe3048a00cb8b63b23007b9d80097e6252acb876dd6f27e46df02"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firefox-140.16.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_firefox;unpack=0"
SRC_URI[x86_64_v2_firefox.sha256sum] = "857dfab6ab70dce4126890065c7fe823b41ccca811f168c769b83cb444f9b93c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firefox-140.16.0-1.el10_2.aarch64.rpm;name=aarch64_firefox;unpack=0"
SRC_URI[aarch64_firefox.sha256sum] = "b661ccb7beb361bc8aa843b5c23e73c0e7399b8951fdfe4fc914315db212a82f"

RDEPENDS:firefox = " \
 almalinux-indexhtml \
 alsa-lib \
 atk \
 bash \
 cairo \
 cairo-gobject \
 dbus-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libffi \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libxcb \
 mozilla-filesystem \
 nspr \
 nss \
 nss-util \
 p11-kit-trust \
 pango \
 pciutils-libs \
 zlib-ng-compat \
 "
