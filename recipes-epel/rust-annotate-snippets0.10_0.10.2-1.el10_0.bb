# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-annotate-snippets0.10"
PV = "0.10.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-annotate-snippets0.10+default-devel \
 rust-annotate-snippets0.10+testing-colors-devel \
 rust-annotate-snippets0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-annotate-snippets0.10-0.10.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "731fcfdbda150dc745b4b220f634e094043429c4651f7444cc47e44916f10dbe"

URI_x86_64_v2_rust-annotate-snippets0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.10+default-devel-0.10.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.10+default-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.10+default-devel.sha256sum] = "4d459a5f0f12807dce93b89d624ed64269fabc45da388c38c119b57e0a72702d"

URI_x86_64_v2_rust-annotate-snippets0.10+testing-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.10+testing-colors-devel-0.10.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.10+testing-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.10+testing-colors-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.10+testing-colors-devel.sha256sum] = "33209e64657b1d3a71fc33e31bcad7ef6d4bbe08b3b12b6d0af475678fd2ab14"

URI_x86_64_v2_rust-annotate-snippets0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.10-devel-0.10.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.10-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.10-devel.sha256sum] = "cb474ea2f3750b7b4d027acdaf6cecd66a580655f7ecb7d3baf1df634aa308fa"

URI_aarch64_rust-annotate-snippets0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.10+default-devel-0.10.2-1.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.10+default-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.10+default-devel.sha256sum] = "1d6cfa398146f8dfe779e201226dfb9d94e8f34b1ff26f692262bceea3491487"

URI_aarch64_rust-annotate-snippets0.10+testing-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.10+testing-colors-devel-0.10.2-1.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.10+testing-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.10+testing-colors-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.10+testing-colors-devel.sha256sum] = "f82dd1d691eef6f1660cb5b5636c0625cfd9d2385404257a25b8c7010603394a"

URI_aarch64_rust-annotate-snippets0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.10-devel-0.10.2-1.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.10-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.10-devel.sha256sum] = "ccaf31076edea6d0d0078221e1daa87a5c223f0c420d1de49e89e788fbce18a3"

RDEPENDS:rust-annotate-snippets0.10+default-devel = " \
 cargo \
 rust-annotate-snippets0.10-devel \
 "
RDEPENDS:rust-annotate-snippets0.10+testing-colors-devel = " \
 cargo \
 rust-annotate-snippets0.10-devel \
 "
RDEPENDS:rust-annotate-snippets0.10-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-unicode-width0.1+default-devel \
 "
