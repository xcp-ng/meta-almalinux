# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kongress"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kongress \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kongress-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c19b5c4df1eeaff76ba640aedb5d0aa99d6ed4444910810f6e59a8b5482fe570"

URI_x86_64_v2_kongress = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kongress-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kongress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kongress}"
SRC_URI[x86_64_v2_kongress.sha256sum] = "6007d3cfdeffadc3e158d979802a7f18a715d429ea446beac4b94368b7cebf75"

URI_aarch64_kongress = "${EPEL_MIRROR}/aarch64/Packages/k/kongress-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kongress;unpack=0"
SRC_URI:append = " ${URI_aarch64_kongress}"
SRC_URI[aarch64_kongress.sha256sum] = "f5e1a43071f6df18d9a9a5073763575f58fee4bec49c3ba65eddb8260c49fe7c"

RDEPENDS:kongress = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kosmindoormap \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtpositioning \
 "
