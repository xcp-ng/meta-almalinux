# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "idris2"
PV = "0.7.0"
PR = "4.el10_1"
PACKAGES = " \
 idris2 \
 idris2-doc \
 idris2-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/idris2-0.7.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2a10aed3f8b1d4796e12e6e306c1c6331c52bec763664b09f2f0035fe19ceff"

URI_x86_64_v2_idris2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/idris2-0.7.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_idris2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idris2}"
SRC_URI[x86_64_v2_idris2.sha256sum] = "7d8fd00a0722f51210e47d8fbff366ef45d3221a08ea4672777ae4b44c2ea38e"

URI_x86_64_v2_idris2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/idris2-doc-0.7.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_idris2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idris2-doc}"
SRC_URI[x86_64_v2_idris2-doc.sha256sum] = "8721601329305c358fb4aefba16cbdec55e810f6647a4100eafc0db38b504b4d"

URI_x86_64_v2_idris2-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/idris2-libs-0.7.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_idris2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idris2-libs}"
SRC_URI[x86_64_v2_idris2-libs.sha256sum] = "2d1a8653e80fc54a71c36579028613c58ae79b984601ae101156342f5dbfee43"

URI_aarch64_idris2 = "${EPEL_MIRROR}/aarch64/Packages/i/idris2-0.7.0-4.el10_1.aarch64.rpm;name=aarch64_idris2;unpack=0"
SRC_URI:append = " ${URI_aarch64_idris2}"
SRC_URI[aarch64_idris2.sha256sum] = "9d4604a8eff9296ca54081e36541e32479b7bd2ef27ca6e4cb116b561d46c191"

URI_aarch64_idris2-doc = "${EPEL_MIRROR}/aarch64/Packages/i/idris2-doc-0.7.0-4.el10_1.noarch.rpm;name=aarch64_idris2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_idris2-doc}"
SRC_URI[aarch64_idris2-doc.sha256sum] = "3b5b3e7f3dd8a6150013b08d0ae873c31b6181c86ed56d9351872ba994a3a137"

URI_aarch64_idris2-libs = "${EPEL_MIRROR}/aarch64/Packages/i/idris2-libs-0.7.0-4.el10_1.aarch64.rpm;name=aarch64_idris2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_idris2-libs}"
SRC_URI[aarch64_idris2-libs.sha256sum] = "6aef11ee63cad024689fe6f9c8339bb29042078dadd07904eb857d546f212c46"

RDEPENDS:idris2 = " \
 chez-scheme \
 idris2-libs \
 "
RDEPENDS:idris2-doc = " \
 fontawesome4-fonts \
 "
RDEPENDS:idris2-libs = " \
 glibc \
 "
