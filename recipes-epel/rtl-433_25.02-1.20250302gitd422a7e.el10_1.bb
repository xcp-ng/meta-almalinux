# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rtl-433"
PV = "25.02"
PR = "1.20250302gitd422a7e.el10_1"
PACKAGES = " \
 rtl-433 \
 rtl-433-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rtl-433-25.02-1.20250302gitd422a7e.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62aeea4226f6be41f0138022865ac758836f1735526fd0e96f1471f9a3b7e0e1"

URI_x86_64_v2_rtl-433 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rtl-433-25.02-1.20250302gitd422a7e.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rtl-433;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rtl-433}"
SRC_URI[x86_64_v2_rtl-433.sha256sum] = "ce6d01ca31c8bc8f210ff0171f10900fb1e09622b08b741a94261a4dec4112d7"

URI_x86_64_v2_rtl-433-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rtl-433-devel-25.02-1.20250302gitd422a7e.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rtl-433-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rtl-433-devel}"
SRC_URI[x86_64_v2_rtl-433-devel.sha256sum] = "93f5c72b3c7286153645ff9d5115231dead432a30cb40e2aa5826bbc1bfefb36"

URI_aarch64_rtl-433 = "${EPEL_MIRROR}/aarch64/Packages/r/rtl-433-25.02-1.20250302gitd422a7e.el10_1.aarch64.rpm;name=aarch64_rtl-433;unpack=0"
SRC_URI:append = " ${URI_aarch64_rtl-433}"
SRC_URI[aarch64_rtl-433.sha256sum] = "53634c36eca475547a13fcc195f087f037f3d54969bd32ffbf6a875b55eb15ae"

URI_aarch64_rtl-433-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rtl-433-devel-25.02-1.20250302gitd422a7e.el10_1.aarch64.rpm;name=aarch64_rtl-433-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rtl-433-devel}"
SRC_URI[aarch64_rtl-433-devel.sha256sum] = "2278e64bd72f15c6d020fabeb2c4f0a2cc7409607c13c1ed345f8625c219fac7"

RDEPENDS:rtl-433 = " \
 SoapySDR \
 glibc \
 libusb1 \
 rtl-sdr \
 "
RDEPENDS:rtl-433-devel = " \
 rtl-433 \
 "
