# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-tinytest"
PV = "1.4.3"
PR = "2.el10_3"
PACKAGES = " \
 R-tinytest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-tinytest-1.4.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b8d88f69231e1fe40b323d2670cb6ddad70274859cd9668545f4821d1a6c0a6"

URI_x86_64_v2_R-tinytest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-tinytest-1.4.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_R-tinytest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-tinytest}"
SRC_URI[x86_64_v2_R-tinytest.sha256sum] = "3b6cbb82104edba893de65e8991d932d7252771f62319325e52994a46c96be7e"

URI_aarch64_R-tinytest = "${EPEL_MIRROR}/aarch64/Packages/r/R-tinytest-1.4.3-2.el10_3.noarch.rpm;name=aarch64_R-tinytest;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-tinytest}"
SRC_URI[aarch64_R-tinytest.sha256sum] = "633164ab38a809465efb7ef32a591c8449cf38aee3708a220aa52438232a3a80"

RDEPENDS:R-tinytest = " \
 R-core \
 "
