# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-py3dns"
PV = "4.0.0"
PR = "11.el10_2"
PACKAGES = " \
 python3-py3dns \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3-py3dns-4.0.0-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f970b8f86031038e695408a476254c22770a48fdfc3553a0b30a0b88b1bd74b"

URI_x86_64_v2_python3-py3dns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-py3dns-4.0.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-py3dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-py3dns}"
SRC_URI[x86_64_v2_python3-py3dns.sha256sum] = "fe591e60389e6fb15e6897ac1031ef624c79a6ab8bacdd75d730085b18f3ed5d"

URI_aarch64_python3-py3dns = "${EPEL_MIRROR}/aarch64/Packages/p/python3-py3dns-4.0.0-11.el10_2.noarch.rpm;name=aarch64_python3-py3dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-py3dns}"
SRC_URI[aarch64_python3-py3dns.sha256sum] = "aef25068c7f326d5c72e4615c633ca36d66fb9ada72c3c1311ac1226934f1dd0"

RDEPENDS:python3-py3dns = " \
 python3 \
 "
