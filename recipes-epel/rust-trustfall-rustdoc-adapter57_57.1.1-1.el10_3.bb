# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trustfall-rustdoc-adapter57"
PV = "57.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-trustfall-rustdoc-adapter57+default-devel \
 rust-trustfall-rustdoc-adapter57+rayon-devel \
 rust-trustfall-rustdoc-adapter57+rustc-hash-devel \
 rust-trustfall-rustdoc-adapter57-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-trustfall-rustdoc-adapter57-57.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8167e368fc99933b2d306d117e353ff06238737b1fb3bdfda1468de3327cc590"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter57+default-devel-57.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter57+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter57+default-devel.sha256sum] = "286f0dfe75db6c58dc1b2e3c360b72864cb94a780e540161eaabd51a2b9744e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter57+rayon-devel-57.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter57+rayon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter57+rayon-devel.sha256sum] = "143fe3c41e64f4cfdd937caf44332e09a9bd34ed590c78de79312223e57184f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter57+rustc-hash-devel-57.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter57+rustc-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter57+rustc-hash-devel.sha256sum] = "4f97fc90bac17c0e5d26d8edd8774e1faad0226dde0d077a1ef5d892ff8dbe1f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-rustdoc-adapter57-devel-57.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-rustdoc-adapter57-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-rustdoc-adapter57-devel.sha256sum] = "2129264ea182cb81e678ad49e8636ef724daa81ec8e1af5c40d66400bc2a519e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter57+default-devel-57.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter57+default-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter57+default-devel.sha256sum] = "5c3e7f5a678c8aa0bf46a85e0f38ab29fae4cf082b30203729898448423aaf05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter57+rayon-devel-57.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter57+rayon-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter57+rayon-devel.sha256sum] = "a3c5a73bd63a4f7fe94a358d74876d98b5c44330749f52c38ad169fe6e8d372f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter57+rustc-hash-devel-57.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter57+rustc-hash-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter57+rustc-hash-devel.sha256sum] = "80bcd82718a16cb92080c53d35d55ad7a130c9f494aa0b0d818cea5b315510bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-rustdoc-adapter57-devel-57.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-trustfall-rustdoc-adapter57-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-rustdoc-adapter57-devel.sha256sum] = "c798cbbe10de96caf4fc97e48d12dc988027906e63080f7ddfc1cc3c66522439"

RDEPENDS:rust-trustfall-rustdoc-adapter57+default-devel = " \
 cargo \
 rust-trustfall-rustdoc-adapter57-devel \
 "
RDEPENDS:rust-trustfall-rustdoc-adapter57+rayon-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-trustfall-rustdoc-adapter57-devel \
 "
RDEPENDS:rust-trustfall-rustdoc-adapter57+rustc-hash-devel = " \
 cargo \
 rust-rustc-hash+default-devel \
 rust-rustdoc-types0.57+rustc-hash-devel \
 rust-trustfall-rustdoc-adapter57-devel \
 "
RDEPENDS:rust-trustfall-rustdoc-adapter57-devel = " \
 bash \
 cargo \
 rust \
 rust-cargo_metadata+default-devel \
 rust-cargo_toml+default-devel \
 rust-cargo_toml+features-devel \
 rust-indexmap+default-devel \
 rust-rustdoc-types0.57+default-devel \
 rust-trustfall+default-devel \
 "
