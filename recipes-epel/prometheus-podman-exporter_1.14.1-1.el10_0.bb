# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prometheus-podman-exporter"
PV = "1.14.1"
PR = "1.el10_0"
PACKAGES = " \
 prometheus-podman-exporter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/prometheus-podman-exporter-1.14.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dd4158f7e471858bd5162cdd5c0bc0156cadc764802423ea2aaa08cba9de922"

URI_x86_64_v2_prometheus-podman-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prometheus-podman-exporter-1.14.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prometheus-podman-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prometheus-podman-exporter}"
SRC_URI[x86_64_v2_prometheus-podman-exporter.sha256sum] = "8702745a680604d9a351588cc2cb1cf2aabc4cd7a5897c5a159f49f11bae52db"

URI_aarch64_prometheus-podman-exporter = "${EPEL_MIRROR}/aarch64/Packages/p/prometheus-podman-exporter-1.14.1-1.el10_0.aarch64.rpm;name=aarch64_prometheus-podman-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_prometheus-podman-exporter}"
SRC_URI[aarch64_prometheus-podman-exporter.sha256sum] = "f70ffecdb232adccaff72a3ad0dbe1ebbe211e01197a5f2614ab64f97c6ae7ea"

RDEPENDS:prometheus-podman-exporter = " \
 bash \
 glibc \
 gpgme \
 "
