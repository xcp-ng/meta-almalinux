# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mmlib"
PV = "1.4.2"
PR = "13.el10_0"
PACKAGES = " \
 mmlib \
 mmlib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mmlib-1.4.2-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb6b59d3c3b9f78f00e27ca9edaf2367fd25e429435be3110eac918457439e0c"

URI_x86_64_v2_mmlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mmlib-1.4.2-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mmlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mmlib}"
SRC_URI[x86_64_v2_mmlib.sha256sum] = "375bbbf6a059880a852ba9758172cd56d8c79c817becc6704d02e41e070186e6"

URI_x86_64_v2_mmlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mmlib-devel-1.4.2-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mmlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mmlib-devel}"
SRC_URI[x86_64_v2_mmlib-devel.sha256sum] = "ba2ff7098a31159771d117284701c2ccff63fb9ecb5cc4c8b71e8801a99c25f7"

URI_aarch64_mmlib = "${EPEL_MIRROR}/aarch64/Packages/m/mmlib-1.4.2-13.el10_0.aarch64.rpm;name=aarch64_mmlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_mmlib}"
SRC_URI[aarch64_mmlib.sha256sum] = "64152975b601e8ff10a9cdc394294f80e6c9aed0e3bec86dbb1244f2b2079156"

URI_aarch64_mmlib-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mmlib-devel-1.4.2-13.el10_0.aarch64.rpm;name=aarch64_mmlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mmlib-devel}"
SRC_URI[aarch64_mmlib-devel.sha256sum] = "ee523bcfbcc7faef5844523499cb9cef9c61d5f84797db68a1eaed910376b41b"

RDEPENDS:mmlib = " \
 glibc \
 "
RDEPENDS:mmlib-devel = " \
 mmlib \
 pkgconf-pkg-config \
 "
