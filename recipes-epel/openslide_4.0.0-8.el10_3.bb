# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openslide"
PV = "4.0.0"
PR = "8.el10_3"
PACKAGES = " \
 openslide \
 openslide-devel \
 openslide-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openslide-4.0.0-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d17d0cf5e0b0f9c0bfec3aaebd88bca985c3420f07fa769ed03ac521de1ac1d"

URI_x86_64_v2_openslide = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openslide-4.0.0-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openslide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openslide}"
SRC_URI[x86_64_v2_openslide.sha256sum] = "10499b8fc4b1463916e476f097bb5bf7b3e4bc9f649dc8ec9771e1ad92d483e2"

URI_x86_64_v2_openslide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openslide-devel-4.0.0-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openslide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openslide-devel}"
SRC_URI[x86_64_v2_openslide-devel.sha256sum] = "9bc289e5a9fb95d2634a01e283eef88a872a1a3899d51eb36d12556bc6051a1a"

URI_x86_64_v2_openslide-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openslide-tools-4.0.0-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openslide-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openslide-tools}"
SRC_URI[x86_64_v2_openslide-tools.sha256sum] = "fe8a4b61c04eafb0ffb8aa54a863f720cdbf78d2cd7b28f967a6a76e5e7bd606"

URI_aarch64_openslide = "${EPEL_MIRROR}/aarch64/Packages/o/openslide-4.0.0-8.el10_3.aarch64.rpm;name=aarch64_openslide;unpack=0"
SRC_URI:append = " ${URI_aarch64_openslide}"
SRC_URI[aarch64_openslide.sha256sum] = "2d988683c22d7631a181ba0d3863a245f964c65c2fc05526f028155c66a7a12f"

URI_aarch64_openslide-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openslide-devel-4.0.0-8.el10_3.aarch64.rpm;name=aarch64_openslide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openslide-devel}"
SRC_URI[aarch64_openslide-devel.sha256sum] = "9c1a1291ee4b23dc53513806f66abcbfcb53822aa8f946c405ca36bbf8065c3d"

URI_aarch64_openslide-tools = "${EPEL_MIRROR}/aarch64/Packages/o/openslide-tools-4.0.0-8.el10_3.aarch64.rpm;name=aarch64_openslide-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_openslide-tools}"
SRC_URI[aarch64_openslide-tools.sha256sum] = "f547befb77634d154ce6e07710678173b0ddf92ab021997a15fc7cdaad56ad23"

RDEPENDS:openslide = " \
 cairo \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules-extra \
 glib2 \
 glibc \
 libdicom \
 libgcc \
 libjpeg-turbo \
 libpng \
 libtiff \
 libxml2 \
 openjpeg2 \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:openslide-devel = " \
 cairo-devel \
 gdk-pixbuf2-devel \
 glib2-devel \
 libdicom-devel \
 libjpeg-turbo-devel \
 libpng-devel \
 libtiff-devel \
 libxml2-devel \
 openjpeg2-devel \
 openslide \
 pkgconf-pkg-config \
 sqlite-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:openslide-tools = " \
 glib2 \
 glibc \
 libgcc \
 libpng \
 openslide \
 "
