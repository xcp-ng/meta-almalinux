# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksudoku"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ksudoku \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ksudoku-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6470830b6647e9f51d1337f47e101ac74bfe12c4f6ebdc4f029403a8229459ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksudoku-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksudoku;unpack=0"
SRC_URI[x86_64_v2_ksudoku.sha256sum] = "172b13b2c106366020453487860d89db454ee0f1e41c765cfc6d7353c86939e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksudoku-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ksudoku;unpack=0"
SRC_URI[aarch64_ksudoku.sha256sum] = "25199441c2acf0dc223cc2d400532156b93b792c7436cb1cee6b1c0dd4af5e84"

RDEPENDS:ksudoku = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libglvnd-opengl \
 libkdegames \
 libstdc++ \
 mesa-libGLU \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
