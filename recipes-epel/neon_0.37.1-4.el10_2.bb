# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "neon"
PV = "0.37.1"
PR = "4.el10_2"
PACKAGES = " \
 neon \
 neon-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/neon-0.37.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2dc765eec58ada5e5a6cb7ba0609c3d8327efc0c1d48b518f43303e91fa22dc0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neon-0.37.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neon;unpack=0"
SRC_URI[x86_64_v2_neon.sha256sum] = "0924e62a2221e4cf71ed08ed0ae71a5fc5b8f752754f23818af1b1bcb1556069"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neon-devel-0.37.1-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neon-devel;unpack=0"
SRC_URI[x86_64_v2_neon-devel.sha256sum] = "4d12ca8b0d1afbb51affd4c2d1dbb0a96dcbee972b7c58ba35340dcb5947271d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/neon-0.37.1-4.el10_2.aarch64.rpm;name=aarch64_neon;unpack=0"
SRC_URI[aarch64_neon.sha256sum] = "70a2e114ab86e4ed54a16499584470f6d86e1a83edfb47dbf8900befbc51e917"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/neon-devel-0.37.1-4.el10_2.aarch64.rpm;name=aarch64_neon-devel;unpack=0"
SRC_URI[aarch64_neon-devel.sha256sum] = "479faa83153650ee686a1a7b5f3f913f3c4da5b3cf14023f8e8dfc9494586e36"

RDEPENDS:neon = " \
 expat \
 glibc \
 krb5-libs \
 libntlm \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:neon-devel = " \
 bash \
 expat-devel \
 neon \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
