# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Pod-Coverage"
PV = "1.10"
PR = "32.el10"
PACKAGES = " \
 perl-Test-Pod-Coverage \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Test-Pod-Coverage-1.10-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9c5509d50e6bf3134b7f52c9d21016d9553b805b9dcfa05f57250749762841e"

URI_x86_64_v2_perl-Test-Pod-Coverage = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Test-Pod-Coverage-1.10-32.el10.noarch.rpm;name=x86_64_v2_perl-Test-Pod-Coverage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Pod-Coverage}"
SRC_URI[x86_64_v2_perl-Test-Pod-Coverage.sha256sum] = "3159c8cba6cbdf24f79d07db92dae79a59ef1ec3ee94d22dbcd5a7f488874adc"

URI_aarch64_perl-Test-Pod-Coverage = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Test-Pod-Coverage-1.10-32.el10.noarch.rpm;name=aarch64_perl-Test-Pod-Coverage;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Pod-Coverage}"
SRC_URI[aarch64_perl-Test-Pod-Coverage.sha256sum] = "3159c8cba6cbdf24f79d07db92dae79a59ef1ec3ee94d22dbcd5a7f488874adc"

RDEPENDS:perl-Test-Pod-Coverage = " \
 perl-Pod-Coverage \
 perl-Test-Simple \
 perl-libs \
 "
