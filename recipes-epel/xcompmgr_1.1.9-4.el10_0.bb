# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xcompmgr"
PV = "1.1.9"
PR = "4.el10_0"
PACKAGES = " \
 xcompmgr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xcompmgr-1.1.9-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d2e33478b9ec9a44019bee3d5238085ddab3358023c6a408d866147a5dbd2de"

URI_x86_64_v2_xcompmgr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xcompmgr-1.1.9-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xcompmgr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcompmgr}"
SRC_URI[x86_64_v2_xcompmgr.sha256sum] = "871179de5e67c4f35a3ddd4af03bf59a2bd8434ba9338e384950cf047ea3300c"

URI_aarch64_xcompmgr = "${EPEL_MIRROR}/aarch64/Packages/x/xcompmgr-1.1.9-4.el10_0.aarch64.rpm;name=aarch64_xcompmgr;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcompmgr}"
SRC_URI[aarch64_xcompmgr.sha256sum] = "539fc6cf9d8c7c156f126e6597b80cf986ac9036fd9f770085d84f3471b12b67"

RDEPENDS:xcompmgr = " \
 glibc \
 libX11 \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrender \
 "
