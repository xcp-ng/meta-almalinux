# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Business-ISBN-Data"
PV = "20260416.001"
PR = "1.el10_3"
PACKAGES = " \
 perl-Business-ISBN-Data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Business-ISBN-Data-20260416.001-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c641a46c92839f76b488bcff758ab0ccf53ce6ef6b5787bc3b345abb213c7975"

URI_x86_64_v2_perl-Business-ISBN-Data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISBN-Data-20260416.001-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISBN-Data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Business-ISBN-Data}"
SRC_URI[x86_64_v2_perl-Business-ISBN-Data.sha256sum] = "37d6c81cace610339f159e95deb8a675a9e52c42eb2a74c4faaec50eb591b2f8"

URI_aarch64_perl-Business-ISBN-Data = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISBN-Data-20260416.001-1.el10_3.noarch.rpm;name=aarch64_perl-Business-ISBN-Data;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Business-ISBN-Data}"
SRC_URI[aarch64_perl-Business-ISBN-Data.sha256sum] = "bcf7fb1cac78d12c93682ac2c060ee0f19c41f931bd67eed1f2a55d528d8b514"

RDEPENDS:perl-Business-ISBN-Data = " \
 perl-Carp \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
