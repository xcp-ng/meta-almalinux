# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jinja2_pluralize"
PV = "0.3.0"
PR = "34.el10_0"
PACKAGES = " \
 python3-jinja2_pluralize \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jinja2_pluralize-0.3.0-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8233829f373e8c153355be047d1a38a736512d4b38a45601d7240bec07412684"

URI_x86_64_v2_python3-jinja2_pluralize = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jinja2_pluralize-0.3.0-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jinja2_pluralize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jinja2_pluralize}"
SRC_URI[x86_64_v2_python3-jinja2_pluralize.sha256sum] = "b381c21f75fb730ecea5316d5ba2950dd5e2e45f55455a3abc574ff7605b4377"

URI_aarch64_python3-jinja2_pluralize = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jinja2_pluralize-0.3.0-34.el10_0.noarch.rpm;name=aarch64_python3-jinja2_pluralize;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jinja2_pluralize}"
SRC_URI[aarch64_python3-jinja2_pluralize.sha256sum] = "a5ef0a1db2bb1038763b92665f3cdec1fe925dcde3d8c9c62549608ea59b0dc5"

RDEPENDS:python3-jinja2_pluralize = " \
 python3 \
 python3-inflect \
 python3-jinja2 \
 "
