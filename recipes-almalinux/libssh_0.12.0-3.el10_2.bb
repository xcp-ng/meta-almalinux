# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libssh"
PV = "0.12.0"
PR = "3.el10_2"
PACKAGES = " \
 libssh \
 libssh-config \
 libssh-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libssh-0.12.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cd37c3a76b5a0125c22bcbfeda01bbae428c7cd0bedf20428c39b015e137f7f"

URI_x86_64_v2_libssh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libssh-0.12.0-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_libssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh}"
SRC_URI[x86_64_v2_libssh.sha256sum] = "e5703f2dc176f26a12f6168203d2d0813db112ae8fe0d4680de5e22d75233d71"

URI_x86_64_v2_libssh-config = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libssh-config-0.12.0-3.el10_2.noarch.rpm;name=x86_64_v2_libssh-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh-config}"
SRC_URI[x86_64_v2_libssh-config.sha256sum] = "42473901905bfd812bc9f2ddd5acb2b88e2b135c977f8b3f96f1c8052c50c3d2"

URI_x86_64_v2_libssh-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libssh-devel-0.12.0-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_libssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh-devel}"
SRC_URI[x86_64_v2_libssh-devel.sha256sum] = "cf889169a138c1d2fe2a780dbecef2c94ee338f4bea052c8ec705aec8df146db"

URI_aarch64_libssh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libssh-0.12.0-3.el10_2.aarch64.rpm;name=aarch64_libssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh}"
SRC_URI[aarch64_libssh.sha256sum] = "08a7eb28a828dbfe8a6fa875caa9d2652648cd6ce2faefeaefea8216996cec28"

URI_aarch64_libssh-config = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libssh-config-0.12.0-3.el10_2.noarch.rpm;name=aarch64_libssh-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh-config}"
SRC_URI[aarch64_libssh-config.sha256sum] = "42473901905bfd812bc9f2ddd5acb2b88e2b135c977f8b3f96f1c8052c50c3d2"

URI_aarch64_libssh-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libssh-devel-0.12.0-3.el10_2.aarch64.rpm;name=aarch64_libssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh-devel}"
SRC_URI[aarch64_libssh-devel.sha256sum] = "142fad30e98dc27dc7e7f71391326a207e449309717cc1bacfad2b63f5a7ab18"

RDEPENDS:libssh = " \
 crypto-policies \
 glibc \
 krb5-libs \
 libfido2 \
 libssh-config \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libssh-config = " \
 "
RDEPENDS:libssh-devel = " \
 cmake-filesystem \
 krb5-devel \
 libssh \
 pkgconf-pkg-config \
 "
