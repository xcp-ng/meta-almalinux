# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-prompt"
PV = "0.11.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-prompt+default-devel \
 rust-gix-prompt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-prompt-0.11.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a4f3a3a917f513ab1fd4a1a1543bdf658e9cc37f6a7ed7db1db2a940c5aae3f"

URI_x86_64_v2_rust-gix-prompt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-prompt+default-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-prompt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-prompt+default-devel}"
SRC_URI[x86_64_v2_rust-gix-prompt+default-devel.sha256sum] = "799cc0ae1586f36ffd28e643e62c3f11ade6ff34cb33d95cbc822f50b0706f5b"

URI_x86_64_v2_rust-gix-prompt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-prompt-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-prompt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-prompt-devel}"
SRC_URI[x86_64_v2_rust-gix-prompt-devel.sha256sum] = "f711828b00d07a72fd977db734049b8cab648ea6d5a2e5809530654f27c788cf"

URI_aarch64_rust-gix-prompt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-prompt+default-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-prompt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-prompt+default-devel}"
SRC_URI[aarch64_rust-gix-prompt+default-devel.sha256sum] = "15ad65025bbd438d8ac21d46669489d0f6d8f55fa1b1bcdc852507f94b799531"

URI_aarch64_rust-gix-prompt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-prompt-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-prompt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-prompt-devel}"
SRC_URI[aarch64_rust-gix-prompt-devel.sha256sum] = "ae37209f4b92502c669e614fbe31f1d066613a6eb4479cd9298578ec3bb9e37f"

RDEPENDS:rust-gix-prompt+default-devel = " \
 cargo \
 rust-gix-prompt-devel \
 "
RDEPENDS:rust-gix-prompt-devel = " \
 cargo \
 rust \
 rust-gix-command+default-devel \
 rust-gix-config-value+default-devel \
 rust-parking_lot+default-devel \
 rust-rustix+default-devel \
 rust-rustix+termios-devel \
 rust-thiserror+default-devel \
 "
