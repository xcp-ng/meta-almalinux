# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-codespan-reporting"
PV = "0.13.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-codespan-reporting+ascii-only-devel \
 rust-codespan-reporting+default-devel \
 rust-codespan-reporting+serde-devel \
 rust-codespan-reporting+serialization-devel \
 rust-codespan-reporting+std-devel \
 rust-codespan-reporting+termcolor-devel \
 rust-codespan-reporting-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-codespan-reporting-0.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "091d06ac68f2de6851a57a7933262a0635289f9606d4ad771a544329dbb111f4"

URI_x86_64_v2_rust-codespan-reporting+ascii-only-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+ascii-only-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+ascii-only-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+ascii-only-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+ascii-only-devel.sha256sum] = "10b11d2f141b671b6130e75a53518328719426dad0052b7dcff183a6b85722aa"

URI_x86_64_v2_rust-codespan-reporting+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+default-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+default-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+default-devel.sha256sum] = "3e70d4f87b2adec192a4798ddbb605711c48d0114fca5285557bc2a499b664ac"

URI_x86_64_v2_rust-codespan-reporting+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+serde-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+serde-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+serde-devel.sha256sum] = "f0b97a08128b2a083ad4abbc1af05ab62222ad522b85a88fa47daf7fefde1b54"

URI_x86_64_v2_rust-codespan-reporting+serialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+serialization-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+serialization-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+serialization-devel.sha256sum] = "0c0727564ea7e909adc9da4f0f6916f395ec9941c023eef94bccfc4070886280"

URI_x86_64_v2_rust-codespan-reporting+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+std-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+std-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+std-devel.sha256sum] = "bef4731bea474453b890c93c272ca3df371b8080d438a7701ea76bf0c5410a54"

URI_x86_64_v2_rust-codespan-reporting+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+termcolor-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+termcolor-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+termcolor-devel.sha256sum] = "9ebfb6c3deef3382f0031708676cedf5957a706bdf8267ba0ed12198a8a5480c"

URI_x86_64_v2_rust-codespan-reporting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting-devel.sha256sum] = "68ca4f6d36c01c9dccf958686029ccebeb4839e52ccb1d1069d7d19e0fd94aac"

URI_aarch64_rust-codespan-reporting+ascii-only-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+ascii-only-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-codespan-reporting+ascii-only-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+ascii-only-devel}"
SRC_URI[aarch64_rust-codespan-reporting+ascii-only-devel.sha256sum] = "6965b8b653311eaab21c1a0a0736ebd8ddc7ee1d931aecaceffdce2a4006a0aa"

URI_aarch64_rust-codespan-reporting+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+default-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-codespan-reporting+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+default-devel}"
SRC_URI[aarch64_rust-codespan-reporting+default-devel.sha256sum] = "5d9b0ea9eea11ff82ebfbe164256102466afc227c2426106dc5903efff6d0e1d"

URI_aarch64_rust-codespan-reporting+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+serde-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-codespan-reporting+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+serde-devel}"
SRC_URI[aarch64_rust-codespan-reporting+serde-devel.sha256sum] = "1c8e8eb05bc4ac02f9d0c291321fdd187764137ce6c6db72bbeb12fd7005d62a"

URI_aarch64_rust-codespan-reporting+serialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+serialization-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-codespan-reporting+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+serialization-devel}"
SRC_URI[aarch64_rust-codespan-reporting+serialization-devel.sha256sum] = "91e5f6a3a7126370a5ef136509dde92f32b8afd09a58db515c5e101f2c380951"

URI_aarch64_rust-codespan-reporting+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+std-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-codespan-reporting+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+std-devel}"
SRC_URI[aarch64_rust-codespan-reporting+std-devel.sha256sum] = "aa574360fdf366e5d67e089634f1ab69ff264b2e43a8b65f5833fe6f42e860f8"

URI_aarch64_rust-codespan-reporting+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+termcolor-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-codespan-reporting+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+termcolor-devel}"
SRC_URI[aarch64_rust-codespan-reporting+termcolor-devel.sha256sum] = "b355a682681a78a7b6e6ff744b4d5bcb27fbeb1f6cbeeb69eba9402ea174372a"

URI_aarch64_rust-codespan-reporting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-codespan-reporting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting-devel}"
SRC_URI[aarch64_rust-codespan-reporting-devel.sha256sum] = "1c94e8416712fbcce28b834c30d867b4dbdb67a17b5e889d2b73fe09e5221d36"

RDEPENDS:rust-codespan-reporting+ascii-only-devel = " \
 cargo \
 rust-codespan-reporting-devel \
 "
RDEPENDS:rust-codespan-reporting+default-devel = " \
 cargo \
 rust-codespan-reporting+std-devel \
 rust-codespan-reporting+termcolor-devel \
 rust-codespan-reporting-devel \
 "
RDEPENDS:rust-codespan-reporting+serde-devel = " \
 cargo \
 rust-codespan-reporting-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-codespan-reporting+serialization-devel = " \
 cargo \
 rust-codespan-reporting+serde-devel \
 rust-codespan-reporting-devel \
 "
RDEPENDS:rust-codespan-reporting+std-devel = " \
 cargo \
 rust-codespan-reporting-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-codespan-reporting+termcolor-devel = " \
 cargo \
 rust-codespan-reporting+std-devel \
 rust-codespan-reporting-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-codespan-reporting-devel = " \
 cargo \
 rust \
 virtual/crate_unicode-width/default__ge_0.1.0_with_crate_unicode-width/default__lt_0.3.0~ \
 "
