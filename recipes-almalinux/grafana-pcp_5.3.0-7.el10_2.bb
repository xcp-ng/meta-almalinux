# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana-pcp"
PV = "5.3.0"
PR = "7.el10_2"
PACKAGES = " \
 grafana-pcp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-pcp-5.3.0-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2680e8a16c503e77b095a001af162176328b69bcd10fa6637137570885d2a733"

URI_x86_64_v2_grafana-pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-pcp-5.3.0-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_grafana-pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grafana-pcp}"
SRC_URI[x86_64_v2_grafana-pcp.sha256sum] = "020526a8ed3af14c9d11aefdfa46117422467dc92eb5144e2366068eed9504d1"

URI_aarch64_grafana-pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-pcp-5.3.0-7.el10_2.aarch64.rpm;name=aarch64_grafana-pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_grafana-pcp}"
SRC_URI[aarch64_grafana-pcp.sha256sum] = "64137909f3ba3d445afebf6b38fd9894b444439dd195425a442809e4c11d3088"

RDEPENDS:grafana-pcp = " \
 bash \
 glibc \
 grafana \
 systemd \
 "
