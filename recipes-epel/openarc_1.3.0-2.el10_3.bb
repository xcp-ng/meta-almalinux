# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openarc"
PV = "1.3.0"
PR = "2.el10_3"
PACKAGES = " \
 libopenarc \
 libopenarc-devel \
 openarc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openarc-1.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4afc3c797c771489a64a30fc0212ef8484e70cd5c2a90e2013cce92de9342ff"

URI_x86_64_v2_libopenarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenarc-1.3.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenarc}"
SRC_URI[x86_64_v2_libopenarc.sha256sum] = "f835a3e2ae9d59c04d0e60dee6bfcb2441e9e69e734de38102dfdba68f964177"

URI_x86_64_v2_libopenarc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenarc-devel-1.3.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenarc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenarc-devel}"
SRC_URI[x86_64_v2_libopenarc-devel.sha256sum] = "58cf062ca2630ef67c7600dc5081d9838c49779adf477caafb7e468fd91aacc3"

URI_x86_64_v2_openarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openarc-1.3.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openarc}"
SRC_URI[x86_64_v2_openarc.sha256sum] = "d0919df01d8a5291e00b5af890cfb7378ed8dd75dc00b2ddcbcd0ac236074e53"

URI_aarch64_libopenarc = "${EPEL_MIRROR}/aarch64/Packages/l/libopenarc-1.3.0-2.el10_3.aarch64.rpm;name=aarch64_libopenarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenarc}"
SRC_URI[aarch64_libopenarc.sha256sum] = "6f42c183d6a8b1de0c602c9d45da2cf86dadd3310aa62d188a89acb4698b36bb"

URI_aarch64_libopenarc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopenarc-devel-1.3.0-2.el10_3.aarch64.rpm;name=aarch64_libopenarc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenarc-devel}"
SRC_URI[aarch64_libopenarc-devel.sha256sum] = "6ed395719b98636b097fe6d2e061c5e79acc1433dcb378265ea0ad8a6147da3a"

URI_aarch64_openarc = "${EPEL_MIRROR}/aarch64/Packages/o/openarc-1.3.0-2.el10_3.aarch64.rpm;name=aarch64_openarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_openarc}"
SRC_URI[aarch64_openarc.sha256sum] = "14b3950c383125cae18b928ea685a4e0390f0a9c563f18a78ab062622db798a6"

RDEPENDS:libopenarc = " \
 glibc \
 libidn2 \
 openssl-libs \
 "
RDEPENDS:libopenarc-devel = " \
 libidn2-devel \
 libopenarc \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:openarc = " \
 bash \
 glibc \
 jansson \
 libopenarc \
 openssl-libs \
 python3 \
 sendmail-milter \
 setup \
 shadow-utils \
 systemd \
 "
