# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lsp-plugins"
PV = "1.2.21"
PR = "1.el10_1"
PACKAGES = " \
 liblsp-r3d-glx \
 liblsp-r3d-glx-devel \
 lsp-plugins \
 lsp-plugins-clap \
 lsp-plugins-doc \
 lsp-plugins-gstreamer \
 lsp-plugins-jack \
 lsp-plugins-ladspa \
 lsp-plugins-lv2 \
 lsp-plugins-vst \
 lsp-plugins-vst3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lsp-plugins-1.2.21-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5528dd0772f1918c5835e06ed2d50c16a738824b878703e4fc9d95ba27636081"

URI_x86_64_v2_liblsp-r3d-glx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblsp-r3d-glx-1.2.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblsp-r3d-glx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblsp-r3d-glx}"
SRC_URI[x86_64_v2_liblsp-r3d-glx.sha256sum] = "f210ba56442eb701f9cbdf25d07fb3c1dc66c1d9ed4ee9a0fee843df438d0b2a"

URI_x86_64_v2_liblsp-r3d-glx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liblsp-r3d-glx-devel-1.2.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liblsp-r3d-glx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblsp-r3d-glx-devel}"
SRC_URI[x86_64_v2_liblsp-r3d-glx-devel.sha256sum] = "482544ec4af9f0e766f4ca26f2acd928180227ad0a0fd2b1b6246de056c03a25"

URI_x86_64_v2_lsp-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsp-plugins-1.2.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsp-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsp-plugins}"
SRC_URI[x86_64_v2_lsp-plugins.sha256sum] = "160d39f36d04fb17d48eaa64151971e48ecc5f254894a22ddd33a542e50522b9"

URI_x86_64_v2_lsp-plugins-clap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsp-plugins-clap-1.2.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsp-plugins-clap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsp-plugins-clap}"
SRC_URI[x86_64_v2_lsp-plugins-clap.sha256sum] = "4fb0e951927e1a14bdaa9f0716b2924a34cb9339cd7e7f7c2161ffef6d441000"

URI_x86_64_v2_lsp-plugins-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsp-plugins-doc-1.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lsp-plugins-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsp-plugins-doc}"
SRC_URI[x86_64_v2_lsp-plugins-doc.sha256sum] = "378398dd09e665ff646a31ec1ab799f6d5cabe8a149c13896c764f964d475b27"

URI_x86_64_v2_lsp-plugins-gstreamer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsp-plugins-gstreamer-1.2.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsp-plugins-gstreamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsp-plugins-gstreamer}"
SRC_URI[x86_64_v2_lsp-plugins-gstreamer.sha256sum] = "7709892ed6054a52ef6c41dc5c2312d7c4f977e531b132d443081c9eb7bd089c"

URI_x86_64_v2_lsp-plugins-jack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsp-plugins-jack-1.2.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsp-plugins-jack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsp-plugins-jack}"
SRC_URI[x86_64_v2_lsp-plugins-jack.sha256sum] = "5bad6fe6ed00ce0ebfa4b8060dd7c6970524a9f13b1277f10b4d70d85eac5111"

URI_x86_64_v2_lsp-plugins-ladspa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsp-plugins-ladspa-1.2.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsp-plugins-ladspa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsp-plugins-ladspa}"
SRC_URI[x86_64_v2_lsp-plugins-ladspa.sha256sum] = "ae95d3066c811b7d4e2243c17b2b5f31992f9819e54c6fe2b7ae995957bcf851"

URI_x86_64_v2_lsp-plugins-lv2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsp-plugins-lv2-1.2.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsp-plugins-lv2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsp-plugins-lv2}"
SRC_URI[x86_64_v2_lsp-plugins-lv2.sha256sum] = "80ad38200cf3216da6bf036e5a0581743061a0b299346792abc6b65dd28de532"

URI_x86_64_v2_lsp-plugins-vst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsp-plugins-vst-1.2.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsp-plugins-vst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsp-plugins-vst}"
SRC_URI[x86_64_v2_lsp-plugins-vst.sha256sum] = "deea65595cc754835ff7b13b666e3be54cebdcb8ab882bae558dff7a9a03e0b2"

URI_x86_64_v2_lsp-plugins-vst3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsp-plugins-vst3-1.2.21-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsp-plugins-vst3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsp-plugins-vst3}"
SRC_URI[x86_64_v2_lsp-plugins-vst3.sha256sum] = "22fe3af2cdb8e56fc5cc8a760082585e2892d43d29e1262486863b7a16413c0d"

URI_aarch64_liblsp-r3d-glx = "${EPEL_MIRROR}/aarch64/Packages/l/liblsp-r3d-glx-1.2.21-1.el10_1.aarch64.rpm;name=aarch64_liblsp-r3d-glx;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblsp-r3d-glx}"
SRC_URI[aarch64_liblsp-r3d-glx.sha256sum] = "640ebfa4bf3bc9b63704644a8d5c437ad3ef077a1acf3ca2d377b063a1518b25"

URI_aarch64_liblsp-r3d-glx-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liblsp-r3d-glx-devel-1.2.21-1.el10_1.aarch64.rpm;name=aarch64_liblsp-r3d-glx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblsp-r3d-glx-devel}"
SRC_URI[aarch64_liblsp-r3d-glx-devel.sha256sum] = "5b3d66359926d6e35c268c27981d81ae3ed13096c901b0084a1c51dc1ba7ada2"

URI_aarch64_lsp-plugins = "${EPEL_MIRROR}/aarch64/Packages/l/lsp-plugins-1.2.21-1.el10_1.aarch64.rpm;name=aarch64_lsp-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsp-plugins}"
SRC_URI[aarch64_lsp-plugins.sha256sum] = "0e42848903aaf49b2d0b3f97c1c18c94a04b2ad00d0a4dfa6864e79ed1bff107"

URI_aarch64_lsp-plugins-clap = "${EPEL_MIRROR}/aarch64/Packages/l/lsp-plugins-clap-1.2.21-1.el10_1.aarch64.rpm;name=aarch64_lsp-plugins-clap;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsp-plugins-clap}"
SRC_URI[aarch64_lsp-plugins-clap.sha256sum] = "e0bb3f8a5275558cd0703d78d155adc504c937e7cadeae3f8dbd2c8662b221d0"

URI_aarch64_lsp-plugins-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lsp-plugins-doc-1.2.21-1.el10_1.noarch.rpm;name=aarch64_lsp-plugins-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsp-plugins-doc}"
SRC_URI[aarch64_lsp-plugins-doc.sha256sum] = "d3b3d8b4a210ac6a9c7b7a6708c86d9dad1c49801aa4aa851ff8a65a63336ea1"

URI_aarch64_lsp-plugins-gstreamer = "${EPEL_MIRROR}/aarch64/Packages/l/lsp-plugins-gstreamer-1.2.21-1.el10_1.aarch64.rpm;name=aarch64_lsp-plugins-gstreamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsp-plugins-gstreamer}"
SRC_URI[aarch64_lsp-plugins-gstreamer.sha256sum] = "bbd1310340356ced697573a45a7fded54d9f976e928eab60b66cdf3f32a439c4"

URI_aarch64_lsp-plugins-jack = "${EPEL_MIRROR}/aarch64/Packages/l/lsp-plugins-jack-1.2.21-1.el10_1.aarch64.rpm;name=aarch64_lsp-plugins-jack;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsp-plugins-jack}"
SRC_URI[aarch64_lsp-plugins-jack.sha256sum] = "8715b3161221295c31169a051e5cb90fa2b40781b4a3f8dd6309ec159cf324ea"

URI_aarch64_lsp-plugins-ladspa = "${EPEL_MIRROR}/aarch64/Packages/l/lsp-plugins-ladspa-1.2.21-1.el10_1.aarch64.rpm;name=aarch64_lsp-plugins-ladspa;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsp-plugins-ladspa}"
SRC_URI[aarch64_lsp-plugins-ladspa.sha256sum] = "7d837e16061ba315c988a82a14017c1a4286c217d6d9a1fd02f3d75f50e1bdad"

URI_aarch64_lsp-plugins-lv2 = "${EPEL_MIRROR}/aarch64/Packages/l/lsp-plugins-lv2-1.2.21-1.el10_1.aarch64.rpm;name=aarch64_lsp-plugins-lv2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsp-plugins-lv2}"
SRC_URI[aarch64_lsp-plugins-lv2.sha256sum] = "648ebe24d549d0950cbe632d5929814b239fbf68310eca621734ca402be19c10"

URI_aarch64_lsp-plugins-vst = "${EPEL_MIRROR}/aarch64/Packages/l/lsp-plugins-vst-1.2.21-1.el10_1.aarch64.rpm;name=aarch64_lsp-plugins-vst;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsp-plugins-vst}"
SRC_URI[aarch64_lsp-plugins-vst.sha256sum] = "3b1679c06a5c00c2bf77603b8ac7c978493f144515e65428d2a70efead24b465"

URI_aarch64_lsp-plugins-vst3 = "${EPEL_MIRROR}/aarch64/Packages/l/lsp-plugins-vst3-1.2.21-1.el10_1.aarch64.rpm;name=aarch64_lsp-plugins-vst3;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsp-plugins-vst3}"
SRC_URI[aarch64_lsp-plugins-vst3.sha256sum] = "973188da772fa1fbba678c2ae17a615d46faede5cd3ec567c50495b461c03be4"

RDEPENDS:liblsp-r3d-glx = " \
 glibc \
 libX11 \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 "
RDEPENDS:liblsp-r3d-glx-devel = " \
 liblsp-r3d-glx \
 pkgconf-pkg-config \
 "
RDEPENDS:lsp-plugins = " \
 glibc \
 gnome-menus \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 "
RDEPENDS:lsp-plugins-clap = " \
 cairo \
 fontconfig \
 freetype \
 glibc \
 libX11 \
 libXrandr \
 libgcc \
 libglvnd-glx \
 libsndfile \
 libstdc++ \
 "
RDEPENDS:lsp-plugins-doc = " \
 "
RDEPENDS:lsp-plugins-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 libstdc++ \
 "
RDEPENDS:lsp-plugins-jack = " \
 cairo \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libX11 \
 libXrandr \
 libgcc \
 libglvnd-glx \
 libsndfile \
 libstdc++ \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:lsp-plugins-ladspa = " \
 glibc \
 ladspa \
 libgcc \
 libsndfile \
 libstdc++ \
 "
RDEPENDS:lsp-plugins-lv2 = " \
 cairo \
 fontconfig \
 freetype \
 glibc \
 libX11 \
 libXrandr \
 libgcc \
 libglvnd-glx \
 libsndfile \
 libstdc++ \
 lv2 \
 "
RDEPENDS:lsp-plugins-vst = " \
 Carla-vst \
 cairo \
 fontconfig \
 freetype \
 glibc \
 libX11 \
 libXrandr \
 libgcc \
 libglvnd-glx \
 libsndfile \
 libstdc++ \
 "
RDEPENDS:lsp-plugins-vst3 = " \
 cairo \
 fontconfig \
 freetype \
 glibc \
 libX11 \
 libXrandr \
 libgcc \
 libglvnd-glx \
 libsndfile \
 libstdc++ \
 "
