# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-blosc"
PV = "1.11.2"
PR = "3.el10_0"
PACKAGES = " \
 python3-blosc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-blosc-1.11.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae02a2d41718ed74d8e999478c3ddee7b46f407c06d218cda9cd24d045c257ad"

URI_x86_64_v2_python3-blosc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-blosc-1.11.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-blosc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-blosc}"
SRC_URI[x86_64_v2_python3-blosc.sha256sum] = "d4ff02aefabd22bc3c091a3e0601975da092f4b99a8906928f81bd490e54725c"

URI_aarch64_python3-blosc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-blosc-1.11.2-3.el10_0.aarch64.rpm;name=aarch64_python3-blosc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-blosc}"
SRC_URI[aarch64_python3-blosc.sha256sum] = "fe4a1674c0f2a8eda9421f424731b850d3dc51e6a0acd231e7efdc84ba36e773"

RDEPENDS:python3-blosc = " \
 blosc \
 glibc \
 python3 \
 "
