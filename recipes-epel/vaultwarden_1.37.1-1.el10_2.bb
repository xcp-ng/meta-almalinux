# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vaultwarden"
PV = "1.37.1"
PR = "1.el10_2"
PACKAGES = " \
 vaultwarden \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vaultwarden-1.37.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d42bf5705bde54571798b714f6ef56a3220c1a84ef64db513b2d3c33316b9c4"

URI_x86_64_v2_vaultwarden = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vaultwarden-1.37.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vaultwarden;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vaultwarden}"
SRC_URI[x86_64_v2_vaultwarden.sha256sum] = "91bd2e8f7f38ddb898d88829da3b6e04975fce5abc4b2cddc38b309a88cfb425"

URI_aarch64_vaultwarden = "${EPEL_MIRROR}/aarch64/Packages/v/vaultwarden-1.37.1-1.el10_2.aarch64.rpm;name=aarch64_vaultwarden;unpack=0"
SRC_URI:append = " ${URI_aarch64_vaultwarden}"
SRC_URI[aarch64_vaultwarden.sha256sum] = "56c25709ec15eff35baf7597f6b88b6b992f436a106da74325c3d6893e893fb2"

RDEPENDS:vaultwarden = " \
 bash \
 glibc \
 libgcc \
 libpq \
 mariadb-connector-c \
 openssl-libs \
 shadow-utils \
 vaultwarden-web \
 "
