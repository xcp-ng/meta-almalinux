# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-executor"
PV = "0.3.32"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures-executor+default-devel \
 rust-futures-executor+std-devel \
 rust-futures-executor+thread-pool-devel \
 rust-futures-executor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-executor-0.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd8ef4886f73be830fac4a8203a0dd7574c3cd4b1db4d84683f8fb4e18e1cd18"

URI_x86_64_v2_rust-futures-executor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+default-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor+default-devel}"
SRC_URI[x86_64_v2_rust-futures-executor+default-devel.sha256sum] = "1131ac3c16073a6ae546f18519dac2f469fa504d56ebe6637e13d9a98a76a761"

URI_x86_64_v2_rust-futures-executor+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+std-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor+std-devel}"
SRC_URI[x86_64_v2_rust-futures-executor+std-devel.sha256sum] = "f6ce35ec7d225626fa63934692750796cf95a01e7fe5ae8acd64aeacfb175e43"

URI_x86_64_v2_rust-futures-executor+thread-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+thread-pool-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor+thread-pool-devel}"
SRC_URI[x86_64_v2_rust-futures-executor+thread-pool-devel.sha256sum] = "f0faf2d6b9013a4ac12e87ae01bad4abafcbc707b8f329c281065e215371c63e"

URI_x86_64_v2_rust-futures-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-executor-devel}"
SRC_URI[x86_64_v2_rust-futures-executor-devel.sha256sum] = "f4d2b2160633ee48423fc199f167d5db0fcd9e8ddac09a8de87e245eda76286d"

URI_aarch64_rust-futures-executor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+default-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor+default-devel}"
SRC_URI[aarch64_rust-futures-executor+default-devel.sha256sum] = "6235bafb6bb298804c3d170a4a8b9cdffaead97ec53c94458e2487efe4348534"

URI_aarch64_rust-futures-executor+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+std-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-executor+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor+std-devel}"
SRC_URI[aarch64_rust-futures-executor+std-devel.sha256sum] = "06344e8ceadf6aa71105245f963465101ebc827ff036395c0c95768fe47daa29"

URI_aarch64_rust-futures-executor+thread-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+thread-pool-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-executor+thread-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor+thread-pool-devel}"
SRC_URI[aarch64_rust-futures-executor+thread-pool-devel.sha256sum] = "0ccc20c763bf71635616985afcf969dff8ef632255aab9daee6cc22859b6776b"

URI_aarch64_rust-futures-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-executor-devel}"
SRC_URI[aarch64_rust-futures-executor-devel.sha256sum] = "ce128161b322c55562b9f7f8e9db7057235f54df51707750d3950401d387a231"

RDEPENDS:rust-futures-executor+default-devel = " \
 cargo \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures-executor+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-executor-devel \
 rust-futures-task+std-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures-executor+thread-pool-devel = " \
 cargo \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures-executor-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-task-devel \
 rust-futures-util-devel \
 "
