# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Pencil2D"
PV = "0.7.2"
PR = "1.el10_2"
PACKAGES = " \
 Pencil2D \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/Pencil2D-0.7.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ca8285ae2f892098a09dc184ed2ecc1ecfccc0679339befad732d0b260a28b8"

URI_x86_64_v2_Pencil2D = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/Pencil2D-0.7.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_Pencil2D;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Pencil2D}"
SRC_URI[x86_64_v2_Pencil2D.sha256sum] = "879ef27b66c7f54fa57c725db3cc79cdda03e657944cf5c2599fe70f27d3bc3a"

URI_aarch64_Pencil2D = "${EPEL_MIRROR}/aarch64/Packages/p/Pencil2D-0.7.2-1.el10_2.aarch64.rpm;name=aarch64_Pencil2D;unpack=0"
SRC_URI:append = " ${URI_aarch64_Pencil2D}"
SRC_URI[aarch64_Pencil2D.sha256sum] = "23162895ef3a639d672d323fbb95360154e8ff951ae8e9d481e6b3098e0855c5"

RDEPENDS:Pencil2D = " \
 ffmpeg-free \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 miniz \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
