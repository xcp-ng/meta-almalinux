# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valkey"
PV = "8.0.9"
PR = "1.el10_2"
PACKAGES = " \
 valkey \
 valkey-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valkey-8.0.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83f3b54187796ce5dc17741d91fd6a4a572defaed37d88c1c517ea21072e152b"

URI_x86_64_v2_valkey = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-8.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_valkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valkey}"
SRC_URI[x86_64_v2_valkey.sha256sum] = "7439c27e4d95d3b500854184556b632a6e5a325eab32142c1b232a580ac44e6a"

URI_x86_64_v2_valkey-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-devel-8.0.9-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_valkey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valkey-devel}"
SRC_URI[x86_64_v2_valkey-devel.sha256sum] = "c66aef2dd0d626eb3afccd2780a6fc5e4d03f11dab1721a0bf27b84994842ba2"

URI_aarch64_valkey = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-8.0.9-1.el10_2.aarch64.rpm;name=aarch64_valkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_valkey}"
SRC_URI[aarch64_valkey.sha256sum] = "3c422160d0cade8908ac8ec40170129b4b578ff1a7851850cc84157187eecd8b"

URI_aarch64_valkey-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-devel-8.0.9-1.el10_2.aarch64.rpm;name=aarch64_valkey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_valkey-devel}"
SRC_URI[aarch64_valkey-devel.sha256sum] = "0d054215154dbc73d36ca5e3c9eff8ea065b6ac4e470c31c88432b15c53fbe20"

RDEPENDS:valkey = " \
 bash \
 glibc \
 logrotate \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:valkey-devel = " \
 "
