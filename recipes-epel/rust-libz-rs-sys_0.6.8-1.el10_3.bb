# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-rs-sys"
PV = "0.6.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-libz-rs-sys+c-allocator-devel \
 rust-libz-rs-sys+custom-prefix-devel \
 rust-libz-rs-sys+default-devel \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys+gz-devel \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+semver-prefix-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys+testing-prefix-devel \
 rust-libz-rs-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libz-rs-sys-0.6.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "084d82bb2459671161d82952d3384eb257d241dd67b62bf1cf2f8d73fb98e1e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+c-allocator-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+c-allocator-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-rs-sys+c-allocator-devel.sha256sum] = "8f172d377aa0d391e622bc31b62098cd440a7413752c2f3b6591ef3d748fd4ad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+custom-prefix-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-rs-sys+custom-prefix-devel.sha256sum] = "8be4bf7cf8c334b68c5de4f5fd7c57ac435784f62d73c953c27eaeac7e1e666f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+default-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-rs-sys+default-devel.sha256sum] = "916c3be29dabf7b9b69b2c64a53db08835b5f292dbf47e7e347e2dc58e292976"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+export-symbols-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+export-symbols-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-rs-sys+export-symbols-devel.sha256sum] = "979e4065b32c53548bb926f6435b6f8823ef84e6341296be700b560cbb8fca41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+gz-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+gz-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-rs-sys+gz-devel.sha256sum] = "16d5d0237a14d7915e0148f34e1a0a00ef5ea5d1c56b5b319846324886587161"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+rust-allocator-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-rs-sys+rust-allocator-devel.sha256sum] = "491f41590dff911f817027d87295bf64ab5002e00e2930a1d9f7e5e2c4786747"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+semver-prefix-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-rs-sys+semver-prefix-devel.sha256sum] = "b56011ccff9f1c527f6d1cc56a6615c4650ecb1d177b3d6534c66a76539c7587"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+std-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-rs-sys+std-devel.sha256sum] = "e508e62ef9596b41b217e41d6f3504d14328d72e7d878bfc5274b25e4799de3a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+testing-prefix-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+testing-prefix-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-rs-sys+testing-prefix-devel.sha256sum] = "65e4fc452fedd2cd23d807dfcf0a1a68255f28164b54e48a94997e75e048382b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libz-rs-sys-devel.sha256sum] = "508c792c707b9174fa68fc983e6d4022741c85076029edb40416cea1ecd74fea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+c-allocator-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+c-allocator-devel;unpack=0"
SRC_URI[aarch64_rust-libz-rs-sys+c-allocator-devel.sha256sum] = "bbe557f705e794657dc78cf169ce529028ba23bdcddc9df7045299b34d43b07d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+custom-prefix-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI[aarch64_rust-libz-rs-sys+custom-prefix-devel.sha256sum] = "fe9294f357fe02762c535538d089e95b2f8cc7582ca87bb94bc106db97a63e42"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+default-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-libz-rs-sys+default-devel.sha256sum] = "d982f01e3c6bac958f4253f9156e126dd48420b3b44e0b16cf0890a2b570a094"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+export-symbols-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+export-symbols-devel;unpack=0"
SRC_URI[aarch64_rust-libz-rs-sys+export-symbols-devel.sha256sum] = "f436c49f0f3385bc3ae50e8e85b2dc93c6562a640f5f1d946917e751e41bceb6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+gz-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+gz-devel;unpack=0"
SRC_URI[aarch64_rust-libz-rs-sys+gz-devel.sha256sum] = "b4bd6105a1d60ffdac717d33af6421094b1571f43bd4761e10b629336a0c651b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+rust-allocator-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI[aarch64_rust-libz-rs-sys+rust-allocator-devel.sha256sum] = "e605886736e109a0d8acd9bbdb31c384b8ad7f0b4324c6ece76e6633e0b69b9b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+semver-prefix-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI[aarch64_rust-libz-rs-sys+semver-prefix-devel.sha256sum] = "24998e9e8f5ca207fb309ebb3d0ffe593706315277d21cd97633e66e479d2dab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+std-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+std-devel;unpack=0"
SRC_URI[aarch64_rust-libz-rs-sys+std-devel.sha256sum] = "f5cc42f32ac77e14658e99e29242c62c1b8f2534761fa32a0ef5c429eba9157f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+testing-prefix-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys+testing-prefix-devel;unpack=0"
SRC_URI[aarch64_rust-libz-rs-sys+testing-prefix-devel.sha256sum] = "660cfea341a7137349f5b2398a5ca5d002dde29fcd162ef24ec219640ac949d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-libz-rs-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libz-rs-sys-devel.sha256sum] = "1d609398d8114b79a401c0f8e308e4fe81417827e4563dc88078ccb74006e630"

RDEPENDS:rust-libz-rs-sys+c-allocator-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+c-allocator-devel \
 "
RDEPENDS:rust-libz-rs-sys+custom-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+default-devel = " \
 cargo \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+export-symbols-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+gz-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+rust-allocator-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+rust-allocator-devel \
 "
RDEPENDS:rust-libz-rs-sys+semver-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+std-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+std-devel \
 "
RDEPENDS:rust-libz-rs-sys+testing-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys-devel = " \
 cargo \
 rust \
 rust-zlib-rs+__internal-api-devel \
 rust-zlib-rs-devel \
 "
