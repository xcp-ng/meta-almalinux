# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4-pecl-zip"
PV = "1.22.7"
PR = "2.el10"
PACKAGES = " \
 php8.4-pecl-zip \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php8.4-pecl-zip-1.22.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad889e6217b1e23071cafcb3d1a9ce868f24c5aa362b1120d24becd607f97c37"

URI_x86_64_v2_php8.4-pecl-zip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-pecl-zip-1.22.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-pecl-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pecl-zip}"
SRC_URI[x86_64_v2_php8.4-pecl-zip.sha256sum] = "528a07a3d1a07991e6f44d78dbb796a1c8d9d1107cd99bee39df9873d29e8d91"
RPROVIDES:php8.4-pecl-zip:x86_64_v2 = "virtual/php-zip"

URI_aarch64_php8.4-pecl-zip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-pecl-zip-1.22.7-2.el10.aarch64.rpm;name=aarch64_php8.4-pecl-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pecl-zip}"
SRC_URI[aarch64_php8.4-pecl-zip.sha256sum] = "970fd7ffb05367c328b7264a156c90238f2659725b44a19cec750857ead32a7f"
RPROVIDES:php8.4-pecl-zip:aarch64 = "virtual/php-zip"

RDEPENDS:php8.4-pecl-zip = " \
 glibc \
 libzip \
 php8.4-common \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/php-zip"

PROVIDES:append:aarch64 = " rpm/virtual/php-zip"
