# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libplasma"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 libplasma \
 libplasma-devel \
 libplasma-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libplasma-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a07d25a455d9e93cdc2e566932693e71c8f5dc28c2eb85d65a97c800c1a4431"

URI_x86_64_v2_libplasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma}"
SRC_URI[x86_64_v2_libplasma.sha256sum] = "6a42cd62d77ab54883d970c8af1fbb18d61af96091f017295aa7a872e57c0d55"

URI_x86_64_v2_libplasma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplasma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma-devel}"
SRC_URI[x86_64_v2_libplasma-devel.sha256sum] = "8c81bb345d174c4f5866e563954453a9c504ec13d2b25ae1e51421b072752b96"

URI_x86_64_v2_libplasma-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-doc-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libplasma-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma-doc}"
SRC_URI[x86_64_v2_libplasma-doc.sha256sum] = "62311c215f2396263a8697087899b94094eac3ce71c9db32a4d44a1ed7753f2a"

URI_aarch64_libplasma = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_libplasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma}"
SRC_URI[aarch64_libplasma.sha256sum] = "1fdd08f40030a3f5752188980a1a0c77cc30c8e886d8616d2f1fb631a185f201"

URI_aarch64_libplasma-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_libplasma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma-devel}"
SRC_URI[aarch64_libplasma-devel.sha256sum] = "50c1573019e6bc89ae4c6aa1d57e98cf81b1dcaf8ddd1c6feeb4f5f8c06392fc"

URI_aarch64_libplasma-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-doc-6.4.5-1.el10_1.noarch.rpm;name=aarch64_libplasma-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma-doc}"
SRC_URI[aarch64_libplasma-doc.sha256sum] = "8420d751c7637fc4c35202a97d60a4d30a07cb06b590a424870aacb6e74ab4bf"

RDEPENDS:libplasma = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpackage \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libX11 \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
RDEPENDS:libplasma-devel = " \
 cmake-filesystem \
 kf6-kpackage-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 libplasma \
 qt6-qtbase-devel \
 "
RDEPENDS:libplasma-doc = " \
 "
