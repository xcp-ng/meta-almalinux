# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libshout"
PV = "2.4.6"
PR = "9.el10"
PACKAGES = " \
 libshout \
 libshout-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libshout-2.4.6-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36e2a2bb7ae6205f66a2319dfaa130bbfcd4ed1d8a84146bf69891b778cbb8cd"

URI_x86_64_v2_libshout = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libshout-2.4.6-9.el10.x86_64_v2.rpm;name=x86_64_v2_libshout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libshout}"
SRC_URI[x86_64_v2_libshout.sha256sum] = "885074f6f5692434e4b7d94da8d7f88a9067358aa2bf197c1ad05c97455ee46e"

URI_x86_64_v2_libshout-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libshout-devel-2.4.6-9.el10.x86_64_v2.rpm;name=x86_64_v2_libshout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libshout-devel}"
SRC_URI[x86_64_v2_libshout-devel.sha256sum] = "4460a5174602986b55c62e5e88a55fe10cfc08c743ca51b04e1219b518098373"

URI_aarch64_libshout = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libshout-2.4.6-9.el10.aarch64.rpm;name=aarch64_libshout;unpack=0"
SRC_URI:append = " ${URI_aarch64_libshout}"
SRC_URI[aarch64_libshout.sha256sum] = "c93ae6b6e871805a9de89928a3f99b05cb1583c55294c2e718092360312f5a95"

URI_aarch64_libshout-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libshout-devel-2.4.6-9.el10.aarch64.rpm;name=aarch64_libshout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libshout-devel}"
SRC_URI[aarch64_libshout-devel.sha256sum] = "7fc14cbfa54dce0a1c87e1e566e636d7453dfa3c23ec1645cd35687df9bc33e8"

RDEPENDS:libshout = " \
 glibc \
 libogg \
 libtheora \
 libvorbis \
 openssl-libs \
 speex \
 "
RDEPENDS:libshout-devel = " \
 libogg-devel \
 libshout \
 libtheora-devel \
 libvorbis-devel \
 openssl-devel \
 pkgconf-pkg-config \
 speex-devel \
 "
