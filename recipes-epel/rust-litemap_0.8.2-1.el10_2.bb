# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-litemap"
PV = "0.8.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-litemap+alloc-devel \
 rust-litemap+databake-devel \
 rust-litemap+default-devel \
 rust-litemap+serde-devel \
 rust-litemap+testing-devel \
 rust-litemap+yoke-devel \
 rust-litemap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-litemap-0.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1f3e26bcd3c8c3a0894b5d5d86448c083d60efa63095872a32d599477e1a4c4"

URI_x86_64_v2_rust-litemap+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+alloc-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+alloc-devel}"
SRC_URI[x86_64_v2_rust-litemap+alloc-devel.sha256sum] = "830cab1602f9b1bcb13b319c1380272f89a78c6164b470e5f0c384e188b794c4"

URI_x86_64_v2_rust-litemap+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+databake-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+databake-devel}"
SRC_URI[x86_64_v2_rust-litemap+databake-devel.sha256sum] = "d6ff0102bf6da9cdc9f875f09fca66a731f76be66f2d80a81ddeccebe7da850f"

URI_x86_64_v2_rust-litemap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+default-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+default-devel}"
SRC_URI[x86_64_v2_rust-litemap+default-devel.sha256sum] = "60afd056ce9c97c3b888572f67f6620b1c0881f336f74d784487d233bbd80860"

URI_x86_64_v2_rust-litemap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+serde-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+serde-devel}"
SRC_URI[x86_64_v2_rust-litemap+serde-devel.sha256sum] = "9d2dc411dff5b3684ee3a93a1ebf8d9d37782cc8ab9c48fda8a28c0977853af2"

URI_x86_64_v2_rust-litemap+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+testing-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+testing-devel}"
SRC_URI[x86_64_v2_rust-litemap+testing-devel.sha256sum] = "9080963d98361fd82c98616b25ac740b73ab130b195dd67f91ffac2cafe3c360"

URI_x86_64_v2_rust-litemap+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+yoke-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+yoke-devel}"
SRC_URI[x86_64_v2_rust-litemap+yoke-devel.sha256sum] = "64835e76048b43b85ba775e2f558cd1e6a744717437db0be1e0ce84785ea0383"

URI_x86_64_v2_rust-litemap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap-devel}"
SRC_URI[x86_64_v2_rust-litemap-devel.sha256sum] = "fbcdfcafd7f49d1dd2a06d74d525abc18c2d08b32e14a1218b0143383153d07f"

URI_aarch64_rust-litemap+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+alloc-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-litemap+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+alloc-devel}"
SRC_URI[aarch64_rust-litemap+alloc-devel.sha256sum] = "78092b85bf592e8c95d997016135582aec779d24412dd0cfa1e8394818a5c992"

URI_aarch64_rust-litemap+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+databake-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-litemap+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+databake-devel}"
SRC_URI[aarch64_rust-litemap+databake-devel.sha256sum] = "c06581cfda708629193a055a90de79971e4fa4c7fc885e63611cca9a488d0e3f"

URI_aarch64_rust-litemap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+default-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-litemap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+default-devel}"
SRC_URI[aarch64_rust-litemap+default-devel.sha256sum] = "1ee4963bb79ab763acd491d85eafb3f136c68acf87170da09a2cd29fc0d7a25f"

URI_aarch64_rust-litemap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+serde-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-litemap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+serde-devel}"
SRC_URI[aarch64_rust-litemap+serde-devel.sha256sum] = "d175daf9a8c17bec76aef3e1833799ed62fd83be41b06fd61682ec210947f018"

URI_aarch64_rust-litemap+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+testing-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-litemap+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+testing-devel}"
SRC_URI[aarch64_rust-litemap+testing-devel.sha256sum] = "d93be18eb11a43abf7633045aabbeeed53721d4f00f9b1efb2cf4b4a20e458c6"

URI_aarch64_rust-litemap+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+yoke-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-litemap+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+yoke-devel}"
SRC_URI[aarch64_rust-litemap+yoke-devel.sha256sum] = "78f35d2efdf34023e71b87b52affe3d2f30b6e50c317e550da18c15e56118765"

URI_aarch64_rust-litemap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-litemap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap-devel}"
SRC_URI[aarch64_rust-litemap-devel.sha256sum] = "f488b5d945efb0d99b38ce06525d87bf5728c3ab00051108d0b477a095889be1"

RDEPENDS:rust-litemap+alloc-devel = " \
 cargo \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+default-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+serde-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-litemap+testing-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+yoke-devel = " \
 cargo \
 rust-litemap-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-litemap-devel = " \
 cargo \
 rust \
 "
