# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_timeout"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_timeout+default-devel \
 rust-uu_timeout-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_timeout-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59d674e816e1cead5daca27818c5301052eac6ee023c66909bc801169a30557d"

URI_x86_64_v2_rust-uu_timeout+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_timeout+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_timeout+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_timeout+default-devel}"
SRC_URI[x86_64_v2_rust-uu_timeout+default-devel.sha256sum] = "30f41844970303f275c36961ae1c59a74c53e4759e75336c773393b20c0db7f7"

URI_x86_64_v2_rust-uu_timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_timeout-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_timeout-devel}"
SRC_URI[x86_64_v2_rust-uu_timeout-devel.sha256sum] = "4cac33fc76c3e9b4c04b2ce7c98c2be750b5fd1e567fa3310fb2d2d1f9950d16"

URI_aarch64_rust-uu_timeout+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_timeout+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_timeout+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_timeout+default-devel}"
SRC_URI[aarch64_rust-uu_timeout+default-devel.sha256sum] = "107edce6d1c72f1975f1c0fe0b5f3a7ad9efbedd160bc5d041a6eaef7710ed95"

URI_aarch64_rust-uu_timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_timeout-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_timeout-devel}"
SRC_URI[aarch64_rust-uu_timeout-devel.sha256sum] = "4d317238e1f8d5eefc00fd67d33f8de40df53cd1124638920b9e59303dbcd4a4"

RDEPENDS:rust-uu_timeout+default-devel = " \
 cargo \
 rust-uu_timeout-devel \
 "
RDEPENDS:rust-uu_timeout-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-nix0.30+signal-devel \
 rust-nix0.30-devel \
 rust-uucore+default-devel \
 rust-uucore+parser-devel \
 rust-uucore+process-devel \
 rust-uucore+signals-devel \
 "
