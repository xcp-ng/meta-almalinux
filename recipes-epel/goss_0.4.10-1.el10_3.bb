# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goss"
PV = "0.4.10"
PR = "1.el10_3"
PACKAGES = " \
 goss \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/goss-0.4.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08a46879b4b7b01700feb70fdd378dffaf79c8b2bf4be690c595a3f5c4ece7c8"

URI_x86_64_v2_goss = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goss-0.4.10-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_goss}"
SRC_URI[x86_64_v2_goss.sha256sum] = "30d1ad319abf95395b4f6ed1faf1ea1590be2fc460c40dedb4562e52013c7dbb"

URI_aarch64_goss = "${EPEL_MIRROR}/aarch64/Packages/g/goss-0.4.10-1.el10_3.aarch64.rpm;name=aarch64_goss;unpack=0"
SRC_URI:append = " ${URI_aarch64_goss}"
SRC_URI[aarch64_goss.sha256sum] = "b27d94838567855f23706cf8fb611d720aa7f7df4297473b1962ad23f40f34f6"

RDEPENDS:goss = " \
 glibc \
 "
