# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha2-asm"
PV = "0.6.4"
PR = "2.el10_0"
PACKAGES = " \
 rust-sha2-asm+default-devel \
 rust-sha2-asm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha2-asm-0.6.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a57b998a757430982e83fa0024ad6db1f344cffdee3b0c0a412e14b8ae00be5b"

URI_x86_64_v2_rust-sha2-asm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2-asm+default-devel-0.6.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2-asm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2-asm+default-devel}"
SRC_URI[x86_64_v2_rust-sha2-asm+default-devel.sha256sum] = "e7b4fe05a94d41587f340821ef453a988571dda00ac2ceb27c0599db3bbbce99"

URI_x86_64_v2_rust-sha2-asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2-asm-devel-0.6.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2-asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2-asm-devel}"
SRC_URI[x86_64_v2_rust-sha2-asm-devel.sha256sum] = "302152f237db11f8722a2a543ba63f0d2f13158954e13c58ea1fc21ff8897ec1"

URI_aarch64_rust-sha2-asm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2-asm+default-devel-0.6.4-2.el10_0.noarch.rpm;name=aarch64_rust-sha2-asm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2-asm+default-devel}"
SRC_URI[aarch64_rust-sha2-asm+default-devel.sha256sum] = "8e25e37000f277ae1e7f1e8945049c7efdfb9e1a9288ce28d56bfa895257e95d"

URI_aarch64_rust-sha2-asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2-asm-devel-0.6.4-2.el10_0.noarch.rpm;name=aarch64_rust-sha2-asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2-asm-devel}"
SRC_URI[aarch64_rust-sha2-asm-devel.sha256sum] = "a731998c5e83db4c6de9251a2b3a669faf5f81d36ba92d1e0e01a6aeea2bc144"

RDEPENDS:rust-sha2-asm+default-devel = " \
 cargo \
 rust-sha2-asm-devel \
 "
RDEPENDS:rust-sha2-asm-devel = " \
 cargo \
 rust-cc+default-devel \
 "
