# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-treq"
PV = "25.5.0"
PR = "1.el10_1"
PACKAGES = " \
 python-treq-doc \
 python3-treq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-treq-25.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac79f2991c931d3298447b70cea8682154230cb3fbd318fe93ea72fe54a4d656"

URI_x86_64_v2_python-treq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-treq-doc-25.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-treq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-treq-doc}"
SRC_URI[x86_64_v2_python-treq-doc.sha256sum] = "206e1c37f7cf0d597cce38d4fd21fe95661b8b93cb1c48ef07c640a863e6aeb8"

URI_x86_64_v2_python3-treq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-treq-25.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-treq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-treq}"
SRC_URI[x86_64_v2_python3-treq.sha256sum] = "decc2738dfcbbcdffa490d6af0216e19ef76f08091ab87658428dfdc52a3b268"

URI_aarch64_python-treq-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-treq-doc-25.5.0-1.el10_1.noarch.rpm;name=aarch64_python-treq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-treq-doc}"
SRC_URI[aarch64_python-treq-doc.sha256sum] = "41b6ab811379e708b018db4c08e01fcdaa157f89d3e307c4cadac95537423b52"

URI_aarch64_python3-treq = "${EPEL_MIRROR}/aarch64/Packages/p/python3-treq-25.5.0-1.el10_1.noarch.rpm;name=aarch64_python3-treq;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-treq}"
SRC_URI[aarch64_python3-treq.sha256sum] = "e273ab9a1fd176adbf88088c8374e63ab3d3de40ee7f1f3691d25e2f54e25bb7"

RDEPENDS:python-treq-doc = " \
 "
RDEPENDS:python3-treq = " \
 python3 \
 python3-attrs \
 python3-hyperlink \
 python3-incremental \
 python3-multipart \
 python3-requests \
 python3-twisted \
 python3-twisted+tls \
 python3-typing-extensions \
 "
