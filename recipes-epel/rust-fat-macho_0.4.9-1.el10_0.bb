# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fat-macho"
PV = "0.4.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-fat-macho+bitcode-devel \
 rust-fat-macho+default-devel \
 rust-fat-macho+llvm-bitcode-devel \
 rust-fat-macho-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fat-macho-0.4.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d26b4acd398700274affbd3de053f111b4db2f624eb9166a29ef57ba1cb327a"

URI_x86_64_v2_rust-fat-macho+bitcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+bitcode-devel-0.4.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+bitcode-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+bitcode-devel.sha256sum] = "1df0fb1dca923798f5575fe920c4498ac607dc0df7a9e5529954f74846ee67f5"

URI_x86_64_v2_rust-fat-macho+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+default-devel-0.4.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+default-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+default-devel.sha256sum] = "40d5f13aab6045e59d0bfdd457a030e81623bc828168ffbe68630ecf42870524"

URI_x86_64_v2_rust-fat-macho+llvm-bitcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+llvm-bitcode-devel-0.4.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+llvm-bitcode-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+llvm-bitcode-devel.sha256sum] = "a09271cdc8de0034dbb695be90275eab022642da02415d34cf04bffe3b58ef15"

URI_x86_64_v2_rust-fat-macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho-devel-0.4.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho-devel}"
SRC_URI[x86_64_v2_rust-fat-macho-devel.sha256sum] = "593f84fbf42c2064d6d94b3a5c7438a94aab04709f6b2e866208a0cdcab769f2"

URI_aarch64_rust-fat-macho+bitcode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+bitcode-devel-0.4.9-1.el10_0.noarch.rpm;name=aarch64_rust-fat-macho+bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+bitcode-devel}"
SRC_URI[aarch64_rust-fat-macho+bitcode-devel.sha256sum] = "519e2902fe84fb65c1b54eb7565872f652fbfbc36acb9024d5730c97570ad2d3"

URI_aarch64_rust-fat-macho+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+default-devel-0.4.9-1.el10_0.noarch.rpm;name=aarch64_rust-fat-macho+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+default-devel}"
SRC_URI[aarch64_rust-fat-macho+default-devel.sha256sum] = "e76181c2f3f03fda5f0cc773b6b7e46926befe2aca806c25f482d0878c0d3106"

URI_aarch64_rust-fat-macho+llvm-bitcode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+llvm-bitcode-devel-0.4.9-1.el10_0.noarch.rpm;name=aarch64_rust-fat-macho+llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+llvm-bitcode-devel}"
SRC_URI[aarch64_rust-fat-macho+llvm-bitcode-devel.sha256sum] = "d3258b20dffc4cb0dc106d65a877acb45b64fc8003b34927a9900c100c0b6068"

URI_aarch64_rust-fat-macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho-devel-0.4.9-1.el10_0.noarch.rpm;name=aarch64_rust-fat-macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho-devel}"
SRC_URI[aarch64_rust-fat-macho-devel.sha256sum] = "b60b6b6a99c554dde4cff2599e875c182784a1f0c4ed2fc1969fd53bbbc2fa7c"

RDEPENDS:rust-fat-macho+bitcode-devel = " \
 cargo \
 rust-fat-macho+llvm-bitcode-devel \
 rust-fat-macho-devel \
 "
RDEPENDS:rust-fat-macho+default-devel = " \
 cargo \
 rust-fat-macho+bitcode-devel \
 rust-fat-macho-devel \
 "
RDEPENDS:rust-fat-macho+llvm-bitcode-devel = " \
 cargo \
 rust-fat-macho-devel \
 rust-llvm-bitcode+default-devel \
 "
RDEPENDS:rust-fat-macho-devel = " \
 cargo \
 rust-goblin+default-devel \
 "
