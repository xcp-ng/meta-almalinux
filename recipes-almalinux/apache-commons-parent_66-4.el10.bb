# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-parent"
PV = "66"
PR = "4.el10"
PACKAGES = " \
 apache-commons-parent \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/apache-commons-parent-66-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1db344a8e402db492334e3adab17dee924b1e2fb729006cfc3d4b7da864d5a56"

URI_x86_64_v2_apache-commons-parent = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-parent-66-4.el10.noarch.rpm;name=x86_64_v2_apache-commons-parent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-parent}"
SRC_URI[x86_64_v2_apache-commons-parent.sha256sum] = "e8baa942cf95ba023eedf587d138c29239065120c5d796f318f895daef2c4844"

URI_aarch64_apache-commons-parent = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-parent-66-4.el10.noarch.rpm;name=aarch64_apache-commons-parent;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-parent}"
SRC_URI[aarch64_apache-commons-parent.sha256sum] = "e8baa942cf95ba023eedf587d138c29239065120c5d796f318f895daef2c4844"

RDEPENDS:apache-commons-parent = " \
 apache-parent \
 build-helper-maven-plugin \
 javapackages-filesystem \
 maven-antrun-plugin \
 maven-assembly-plugin \
 maven-bundle-plugin \
 maven-compiler-plugin \
 maven-jar-plugin \
 maven-surefire-plugin \
 moditect \
 "
