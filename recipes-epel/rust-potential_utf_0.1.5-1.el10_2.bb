# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-potential_utf"
PV = "0.1.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-potential_utf+alloc-devel \
 rust-potential_utf+databake-devel \
 rust-potential_utf+default-devel \
 rust-potential_utf+serde-devel \
 rust-potential_utf+writeable-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-potential_utf-0.1.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48934086525af660d7ceb93938aebd31e2cbaf2eb7e5eb0a3cc958308f615853"

URI_x86_64_v2_rust-potential_utf+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+alloc-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+alloc-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+alloc-devel.sha256sum] = "e773a8866bb53d7985aa0614d435682110fb1b7a6c391c9826b3d57ab19bbb1d"

URI_x86_64_v2_rust-potential_utf+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+databake-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+databake-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+databake-devel.sha256sum] = "618d0a4f27efb5c02d7db47b4f1d6bd4179cf1d35f956a08bb9c27d3d23037d9"

URI_x86_64_v2_rust-potential_utf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+default-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+default-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+default-devel.sha256sum] = "b8b799662dab441b7a807575782af99b771da8f48d9b88e5dcd568476b7cb7a9"

URI_x86_64_v2_rust-potential_utf+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+serde-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+serde-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+serde-devel.sha256sum] = "68380d1689d36651a1a1daac4acc223eaa290b8126a6289de3dfab8bf70cc823"

URI_x86_64_v2_rust-potential_utf+writeable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+writeable-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+writeable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+writeable-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+writeable-devel.sha256sum] = "8e2420542f1c8fd67a7d4b44e2be12579245550488319159009e6d09e90083d9"

URI_x86_64_v2_rust-potential_utf+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+zerovec-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf+zerovec-devel}"
SRC_URI[x86_64_v2_rust-potential_utf+zerovec-devel.sha256sum] = "27373b911e156228e4821457f33b08d2325518e57b4f3525b6176240ee1716bb"

URI_x86_64_v2_rust-potential_utf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf-devel-0.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-potential_utf-devel}"
SRC_URI[x86_64_v2_rust-potential_utf-devel.sha256sum] = "650fd74752969da1102aeb9f2a196baf3590f6b1d0ad84948ac40fb88b919a9d"

URI_aarch64_rust-potential_utf+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+alloc-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-potential_utf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+alloc-devel}"
SRC_URI[aarch64_rust-potential_utf+alloc-devel.sha256sum] = "5a79e42bd241d3b1a77374db17388833351badcdcc3589c50686f89ac96a224d"

URI_aarch64_rust-potential_utf+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+databake-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-potential_utf+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+databake-devel}"
SRC_URI[aarch64_rust-potential_utf+databake-devel.sha256sum] = "44bcb5387aac90a9f8ec240feeb768ae92372c454646eb0a213b8797b2c2d7f8"

URI_aarch64_rust-potential_utf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+default-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-potential_utf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+default-devel}"
SRC_URI[aarch64_rust-potential_utf+default-devel.sha256sum] = "df05bc3b02e15dc9c3cbc0e17904d87f0777e573d4155c4b10f8727106e9e138"

URI_aarch64_rust-potential_utf+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+serde-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-potential_utf+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+serde-devel}"
SRC_URI[aarch64_rust-potential_utf+serde-devel.sha256sum] = "f393d54b4511641b4b3bf835f74d1b5b306ab04dd318dfe30b0d75960f4da26a"

URI_aarch64_rust-potential_utf+writeable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+writeable-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-potential_utf+writeable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+writeable-devel}"
SRC_URI[aarch64_rust-potential_utf+writeable-devel.sha256sum] = "da928f5818da9405ebeb54d5db43cbf28d0acfe34599709265346d6e9c0cbc13"

URI_aarch64_rust-potential_utf+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+zerovec-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-potential_utf+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf+zerovec-devel}"
SRC_URI[aarch64_rust-potential_utf+zerovec-devel.sha256sum] = "97f72ccfe2922efd66531f7f476cd5c16faa72824ff1c4334d0f035d5184638c"

URI_aarch64_rust-potential_utf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf-devel-0.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-potential_utf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-potential_utf-devel}"
SRC_URI[aarch64_rust-potential_utf-devel.sha256sum] = "a5f8efe77618eedf208d3072f8bb25b8bfa984f13dff2d3735aaf7a2424b7d62"

RDEPENDS:rust-potential_utf+alloc-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-writeable+alloc-devel \
 rust-writeable-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-potential_utf+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-potential_utf-devel \
 "
RDEPENDS:rust-potential_utf+default-devel = " \
 cargo \
 rust-potential_utf+alloc-devel \
 rust-potential_utf-devel \
 "
RDEPENDS:rust-potential_utf+serde-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-potential_utf+writeable-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-potential_utf+zerovec-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-potential_utf-devel = " \
 cargo \
 rust \
 "
