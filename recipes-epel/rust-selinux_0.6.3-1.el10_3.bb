# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-selinux"
PV = "0.6.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-selinux+default-devel \
 rust-selinux-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-selinux-0.6.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0d1d7d5b8a78fe602e99874cd3fd347abd3e230d0d8a82e8b4360e0ca959b56"

URI_x86_64_v2_rust-selinux+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selinux+default-devel-0.6.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selinux+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selinux+default-devel}"
SRC_URI[x86_64_v2_rust-selinux+default-devel.sha256sum] = "5f648cf5262b4991453d644210a7048cac45aa7894939d7890862083c8f46a4e"

URI_x86_64_v2_rust-selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selinux-devel-0.6.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selinux-devel}"
SRC_URI[x86_64_v2_rust-selinux-devel.sha256sum] = "b363c0089284ceed302ed01243c2e57e7161a3f2e49f3ef565a6ae417658d2d3"

URI_aarch64_rust-selinux+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selinux+default-devel-0.6.3-1.el10_3.noarch.rpm;name=aarch64_rust-selinux+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selinux+default-devel}"
SRC_URI[aarch64_rust-selinux+default-devel.sha256sum] = "260fc71fe15f827019c4b49bb87f1483e22f51187d8fa9fbbfce01665f0ce3dc"

URI_aarch64_rust-selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selinux-devel-0.6.3-1.el10_3.noarch.rpm;name=aarch64_rust-selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selinux-devel}"
SRC_URI[aarch64_rust-selinux-devel.sha256sum] = "f0e692e43f5886692543f9666031c515c694d6f1377a3dd3d0b5a52c9063363b"

RDEPENDS:rust-selinux+default-devel = " \
 cargo \
 rust-selinux-devel \
 "
RDEPENDS:rust-selinux-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-errno+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot+default-devel \
 rust-selinux-sys+default-devel \
 rust-thiserror+default-devel \
 "
