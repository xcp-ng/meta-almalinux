# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum-macros"
PV = "0.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-axum-macros+__private-devel \
 rust-axum-macros+default-devel \
 rust-axum-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-macros-0.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f74635da39d13d976e937ed6737b9aefe5ab3b92a92cf1fc94f657364190a5e"

URI_x86_64_v2_rust-axum-macros+__private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros+__private-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros+__private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros+__private-devel}"
SRC_URI[x86_64_v2_rust-axum-macros+__private-devel.sha256sum] = "1a4250d9ad816df869edf5c01146b66f6fcb6ff74ad646da5d1a327a62e8ee3c"

URI_x86_64_v2_rust-axum-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros+default-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros+default-devel}"
SRC_URI[x86_64_v2_rust-axum-macros+default-devel.sha256sum] = "6c56ccf5474d27ef674ae5c729966ab20ee15d9c89da40ae52ef5e8b48107960"

URI_x86_64_v2_rust-axum-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros-devel}"
SRC_URI[x86_64_v2_rust-axum-macros-devel.sha256sum] = "44593c6e7997a567f35d814693bf312d642a5e66ca25718bed6d3bb6879b9e88"

URI_aarch64_rust-axum-macros+__private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros+__private-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-axum-macros+__private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros+__private-devel}"
SRC_URI[aarch64_rust-axum-macros+__private-devel.sha256sum] = "f4b79764d7791472514bb43c1d8226c7a522fe6d42612fed6d4fed9123f539b8"

URI_aarch64_rust-axum-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros+default-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-axum-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros+default-devel}"
SRC_URI[aarch64_rust-axum-macros+default-devel.sha256sum] = "a0d4b44894256ade8f9ca1659683c70051d8b8d3a15cec8ab1fdea9f43dcb196"

URI_aarch64_rust-axum-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-axum-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros-devel}"
SRC_URI[aarch64_rust-axum-macros-devel.sha256sum] = "3b695a3212feb0528b280c9d81713e57524a1186a9afcceae15260f9afe426f9"

RDEPENDS:rust-axum-macros+__private-devel = " \
 cargo \
 rust-axum-macros-devel \
 rust-syn+visit-mut-devel \
 "
RDEPENDS:rust-axum-macros+default-devel = " \
 cargo \
 rust-axum-macros-devel \
 "
RDEPENDS:rust-axum-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 "
