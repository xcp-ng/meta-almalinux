# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluefish"
PV = "2.2.16"
PR = "1.el10_0"
PACKAGES = " \
 bluefish \
 bluefish-shared-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bluefish-2.2.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ffa300e4c981e1c174f18693279c74b8a76e2508d6830b88c6775671fdb80fc"

URI_x86_64_v2_bluefish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluefish-2.2.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluefish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluefish}"
SRC_URI[x86_64_v2_bluefish.sha256sum] = "4613f941cc78c36e20edf3e300a5ac22fa331fd00781bfa31e2135f5f0ec50df"

URI_x86_64_v2_bluefish-shared-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluefish-shared-data-2.2.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bluefish-shared-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluefish-shared-data}"
SRC_URI[x86_64_v2_bluefish-shared-data.sha256sum] = "a2b7b0e217e0166325639a8ad26217e4c8ccb000f0dbfb2d8a0526e50e5d70f3"

URI_aarch64_bluefish = "${EPEL_MIRROR}/aarch64/Packages/b/bluefish-2.2.16-1.el10_0.aarch64.rpm;name=aarch64_bluefish;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluefish}"
SRC_URI[aarch64_bluefish.sha256sum] = "fe874a6e1243d34336874782ffcfdd7810565626ee35a184d6bbe5e6943bb402"

URI_aarch64_bluefish-shared-data = "${EPEL_MIRROR}/aarch64/Packages/b/bluefish-shared-data-2.2.16-1.el10_0.noarch.rpm;name=aarch64_bluefish-shared-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluefish-shared-data}"
SRC_URI[aarch64_bluefish-shared-data.sha256sum] = "b4731a856872cbc4be0fe625d505ca23e44c0221f5ad58a3a38b59d374ec2e95"

RDEPENDS:bluefish = " \
 atk \
 bluefish-shared-data \
 cairo \
 cairo-gobject \
 enchant2 \
 findutils \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 grep \
 gtk3 \
 gucharmap-libs \
 harfbuzz \
 libxml2 \
 pango \
 pcre2 \
 python3-libs \
 xml-common \
 "
RDEPENDS:bluefish-shared-data = " \
 bash \
 bluefish \
 python3 \
 "
