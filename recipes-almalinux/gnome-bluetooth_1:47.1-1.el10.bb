# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-bluetooth"
PE = "1"
PV = "47.1"
PR = "1.el10"
PACKAGES = " \
 gnome-bluetooth \
 gnome-bluetooth-libs \
 gnome-bluetooth-libs-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-bluetooth-47.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "975dd5aee7b33ca13f1b129f2c75aa986684de18e04c90320211762ff291cc9e"

URI_x86_64_v2_gnome-bluetooth = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-bluetooth-47.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-bluetooth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-bluetooth}"
SRC_URI[x86_64_v2_gnome-bluetooth.sha256sum] = "bdf80325cf01c79b8fa410d1956c01e39046b53edc2cae7f5e7d629ee22d673a"

URI_x86_64_v2_gnome-bluetooth-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-bluetooth-libs-47.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-bluetooth-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-bluetooth-libs}"
SRC_URI[x86_64_v2_gnome-bluetooth-libs.sha256sum] = "309e172d91f17bf9555ae5a6a9b91f9a1664d986a775570621a9eb62412b0801"

URI_x86_64_v2_gnome-bluetooth-libs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-bluetooth-libs-devel-47.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-bluetooth-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-bluetooth-libs-devel}"
SRC_URI[x86_64_v2_gnome-bluetooth-libs-devel.sha256sum] = "3df7934228d0b7b4f95b754b66083de2360e4482fe4cbea644332eea4fa092f2"

URI_aarch64_gnome-bluetooth = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-bluetooth-47.1-1.el10.aarch64.rpm;name=aarch64_gnome-bluetooth;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-bluetooth}"
SRC_URI[aarch64_gnome-bluetooth.sha256sum] = "baae9992346a7130b28c482b476ec0fe50c52e9692706d61d07eb97e316af690"

URI_aarch64_gnome-bluetooth-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-bluetooth-libs-47.1-1.el10.aarch64.rpm;name=aarch64_gnome-bluetooth-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-bluetooth-libs}"
SRC_URI[aarch64_gnome-bluetooth-libs.sha256sum] = "ba015851c492626760e47e4befb6a4e9b9402c0c4d764634061ea0740cf5a92f"

URI_aarch64_gnome-bluetooth-libs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-bluetooth-libs-devel-47.1-1.el10.aarch64.rpm;name=aarch64_gnome-bluetooth-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-bluetooth-libs-devel}"
SRC_URI[aarch64_gnome-bluetooth-libs-devel.sha256sum] = "9e6674c2e2f0a8f91ef13b3419e148ebdda32ca42e64dfa97507b1aeff9105e6"

RDEPENDS:gnome-bluetooth = " \
 bluez \
 bluez-obexd \
 glib2 \
 glibc \
 gnome-bluetooth-libs \
 gtk4 \
 libadwaita \
 libgcc \
 pipewire-pulseaudio \
 "
RDEPENDS:gnome-bluetooth-libs = " \
 glib2 \
 glibc \
 gsound \
 gtk4 \
 libadwaita \
 libgcc \
 libnotify \
 systemd-libs \
 upower-libs \
 "
RDEPENDS:gnome-bluetooth-libs-devel = " \
 glib2-devel \
 gnome-bluetooth \
 gnome-bluetooth-libs \
 gtk4-devel \
 libadwaita-devel \
 pkgconf-pkg-config \
 "
