# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-LWP-Protocol-http10"
PV = "6.03"
PR = "38.el10_0"
PACKAGES = " \
 perl-LWP-Protocol-http10 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-LWP-Protocol-http10-6.03-38.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "866c33aade2980a484e84ff439088c75073014c8f6c5dbd28d4cfbe9630925df"

URI_x86_64_v2_perl-LWP-Protocol-http10 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-LWP-Protocol-http10-6.03-38.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-LWP-Protocol-http10;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-LWP-Protocol-http10}"
SRC_URI[x86_64_v2_perl-LWP-Protocol-http10.sha256sum] = "90628f51c48e48ca71e5de68c13017db9cb94467553062171343e1a8d8420ea5"

URI_aarch64_perl-LWP-Protocol-http10 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-LWP-Protocol-http10-6.03-38.el10_0.noarch.rpm;name=aarch64_perl-LWP-Protocol-http10;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-LWP-Protocol-http10}"
SRC_URI[aarch64_perl-LWP-Protocol-http10.sha256sum] = "64a7e54e7fce14418d0025d900153b06cf55446e0c1ad31b731af9619fb51544"

RDEPENDS:perl-LWP-Protocol-http10 = " \
 perl-HTTP-Message \
 perl-IO \
 perl-URI \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 "
