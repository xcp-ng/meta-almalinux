# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_properties_data"
PV = "1.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-icu_properties_data+default-devel \
 rust-icu_properties_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_properties_data-1.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc00e4f94699397c74f97b7931ac81e349c1ba1d3b9773ec31cc294de2498daa"

URI_x86_64_v2_rust-icu_properties_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties_data+default-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_properties_data+default-devel.sha256sum] = "acedfa810b437071ed2a24b12d4e024057775490f96ff5518b470ceccca758c7"

URI_x86_64_v2_rust-icu_properties_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties_data-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties_data-devel}"
SRC_URI[x86_64_v2_rust-icu_properties_data-devel.sha256sum] = "bbe0c5e0241b7afb49752519f955d081e6521e05df0ad456961e16c941406094"

URI_aarch64_rust-icu_properties_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties_data+default-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_properties_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties_data+default-devel}"
SRC_URI[aarch64_rust-icu_properties_data+default-devel.sha256sum] = "50bc2e561af3480d38077011a3471267a5a74835cf2f4df33a9bcf73e40b5f1a"

URI_aarch64_rust-icu_properties_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties_data-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_properties_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties_data-devel}"
SRC_URI[aarch64_rust-icu_properties_data-devel.sha256sum] = "de9c4e09df7f797e25de5465c481b3ad0cebf69d868bb885da8cd9921e787acc"

RDEPENDS:rust-icu_properties_data+default-devel = " \
 cargo \
 rust-icu_properties_data-devel \
 "
RDEPENDS:rust-icu_properties_data-devel = " \
 cargo \
 rust \
 "
