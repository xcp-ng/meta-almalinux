# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-XML"
PV = "0.08"
PR = "26.el10_0"
PACKAGES = " \
 perl-Test-XML \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-XML-0.08-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f27b63764f5cff5785771cb49fe1ba7c209aa462140537ee670606bbc4c6af71"

URI_x86_64_v2_perl-Test-XML = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-XML-0.08-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-XML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-XML}"
SRC_URI[x86_64_v2_perl-Test-XML.sha256sum] = "b8385721dc4892e4c902a4c081cd4ef4d64f06e60f63f95d1f4fb016bfd0bcc0"

URI_aarch64_perl-Test-XML = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-XML-0.08-26.el10_0.noarch.rpm;name=aarch64_perl-Test-XML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-XML}"
SRC_URI[aarch64_perl-Test-XML.sha256sum] = "805ee4d300d77c81b0b5099514bb3deb1a2e9486033a323d9441e1381cb7a633"

RDEPENDS:perl-Test-XML = " \
 perl-Carp \
 perl-Test-Simple \
 perl-Test-XML \
 perl-XML-LibXML \
 perl-XML-Parser \
 perl-XML-SAX \
 perl-XML-SAX-Writer \
 perl-XML-SemanticDiff \
 perl-XML-Twig \
 perl-XML-XPath \
 perl-libs \
 "
