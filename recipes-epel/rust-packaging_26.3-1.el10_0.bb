# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-packaging"
PV = "26.3"
PR = "1.el10_0"
PACKAGES = " \
 cargo-rpm-macros \
 rust-srpm-macros-epel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-packaging-26.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47ea2c017dbf66620f39ebecafc4c40af88466b3c90c9aa2f1abe633f412de64"

URI_x86_64_v2_cargo-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-rpm-macros-26.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cargo-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo-rpm-macros}"
SRC_URI[x86_64_v2_cargo-rpm-macros.sha256sum] = "a87b41967795822d9d35ffc2fc1130b3cd7885fdcd3118aade42175f4fefc466"

URI_x86_64_v2_rust-srpm-macros-epel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-srpm-macros-epel-26.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-srpm-macros-epel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-srpm-macros-epel}"
SRC_URI[x86_64_v2_rust-srpm-macros-epel.sha256sum] = "71cc9ea96e1c01f6b5affe51abd9a71d34d4a891f22b21f8cc5e3bad88a0f8d6"

URI_aarch64_cargo-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/c/cargo-rpm-macros-26.3-1.el10_0.noarch.rpm;name=aarch64_cargo-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo-rpm-macros}"
SRC_URI[aarch64_cargo-rpm-macros.sha256sum] = "7ea0849f04c5b5611d87b66f60d8fe7fcb78debbf145aa7043ab8b3b118b9a4d"

URI_aarch64_rust-srpm-macros-epel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-srpm-macros-epel-26.3-1.el10_0.noarch.rpm;name=aarch64_rust-srpm-macros-epel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-srpm-macros-epel}"
SRC_URI[aarch64_rust-srpm-macros-epel.sha256sum] = "4ab0e15b974c9260d2e9cd2d20feff4bc64fb5d322ea0428b88dc4ebbf1ea75b"

RDEPENDS:cargo-rpm-macros = " \
 cargo \
 cargo2rpm \
 gawk \
 grep \
 rust-srpm-macros-epel \
 "
RDEPENDS:rust-srpm-macros-epel = " \
 rust-toolset-srpm-macros \
 "
