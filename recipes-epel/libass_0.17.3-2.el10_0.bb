# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libass"
PV = "0.17.3"
PR = "2.el10_0"
PACKAGES = " \
 libass \
 libass-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libass-0.17.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b0756222231f5505b9d71c235f68b3158c5faa02472fb077e9deeef45c0d312"

URI_x86_64_v2_libass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libass-0.17.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libass}"
SRC_URI[x86_64_v2_libass.sha256sum] = "fb96a6082da2352c3686319f254144c7ed33db7a70521bdddd958fb31727882c"

URI_x86_64_v2_libass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libass-devel-0.17.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libass-devel}"
SRC_URI[x86_64_v2_libass-devel.sha256sum] = "aa7f8550c76fe53c55f5cdc5524adff6ea44d1f5dd35d9f04c14e2943ed70522"

URI_aarch64_libass = "${EPEL_MIRROR}/aarch64/Packages/l/libass-0.17.3-2.el10_0.aarch64.rpm;name=aarch64_libass;unpack=0"
SRC_URI:append = " ${URI_aarch64_libass}"
SRC_URI[aarch64_libass.sha256sum] = "236dc30fc165828f76d3762314ed0a8bbd63267f4fc57f71031f92c14bc51a7a"

URI_aarch64_libass-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libass-devel-0.17.3-2.el10_0.aarch64.rpm;name=aarch64_libass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libass-devel}"
SRC_URI[aarch64_libass-devel.sha256sum] = "c10f7eab3a6e7e18805123279800b277d1634ef7b8c4fd2f2ab73e6dbbfd1855"

RDEPENDS:libass = " \
 fontconfig \
 freetype \
 fribidi \
 glibc \
 harfbuzz \
 libunibreak \
 "
RDEPENDS:libass-devel = " \
 fontconfig-devel \
 freetype-devel \
 fribidi-devel \
 harfbuzz-devel \
 libass \
 libunibreak-devel \
 pkgconf-pkg-config \
 "
