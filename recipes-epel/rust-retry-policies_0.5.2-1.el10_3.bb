# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-retry-policies"
PV = "0.5.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-retry-policies+default-devel \
 rust-retry-policies-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-retry-policies-0.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99eaeccaa58dd748b6062c17cf45d7fcf283509b3af54537cb4671d4d22cf4b9"

URI_x86_64_v2_rust-retry-policies+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-retry-policies+default-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-retry-policies+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-retry-policies+default-devel}"
SRC_URI[x86_64_v2_rust-retry-policies+default-devel.sha256sum] = "903aff359236894b0389b905cc30a02bbf65668276f69c372c47444fb2e4c67e"

URI_x86_64_v2_rust-retry-policies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-retry-policies-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-retry-policies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-retry-policies-devel}"
SRC_URI[x86_64_v2_rust-retry-policies-devel.sha256sum] = "99fdd99d0323b461b3b50dbe0a044976482accd0998510f62f5f710f96d59e0f"

URI_aarch64_rust-retry-policies+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-retry-policies+default-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-retry-policies+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-retry-policies+default-devel}"
SRC_URI[aarch64_rust-retry-policies+default-devel.sha256sum] = "d65d5f710a6ac6074d838110da6640658ae296449afb7d9d4da8336ef33875a4"

URI_aarch64_rust-retry-policies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-retry-policies-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-retry-policies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-retry-policies-devel}"
SRC_URI[aarch64_rust-retry-policies-devel.sha256sum] = "fda7b19ba5a022cb49be53a130f36321fb71fea27adb6dbb0b68111450f4f023"

RDEPENDS:rust-retry-policies+default-devel = " \
 cargo \
 rust-retry-policies-devel \
 "
RDEPENDS:rust-retry-policies-devel = " \
 cargo \
 rust-rand+default-devel \
 "
