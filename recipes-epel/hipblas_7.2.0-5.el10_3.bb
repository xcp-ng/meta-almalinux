# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipblas"
PV = "7.2.0"
PR = "5.el10_3"
PACKAGES:x86_64_v2 = " \
 hipblas \
 hipblas-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipblas-7.2.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28a0e69ead6f7b0415125924315948e9c1ec6987cf717949ec90fe4ca78e3662"

URI_x86_64_v2_hipblas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblas-7.2.0-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblas}"
SRC_URI[x86_64_v2_hipblas.sha256sum] = "5fff85395077067cf3d34204b0964df8c7365e8c098587708c8128926cf60166"

URI_x86_64_v2_hipblas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblas-devel-7.2.0-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblas-devel}"
SRC_URI[x86_64_v2_hipblas-devel.sha256sum] = "d889d29852578000654248c4b95ee5fdf3629ddb788a7166247fbd51afeabfa5"

RDEPENDS:hipblas = " \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocsolver \
 "
RDEPENDS:hipblas-devel = " \
 cmake-filesystem \
 hipblas \
 hipblas-common-devel \
 "
