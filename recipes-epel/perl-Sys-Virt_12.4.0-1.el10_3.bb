# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-Virt"
PV = "12.4.0"
PR = "1.el10_3"
PACKAGES = " \
 perl-Sys-Virt \
 perl-Sys-Virt-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-Virt-12.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "284c0dfd6d261c427e7ebce23ead68ba73deeb16fe60de5adc20706a52dcaf83"

URI_x86_64_v2_perl-Sys-Virt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-Virt-12.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Virt}"
SRC_URI[x86_64_v2_perl-Sys-Virt.sha256sum] = "dbc3c9a1ee454b53b412b23d3daadb2acc2c3221e3a3ad6ee18b245202eb0129"

URI_x86_64_v2_perl-Sys-Virt-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-Virt-tests-12.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Virt-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Virt-tests}"
SRC_URI[x86_64_v2_perl-Sys-Virt-tests.sha256sum] = "73a1817545dab496dda4e77850763c1726ae7080381db26a846129b95021dfc6"

URI_aarch64_perl-Sys-Virt = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-Virt-12.4.0-1.el10_3.aarch64.rpm;name=aarch64_perl-Sys-Virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Virt}"
SRC_URI[aarch64_perl-Sys-Virt.sha256sum] = "0303c6d570427cbc6e4247ef59041232489e49c5023e7185fd69e905317fae97"

URI_aarch64_perl-Sys-Virt-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-Virt-tests-12.4.0-1.el10_3.aarch64.rpm;name=aarch64_perl-Sys-Virt-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Virt-tests}"
SRC_URI[aarch64_perl-Sys-Virt-tests.sha256sum] = "7c901bfcc6b6c40762c6d9aea97416f63338bfc83a0663b556116235d81eba53"

RDEPENDS:perl-Sys-Virt = " \
 glibc \
 libvirt-libs \
 perl-libs \
 perl-overload \
 perl-parent \
 "
RDEPENDS:perl-Sys-Virt-tests = " \
 bash \
 perl-Sys-Hostname \
 perl-Sys-Virt \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-XML-XPath \
 perl-base \
 perl-interpreter \
 perl-libs \
 "
