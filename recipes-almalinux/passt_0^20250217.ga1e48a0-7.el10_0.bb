# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "passt"
PV = "0^20250217.ga1e48a0"
PR = "7.el10_0"
PACKAGES = " \
 passt \
 passt-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/passt-0^20250217.ga1e48a0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3af69d27cc05ca3ea352cc2adf5a679580d90c9cadeb13421d59b5c0c38072a"

URI_x86_64_v2_passt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-0^20250217.ga1e48a0-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_passt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_passt}"
SRC_URI[x86_64_v2_passt.sha256sum] = "150e55f7f6d635e559cfaea0113cf43724a994a53adb05cc6f885dea5c897a40"

URI_x86_64_v2_passt-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-selinux-0^20250217.ga1e48a0-7.el10_0.noarch.rpm;name=x86_64_v2_passt-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_passt-selinux}"
SRC_URI[x86_64_v2_passt-selinux.sha256sum] = "1b172f1156f5eb1189e1d6b16fbb0545247696beab600a8f59740b2dc546abdd"

URI_aarch64_passt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-0^20250217.ga1e48a0-7.el10_0.aarch64.rpm;name=aarch64_passt;unpack=0"
SRC_URI:append = " ${URI_aarch64_passt}"
SRC_URI[aarch64_passt.sha256sum] = "52698505a6b9d89ba4b5f6becbd82aa7a530f1d5d1f8fe01dd0130f54b50461f"

URI_aarch64_passt-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-selinux-0^20250217.ga1e48a0-7.el10_0.noarch.rpm;name=aarch64_passt-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_passt-selinux}"
SRC_URI[aarch64_passt-selinux.sha256sum] = "1b172f1156f5eb1189e1d6b16fbb0545247696beab600a8f59740b2dc546abdd"

RDEPENDS:passt = " \
 glibc \
 passt-selinux \
 "
RDEPENDS:passt-selinux = " \
 bash \
 passt \
 policycoreutils \
 selinux-policy \
 "
