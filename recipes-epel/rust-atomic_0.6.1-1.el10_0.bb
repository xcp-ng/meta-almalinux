# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-atomic"
PV = "0.6.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-atomic+default-devel \
 rust-atomic+fallback-devel \
 rust-atomic+nightly-devel \
 rust-atomic+serde-devel \
 rust-atomic+std-devel \
 rust-atomic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-atomic-0.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d494eae14664522ed1b9fa58610f55e827313d374b1d2289859564da133399b0"

URI_x86_64_v2_rust-atomic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic+default-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic+default-devel}"
SRC_URI[x86_64_v2_rust-atomic+default-devel.sha256sum] = "b4af5113f1c0aca46a606d857bc7b045fe2be3b14fc7ae6844cd43fb6a8b808c"

URI_x86_64_v2_rust-atomic+fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic+fallback-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic+fallback-devel}"
SRC_URI[x86_64_v2_rust-atomic+fallback-devel.sha256sum] = "42c67bf2d6eaa661f779e9cfe73380a43b35a8f2bc4d304d7ea48f0022f7a2ef"

URI_x86_64_v2_rust-atomic+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic+nightly-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic+nightly-devel}"
SRC_URI[x86_64_v2_rust-atomic+nightly-devel.sha256sum] = "8b6954312b56a1a6568371d23740a6edea492dd34f917db74dbb8014f7f5cd4f"

URI_x86_64_v2_rust-atomic+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic+serde-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic+serde-devel}"
SRC_URI[x86_64_v2_rust-atomic+serde-devel.sha256sum] = "1921a859a5c16b1267e9305dd2d1b27cbdd53f309cab9783835ff3e0d6bda8a5"

URI_x86_64_v2_rust-atomic+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic+std-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic+std-devel}"
SRC_URI[x86_64_v2_rust-atomic+std-devel.sha256sum] = "341bd1a625bd317945c1af8ed2249f07e4b1a337fcc01bbdef9256642682bb8d"

URI_x86_64_v2_rust-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic-devel-0.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic-devel}"
SRC_URI[x86_64_v2_rust-atomic-devel.sha256sum] = "ca60123ce98d71daaa44ee4c962f72a2e14076a1ff60c6773b79503c96b4e9d1"

URI_aarch64_rust-atomic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic+default-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-atomic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic+default-devel}"
SRC_URI[aarch64_rust-atomic+default-devel.sha256sum] = "f77f713ebfb96b3be845c3f4a38c141e96e618eade1c183e230187ab8513960c"

URI_aarch64_rust-atomic+fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic+fallback-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-atomic+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic+fallback-devel}"
SRC_URI[aarch64_rust-atomic+fallback-devel.sha256sum] = "9987ba4176e2ac49e749deacef32ae10d87649714a4ddd6b7dcaa948c058eedd"

URI_aarch64_rust-atomic+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic+nightly-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-atomic+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic+nightly-devel}"
SRC_URI[aarch64_rust-atomic+nightly-devel.sha256sum] = "b7977ef42fe6f6685f2c93a452b3ffb8085b2d4aa00eebd53b8e399a477018e5"

URI_aarch64_rust-atomic+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic+serde-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-atomic+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic+serde-devel}"
SRC_URI[aarch64_rust-atomic+serde-devel.sha256sum] = "58c3f7601005cc22c532369c095e2e92ecf854347d9bed4bb9543f65474cfb97"

URI_aarch64_rust-atomic+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic+std-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-atomic+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic+std-devel}"
SRC_URI[aarch64_rust-atomic+std-devel.sha256sum] = "80f071aa82d87f00075579e4527f87bc221930ffe324007d60465c9c58e18151"

URI_aarch64_rust-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic-devel-0.6.1-1.el10_0.noarch.rpm;name=aarch64_rust-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic-devel}"
SRC_URI[aarch64_rust-atomic-devel.sha256sum] = "01a73acb39c3dcb6de29df391ae8a1b7a0cfb2724471de771b0f536cdd862ffb"

RDEPENDS:rust-atomic+default-devel = " \
 cargo \
 rust-atomic+fallback-devel \
 rust-atomic-devel \
 "
RDEPENDS:rust-atomic+fallback-devel = " \
 cargo \
 rust-atomic-devel \
 "
RDEPENDS:rust-atomic+nightly-devel = " \
 cargo \
 rust-atomic-devel \
 "
RDEPENDS:rust-atomic+serde-devel = " \
 cargo \
 rust-atomic-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-atomic+std-devel = " \
 cargo \
 rust-atomic-devel \
 "
RDEPENDS:rust-atomic-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 "
