# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-autodoc-typehints"
PV = "2.5.0"
PR = "4.el10_0"
PACKAGES = " \
 python3-sphinx-autodoc-typehints \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-autodoc-typehints-2.5.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b07a189cf47bb27f0c8766123a9eeaa5dd9c00fe33b8d93ca68ae0afd88bed5f"

URI_x86_64_v2_python3-sphinx-autodoc-typehints = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-autodoc-typehints-2.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-autodoc-typehints;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-autodoc-typehints}"
SRC_URI[x86_64_v2_python3-sphinx-autodoc-typehints.sha256sum] = "8d1401ba6f1c9c59a1fd21fb244c08732ac71076da3f4121aafd6710e9a3b855"

URI_aarch64_python3-sphinx-autodoc-typehints = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-autodoc-typehints-2.5.0-4.el10_0.noarch.rpm;name=aarch64_python3-sphinx-autodoc-typehints;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-autodoc-typehints}"
SRC_URI[aarch64_python3-sphinx-autodoc-typehints.sha256sum] = "f3e2bef1a13877fda5ffa304fc4a31bcaeaf8b277a5cc6ca0b6e415bf23acdc9"

RDEPENDS:python3-sphinx-autodoc-typehints = " \
 python3 \
 python3-sphinx \
 "
