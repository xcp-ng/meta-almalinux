# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cairo"
PV = "0.13.11.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-cairo \
 ghc-cairo-devel \
 ghc-cairo-doc \
 ghc-cairo-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cairo-0.13.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "711e365949425a3a8965f8dca2ca4678590aad6abcf71a902d28a33a1d586524"

URI_x86_64_v2_ghc-cairo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cairo-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cairo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cairo}"
SRC_URI[x86_64_v2_ghc-cairo.sha256sum] = "b8a67232e320bff0aabab82f32bff6fb874a57434cb5a1ebed892dee8f4b252b"

URI_x86_64_v2_ghc-cairo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cairo-devel-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cairo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cairo-devel}"
SRC_URI[x86_64_v2_ghc-cairo-devel.sha256sum] = "ed319553b2ea55284d032748829bfe6e0e7d441027fa0d7a13bdfb7dd8ad8906"

URI_x86_64_v2_ghc-cairo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cairo-doc-0.13.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cairo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cairo-doc}"
SRC_URI[x86_64_v2_ghc-cairo-doc.sha256sum] = "f7e2dba7eda74b7889a1f21dc52759795c72d379ae31a2d453217cd79b2ac881"

URI_x86_64_v2_ghc-cairo-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cairo-prof-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cairo-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cairo-prof}"
SRC_URI[x86_64_v2_ghc-cairo-prof.sha256sum] = "c93b97476bca4a679578c8df8dfb80e5cbf05fb678e240536729033f109b12eb"

URI_aarch64_ghc-cairo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cairo-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-cairo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cairo}"
SRC_URI[aarch64_ghc-cairo.sha256sum] = "b960c3fe3d8a5ed7b9191b21becc8c577687d60cad87676bbe30b3b997de8f8a"

URI_aarch64_ghc-cairo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cairo-devel-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-cairo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cairo-devel}"
SRC_URI[aarch64_ghc-cairo-devel.sha256sum] = "e07d98421b4be09280d217a6cd37fdd7ab31dae7ba1cc3de4d9c1803454c4330"

URI_aarch64_ghc-cairo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cairo-doc-0.13.11.0-1.el10_0.noarch.rpm;name=aarch64_ghc-cairo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cairo-doc}"
SRC_URI[aarch64_ghc-cairo-doc.sha256sum] = "acf72645d5f9432eabc5c878f1e57604797638784a7d983bbd18827259e1d92e"

URI_aarch64_ghc-cairo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cairo-prof-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-cairo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cairo-prof}"
SRC_URI[aarch64_ghc-cairo-prof.sha256sum] = "d14efc6250b7ec33af2509ca82dce8bcb4670025db091349e06074264d5ff61c"

RDEPENDS:ghc-cairo = " \
 cairo \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-utf8-string \
 glibc \
 gmp \
 libpng \
 zlib-ng-compat \
 "
RDEPENDS:ghc-cairo-devel = " \
 cairo-devel \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cairo \
 ghc-compiler \
 ghc-mtl-devel \
 ghc-text-devel \
 ghc-utf8-string-devel \
 "
RDEPENDS:ghc-cairo-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cairo-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cairo-devel \
 ghc-mtl-prof \
 ghc-text-prof \
 ghc-utf8-string-prof \
 "
