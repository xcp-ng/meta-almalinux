# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling"
PV = "0.20.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-darling+default-devel \
 rust-darling+diagnostics-devel \
 rust-darling+suggestions-devel \
 rust-darling-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling-0.20.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b865217bcd371363275dd78c60e65b7415839e51e1db334380976909327946b9"

URI_x86_64_v2_rust-darling+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling+default-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling+default-devel}"
SRC_URI[x86_64_v2_rust-darling+default-devel.sha256sum] = "136052e48830bdcfba6248b9b3debbfcf3979cbdf43eafce13e7f42f8332533b"

URI_x86_64_v2_rust-darling+diagnostics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling+diagnostics-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling+diagnostics-devel}"
SRC_URI[x86_64_v2_rust-darling+diagnostics-devel.sha256sum] = "476bef8d6a3fe134aa02195a92e9a2a6dc54622b953a1919e7424cba04b89a29"

URI_x86_64_v2_rust-darling+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling+suggestions-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling+suggestions-devel}"
SRC_URI[x86_64_v2_rust-darling+suggestions-devel.sha256sum] = "7433972b23afd732a552224919abdef7da4839694dad7114194a2368ed64ed41"

URI_x86_64_v2_rust-darling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling-devel}"
SRC_URI[x86_64_v2_rust-darling-devel.sha256sum] = "d7bd213515700724107a739eb9d866edab7c2b4135a0ba130938435d2721ab4f"

URI_aarch64_rust-darling+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling+default-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling+default-devel}"
SRC_URI[aarch64_rust-darling+default-devel.sha256sum] = "381f87f6c58e516da6af437461e6c2f8b7e9ccf6528f9d7ef5a5ba360bccd915"

URI_aarch64_rust-darling+diagnostics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling+diagnostics-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling+diagnostics-devel}"
SRC_URI[aarch64_rust-darling+diagnostics-devel.sha256sum] = "9fb6a0492ad4fc9f2b12e24a9e2bfbcb1284162f44f6336481e5dec4d539f5ea"

URI_aarch64_rust-darling+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling+suggestions-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling+suggestions-devel}"
SRC_URI[aarch64_rust-darling+suggestions-devel.sha256sum] = "ea2e1e93b683eded8c07303cb47f9ed6ba7c818a8e85b5449fa7f7a3dccde9fd"

URI_aarch64_rust-darling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling-devel}"
SRC_URI[aarch64_rust-darling-devel.sha256sum] = "df8b3de6946400f416205a55374eee5e987cd4337206700d7e2e3d81b9373600"

RDEPENDS:rust-darling+default-devel = " \
 cargo \
 rust-darling+suggestions-devel \
 rust-darling-devel \
 "
RDEPENDS:rust-darling+diagnostics-devel = " \
 cargo \
 rust-darling-devel \
 rust-darling_core+diagnostics-devel \
 "
RDEPENDS:rust-darling+suggestions-devel = " \
 cargo \
 rust-darling-devel \
 rust-darling_core+suggestions-devel \
 "
RDEPENDS:rust-darling-devel = " \
 cargo \
 rust \
 rust-darling_core+default-devel \
 rust-darling_macro+default-devel \
 "
