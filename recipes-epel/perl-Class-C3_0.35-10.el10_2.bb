# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-C3"
PV = "0.35"
PR = "10.el10_2"
PACKAGES = " \
 perl-Class-C3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-C3-0.35-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3149cc6230f6bc0050125e04832bb77ee3713a8a2f0b4ce44353ad265e0c8af"

URI_x86_64_v2_perl-Class-C3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-C3-0.35-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-C3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-C3}"
SRC_URI[x86_64_v2_perl-Class-C3.sha256sum] = "106529ec82d8418eaa0f09378695fd81ee444d06114d9705eb022fba7044a261"

URI_aarch64_perl-Class-C3 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-C3-0.35-10.el10_2.noarch.rpm;name=aarch64_perl-Class-C3;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-C3}"
SRC_URI[aarch64_perl-Class-C3.sha256sum] = "b77a3dd134f467aee2eb44ca569d3f2e40bf69994c8c36834cf9071fee7d58c2"

RDEPENDS:perl-Class-C3 = " \
 perl-Algorithm-C3 \
 perl-Class-C3 \
 perl-Scalar-List-Utils \
 perl-libs \
 "
