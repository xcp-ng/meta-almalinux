# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flexmark-java"
PV = "0.64.6"
PR = "18.el10_3"
PACKAGES = " \
 flexmark-java \
 flexmark-java-all \
 flexmark-java-ext-abbreviation \
 flexmark-java-ext-admonition \
 flexmark-java-ext-anchorlink \
 flexmark-java-ext-aside \
 flexmark-java-ext-attributes \
 flexmark-java-ext-autolink \
 flexmark-java-ext-definition \
 flexmark-java-ext-emoji \
 flexmark-java-ext-enumerated-reference \
 flexmark-java-ext-escaped-character \
 flexmark-java-ext-footnotes \
 flexmark-java-ext-gfm-issues \
 flexmark-java-ext-gfm-strikethrough \
 flexmark-java-ext-gfm-tasklist \
 flexmark-java-ext-gfm-users \
 flexmark-java-ext-gitlab \
 flexmark-java-ext-ins \
 flexmark-java-ext-jekyll-front-matter \
 flexmark-java-ext-jekyll-tag \
 flexmark-java-ext-macros \
 flexmark-java-ext-media-tags \
 flexmark-java-ext-resizable-image \
 flexmark-java-ext-spec-example \
 flexmark-java-ext-superscript \
 flexmark-java-ext-tables \
 flexmark-java-ext-toc \
 flexmark-java-ext-typographic \
 flexmark-java-ext-wikilink \
 flexmark-java-ext-xwiki-macros \
 flexmark-java-ext-yaml-front-matter \
 flexmark-java-ext-youtube-embedded \
 flexmark-java-ext-zzzzzz \
 flexmark-java-html2md-converter \
 flexmark-java-javadoc \
 flexmark-java-jira-converter \
 flexmark-java-osgi \
 flexmark-java-test-util \
 flexmark-java-tree-iteration \
 flexmark-java-util \
 flexmark-java-util-ast \
 flexmark-java-util-builder \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 flexmark-java-util-dependency \
 flexmark-java-util-experimental \
 flexmark-java-util-format \
 flexmark-java-util-html \
 flexmark-java-util-misc \
 flexmark-java-util-options \
 flexmark-java-util-sequence \
 flexmark-java-util-visitor \
 flexmark-java-youtrack-converter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flexmark-java-0.64.6-18.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7ea0ef38829e575855add52f3564ee6e1d868cb7e912dc41e41439dcc601058"

URI_x86_64_v2_flexmark-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java}"
SRC_URI[x86_64_v2_flexmark-java.sha256sum] = "4776e7759c36eb642deb4fb938b00510c6b64ff9b43eba45ba42318ba83067cb"

URI_x86_64_v2_flexmark-java-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-all-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-all}"
SRC_URI[x86_64_v2_flexmark-java-all.sha256sum] = "7ac082bf400d08f2be15ea03703929fe2135222ba480fbc5352d9beeba75e3ab"

URI_x86_64_v2_flexmark-java-ext-abbreviation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-abbreviation-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-abbreviation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-abbreviation}"
SRC_URI[x86_64_v2_flexmark-java-ext-abbreviation.sha256sum] = "ed23d51c4846a6ee8099fec63981732efaedc1b1f11ac554862b3cc077d58887"

URI_x86_64_v2_flexmark-java-ext-admonition = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-admonition-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-admonition;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-admonition}"
SRC_URI[x86_64_v2_flexmark-java-ext-admonition.sha256sum] = "898c5d31d10c9cdbe9d31c99238739fd2c07245efc4d229b77bb5e08dd71f2f2"

URI_x86_64_v2_flexmark-java-ext-anchorlink = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-anchorlink-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-anchorlink;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-anchorlink}"
SRC_URI[x86_64_v2_flexmark-java-ext-anchorlink.sha256sum] = "5e25ff6c087d9f9ca70e81db2824868e296860020b46be00877699e2d78f9ce6"

URI_x86_64_v2_flexmark-java-ext-aside = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-aside-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-aside;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-aside}"
SRC_URI[x86_64_v2_flexmark-java-ext-aside.sha256sum] = "5aa549e717d7a109aa87372721e35766f18b5a2b903ee1cffe3fe3d28aeedbc9"

URI_x86_64_v2_flexmark-java-ext-attributes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-attributes-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-attributes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-attributes}"
SRC_URI[x86_64_v2_flexmark-java-ext-attributes.sha256sum] = "b7d6e4465268705a6b4e98401a11fcdbf7b886224d31ba7bb7de549907851ef6"

URI_x86_64_v2_flexmark-java-ext-autolink = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-autolink-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-autolink;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-autolink}"
SRC_URI[x86_64_v2_flexmark-java-ext-autolink.sha256sum] = "fa94441fe89ac2826154c97aacd834051e0894fd639e971422bdff294f6435c0"

URI_x86_64_v2_flexmark-java-ext-definition = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-definition-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-definition;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-definition}"
SRC_URI[x86_64_v2_flexmark-java-ext-definition.sha256sum] = "ab37c1c25e887287ece1c3aed70ed5fe576ae3ebe6c18d69038b3e407c2926a7"

URI_x86_64_v2_flexmark-java-ext-emoji = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-emoji-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-emoji;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-emoji}"
SRC_URI[x86_64_v2_flexmark-java-ext-emoji.sha256sum] = "6167ab4b26577657e05c105d733edd73e333ec745e0154bce59fceb4b87fa1cc"

URI_x86_64_v2_flexmark-java-ext-enumerated-reference = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-enumerated-reference-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-enumerated-reference;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-enumerated-reference}"
SRC_URI[x86_64_v2_flexmark-java-ext-enumerated-reference.sha256sum] = "4c993a037ad9ec64ee47f59ed0faca8d18d391e613af04eab574839786cd3ff2"

URI_x86_64_v2_flexmark-java-ext-escaped-character = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-escaped-character-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-escaped-character;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-escaped-character}"
SRC_URI[x86_64_v2_flexmark-java-ext-escaped-character.sha256sum] = "492325f02e9073e9b4e1d0c05e3a1907dc523cb96244e44020070ba9f2aeb4f5"

URI_x86_64_v2_flexmark-java-ext-footnotes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-footnotes-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-footnotes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-footnotes}"
SRC_URI[x86_64_v2_flexmark-java-ext-footnotes.sha256sum] = "f457391b39c38b4d481508a6a67128954b5a396af073886642571393704c53a3"

URI_x86_64_v2_flexmark-java-ext-gfm-issues = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-gfm-issues-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-gfm-issues;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-gfm-issues}"
SRC_URI[x86_64_v2_flexmark-java-ext-gfm-issues.sha256sum] = "865fdffa990ccf3163e167df5bb4d4dbaa4b6cc22ccb561966c26c55b1072181"

URI_x86_64_v2_flexmark-java-ext-gfm-strikethrough = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-gfm-strikethrough-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-gfm-strikethrough;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-gfm-strikethrough}"
SRC_URI[x86_64_v2_flexmark-java-ext-gfm-strikethrough.sha256sum] = "0c700c5288a8af5fb98379c16aada294530d1cb4a070ede3de256a0476fa5785"

URI_x86_64_v2_flexmark-java-ext-gfm-tasklist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-gfm-tasklist-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-gfm-tasklist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-gfm-tasklist}"
SRC_URI[x86_64_v2_flexmark-java-ext-gfm-tasklist.sha256sum] = "b4f3543d7ff5db7f7a7e3d80f23703c9a8789286d4fe58cf124db412e127bb9f"

URI_x86_64_v2_flexmark-java-ext-gfm-users = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-gfm-users-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-gfm-users;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-gfm-users}"
SRC_URI[x86_64_v2_flexmark-java-ext-gfm-users.sha256sum] = "bd6c8341bf98bea453d3bfbf88a08dc55ed589f43174003d18dc34c29d3e7064"

URI_x86_64_v2_flexmark-java-ext-gitlab = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-gitlab-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-gitlab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-gitlab}"
SRC_URI[x86_64_v2_flexmark-java-ext-gitlab.sha256sum] = "9e0fcc54ea03b6495461c52c1040a0fea3ed37e572aa1894a473a88cd659a045"

URI_x86_64_v2_flexmark-java-ext-ins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-ins-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-ins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-ins}"
SRC_URI[x86_64_v2_flexmark-java-ext-ins.sha256sum] = "e3f381eb250124ae7afdc85e476d26f4a7a4c2488602257b0a27d322341199ba"

URI_x86_64_v2_flexmark-java-ext-jekyll-front-matter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-jekyll-front-matter-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-jekyll-front-matter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-jekyll-front-matter}"
SRC_URI[x86_64_v2_flexmark-java-ext-jekyll-front-matter.sha256sum] = "6ecfcab47c8581528b0fd52740f45eddccdd0054f3bfa3139b0732c779b68014"

URI_x86_64_v2_flexmark-java-ext-jekyll-tag = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-jekyll-tag-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-jekyll-tag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-jekyll-tag}"
SRC_URI[x86_64_v2_flexmark-java-ext-jekyll-tag.sha256sum] = "88e0d2bb743d57ea41e1c33a56292b87756bfdd18d49a1804b1a86c4fab24769"

URI_x86_64_v2_flexmark-java-ext-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-macros-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-macros}"
SRC_URI[x86_64_v2_flexmark-java-ext-macros.sha256sum] = "6e6d509ddb8063c771b72d00d0ca282d415bfd42e565dfc3a2cc22f72d61ea1a"

URI_x86_64_v2_flexmark-java-ext-media-tags = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-media-tags-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-media-tags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-media-tags}"
SRC_URI[x86_64_v2_flexmark-java-ext-media-tags.sha256sum] = "61d42f120fa4f051fb4af8f11535bec0757b04697f40545ea3188efbefdd2541"

URI_x86_64_v2_flexmark-java-ext-resizable-image = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-resizable-image-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-resizable-image;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-resizable-image}"
SRC_URI[x86_64_v2_flexmark-java-ext-resizable-image.sha256sum] = "e27a0b04aac7fa32870d2295f76da96b6f94102bedf2fefb3a374eaa1d827bd4"

URI_x86_64_v2_flexmark-java-ext-spec-example = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-spec-example-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-spec-example;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-spec-example}"
SRC_URI[x86_64_v2_flexmark-java-ext-spec-example.sha256sum] = "07c897d41da8937912aebaef9bc1d8c57fde66304806c885f796f1a28a8ebf55"

URI_x86_64_v2_flexmark-java-ext-superscript = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-superscript-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-superscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-superscript}"
SRC_URI[x86_64_v2_flexmark-java-ext-superscript.sha256sum] = "07c3f7c3c4d52c3bbe6be0f91462353af61eb9640b5160c089c290d52f593caa"

URI_x86_64_v2_flexmark-java-ext-tables = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-tables-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-tables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-tables}"
SRC_URI[x86_64_v2_flexmark-java-ext-tables.sha256sum] = "59fe8705cfb9383f056093809011f2e789f45fb49b08693bd6cc61ff6f78dc4c"

URI_x86_64_v2_flexmark-java-ext-toc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-toc-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-toc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-toc}"
SRC_URI[x86_64_v2_flexmark-java-ext-toc.sha256sum] = "05df32c43e35fad51bd052de51dfbf6385a6e3143be18e145e1428b1644a7300"

URI_x86_64_v2_flexmark-java-ext-typographic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-typographic-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-typographic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-typographic}"
SRC_URI[x86_64_v2_flexmark-java-ext-typographic.sha256sum] = "dc037deb22bfe97a0769bfd6f6421041a846e7d7031061565da6daeabdb3854d"

URI_x86_64_v2_flexmark-java-ext-wikilink = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-wikilink-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-wikilink;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-wikilink}"
SRC_URI[x86_64_v2_flexmark-java-ext-wikilink.sha256sum] = "f7d67d47d0915a8ef342d8e8a84f14752ab56171dafb87a81f8224e192f475c3"

URI_x86_64_v2_flexmark-java-ext-xwiki-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-xwiki-macros-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-xwiki-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-xwiki-macros}"
SRC_URI[x86_64_v2_flexmark-java-ext-xwiki-macros.sha256sum] = "b8a2fc1e43d1fc52cfb8a0c7bd56c69eb031ce983f22dc91eb54767d339a1c9f"

URI_x86_64_v2_flexmark-java-ext-yaml-front-matter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-yaml-front-matter-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-yaml-front-matter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-yaml-front-matter}"
SRC_URI[x86_64_v2_flexmark-java-ext-yaml-front-matter.sha256sum] = "cba6a97417103993efba2a9738f5239ae0cc608c25389ea980008ec0caec7090"

URI_x86_64_v2_flexmark-java-ext-youtube-embedded = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-youtube-embedded-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-youtube-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-youtube-embedded}"
SRC_URI[x86_64_v2_flexmark-java-ext-youtube-embedded.sha256sum] = "3d0473ea55afd18d36b1889b18d5eddee714f22179e6e28359b9ee167ec2bf2a"

URI_x86_64_v2_flexmark-java-ext-zzzzzz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-ext-zzzzzz-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-ext-zzzzzz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-ext-zzzzzz}"
SRC_URI[x86_64_v2_flexmark-java-ext-zzzzzz.sha256sum] = "3408af33888db9ac048cbf4d9785b2ac1fc07e596aaed211d4f214bc044c4f7a"

URI_x86_64_v2_flexmark-java-html2md-converter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-html2md-converter-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-html2md-converter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-html2md-converter}"
SRC_URI[x86_64_v2_flexmark-java-html2md-converter.sha256sum] = "1bf76629c2f725894c935cfc7b70f1c2b4f42acbe9430f571ca1b3ca1aec4a5b"

URI_x86_64_v2_flexmark-java-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-javadoc-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-javadoc}"
SRC_URI[x86_64_v2_flexmark-java-javadoc.sha256sum] = "734034f3f9dceab64ef2c82696a826c7718070a2413571bf74338ca7c971439e"

URI_x86_64_v2_flexmark-java-jira-converter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-jira-converter-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-jira-converter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-jira-converter}"
SRC_URI[x86_64_v2_flexmark-java-jira-converter.sha256sum] = "7fcb5063dd5f324165fc877c3785e2645cfb88831d79b68d3bfbc3a3103ba9fc"

URI_x86_64_v2_flexmark-java-osgi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-osgi-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-osgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-osgi}"
SRC_URI[x86_64_v2_flexmark-java-osgi.sha256sum] = "45c48837dc3de3cd17c67f7b1418a1e8f9c21ce19b8aa040615615e747d71927"

URI_x86_64_v2_flexmark-java-test-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-test-util-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-test-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-test-util}"
SRC_URI[x86_64_v2_flexmark-java-test-util.sha256sum] = "191f3f115795a6cda38f199d24e937bb5571d0ba6550a417d3f509a4039505c2"

URI_x86_64_v2_flexmark-java-tree-iteration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-tree-iteration-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-tree-iteration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-tree-iteration}"
SRC_URI[x86_64_v2_flexmark-java-tree-iteration.sha256sum] = "c70d52c9125ed09f03ed99a4ea21bd81ef5c8ebbd79d975c30bbbb807d1dfa54"

URI_x86_64_v2_flexmark-java-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util}"
SRC_URI[x86_64_v2_flexmark-java-util.sha256sum] = "16ceae7765a4c2d35ee4fe7629a259b00abf7dcfec4d993a71690e168e2617ae"

URI_x86_64_v2_flexmark-java-util-ast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-ast-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-ast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-ast}"
SRC_URI[x86_64_v2_flexmark-java-util-ast.sha256sum] = "2547ad95c770612cc52647aeab6051541b5f0bbdf0c960d9ec439a37a166c740"

URI_x86_64_v2_flexmark-java-util-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-builder-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-builder}"
SRC_URI[x86_64_v2_flexmark-java-util-builder.sha256sum] = "829001374bad71d7c3ac0124ddf2c394db9e76bc7324c730b966eb939941f521"

URI_x86_64_v2_flexmark-java-util-collection = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-collection-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-collection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-collection}"
SRC_URI[x86_64_v2_flexmark-java-util-collection.sha256sum] = "4f95b2d463b6ceeaee6ecc12588b3e90d720018517d55491c97981070c9663f0"

URI_x86_64_v2_flexmark-java-util-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-data-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-data}"
SRC_URI[x86_64_v2_flexmark-java-util-data.sha256sum] = "b2d9f57f07e2564d8ae48c375a53bbbe6fffab3ceb7e368210e38b4aacec2d57"

URI_x86_64_v2_flexmark-java-util-dependency = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-dependency-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-dependency;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-dependency}"
SRC_URI[x86_64_v2_flexmark-java-util-dependency.sha256sum] = "24c8627b4c163d44c709f7cfa57656e81b5ba06d4132ec3247aabc261e3db37e"

URI_x86_64_v2_flexmark-java-util-experimental = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-experimental-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-experimental}"
SRC_URI[x86_64_v2_flexmark-java-util-experimental.sha256sum] = "262eb33eecfb4edc43fe8dc7ed5368a1a3265a06126820e9798ece7c2ed1b023"

URI_x86_64_v2_flexmark-java-util-format = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-format-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-format;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-format}"
SRC_URI[x86_64_v2_flexmark-java-util-format.sha256sum] = "92bc8593c2430214350c8b48cfa1b29e214cc250769ec6888e63e19167160221"

URI_x86_64_v2_flexmark-java-util-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-html-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-html}"
SRC_URI[x86_64_v2_flexmark-java-util-html.sha256sum] = "d331951b45d81bb230d03f132662c2a73f528fb713a69f39f653231b525501ec"

URI_x86_64_v2_flexmark-java-util-misc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-misc-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-misc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-misc}"
SRC_URI[x86_64_v2_flexmark-java-util-misc.sha256sum] = "a9049722d16335d2db2a5a136c1bce8755de9c59f745ee976bace1571a0cc1db"

URI_x86_64_v2_flexmark-java-util-options = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-options-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-options;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-options}"
SRC_URI[x86_64_v2_flexmark-java-util-options.sha256sum] = "d1c140aee7045da2d04beb1009646ade636763af8298888db5e30fa6c63ca4c2"

URI_x86_64_v2_flexmark-java-util-sequence = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-sequence-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-sequence;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-sequence}"
SRC_URI[x86_64_v2_flexmark-java-util-sequence.sha256sum] = "a895ed21c40b7a81a2ee0a60eb9d4427eda0def96c49aefd470b8b94bc78b4ce"

URI_x86_64_v2_flexmark-java-util-visitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-util-visitor-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-util-visitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-util-visitor}"
SRC_URI[x86_64_v2_flexmark-java-util-visitor.sha256sum] = "e491ebd64ec699dd4437a2e218ea6d158c4bd43577c1a5747d04f353be546912"

URI_x86_64_v2_flexmark-java-youtrack-converter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flexmark-java-youtrack-converter-0.64.6-18.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_flexmark-java-youtrack-converter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flexmark-java-youtrack-converter}"
SRC_URI[x86_64_v2_flexmark-java-youtrack-converter.sha256sum] = "c639ade6c58c3643e332dfbc0729e6a16b19762045915920c9820028d1fe44bc"

URI_aarch64_flexmark-java = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java}"
SRC_URI[aarch64_flexmark-java.sha256sum] = "17e8f3331e9a35efff6abdc4c11df8f63340a49c3d880123a0877c25f5402dbf"

URI_aarch64_flexmark-java-all = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-all-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-all}"
SRC_URI[aarch64_flexmark-java-all.sha256sum] = "5036d38498390eb629e82882c0056d20a93ec0e895d571247822c6648fc6aacf"

URI_aarch64_flexmark-java-ext-abbreviation = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-abbreviation-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-abbreviation;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-abbreviation}"
SRC_URI[aarch64_flexmark-java-ext-abbreviation.sha256sum] = "f2a4d6f574e8c53038e1dc347cc922a00dabdd3eb47077d1cb39fa9a11381838"

URI_aarch64_flexmark-java-ext-admonition = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-admonition-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-admonition;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-admonition}"
SRC_URI[aarch64_flexmark-java-ext-admonition.sha256sum] = "57adfe3cf5aa3f373c8fb3f0745b78546fb4e6e56ce19939120df9caa33a2c3a"

URI_aarch64_flexmark-java-ext-anchorlink = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-anchorlink-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-anchorlink;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-anchorlink}"
SRC_URI[aarch64_flexmark-java-ext-anchorlink.sha256sum] = "25d460e54e490a4824703e7fe2682bac4e071830d6fa77d1102d8d6fcafa1b78"

URI_aarch64_flexmark-java-ext-aside = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-aside-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-aside;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-aside}"
SRC_URI[aarch64_flexmark-java-ext-aside.sha256sum] = "5b543ecf2c080a6ef4752fdae29ccc308f24a3167096b022e8452bc3fe2fc42c"

URI_aarch64_flexmark-java-ext-attributes = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-attributes-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-attributes;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-attributes}"
SRC_URI[aarch64_flexmark-java-ext-attributes.sha256sum] = "42874818fcc986d7719604cc9e7e3e47d42dec11adbcb0672f80d1163ef95e7e"

URI_aarch64_flexmark-java-ext-autolink = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-autolink-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-autolink;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-autolink}"
SRC_URI[aarch64_flexmark-java-ext-autolink.sha256sum] = "8b31aef07b1e922d3d48cc06dc1e38f4a53052ac3744c78d9e0d723a67130d89"

URI_aarch64_flexmark-java-ext-definition = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-definition-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-definition;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-definition}"
SRC_URI[aarch64_flexmark-java-ext-definition.sha256sum] = "2fdf95a07eeef5fa8d5ecad1912e11451c2b9da1f86800073ea6f9384252a2ae"

URI_aarch64_flexmark-java-ext-emoji = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-emoji-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-emoji;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-emoji}"
SRC_URI[aarch64_flexmark-java-ext-emoji.sha256sum] = "8f5028408f33d5f3973d622dadbd7ab0c340acd1f480e08fb27fea95a87db2d0"

URI_aarch64_flexmark-java-ext-enumerated-reference = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-enumerated-reference-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-enumerated-reference;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-enumerated-reference}"
SRC_URI[aarch64_flexmark-java-ext-enumerated-reference.sha256sum] = "b4e6296bfd56662687eddecb8b2a52db0f983c83249ec0d64e5872959eaf74bc"

URI_aarch64_flexmark-java-ext-escaped-character = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-escaped-character-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-escaped-character;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-escaped-character}"
SRC_URI[aarch64_flexmark-java-ext-escaped-character.sha256sum] = "3206ddd8839825a8fcc0c0423974390898846830ff4353d2e6ae443e78cce89d"

URI_aarch64_flexmark-java-ext-footnotes = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-footnotes-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-footnotes;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-footnotes}"
SRC_URI[aarch64_flexmark-java-ext-footnotes.sha256sum] = "e20a7326f93bca1faef513b920f87d76256c5e758e68dbfbf81905a45fd6891e"

URI_aarch64_flexmark-java-ext-gfm-issues = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-gfm-issues-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-gfm-issues;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-gfm-issues}"
SRC_URI[aarch64_flexmark-java-ext-gfm-issues.sha256sum] = "38f8505a337a81571d439782c84c6abb75a0efbf8fd9099d9b945b9f8c0d3530"

URI_aarch64_flexmark-java-ext-gfm-strikethrough = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-gfm-strikethrough-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-gfm-strikethrough;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-gfm-strikethrough}"
SRC_URI[aarch64_flexmark-java-ext-gfm-strikethrough.sha256sum] = "9a296c455868ab97d53a932d5cbcecadeec5576c2d41e1b43755618533fbdb74"

URI_aarch64_flexmark-java-ext-gfm-tasklist = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-gfm-tasklist-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-gfm-tasklist;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-gfm-tasklist}"
SRC_URI[aarch64_flexmark-java-ext-gfm-tasklist.sha256sum] = "c1453aa88a18094d6106b58f0b7a660efc0416cf0b6b56d9b6bff8b54a3e21a5"

URI_aarch64_flexmark-java-ext-gfm-users = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-gfm-users-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-gfm-users;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-gfm-users}"
SRC_URI[aarch64_flexmark-java-ext-gfm-users.sha256sum] = "9d58a02cd6792428e5f913238a1e3e13f7fb937c2b0de8d1eb17dd076d14b22a"

URI_aarch64_flexmark-java-ext-gitlab = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-gitlab-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-gitlab;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-gitlab}"
SRC_URI[aarch64_flexmark-java-ext-gitlab.sha256sum] = "b7c3efe1e0fee5355c32d9a5d11d51a984d9887d41da81aa86eb2b3b3eb8c87a"

URI_aarch64_flexmark-java-ext-ins = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-ins-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-ins;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-ins}"
SRC_URI[aarch64_flexmark-java-ext-ins.sha256sum] = "43587a87378e64ccbe117a8b0690bdb29437ae9dcbdad6ff0b9beb8ec6e795d4"

URI_aarch64_flexmark-java-ext-jekyll-front-matter = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-jekyll-front-matter-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-jekyll-front-matter;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-jekyll-front-matter}"
SRC_URI[aarch64_flexmark-java-ext-jekyll-front-matter.sha256sum] = "8388d6f469e83be60597e4f25d2009e318c39daa87b1cfe8c1759c02f9c58924"

URI_aarch64_flexmark-java-ext-jekyll-tag = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-jekyll-tag-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-jekyll-tag;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-jekyll-tag}"
SRC_URI[aarch64_flexmark-java-ext-jekyll-tag.sha256sum] = "7eeded255f63aca2669e33452f6721fb0112acf4f6667ce97309a11b653b11a6"

URI_aarch64_flexmark-java-ext-macros = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-macros-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-macros}"
SRC_URI[aarch64_flexmark-java-ext-macros.sha256sum] = "a65f4e57248bfca686f3c9fc1d5f745c65fc9e19f303d3575de3f812088406e0"

URI_aarch64_flexmark-java-ext-media-tags = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-media-tags-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-media-tags;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-media-tags}"
SRC_URI[aarch64_flexmark-java-ext-media-tags.sha256sum] = "0a7461ece6e4982df20e59f2a8c284619e01d5cf14b706ad3bda186924351212"

URI_aarch64_flexmark-java-ext-resizable-image = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-resizable-image-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-resizable-image;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-resizable-image}"
SRC_URI[aarch64_flexmark-java-ext-resizable-image.sha256sum] = "c5347e5b028b8b9920ffa38ca1e1aa60406fb59fdb9bf2bf5eed36523c07ca8e"

URI_aarch64_flexmark-java-ext-spec-example = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-spec-example-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-spec-example;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-spec-example}"
SRC_URI[aarch64_flexmark-java-ext-spec-example.sha256sum] = "f91b8c4ccab4ec72259f9898b640935c3d6c2d717641073194b4c741e544ab58"

URI_aarch64_flexmark-java-ext-superscript = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-superscript-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-superscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-superscript}"
SRC_URI[aarch64_flexmark-java-ext-superscript.sha256sum] = "4976e9ad03b504ed437b0b492251f8d100cf5bb97f55d6b12fcebe1ff5bd2f67"

URI_aarch64_flexmark-java-ext-tables = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-tables-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-tables;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-tables}"
SRC_URI[aarch64_flexmark-java-ext-tables.sha256sum] = "e7b6d8948f5ba48a344d36a92baf7ee4d54fc6b30f6a22a21394ce4d7774bf90"

URI_aarch64_flexmark-java-ext-toc = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-toc-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-toc;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-toc}"
SRC_URI[aarch64_flexmark-java-ext-toc.sha256sum] = "57e965da52b11590bf4736d590c0236feb0485c59f31630e394a360cf87cc1d6"

URI_aarch64_flexmark-java-ext-typographic = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-typographic-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-typographic;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-typographic}"
SRC_URI[aarch64_flexmark-java-ext-typographic.sha256sum] = "82bb83a22defe406e806e6221c2a577b68bf16206611fb944316191a1c2f5f24"

URI_aarch64_flexmark-java-ext-wikilink = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-wikilink-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-wikilink;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-wikilink}"
SRC_URI[aarch64_flexmark-java-ext-wikilink.sha256sum] = "49e65d52ff3d00cbb7214c9e383d62b8586d874650b5a723cc169a18f40830d4"

URI_aarch64_flexmark-java-ext-xwiki-macros = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-xwiki-macros-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-xwiki-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-xwiki-macros}"
SRC_URI[aarch64_flexmark-java-ext-xwiki-macros.sha256sum] = "5f9e155526aa760ef438438ad15ab50bcae9438645feaaacd188889962e2852a"

URI_aarch64_flexmark-java-ext-yaml-front-matter = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-yaml-front-matter-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-yaml-front-matter;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-yaml-front-matter}"
SRC_URI[aarch64_flexmark-java-ext-yaml-front-matter.sha256sum] = "6cba1aa5e56e00a045518e2d1ca08e3226487612b5cccae62e0aa32f11c29559"

URI_aarch64_flexmark-java-ext-youtube-embedded = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-youtube-embedded-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-youtube-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-youtube-embedded}"
SRC_URI[aarch64_flexmark-java-ext-youtube-embedded.sha256sum] = "87d6d589dc8ca8e7ee1473fb5b27c2630a6648f8d8489a1a4dd13b7f75439d0c"

URI_aarch64_flexmark-java-ext-zzzzzz = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-ext-zzzzzz-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-ext-zzzzzz;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-ext-zzzzzz}"
SRC_URI[aarch64_flexmark-java-ext-zzzzzz.sha256sum] = "b0c1bc430f164b9a6ed5fcb0548ff6d943c67f015cbbbd0bf386b7fb977f382e"

URI_aarch64_flexmark-java-html2md-converter = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-html2md-converter-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-html2md-converter;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-html2md-converter}"
SRC_URI[aarch64_flexmark-java-html2md-converter.sha256sum] = "c3b3062f6f9f1e79600d19a925f262411411f9bbe7c42fca8e7179aa4eff25d5"

URI_aarch64_flexmark-java-javadoc = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-javadoc-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-javadoc}"
SRC_URI[aarch64_flexmark-java-javadoc.sha256sum] = "5800bafc6556211a4527f09d742b48abf570950fbd7f7e3508f3fc48d8462c42"

URI_aarch64_flexmark-java-jira-converter = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-jira-converter-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-jira-converter;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-jira-converter}"
SRC_URI[aarch64_flexmark-java-jira-converter.sha256sum] = "a24e64e97597b2daa39608979de9e999acd79e98f7ef4127112e344972b81b8c"

URI_aarch64_flexmark-java-osgi = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-osgi-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-osgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-osgi}"
SRC_URI[aarch64_flexmark-java-osgi.sha256sum] = "40818c0db243ecf6f7a009de3a4c5748168a0cb2e9db3d86238109f9bfd5bca2"

URI_aarch64_flexmark-java-test-util = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-test-util-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-test-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-test-util}"
SRC_URI[aarch64_flexmark-java-test-util.sha256sum] = "c0fe1a265ca2a7872458e054b6977f4b2acd3f0730d8678e15ca7865bf591d25"

URI_aarch64_flexmark-java-tree-iteration = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-tree-iteration-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-tree-iteration;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-tree-iteration}"
SRC_URI[aarch64_flexmark-java-tree-iteration.sha256sum] = "cc290a0af651f325796f1bd65acf04c5220d6e6844f66dbfea7da52c2495fe63"

URI_aarch64_flexmark-java-util = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util}"
SRC_URI[aarch64_flexmark-java-util.sha256sum] = "13503ab4fd58c442f48382b7fe3dfe382d4ca8add7ce45bc0e4e8a7b40451603"

URI_aarch64_flexmark-java-util-ast = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-ast-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-ast;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-ast}"
SRC_URI[aarch64_flexmark-java-util-ast.sha256sum] = "7fcd0832af21fe2b9fef435c3a6b3d5c937e142e7f245f5b1594fbe0b184809f"

URI_aarch64_flexmark-java-util-builder = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-builder-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-builder}"
SRC_URI[aarch64_flexmark-java-util-builder.sha256sum] = "6171f9b4362f450d20de273f6b2f36395608321d6802e99c821345ea2b3472c0"

URI_aarch64_flexmark-java-util-collection = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-collection-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-collection;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-collection}"
SRC_URI[aarch64_flexmark-java-util-collection.sha256sum] = "87bc39b98202665ab8de52a8a431d20ba42e42b60488cbe53e9eda2ee794279d"

URI_aarch64_flexmark-java-util-data = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-data-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-data}"
SRC_URI[aarch64_flexmark-java-util-data.sha256sum] = "115b0ce1481e916d236888664fd52c804ded062d53dd13bc0d09cb6a8dfaa196"

URI_aarch64_flexmark-java-util-dependency = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-dependency-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-dependency;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-dependency}"
SRC_URI[aarch64_flexmark-java-util-dependency.sha256sum] = "449acdf884cb433b71ba8fee0a5916a3f8fc85622acf44cf63b927ef1c1be465"

URI_aarch64_flexmark-java-util-experimental = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-experimental-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-experimental}"
SRC_URI[aarch64_flexmark-java-util-experimental.sha256sum] = "f9e244bf489701e9fea6d1b3c357c064dbdcea88f26441319a7c0f2c7be4f23d"

URI_aarch64_flexmark-java-util-format = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-format-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-format;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-format}"
SRC_URI[aarch64_flexmark-java-util-format.sha256sum] = "5767b0fd40e588668f135873c4da63b62029a9f0a62b0b1762fdaf781fccc264"

URI_aarch64_flexmark-java-util-html = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-html-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-html}"
SRC_URI[aarch64_flexmark-java-util-html.sha256sum] = "db1ee775fa980be0ada9c353e229b7f16343ce8bb2270b322894f847ef9b949b"

URI_aarch64_flexmark-java-util-misc = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-misc-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-misc;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-misc}"
SRC_URI[aarch64_flexmark-java-util-misc.sha256sum] = "6e12aea3089142ac4169c461ff19cc54af5d576cb604af5a48dbcbfff0e1ea92"

URI_aarch64_flexmark-java-util-options = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-options-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-options;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-options}"
SRC_URI[aarch64_flexmark-java-util-options.sha256sum] = "9db032fa426dc19106687426fae6d40d0348194de775a64fd437d464f7cacb79"

URI_aarch64_flexmark-java-util-sequence = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-sequence-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-sequence;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-sequence}"
SRC_URI[aarch64_flexmark-java-util-sequence.sha256sum] = "3526e240f7a34ca56cca19037dc8ecbf9a48778cd9b5cfeacc787e3582df3838"

URI_aarch64_flexmark-java-util-visitor = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-util-visitor-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-util-visitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-util-visitor}"
SRC_URI[aarch64_flexmark-java-util-visitor.sha256sum] = "6b983b09e6223716581b27dbdf2947a59224e6064ad05f416ab62f8fcdb942ef"

URI_aarch64_flexmark-java-youtrack-converter = "${EPEL_MIRROR}/aarch64/Packages/f/flexmark-java-youtrack-converter-0.64.6-18.el10_3.noarch.rpm;name=aarch64_flexmark-java-youtrack-converter;unpack=0"
SRC_URI:append = " ${URI_aarch64_flexmark-java-youtrack-converter}"
SRC_URI[aarch64_flexmark-java-youtrack-converter.sha256sum] = "15a43fa62dea3a933b1da13aecf1ab13c592082141b8358f554a6906cb5fc358"

RDEPENDS:flexmark-java = " \
 flexmark-java-util-ast \
 flexmark-java-util-builder \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 flexmark-java-util-dependency \
 flexmark-java-util-format \
 flexmark-java-util-html \
 flexmark-java-util-misc \
 flexmark-java-util-sequence \
 flexmark-java-util-visitor \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-all = " \
 flexmark-java \
 flexmark-java-ext-abbreviation \
 flexmark-java-ext-admonition \
 flexmark-java-ext-anchorlink \
 flexmark-java-ext-aside \
 flexmark-java-ext-attributes \
 flexmark-java-ext-autolink \
 flexmark-java-ext-definition \
 flexmark-java-ext-emoji \
 flexmark-java-ext-enumerated-reference \
 flexmark-java-ext-escaped-character \
 flexmark-java-ext-footnotes \
 flexmark-java-ext-gfm-issues \
 flexmark-java-ext-gfm-strikethrough \
 flexmark-java-ext-gfm-tasklist \
 flexmark-java-ext-gfm-users \
 flexmark-java-ext-gitlab \
 flexmark-java-ext-ins \
 flexmark-java-ext-jekyll-front-matter \
 flexmark-java-ext-jekyll-tag \
 flexmark-java-ext-macros \
 flexmark-java-ext-media-tags \
 flexmark-java-ext-resizable-image \
 flexmark-java-ext-superscript \
 flexmark-java-ext-tables \
 flexmark-java-ext-toc \
 flexmark-java-ext-typographic \
 flexmark-java-ext-wikilink \
 flexmark-java-ext-xwiki-macros \
 flexmark-java-ext-yaml-front-matter \
 flexmark-java-ext-youtube-embedded \
 flexmark-java-html2md-converter \
 flexmark-java-jira-converter \
 flexmark-java-util-ast \
 flexmark-java-util-builder \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 flexmark-java-util-dependency \
 flexmark-java-util-format \
 flexmark-java-util-html \
 flexmark-java-util-misc \
 flexmark-java-util-options \
 flexmark-java-util-sequence \
 flexmark-java-util-visitor \
 flexmark-java-youtrack-converter \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-abbreviation = " \
 flexmark-java \
 flexmark-java-ext-autolink \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-admonition = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-anchorlink = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-aside = " \
 flexmark-java \
 flexmark-java-jira-converter \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-attributes = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-autolink = " \
 autolink-java \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-definition = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-emoji = " \
 flexmark-java \
 flexmark-java-jira-converter \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-enumerated-reference = " \
 flexmark-java \
 flexmark-java-ext-attributes \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-escaped-character = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-footnotes = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-gfm-issues = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-gfm-strikethrough = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-gfm-tasklist = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-gfm-users = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-gitlab = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-ins = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-jekyll-front-matter = " \
 flexmark-java \
 flexmark-java-ext-yaml-front-matter \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-jekyll-tag = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-macros = " \
 flexmark-java \
 flexmark-java-ext-gitlab \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-media-tags = " \
 flexmark-java \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-resizable-image = " \
 flexmark-java \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-spec-example = " \
 flexmark-java \
 flexmark-java-test-util \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-superscript = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-tables = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-toc = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-typographic = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-wikilink = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-xwiki-macros = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-yaml-front-matter = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-youtube-embedded = " \
 flexmark-java \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-ext-zzzzzz = " \
 flexmark-java \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-html2md-converter = " \
 flexmark-java \
 flexmark-java-ext-emoji \
 flexmark-java-util \
 javapackages-filesystem \
 jsoup \
 "
RDEPENDS:flexmark-java-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-jira-converter = " \
 flexmark-java \
 flexmark-java-ext-gfm-strikethrough \
 flexmark-java-ext-ins \
 flexmark-java-ext-superscript \
 flexmark-java-ext-tables \
 flexmark-java-ext-wikilink \
 flexmark-java-util \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-osgi = " \
 flexmark-java \
 flexmark-java-ext-abbreviation \
 flexmark-java-ext-admonition \
 flexmark-java-ext-anchorlink \
 flexmark-java-ext-aside \
 flexmark-java-ext-attributes \
 flexmark-java-ext-autolink \
 flexmark-java-ext-definition \
 flexmark-java-ext-emoji \
 flexmark-java-ext-enumerated-reference \
 flexmark-java-ext-escaped-character \
 flexmark-java-ext-footnotes \
 flexmark-java-ext-gfm-issues \
 flexmark-java-ext-gfm-strikethrough \
 flexmark-java-ext-gfm-tasklist \
 flexmark-java-ext-gfm-users \
 flexmark-java-ext-gitlab \
 flexmark-java-ext-ins \
 flexmark-java-ext-jekyll-front-matter \
 flexmark-java-ext-jekyll-tag \
 flexmark-java-ext-media-tags \
 flexmark-java-ext-resizable-image \
 flexmark-java-ext-superscript \
 flexmark-java-ext-tables \
 flexmark-java-ext-toc \
 flexmark-java-ext-typographic \
 flexmark-java-ext-wikilink \
 flexmark-java-ext-xwiki-macros \
 flexmark-java-ext-yaml-front-matter \
 flexmark-java-ext-youtube-embedded \
 flexmark-java-html2md-converter \
 flexmark-java-jira-converter \
 flexmark-java-util \
 flexmark-java-util-ast \
 flexmark-java-util-builder \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 flexmark-java-util-dependency \
 flexmark-java-util-format \
 flexmark-java-util-html \
 flexmark-java-util-misc \
 flexmark-java-util-options \
 flexmark-java-util-sequence \
 flexmark-java-util-visitor \
 flexmark-java-youtrack-converter \
 javapackages-filesystem \
 "
RDEPENDS:flexmark-java-test-util = " \
 flexmark-java-util-ast \
 flexmark-java-util-data \
 flexmark-java-util-format \
 flexmark-java-util-misc \
 flexmark-java-util-sequence \
 javapackages-filesystem \
 jetbrains-annotations \
 junit \
 "
RDEPENDS:flexmark-java-tree-iteration = " \
 flexmark-java-util-ast \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 javapackages-filesystem \
 jetbrains-annotations \
 slf4j \
 "
RDEPENDS:flexmark-java-util = " \
 flexmark-java-util-ast \
 flexmark-java-util-builder \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 flexmark-java-util-dependency \
 flexmark-java-util-format \
 flexmark-java-util-html \
 flexmark-java-util-misc \
 flexmark-java-util-options \
 flexmark-java-util-sequence \
 flexmark-java-util-visitor \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-ast = " \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 flexmark-java-util-misc \
 flexmark-java-util-sequence \
 flexmark-java-util-visitor \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-builder = " \
 flexmark-java-util-data \
 flexmark-java-util-misc \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-collection = " \
 flexmark-java-util-misc \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-data = " \
 flexmark-java-util-misc \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-dependency = " \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 flexmark-java-util-misc \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-experimental = " \
 flexmark-java-util-ast \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 flexmark-java-util-misc \
 flexmark-java-util-sequence \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-format = " \
 flexmark-java-util-ast \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 flexmark-java-util-html \
 flexmark-java-util-misc \
 flexmark-java-util-sequence \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-html = " \
 flexmark-java-util-misc \
 flexmark-java-util-sequence \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-misc = " \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-options = " \
 flexmark-java-util-misc \
 flexmark-java-util-sequence \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-sequence = " \
 flexmark-java-util-collection \
 flexmark-java-util-data \
 flexmark-java-util-misc \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-util-visitor = " \
 javapackages-filesystem \
 jetbrains-annotations \
 "
RDEPENDS:flexmark-java-youtrack-converter = " \
 flexmark-java \
 flexmark-java-ext-gfm-strikethrough \
 flexmark-java-ext-tables \
 flexmark-java-util \
 javapackages-filesystem \
 "
