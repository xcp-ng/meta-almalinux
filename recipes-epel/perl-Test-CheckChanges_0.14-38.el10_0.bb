# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-CheckChanges"
PV = "0.14"
PR = "38.el10_0"
PACKAGES = " \
 perl-Test-CheckChanges \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-CheckChanges-0.14-38.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8742a1ea301245d04a24f56f4a3d9c0e7ae40c790afb6df1764a13a58ccbd237"

URI_x86_64_v2_perl-Test-CheckChanges = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-CheckChanges-0.14-38.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-CheckChanges;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-CheckChanges}"
SRC_URI[x86_64_v2_perl-Test-CheckChanges.sha256sum] = "63346aeb562c34c08fd6007f7e3ad1972013437e16a81f72c93641887f993fe8"

URI_aarch64_perl-Test-CheckChanges = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-CheckChanges-0.14-38.el10_0.noarch.rpm;name=aarch64_perl-Test-CheckChanges;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-CheckChanges}"
SRC_URI[aarch64_perl-Test-CheckChanges.sha256sum] = "ee89f330d9395c0f444a88aaf63a0aec267c909cfa535fb018e77efc0fdc9e77"

RDEPENDS:perl-Test-CheckChanges = " \
 perl-Carp \
 perl-File-Basename \
 perl-Module-Build-Deprecated \
 perl-PathTools \
 perl-Test-Simple \
 perl-libs \
 "
