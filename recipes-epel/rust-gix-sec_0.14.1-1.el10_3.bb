# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-sec"
PV = "0.14.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-sec+default-devel \
 rust-gix-sec+document-features-devel \
 rust-gix-sec+serde-devel \
 rust-gix-sec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-sec-0.14.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82e3deb142081647cbd7af5438ae987000c2fdc3d5164140c0413300e98588b4"

URI_x86_64_v2_rust-gix-sec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+default-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+default-devel.sha256sum] = "da89d2eb3d661cf5120ef9ae9d66c5bb4cbb06a011a905df8eade0188e3863ae"

URI_x86_64_v2_rust-gix-sec+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+document-features-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+document-features-devel.sha256sum] = "60509dc9b8a843304a97ca7658ac3aa7707b544e77120cb21ac4b5ab507c170c"

URI_x86_64_v2_rust-gix-sec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+serde-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+serde-devel.sha256sum] = "ce9409a473ca15c5272d31c0aff93e814171c71fd82ca2e8f6faa56b474f866d"

URI_x86_64_v2_rust-gix-sec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec-devel}"
SRC_URI[x86_64_v2_rust-gix-sec-devel.sha256sum] = "ad53bfc7b752e89c2c3949fda8db55d552a84fc2bbe8afb4f83804180daa28f5"

URI_aarch64_rust-gix-sec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+default-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-sec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+default-devel}"
SRC_URI[aarch64_rust-gix-sec+default-devel.sha256sum] = "02c733128e7e5d5a4f0ef76044ac2799254bcb4b3b5aba87e752555c7866c5d1"

URI_aarch64_rust-gix-sec+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+document-features-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-sec+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+document-features-devel}"
SRC_URI[aarch64_rust-gix-sec+document-features-devel.sha256sum] = "dad593fe0d1eb32c1ab562a5838ab58b2e646257b4f2aed48f52ec0a0ee542de"

URI_aarch64_rust-gix-sec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+serde-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-sec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+serde-devel}"
SRC_URI[aarch64_rust-gix-sec+serde-devel.sha256sum] = "8d6fa0bb10af77ae6a56819c4cface722693e27da0cc88c27e200a5a885b349b"

URI_aarch64_rust-gix-sec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-sec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec-devel}"
SRC_URI[aarch64_rust-gix-sec-devel.sha256sum] = "3343542ea081c1ed5924c6a45ec42d150cf83811ef9a6fb22c26476cc1d62ec7"

RDEPENDS:rust-gix-sec+default-devel = " \
 cargo \
 rust-gix-sec-devel \
 "
RDEPENDS:rust-gix-sec+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-sec-devel \
 "
RDEPENDS:rust-gix-sec+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-gix-sec-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-sec-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 "
