# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-tencent-cos"
PV = "3.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-tencent-cos+default-devel \
 rust-reqsign-tencent-cos-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-tencent-cos-3.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "66a78862f272f3872fce6be8c0a7efe96e2786a91893439463b53ba7ee64cb6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-tencent-cos+default-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-tencent-cos+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-tencent-cos+default-devel.sha256sum] = "ae80030fdf3373133ccf544c1a57f5200d998a0da5ffd4572c9304123504a8d0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-tencent-cos-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-tencent-cos-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-tencent-cos-devel.sha256sum] = "ea24da88536affd5c9f1ef6491c6c1dc9b5baaa9d42e443241c194875faff218"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-tencent-cos+default-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-tencent-cos+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-tencent-cos+default-devel.sha256sum] = "8801cd3382b6f2f5b0d701e6fa7ba621ccd93c26b75103cf0696ad110e2c8f94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-tencent-cos-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-tencent-cos-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-tencent-cos-devel.sha256sum] = "ffa8311cfb326c52ea50cdb2c6ae5c70ea14882f9776b29c9ff4782ea0d4662b"

RDEPENDS:rust-reqsign-tencent-cos+default-devel = " \
 cargo \
 rust-reqsign-tencent-cos-devel \
 "
RDEPENDS:rust-reqsign-tencent-cos-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
