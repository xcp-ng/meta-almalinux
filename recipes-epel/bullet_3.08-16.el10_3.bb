# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bullet"
PV = "3.08"
PR = "16.el10_3"
PACKAGES = " \
 bullet \
 bullet-devel \
 bullet-devel-doc \
 bullet-extras \
 bullet-extras-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bullet-3.08-16.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c1f2a66e7c8b95dab1cb103ce9b0f191d2137b75b3829df0a07085154eb6658"

URI_x86_64_v2_bullet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-3.08-16.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet}"
SRC_URI[x86_64_v2_bullet.sha256sum] = "d430d8ad7b8d70f460e744bbf8dee22492a6e3ebb9be321fab3ce5b68aef2f7b"

URI_x86_64_v2_bullet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-devel-3.08-16.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-devel}"
SRC_URI[x86_64_v2_bullet-devel.sha256sum] = "4eb96345fdb7ad83a9e35dc74e5b382ccc29ddf321f71abd4260ac4b7a0e3a8b"

URI_x86_64_v2_bullet-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-devel-doc-3.08-16.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-devel-doc}"
SRC_URI[x86_64_v2_bullet-devel-doc.sha256sum] = "8e6ae7b19ef933a3010478c4206a98599f2521b6009bb701fa18f7483e296ac5"

URI_x86_64_v2_bullet-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-extras-3.08-16.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-extras}"
SRC_URI[x86_64_v2_bullet-extras.sha256sum] = "c87ac8845ed8907cad3a0251eb61bf08449ec8d2ca0a2e50d5d96e4f2cd23181"

URI_x86_64_v2_bullet-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-extras-devel-3.08-16.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-extras-devel}"
SRC_URI[x86_64_v2_bullet-extras-devel.sha256sum] = "ce380618b0c0ad66a59f714f3428fdd4a4fa16d3512cebd5849ebb1d1a99dcca"

URI_aarch64_bullet = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-3.08-16.el10_3.aarch64.rpm;name=aarch64_bullet;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet}"
SRC_URI[aarch64_bullet.sha256sum] = "5ac10cfb6f8c0273a71e09c30396c47a814787065fe22dab89462d34e02b130a"

URI_aarch64_bullet-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-devel-3.08-16.el10_3.aarch64.rpm;name=aarch64_bullet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-devel}"
SRC_URI[aarch64_bullet-devel.sha256sum] = "cd1d6ee0184045ee15d2dcd579631d728a848b144464dc87217db01c1a096837"

URI_aarch64_bullet-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-devel-doc-3.08-16.el10_3.aarch64.rpm;name=aarch64_bullet-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-devel-doc}"
SRC_URI[aarch64_bullet-devel-doc.sha256sum] = "3739b9fd3c6e15565c65f82a419a0f17007e346e9ecc79f314227eab61f71396"

URI_aarch64_bullet-extras = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-extras-3.08-16.el10_3.aarch64.rpm;name=aarch64_bullet-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-extras}"
SRC_URI[aarch64_bullet-extras.sha256sum] = "2fd203c9b69d4fbcd43675c860b63d8edbb4195c6c590242f65a4873a076a45f"

URI_aarch64_bullet-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-extras-devel-3.08-16.el10_3.aarch64.rpm;name=aarch64_bullet-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-extras-devel}"
SRC_URI[aarch64_bullet-extras-devel.sha256sum] = "e56beabdc40dc347bc64b8ecfc163d5028bc635f13753ca7bb32f943019540ce"

RDEPENDS:bullet = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:bullet-devel = " \
 bullet \
 cmake \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:bullet-devel-doc = " \
 bullet-extras \
 "
RDEPENDS:bullet-extras = " \
 bullet \
 glibc \
 libgcc \
 libstdc++ \
 tinyxml2 \
 "
RDEPENDS:bullet-extras-devel = " \
 bullet-devel \
 bullet-extras \
 "
