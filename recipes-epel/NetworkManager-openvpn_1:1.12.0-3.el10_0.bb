# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-openvpn"
PE = "1"
PV = "1.12.0"
PR = "3.el10_0"
PACKAGES = " \
 NetworkManager-openvpn \
 NetworkManager-openvpn-gnome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/NetworkManager-openvpn-1.12.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2aca51cf068c60a0c10bd4c498340c82c605f53fb12cd477d10e6aee476b7149"

URI_x86_64_v2_NetworkManager-openvpn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-openvpn-1.12.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-openvpn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-openvpn}"
SRC_URI[x86_64_v2_NetworkManager-openvpn.sha256sum] = "a9d2c22aa6f48554bde9db174cb501f037119cadc732ca7d092877f7d0ab0f44"

URI_x86_64_v2_NetworkManager-openvpn-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-openvpn-gnome-1.12.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-openvpn-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-openvpn-gnome}"
SRC_URI[x86_64_v2_NetworkManager-openvpn-gnome.sha256sum] = "23ce8414531dea389c35e19518fc5cf3f8a4bea6fd849151f886686bd511ed3a"

URI_aarch64_NetworkManager-openvpn = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-openvpn-1.12.0-3.el10_0.aarch64.rpm;name=aarch64_NetworkManager-openvpn;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-openvpn}"
SRC_URI[aarch64_NetworkManager-openvpn.sha256sum] = "9572ff72b3479f7a40074de441a56bb3434aef23a62865f152f13c2de7dd4371"

URI_aarch64_NetworkManager-openvpn-gnome = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-openvpn-gnome-1.12.0-3.el10_0.aarch64.rpm;name=aarch64_NetworkManager-openvpn-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-openvpn-gnome}"
SRC_URI[aarch64_NetworkManager-openvpn-gnome.sha256sum] = "e7dcb629caa66e65426af0f066364695989f9abe5af6ef65550bb882d322a427"

RDEPENDS:NetworkManager-openvpn = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 dbus \
 glib2 \
 glibc \
 libgcc \
 openvpn \
 shadow-utils \
 "
RDEPENDS:NetworkManager-openvpn-gnome = " \
 NetworkManager-libnm \
 NetworkManager-openvpn \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 pango \
 shared-mime-info \
 vulkan-loader \
 "
