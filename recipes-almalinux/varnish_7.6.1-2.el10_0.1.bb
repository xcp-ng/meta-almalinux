# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "varnish"
PV = "7.6.1"
PR = "2.el10_0.1"
PACKAGES = " \
 varnish \
 varnish-devel \
 varnish-docs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/varnish-7.6.1-2.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc8e571cbf7136b6cab1dd2b32a0a0e397b187cf40ad6df1cca149b61c381380"

URI_x86_64_v2_varnish = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/varnish-7.6.1-2.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_varnish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_varnish}"
SRC_URI[x86_64_v2_varnish.sha256sum] = "e3eff6dafa83b74fdbfdc41ddca6c14c785e625dc09b8a0918a8936cdbf053c1"

URI_x86_64_v2_varnish-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/varnish-devel-7.6.1-2.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_varnish-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_varnish-devel}"
SRC_URI[x86_64_v2_varnish-devel.sha256sum] = "45abb669803d5b68d5d69650cec46584bd6cff41bf71b51391521c8a05b9fddf"

URI_x86_64_v2_varnish-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/varnish-docs-7.6.1-2.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_varnish-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_varnish-docs}"
SRC_URI[x86_64_v2_varnish-docs.sha256sum] = "f154792874d8b60378df156fbde0ddd0371435bf73f58a160e99674e83daf30d"

URI_aarch64_varnish = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/varnish-7.6.1-2.el10_0.1.aarch64.rpm;name=aarch64_varnish;unpack=0"
SRC_URI:append = " ${URI_aarch64_varnish}"
SRC_URI[aarch64_varnish.sha256sum] = "d566894491afd8e7721de8c9228f63ff23c982039919389fac60c02e62a0a03e"

URI_aarch64_varnish-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/varnish-devel-7.6.1-2.el10_0.1.aarch64.rpm;name=aarch64_varnish-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_varnish-devel}"
SRC_URI[aarch64_varnish-devel.sha256sum] = "f835166d0555601c16ddf945adb77c9bae282d2aa65ccfafe8e4e71e87bb0ded"

URI_aarch64_varnish-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/varnish-docs-7.6.1-2.el10_0.1.aarch64.rpm;name=aarch64_varnish-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_varnish-docs}"
SRC_URI[aarch64_varnish-docs.sha256sum] = "72639ec60e34ab577bde621d7dafc58e22b37abe31479eeaa2f58617caff1f21"

RDEPENDS:varnish = " \
 bash \
 gcc \
 glibc \
 libedit \
 libgcc \
 logrotate \
 ncurses \
 ncurses-libs \
 pcre2 \
 redhat-rpm-config \
 shadow-utils \
 systemd \
 util-linux \
 "
RDEPENDS:varnish-devel = " \
 pkgconf-pkg-config \
 python3 \
 varnish \
 "
RDEPENDS:varnish-docs = " \
 "
