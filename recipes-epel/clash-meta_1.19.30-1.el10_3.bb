# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clash-meta"
PV = "1.19.30"
PR = "1.el10_3"
PACKAGES = " \
 clash-meta \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/clash-meta-1.19.30-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a7d4bc56f04dbda74c7716f53ed360d8404de2021d00c2d6010ffe9f68b64e6b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clash-meta-1.19.30-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clash-meta;unpack=0"
SRC_URI[x86_64_v2_clash-meta.sha256sum] = "d30b769bd188accf6e9b61a7e24309635bf9845d6743ac890f21078b21f60534"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clash-meta-1.19.30-1.el10_3.aarch64.rpm;name=aarch64_clash-meta;unpack=0"
SRC_URI[aarch64_clash-meta.sha256sum] = "b43cde08ccc7e4fbe6472cabf039d61a17bf71ef04dd0eaf954265d2e9d2df13"

RDEPENDS:clash-meta = " \
 glibc \
 "
