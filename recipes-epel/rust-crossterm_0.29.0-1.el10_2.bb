# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossterm"
PV = "0.29.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossterm+bracketed-paste-devel \
 rust-crossterm+default-devel \
 rust-crossterm+derive-more-devel \
 rust-crossterm+event-stream-devel \
 rust-crossterm+events-devel \
 rust-crossterm+filedescriptor-devel \
 rust-crossterm+libc-devel \
 rust-crossterm+osc52-devel \
 rust-crossterm+serde-devel \
 rust-crossterm+use-dev-tty-devel \
 rust-crossterm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossterm-0.29.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1380849e4ea4b147d8926e77f8054b81ab452cfd49264a5e8a29b39ea695844"

URI_x86_64_v2_rust-crossterm+bracketed-paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+bracketed-paste-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+bracketed-paste-devel}"
SRC_URI[x86_64_v2_rust-crossterm+bracketed-paste-devel.sha256sum] = "709148efc9a95926b51037e8c18d917f00d22f5e1c2aa936682885af79e45ca9"

URI_x86_64_v2_rust-crossterm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+default-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+default-devel}"
SRC_URI[x86_64_v2_rust-crossterm+default-devel.sha256sum] = "b4cd24a22d315bc18d90554a1a2e3169a46beb0cfc25d6b62b89a3736ae735d8"

URI_x86_64_v2_rust-crossterm+derive-more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+derive-more-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+derive-more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+derive-more-devel}"
SRC_URI[x86_64_v2_rust-crossterm+derive-more-devel.sha256sum] = "eb5d5a0fb2c11cad1db33d6725af06605b5d7a3c4a1e343112914cd78e187655"

URI_x86_64_v2_rust-crossterm+event-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+event-stream-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+event-stream-devel}"
SRC_URI[x86_64_v2_rust-crossterm+event-stream-devel.sha256sum] = "cd8da5788d9f36cfa1fe854cbfc22c0ffed44cc56560133d57cf6878bc41bcfc"

URI_x86_64_v2_rust-crossterm+events-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+events-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+events-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+events-devel}"
SRC_URI[x86_64_v2_rust-crossterm+events-devel.sha256sum] = "24ae8e91628dc2fdd64374c6a856078739eb6da76384317ee97c001d9f42aafc"

URI_x86_64_v2_rust-crossterm+filedescriptor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+filedescriptor-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+filedescriptor-devel}"
SRC_URI[x86_64_v2_rust-crossterm+filedescriptor-devel.sha256sum] = "ac4d5c0551370fc50ceb9ba1785e1918ec85625e0282d08f420605280110704c"

URI_x86_64_v2_rust-crossterm+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+libc-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+libc-devel}"
SRC_URI[x86_64_v2_rust-crossterm+libc-devel.sha256sum] = "550e8064894373ac2b38bcb22b47f03702ab6bd7d201108d02953d909d610d2c"

URI_x86_64_v2_rust-crossterm+osc52-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+osc52-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+osc52-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+osc52-devel}"
SRC_URI[x86_64_v2_rust-crossterm+osc52-devel.sha256sum] = "1dbcac746eaed88f676ebc242803f90f869a0d4fe5756c41becc2a244f9f0e18"

URI_x86_64_v2_rust-crossterm+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+serde-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+serde-devel}"
SRC_URI[x86_64_v2_rust-crossterm+serde-devel.sha256sum] = "13d8f3992716e14801ca06b382fca0f5052dde802a22b7da8ad3b17a32bbd328"

URI_x86_64_v2_rust-crossterm+use-dev-tty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+use-dev-tty-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+use-dev-tty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+use-dev-tty-devel}"
SRC_URI[x86_64_v2_rust-crossterm+use-dev-tty-devel.sha256sum] = "19ed6aa9c18d6bf243d206e82edd9c36f3f021c5389ce97b6b30c438cdadeae0"

URI_x86_64_v2_rust-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm-devel-0.29.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm-devel}"
SRC_URI[x86_64_v2_rust-crossterm-devel.sha256sum] = "5ff6201d19d886802e774bb221abb771a9be4ffe997933a68c1e403631d05b8b"

URI_aarch64_rust-crossterm+bracketed-paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+bracketed-paste-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+bracketed-paste-devel}"
SRC_URI[aarch64_rust-crossterm+bracketed-paste-devel.sha256sum] = "c230f9e3afaa53f6848ec5c3841eba0ddab2f496c03a97cc9c771ff7404c4c08"

URI_aarch64_rust-crossterm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+default-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+default-devel}"
SRC_URI[aarch64_rust-crossterm+default-devel.sha256sum] = "10680177e3f92d0d04999445b1526acb0fa43105960f41122896d75eeffd0372"

URI_aarch64_rust-crossterm+derive-more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+derive-more-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm+derive-more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+derive-more-devel}"
SRC_URI[aarch64_rust-crossterm+derive-more-devel.sha256sum] = "d5db08616ced90c1605d7bf474572d34e42d8a410cc01bd22ff02f32c0d7ce48"

URI_aarch64_rust-crossterm+event-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+event-stream-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+event-stream-devel}"
SRC_URI[aarch64_rust-crossterm+event-stream-devel.sha256sum] = "24ffa2cd331d97d689cdd8fd0d09f7a74db5d8116bde2525dd37c5a1ac8e99c4"

URI_aarch64_rust-crossterm+events-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+events-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm+events-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+events-devel}"
SRC_URI[aarch64_rust-crossterm+events-devel.sha256sum] = "fc5a763577b7611f04ffaaa949b3af373be574177b8cfbfe11ed7fd4015ac0e3"

URI_aarch64_rust-crossterm+filedescriptor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+filedescriptor-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm+filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+filedescriptor-devel}"
SRC_URI[aarch64_rust-crossterm+filedescriptor-devel.sha256sum] = "afc641f50e31fece40cec2c2a2595ef54fc1ecf596203401be1e09260e15746f"

URI_aarch64_rust-crossterm+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+libc-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+libc-devel}"
SRC_URI[aarch64_rust-crossterm+libc-devel.sha256sum] = "3f955e6cdd2aa29c84208f50e5cad663e707175693755448425778dee52c3cae"

URI_aarch64_rust-crossterm+osc52-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+osc52-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm+osc52-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+osc52-devel}"
SRC_URI[aarch64_rust-crossterm+osc52-devel.sha256sum] = "770062c80b0d1f00f863b83842933d09831b41f7283080b926880dd4897d168e"

URI_aarch64_rust-crossterm+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+serde-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+serde-devel}"
SRC_URI[aarch64_rust-crossterm+serde-devel.sha256sum] = "dc152bdce7deb1428d9acd80feba1648d18dcec4aca4ddb17e0345ba36ba4e60"

URI_aarch64_rust-crossterm+use-dev-tty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+use-dev-tty-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm+use-dev-tty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+use-dev-tty-devel}"
SRC_URI[aarch64_rust-crossterm+use-dev-tty-devel.sha256sum] = "34d5d26dcb7b709060403ebf906383b77e45501b99c346431171d95c72221f5c"

URI_aarch64_rust-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm-devel-0.29.0-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm-devel}"
SRC_URI[aarch64_rust-crossterm-devel.sha256sum] = "110dceb65b8220c6b8fac49fe9747419265a1c490526e141b69080ababfa1af2"

RDEPENDS:rust-crossterm+bracketed-paste-devel = " \
 cargo \
 rust-crossterm-devel \
 "
RDEPENDS:rust-crossterm+default-devel = " \
 cargo \
 rust-crossterm+bracketed-paste-devel \
 rust-crossterm+derive-more-devel \
 rust-crossterm+events-devel \
 rust-crossterm-devel \
 "
RDEPENDS:rust-crossterm+derive-more-devel = " \
 cargo \
 rust-crossterm-devel \
 rust-derive_more+default-devel \
 rust-derive_more+is_variant-devel \
 "
RDEPENDS:rust-crossterm+event-stream-devel = " \
 cargo \
 rust-crossterm+events-devel \
 rust-crossterm-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-crossterm+events-devel = " \
 cargo \
 rust-crossterm-devel \
 rust-mio+default-devel \
 rust-mio+os-poll-devel \
 rust-signal-hook-mio+default-devel \
 rust-signal-hook-mio+support-v1_0-devel \
 rust-signal-hook0.3+default-devel \
 "
RDEPENDS:rust-crossterm+filedescriptor-devel = " \
 cargo \
 rust-crossterm-devel \
 rust-filedescriptor+default-devel \
 "
RDEPENDS:rust-crossterm+libc-devel = " \
 cargo \
 rust-crossterm-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-crossterm+osc52-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-crossterm-devel \
 "
RDEPENDS:rust-crossterm+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-crossterm-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-crossterm+use-dev-tty-devel = " \
 cargo \
 rust-crossterm+filedescriptor-devel \
 rust-crossterm-devel \
 rust-rustix+process-devel \
 "
RDEPENDS:rust-crossterm-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-document-features+default-devel \
 rust-parking_lot+default-devel \
 rust-rustix+std-devel \
 rust-rustix+stdio-devel \
 rust-rustix+termios-devel \
 rust-rustix-devel \
 "
