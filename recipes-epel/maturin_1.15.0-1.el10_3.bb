# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maturin"
PV = "1.15.0"
PR = "1.el10_3"
PACKAGES = " \
 maturin \
 maturin+patchelf \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/maturin-1.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b258864670d8a9a29d366f44a8db769d5bda62b3536b0cf6f780a61119ab9fd4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maturin-1.15.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maturin;unpack=0"
SRC_URI[x86_64_v2_maturin.sha256sum] = "8a92a557612fb9479777e8fbcafb4f7b429093842a17f8ede4d4ca33b3c3ff15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maturin+patchelf-1.15.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maturin+patchelf;unpack=0"
SRC_URI[x86_64_v2_maturin+patchelf.sha256sum] = "e5c71f08677aabd5c7a99e582aa49dcc083c134065fb82f7451980c188cc92f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/maturin-1.15.0-1.el10_3.aarch64.rpm;name=aarch64_maturin;unpack=0"
SRC_URI[aarch64_maturin.sha256sum] = "059d97aa7dcf97479734bead56076f0b98b5bbd51201b94a84809759ce1f167b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/maturin+patchelf-1.15.0-1.el10_3.aarch64.rpm;name=aarch64_maturin+patchelf;unpack=0"
SRC_URI[aarch64_maturin+patchelf.sha256sum] = "c807b4f8905d03f88728bea3286adb0a65b0d1a357bfc8641d3f9fa09fc80133"

RDEPENDS:maturin = " \
 cargo \
 glibc \
 libgcc \
 libzstd \
 python3 \
 "
RDEPENDS:maturin+patchelf = " \
 maturin \
 patchelf \
 python3 \
 "
