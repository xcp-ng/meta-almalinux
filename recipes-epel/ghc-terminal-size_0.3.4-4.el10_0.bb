# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-terminal-size"
PV = "0.3.4"
PR = "4.el10_0"
PACKAGES = " \
 ghc-terminal-size \
 ghc-terminal-size-devel \
 ghc-terminal-size-doc \
 ghc-terminal-size-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-terminal-size-0.3.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9b45438f459c1de34f4bfb96aa7722ff6693e533e037e88bdcc1e2949ff7f28"

URI_x86_64_v2_ghc-terminal-size = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-terminal-size-0.3.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-terminal-size;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-terminal-size}"
SRC_URI[x86_64_v2_ghc-terminal-size.sha256sum] = "186945768c8c7b752b1f98c516785a662d798aeff2993ab390445eb55b261f89"

URI_x86_64_v2_ghc-terminal-size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-terminal-size-devel-0.3.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-terminal-size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-terminal-size-devel}"
SRC_URI[x86_64_v2_ghc-terminal-size-devel.sha256sum] = "cdd1d3a10815ad87198ec9fbfde0da388b3063d978af50785903c563cbf32827"

URI_x86_64_v2_ghc-terminal-size-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-terminal-size-doc-0.3.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-terminal-size-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-terminal-size-doc}"
SRC_URI[x86_64_v2_ghc-terminal-size-doc.sha256sum] = "4198980262a363f5f1cc6277d706d3f91220d68d5c57a90a9cdc6193490854fd"

URI_x86_64_v2_ghc-terminal-size-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-terminal-size-prof-0.3.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-terminal-size-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-terminal-size-prof}"
SRC_URI[x86_64_v2_ghc-terminal-size-prof.sha256sum] = "70eb121e7f83375c25747aac2b808142f33975a5b5be03fff4c5ea83995e43ed"

URI_aarch64_ghc-terminal-size = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-terminal-size-0.3.4-4.el10_0.aarch64.rpm;name=aarch64_ghc-terminal-size;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-terminal-size}"
SRC_URI[aarch64_ghc-terminal-size.sha256sum] = "3e8e5a377250330d008a8efc8e334bdf8cb255b419c1831e1540cbb71028d4c1"

URI_aarch64_ghc-terminal-size-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-terminal-size-devel-0.3.4-4.el10_0.aarch64.rpm;name=aarch64_ghc-terminal-size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-terminal-size-devel}"
SRC_URI[aarch64_ghc-terminal-size-devel.sha256sum] = "f63008ac3a9affdcf12aed45f805b161ef0be9a20d8f99fab7137617d3def368"

URI_aarch64_ghc-terminal-size-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-terminal-size-doc-0.3.4-4.el10_0.noarch.rpm;name=aarch64_ghc-terminal-size-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-terminal-size-doc}"
SRC_URI[aarch64_ghc-terminal-size-doc.sha256sum] = "4ddcc9971869ba6e38451c060e6a31c1e06238f2406f6d8b7964a9d64d2784b8"

URI_aarch64_ghc-terminal-size-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-terminal-size-prof-0.3.4-4.el10_0.aarch64.rpm;name=aarch64_ghc-terminal-size-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-terminal-size-prof}"
SRC_URI[aarch64_ghc-terminal-size-prof.sha256sum] = "89e4622348b80bb029593e61c66b8b6fff69e055c668ccc077cc2fb4037c7b2a"

RDEPENDS:ghc-terminal-size = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-terminal-size-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-terminal-size \
 "
RDEPENDS:ghc-terminal-size-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-terminal-size-prof = " \
 ghc-base-prof \
 ghc-terminal-size-devel \
 "
