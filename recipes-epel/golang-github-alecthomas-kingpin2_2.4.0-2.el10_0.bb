# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-alecthomas-kingpin2"
PV = "2.4.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-alecthomas-kingpin2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-alecthomas-kingpin2-2.4.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e36bea716b4e3b947e7f4202f920dc8bf1544ca7ac41330850ccf3275def4d7"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-alecthomas-kingpin2-devel: golang(github.com/alecthomas/units)

URI_x86_64_v2_golang-github-alecthomas-kingpin2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-alecthomas-kingpin2-devel-2.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-alecthomas-kingpin2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-alecthomas-kingpin2-devel}"
SRC_URI[x86_64_v2_golang-github-alecthomas-kingpin2-devel.sha256sum] = "d7a97d40b8c5a696c876908e30e4f90e8fa5f73415b2acd3d3ada8545a86df8d"

URI_aarch64_golang-github-alecthomas-kingpin2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-alecthomas-kingpin2-devel-2.4.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-alecthomas-kingpin2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-alecthomas-kingpin2-devel}"
SRC_URI[aarch64_golang-github-alecthomas-kingpin2-devel.sha256sum] = "6b22ee483130cd8a741ad555fb2eb1fe236ab49d4fb82e4ac6e6cd91c3132742"

RDEPENDS:golang-github-alecthomas-kingpin2-devel:x86_64_v2 = " \
 go-filesystem \
 golang-github-xhit-str2duration2-devel \
"
RDEPENDS:golang-github-alecthomas-kingpin2-devel:aarch64 = " \
 go-filesystem \
 golang-github-alecthomas-units-devel \
 golang-github-xhit-str2duration2-devel \
"
