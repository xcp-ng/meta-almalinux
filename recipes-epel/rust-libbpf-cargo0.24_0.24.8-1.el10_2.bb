# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbpf-cargo0.24"
PV = "0.24.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-libbpf-cargo0.24+default-devel \
 rust-libbpf-cargo0.24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbpf-cargo0.24-0.24.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6678faf7106d7e2ad0d5c3a2469f6820f245ec95bf388c45b7050ef0f887e666"

URI_x86_64_v2_rust-libbpf-cargo0.24+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-cargo0.24+default-devel-0.24.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-cargo0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-cargo0.24+default-devel}"
SRC_URI[x86_64_v2_rust-libbpf-cargo0.24+default-devel.sha256sum] = "ae196c5a8c4b6463c1b6f1299406d495e8ca62ab9d15d2b1cf24979b04071f46"

URI_x86_64_v2_rust-libbpf-cargo0.24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-cargo0.24-devel-0.24.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-cargo0.24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-cargo0.24-devel}"
SRC_URI[x86_64_v2_rust-libbpf-cargo0.24-devel.sha256sum] = "0eedc11f5a122b436c34fefaa5b70034566eb7bbc6bba385f36369fb479cb207"

URI_aarch64_rust-libbpf-cargo0.24+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-cargo0.24+default-devel-0.24.8-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-cargo0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-cargo0.24+default-devel}"
SRC_URI[aarch64_rust-libbpf-cargo0.24+default-devel.sha256sum] = "29c88973aa72039e46866e5be9b66df834a466c11b127cf99ef450e917d91630"

URI_aarch64_rust-libbpf-cargo0.24-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-cargo0.24-devel-0.24.8-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-cargo0.24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-cargo0.24-devel}"
SRC_URI[aarch64_rust-libbpf-cargo0.24-devel.sha256sum] = "90a66fa81789d40b2739d741dc48fa958d80efd9c9910db6c8f316f792737f70"

RDEPENDS:rust-libbpf-cargo0.24+default-devel = " \
 cargo \
 rust-libbpf-cargo0.24-devel \
 rust-libbpf-rs0.24+default-devel \
 "
RDEPENDS:rust-libbpf-cargo0.24-devel = " \
 cargo \
 clang \
 rust \
 rust-anyhow+default-devel \
 rust-cargo_metadata0.15+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-libbpf-rs0.24-devel \
 rust-memmap2_0.5+default-devel \
 rust-regex+std-devel \
 rust-regex+unicode-perl-devel \
 rust-regex-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-tempfile+default-devel \
 rustfmt \
 "
