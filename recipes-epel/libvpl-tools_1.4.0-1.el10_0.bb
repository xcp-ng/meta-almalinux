# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpl-tools"
PV = "1.4.0"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 libvpl-tools \
 libvpl-tools-devel \
 libvpl-tools-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/libvpl-tools-1.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88474d0f982df900b9d95a135281cba98970bb5d1d834e93229ee98d2ccfb88e"

URI_x86_64_v2_libvpl-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-1.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools}"
SRC_URI[x86_64_v2_libvpl-tools.sha256sum] = "f7b702ffbee451447ed105cdc8f11f94c6b2c9ae978aa1bb6beb96ac72d896e7"

URI_x86_64_v2_libvpl-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-devel-1.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools-devel}"
SRC_URI[x86_64_v2_libvpl-tools-devel.sha256sum] = "33b3ad65f72dbf43d75396d17870248384320beef2f14aeab7edea248be8c1fa"

URI_x86_64_v2_libvpl-tools-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-tools-libs-1.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpl-tools-libs}"
SRC_URI[x86_64_v2_libvpl-tools-libs.sha256sum] = "9908c053a3e55a5b4cdc658e34ce30d196de3146a93b25c197bca8b1f3800d5a"

RDEPENDS:libvpl-tools = " \
 glib2 \
 glibc \
 glibmm2.68 \
 gtk4 \
 gtkmm4.0 \
 libX11 \
 libepoxy \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libva \
 libvpl \
 libvpl-tools-libs \
 "
RDEPENDS:libvpl-tools-devel = " \
 libvpl-tools-libs \
 "
RDEPENDS:libvpl-tools-libs = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libvpl-tools \
 libwayland-client \
 "
