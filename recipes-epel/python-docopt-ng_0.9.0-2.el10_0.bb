# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-docopt-ng"
PV = "0.9.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-docopt-ng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-docopt-ng-0.9.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fdb1cf64e87079a03981f701c3ceb898f0bda5c29013d1632ba5e0413888dcc"

URI_x86_64_v2_python3-docopt-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-docopt-ng-0.9.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-docopt-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-docopt-ng}"
SRC_URI[x86_64_v2_python3-docopt-ng.sha256sum] = "bc7a13c60163a3cb9c8a6f7cc1d578f5f1b203c5abd180e19b2ef9dd35a70087"

URI_aarch64_python3-docopt-ng = "${EPEL_MIRROR}/aarch64/Packages/p/python3-docopt-ng-0.9.0-2.el10_0.noarch.rpm;name=aarch64_python3-docopt-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-docopt-ng}"
SRC_URI[aarch64_python3-docopt-ng.sha256sum] = "7abed883fffefc11f351ebc418f7c2e8874beb3707f2db77d1db64832fea74d7"

RDEPENDS:python3-docopt-ng = " \
 python3 \
 "
