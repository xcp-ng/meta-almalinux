# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-background-logo"
PV = "49.0"
PR = "1.el10.alma.1"
PACKAGES = " \
 gnome-shell-extension-background-logo \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-extension-background-logo-49.0-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dafd4be9ed7ed6eeb6735ea1844c8c0ceaa1269e2b2b4513c3ee9ff2f2f976a"

URI_x86_64_v2_gnome-shell-extension-background-logo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-background-logo-49.0-1.el10.alma.1.noarch.rpm;name=x86_64_v2_gnome-shell-extension-background-logo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-background-logo}"
SRC_URI[x86_64_v2_gnome-shell-extension-background-logo.sha256sum] = "62126722932e09966f4fed32c42d35de4300a280838176d71a58733f5c9f5a55"

URI_aarch64_gnome-shell-extension-background-logo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-background-logo-49.0-1.el10.alma.1.noarch.rpm;name=aarch64_gnome-shell-extension-background-logo;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-background-logo}"
SRC_URI[aarch64_gnome-shell-extension-background-logo.sha256sum] = "62126722932e09966f4fed32c42d35de4300a280838176d71a58733f5c9f5a55"

RDEPENDS:gnome-shell-extension-background-logo = " \
 almalinux-logos \
 gnome-shell \
 "
