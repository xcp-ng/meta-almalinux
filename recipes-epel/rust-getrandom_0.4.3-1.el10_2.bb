# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getrandom"
PV = "0.4.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-getrandom+sys_rng-devel \
 rust-getrandom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getrandom-0.4.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e95f03cda5adca5e23f01013408d9afdcf25d1b12b64175a8af6116ce5d2285"

URI_x86_64_v2_rust-getrandom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom+default-devel-0.4.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom+default-devel}"
SRC_URI[x86_64_v2_rust-getrandom+default-devel.sha256sum] = "bc09c95a0f6ee1c358fda2f612613baeb3771defb338214e1c836308788b119b"
RPROVIDES:rust-getrandom+default-devel:x86_64_v2 = "virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~"

URI_x86_64_v2_rust-getrandom+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom+std-devel-0.4.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom+std-devel}"
SRC_URI[x86_64_v2_rust-getrandom+std-devel.sha256sum] = "378a2abb8173016242f7b6bd1f0c1de49548f99ec33f61fbda643dc5a18bad03"

URI_x86_64_v2_rust-getrandom+sys_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom+sys_rng-devel-0.4.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom+sys_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom+sys_rng-devel}"
SRC_URI[x86_64_v2_rust-getrandom+sys_rng-devel.sha256sum] = "224e31764e5bb4de01bfd7c55ba129e6c62802595d974b675b7caf6759b225f4"

URI_x86_64_v2_rust-getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom-devel-0.4.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom-devel}"
SRC_URI[x86_64_v2_rust-getrandom-devel.sha256sum] = "51610affd8b52c702a6794fce0d672dbc548a5a632426b9ba56b38cdde49893a"
RPROVIDES:rust-getrandom-devel:x86_64_v2 = "virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"

URI_aarch64_rust-getrandom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom+default-devel-0.4.3-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom+default-devel}"
SRC_URI[aarch64_rust-getrandom+default-devel.sha256sum] = "f9dfaf3ff8ed5bd49ee8668b3eba46732cfccbccd46b6791b3bf763980d30449"
RPROVIDES:rust-getrandom+default-devel:aarch64 = "virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~"

URI_aarch64_rust-getrandom+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom+std-devel-0.4.3-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom+std-devel}"
SRC_URI[aarch64_rust-getrandom+std-devel.sha256sum] = "a5332c4ce8bbfd8c4dda94bdd9b61caab36b3af3c0c06993c32ce3710acdb834"

URI_aarch64_rust-getrandom+sys_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom+sys_rng-devel-0.4.3-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom+sys_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom+sys_rng-devel}"
SRC_URI[aarch64_rust-getrandom+sys_rng-devel.sha256sum] = "53ac0093f78c4f2583a22d9e15f64c8fc58e66e073fc84313440ee9a9ab1b787"

URI_aarch64_rust-getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom-devel-0.4.3-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom-devel}"
SRC_URI[aarch64_rust-getrandom-devel.sha256sum] = "381bab6268a455d651594cdcb80064b0a72bc81ddb215125b56d046838286322"
RPROVIDES:rust-getrandom-devel:aarch64 = "virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"

RDEPENDS:rust-getrandom+default-devel = " \
 cargo \
 rust-getrandom-devel \
 "
RDEPENDS:rust-getrandom+std-devel = " \
 cargo \
 rust-getrandom-devel \
 "
RDEPENDS:rust-getrandom+sys_rng-devel = " \
 cargo \
 rust-getrandom-devel \
 rust-rand_core+default-devel \
 "
RDEPENDS:rust-getrandom-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~ rpm/virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~ rpm/virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"
