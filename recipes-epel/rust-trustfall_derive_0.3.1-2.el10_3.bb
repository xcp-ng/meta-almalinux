# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trustfall_derive"
PV = "0.3.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-trustfall_derive+default-devel \
 rust-trustfall_derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-trustfall_derive-0.3.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b89eb6d018145d73369656a2471bdf7132f5ab4deb7ae8e698bc66da875e1465"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_derive+default-devel-0.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_derive+default-devel.sha256sum] = "fa747029bcbbbea28cff27d1b3c7a54e38c7955024399c77c530083f453d2ed5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall_derive-devel-0.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall_derive-devel.sha256sum] = "b80eace2890bf5da29ed4da2005b1788f14a4f0ccb6f9d5844bffe73aef670cd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_derive+default-devel-0.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-trustfall_derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_derive+default-devel.sha256sum] = "56883b726bea132178b83db6f8f514625a2c330e7e673e5b83811b01beb436b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall_derive-devel-0.3.1-2.el10_3.noarch.rpm;name=aarch64_rust-trustfall_derive-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall_derive-devel.sha256sum] = "c16109661243e8d69f8fb9c4325e53aee362507da93da672ee5da8fcee191453"

RDEPENDS:rust-trustfall_derive+default-devel = " \
 cargo \
 rust-trustfall_derive-devel \
 "
RDEPENDS:rust-trustfall_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
