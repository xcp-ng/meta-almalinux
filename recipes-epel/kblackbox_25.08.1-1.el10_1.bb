# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kblackbox"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kblackbox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kblackbox-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1a782adc9b3db4d6613b3d32f293edd8c09a9a3be09b3df495a647b6c134bdf"

URI_x86_64_v2_kblackbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kblackbox-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kblackbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kblackbox}"
SRC_URI[x86_64_v2_kblackbox.sha256sum] = "6f99e0d70f32e323cdd2ec3ec0609840f048d3ba235472c45ff393154be64d20"

URI_aarch64_kblackbox = "${EPEL_MIRROR}/aarch64/Packages/k/kblackbox-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kblackbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_kblackbox}"
SRC_URI[aarch64_kblackbox.sha256sum] = "91dfdca7f3794950604d99c2d7334c81df32529c680f2e43bcdd20e77fe2d36f"

RDEPENDS:kblackbox = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
