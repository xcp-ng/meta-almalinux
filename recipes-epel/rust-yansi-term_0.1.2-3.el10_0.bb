# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yansi-term"
PV = "0.1.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-yansi-term+default-devel \
 rust-yansi-term+derive_serde_style-devel \
 rust-yansi-term+serde-devel \
 rust-yansi-term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yansi-term-0.1.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5df9b7d2379fe4203cf9ade50c99e3dcb7801f017108912b080cdbb77b4f3b76"

URI_x86_64_v2_rust-yansi-term+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi-term+default-devel-0.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi-term+default-devel}"
SRC_URI[x86_64_v2_rust-yansi-term+default-devel.sha256sum] = "5ad7444c145b1e4129d320ba8fa0d77d8d2d461ead58360e1d699ee6e17d9e13"

URI_x86_64_v2_rust-yansi-term+derive_serde_style-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi-term+derive_serde_style-devel-0.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi-term+derive_serde_style-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi-term+derive_serde_style-devel}"
SRC_URI[x86_64_v2_rust-yansi-term+derive_serde_style-devel.sha256sum] = "fa465a5a69c3aaf674ae310bb732e60f751cd6ba24702cf8ab30d68b44c4c01f"

URI_x86_64_v2_rust-yansi-term+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi-term+serde-devel-0.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi-term+serde-devel}"
SRC_URI[x86_64_v2_rust-yansi-term+serde-devel.sha256sum] = "6074752366c4b1bb8aee70a16a7b16bdb5aeb1558888e89c5a62cfbabc6d7090"

URI_x86_64_v2_rust-yansi-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi-term-devel-0.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi-term-devel}"
SRC_URI[x86_64_v2_rust-yansi-term-devel.sha256sum] = "340ddf025646d043acc3f54de50b366fae4c1fff28f5dede0341b68e1db80ad8"

URI_aarch64_rust-yansi-term+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi-term+default-devel-0.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-yansi-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi-term+default-devel}"
SRC_URI[aarch64_rust-yansi-term+default-devel.sha256sum] = "f1193731199a71942f8f5126ad4278025e56d4834a42ba0c30606d641ee9d7e2"

URI_aarch64_rust-yansi-term+derive_serde_style-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi-term+derive_serde_style-devel-0.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-yansi-term+derive_serde_style-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi-term+derive_serde_style-devel}"
SRC_URI[aarch64_rust-yansi-term+derive_serde_style-devel.sha256sum] = "b6fbe54b440841d7e8d5c8ec5083d1200163e2bf67357068cc747594847ade12"

URI_aarch64_rust-yansi-term+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi-term+serde-devel-0.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-yansi-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi-term+serde-devel}"
SRC_URI[aarch64_rust-yansi-term+serde-devel.sha256sum] = "0687b43fc412d4917c5340ae238fffc81e3e4f2d9a949689e4cb7d694433ab16"

URI_aarch64_rust-yansi-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi-term-devel-0.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-yansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi-term-devel}"
SRC_URI[aarch64_rust-yansi-term-devel.sha256sum] = "10d785041be200782c72358404cba161dc9d00790397cb849817d6e88d132ce4"

RDEPENDS:rust-yansi-term+default-devel = " \
 cargo \
 rust-yansi-term-devel \
 "
RDEPENDS:rust-yansi-term+derive_serde_style-devel = " \
 cargo \
 rust-yansi-term+serde-devel \
 rust-yansi-term-devel \
 "
RDEPENDS:rust-yansi-term+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-yansi-term-devel \
 "
RDEPENDS:rust-yansi-term-devel = " \
 cargo \
 "
