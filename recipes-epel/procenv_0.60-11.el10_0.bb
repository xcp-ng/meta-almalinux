# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "procenv"
PV = "0.60"
PR = "11.el10_0"
PACKAGES = " \
 procenv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/procenv-0.60-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cd5b591279e96faf07d99a6aef0a2b351a9b790d26721854ae9c3b1915fcf1c"

URI_x86_64_v2_procenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/procenv-0.60-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_procenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procenv}"
SRC_URI[x86_64_v2_procenv.sha256sum] = "9c7a9a730faffc2faf2de3d4fd2fa53881bd173fa28e1e733ad0503388905167"

URI_aarch64_procenv = "${EPEL_MIRROR}/aarch64/Packages/p/procenv-0.60-11.el10_0.aarch64.rpm;name=aarch64_procenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_procenv}"
SRC_URI[aarch64_procenv.sha256sum] = "7f584a5aa6ce5f274945fdcf363aab105c91bcd2c8720e9ec1999e8b87fe57d1"

RDEPENDS:procenv = " \
 glibc \
 libcap \
 libselinux \
 numactl-libs \
 "
