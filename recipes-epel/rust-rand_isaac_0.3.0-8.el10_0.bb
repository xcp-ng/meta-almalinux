# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_isaac"
PV = "0.3.0"
PR = "8.el10_0"
PACKAGES = " \
 rust-rand_isaac+default-devel \
 rust-rand_isaac+serde-devel \
 rust-rand_isaac+serde1-devel \
 rust-rand_isaac+serde_derive-devel \
 rust-rand_isaac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_isaac-0.3.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd2be4794e35de27c4e42132d22a8958caaea7038cd452b43e3dd2deffc78323"

URI_x86_64_v2_rust-rand_isaac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac+default-devel-0.3.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac+default-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac+default-devel.sha256sum] = "21627c1a4a4a96fabc9f8df79cb43dce5eeb17184e54ed9e9bed498dcdd8afb5"

URI_x86_64_v2_rust-rand_isaac+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac+serde-devel-0.3.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac+serde-devel.sha256sum] = "9061c60acad76196d2528909300ce02db26dc473548ea72ec2b9a06621ee614f"

URI_x86_64_v2_rust-rand_isaac+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac+serde1-devel-0.3.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac+serde1-devel.sha256sum] = "1d9723ad99fb28eaf24f3adf8f59e092529157d84fe44feae00c8060ead77840"

URI_x86_64_v2_rust-rand_isaac+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac+serde_derive-devel-0.3.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac+serde_derive-devel.sha256sum] = "716937f0eb5ca6e6a1490b1025955ed1070462831f7dfca190220348b403be83"

URI_x86_64_v2_rust-rand_isaac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac-devel-0.3.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac-devel.sha256sum] = "855c7459aa53e9b1b22edfadfe2414636e95e00220725d8d2675dac11e0febd2"

URI_aarch64_rust-rand_isaac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac+default-devel-0.3.0-8.el10_0.noarch.rpm;name=aarch64_rust-rand_isaac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac+default-devel}"
SRC_URI[aarch64_rust-rand_isaac+default-devel.sha256sum] = "12fc3961cd1798e02b72a6fe1eba4b9ba19b09102a9881b99a1a82231e94c080"

URI_aarch64_rust-rand_isaac+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac+serde-devel-0.3.0-8.el10_0.noarch.rpm;name=aarch64_rust-rand_isaac+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac+serde-devel}"
SRC_URI[aarch64_rust-rand_isaac+serde-devel.sha256sum] = "9d24173b16dde65b11c1fda5988abe03be4fbbbc88580fc67283b6b932aec4ab"

URI_aarch64_rust-rand_isaac+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac+serde1-devel-0.3.0-8.el10_0.noarch.rpm;name=aarch64_rust-rand_isaac+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac+serde1-devel}"
SRC_URI[aarch64_rust-rand_isaac+serde1-devel.sha256sum] = "e16f79fe2d15f88d7b8684832fa193db6e4df2d00206a8eeca0def632e795bff"

URI_aarch64_rust-rand_isaac+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac+serde_derive-devel-0.3.0-8.el10_0.noarch.rpm;name=aarch64_rust-rand_isaac+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac+serde_derive-devel}"
SRC_URI[aarch64_rust-rand_isaac+serde_derive-devel.sha256sum] = "c36e84b490fdb89da9402600022e321faa084a6f1bb50cb9b4ce5e5ebf69630b"

URI_aarch64_rust-rand_isaac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac-devel-0.3.0-8.el10_0.noarch.rpm;name=aarch64_rust-rand_isaac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac-devel}"
SRC_URI[aarch64_rust-rand_isaac-devel.sha256sum] = "8378f0046f74b39a73f155bd1a01a04912c676124d6eeeeb4e1460811c285f92"

RDEPENDS:rust-rand_isaac+default-devel = " \
 cargo \
 rust-rand_isaac-devel \
 "
RDEPENDS:rust-rand_isaac+serde-devel = " \
 cargo \
 rust-rand_isaac-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_isaac+serde1-devel = " \
 cargo \
 rust-rand_core0.6+serde1-devel \
 rust-rand_isaac+serde-devel \
 rust-rand_isaac-devel \
 "
RDEPENDS:rust-rand_isaac+serde_derive-devel = " \
 cargo \
 rust-rand_isaac-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-rand_isaac-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
