# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kscreen"
PE = "1"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 kscreen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kscreen-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bffb736c4adf792508bdbfbbda3193382f06fc4cb38703b0f7ff587d7b96c1b"

URI_x86_64_v2_kscreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreen-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreen}"
SRC_URI[x86_64_v2_kscreen.sha256sum] = "1ff3f1bb90d6672abedd224c277a11535a8c342316d2d76f4d827c18df109c71"

URI_aarch64_kscreen = "${EPEL_MIRROR}/aarch64/Packages/k/kscreen-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kscreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreen}"
SRC_URI[aarch64_kscreen.sha256sum] = "6b416a7bcc4ea4c11fdc859fc66d1470a27b8cac46e104a74c54cc5a78053002"

RDEPENDS:kscreen = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 layer-shell-qt \
 libX11 \
 libXi \
 libkscreen \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsensors \
 qt6-qtwayland \
 "
