# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtvirtualkeyboard"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtvirtualkeyboard \
 qt6-qtvirtualkeyboard-devel \
 qt6-qtvirtualkeyboard-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtvirtualkeyboard-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8da2d2994ee839d3ff79cd8d42faf1a6b7c4e3df5dcc2caff344c0d6dd10500"

URI_x86_64_v2_qt6-qtvirtualkeyboard = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtvirtualkeyboard}"
SRC_URI[x86_64_v2_qt6-qtvirtualkeyboard.sha256sum] = "d47fffa93413ceea95af4001000dcd12bd1ffcaa48fcff159f518d1d6db0d32b"

URI_x86_64_v2_qt6-qtvirtualkeyboard-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtvirtualkeyboard-devel}"
SRC_URI[x86_64_v2_qt6-qtvirtualkeyboard-devel.sha256sum] = "0beb3f10477b11767b2f9e7b41bc19dd874e050ff7a9c3798976231230042894"

URI_x86_64_v2_qt6-qtvirtualkeyboard-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtvirtualkeyboard-examples}"
SRC_URI[x86_64_v2_qt6-qtvirtualkeyboard-examples.sha256sum] = "5ceed527cd9a67b36a23d36daaf9e657bac7e56f2cd006d489ee54e74964372f"

URI_aarch64_qt6-qtvirtualkeyboard = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtvirtualkeyboard-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtvirtualkeyboard}"
SRC_URI[aarch64_qt6-qtvirtualkeyboard.sha256sum] = "8c3c3647c24af2309663f602fd224a626298e9f3f3b6d4798e75209d0479fdbe"

URI_aarch64_qt6-qtvirtualkeyboard-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtvirtualkeyboard-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtvirtualkeyboard-devel}"
SRC_URI[aarch64_qt6-qtvirtualkeyboard-devel.sha256sum] = "ff7320e9d058d62dd6230261cb36a7fb414a3aaff06617cf782df9b919f774ea"

URI_aarch64_qt6-qtvirtualkeyboard-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtvirtualkeyboard-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtvirtualkeyboard-examples}"
SRC_URI[aarch64_qt6-qtvirtualkeyboard-examples.sha256sum] = "9c95d160cf1e3ac80a888ccf30bda692b854480c32688995665ab3ba64d1d1a0"

RDEPENDS:qt6-qtvirtualkeyboard = " \
 glibc \
 hunspell \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:qt6-qtvirtualkeyboard-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtvirtualkeyboard \
 qt6-qtvirtualkeyboard-devel \
 "
RDEPENDS:qt6-qtvirtualkeyboard-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtvirtualkeyboard \
 "
