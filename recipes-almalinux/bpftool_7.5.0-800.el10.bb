# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bpftool"
PV = "7.5.0"
PR = "800.el10"
PACKAGES = " \
 bpftool \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bpftool-7.5.0-800.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd6cd239240b3eb6e4a9d26c1073277ab09bdfef284603a0f90ece046356ae13"

URI_x86_64_v2_bpftool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bpftool-7.5.0-800.el10.x86_64_v2.rpm;name=x86_64_v2_bpftool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpftool}"
SRC_URI[x86_64_v2_bpftool.sha256sum] = "ddcb6b7ad2ce12dd010fb5c12564aae802ab87b5d915dcadc864b5f29d46b361"

URI_aarch64_bpftool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bpftool-7.5.0-800.el10.aarch64.rpm;name=aarch64_bpftool;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpftool}"
SRC_URI[aarch64_bpftool.sha256sum] = "1e195d2eb8277998c949d0d3c0676d69255ac1461c6f68ff03f1205f6bb9ba64"

RDEPENDS:bpftool:x86_64_v2 = " \
 elfutils-libelf \
 glibc \
 libcap \
 zlib-ng-compat \
"
RDEPENDS:bpftool:aarch64 = " \
 elfutils-libelf \
 glibc \
 libcap \
 llvm-libs \
 zlib-ng-compat \
"
