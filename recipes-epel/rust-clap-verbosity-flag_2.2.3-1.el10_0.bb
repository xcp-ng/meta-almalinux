# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap-verbosity-flag"
PV = "2.2.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-clap-verbosity-flag+default-devel \
 rust-clap-verbosity-flag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap-verbosity-flag-2.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bb502083ead2800c163cffbe04fb9025f43366226381ee9389dc3c72212cc85"

URI_x86_64_v2_rust-clap-verbosity-flag+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-verbosity-flag+default-devel-2.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-verbosity-flag+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-verbosity-flag+default-devel}"
SRC_URI[x86_64_v2_rust-clap-verbosity-flag+default-devel.sha256sum] = "1fe7fb25415e9b8b8d7126c94c6a8d8453045dbab36e16fe412a6466bac08d26"

URI_x86_64_v2_rust-clap-verbosity-flag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-verbosity-flag-devel-2.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-verbosity-flag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-verbosity-flag-devel}"
SRC_URI[x86_64_v2_rust-clap-verbosity-flag-devel.sha256sum] = "1dbffa39dac0ce03038637e182969a406844ab78c0f58b47a3478c27bf4d2687"

URI_aarch64_rust-clap-verbosity-flag+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-verbosity-flag+default-devel-2.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-clap-verbosity-flag+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-verbosity-flag+default-devel}"
SRC_URI[aarch64_rust-clap-verbosity-flag+default-devel.sha256sum] = "ba2b01645e79c5751bcdf4299d8eeba32df198d9df074bf94744ff51045cafe1"

URI_aarch64_rust-clap-verbosity-flag-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-verbosity-flag-devel-2.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-clap-verbosity-flag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-verbosity-flag-devel}"
SRC_URI[aarch64_rust-clap-verbosity-flag-devel.sha256sum] = "b3dc2c26c7335c568c125511c65094a5f20887b26858a2e3a712b446c788a840"

RDEPENDS:rust-clap-verbosity-flag+default-devel = " \
 cargo \
 rust-clap-verbosity-flag-devel \
 "
RDEPENDS:rust-clap-verbosity-flag-devel = " \
 cargo \
 rust \
 rust-clap+derive-devel \
 rust-clap+std-devel \
 rust-clap-devel \
 rust-log+default-devel \
 "
