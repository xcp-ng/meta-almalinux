# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-openprinting-ipp-usb"
PV = "0.9.27"
PR = "7.el10_2.3"
PACKAGES = " \
 ipp-usb \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-github-openprinting-ipp-usb-0.9.27-7.el10_2.3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a30b97a2c5dbc8b820675b4d7f3fe703af531515c056bd202d4fc7069d692a6b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipp-usb-0.9.27-7.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_ipp-usb;unpack=0"
SRC_URI[x86_64_v2_ipp-usb.sha256sum] = "a761a88724f2a8bcb27a7d9e964ce31af4008307809b16d011fcc03578fdb6f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipp-usb-0.9.27-7.el10_2.3.aarch64.rpm;name=aarch64_ipp-usb;unpack=0"
SRC_URI[aarch64_ipp-usb.sha256sum] = "9d24f8bb01144e65e82e32a078f6ea9b09bdcbaf8fe9da866ebcfa6ed19056e8"

RDEPENDS:ipp-usb = " \
 avahi-libs \
 bash \
 glibc \
 libusb1 \
 systemd \
 systemd-udev \
 "
