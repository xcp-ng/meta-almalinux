# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "marble"
PE = "1"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 marble \
 marble-astro \
 marble-astro-devel \
 marble-common \
 marble-plasma \
 marble-qt \
 marble-widget-data \
 marble-widget-qt6 \
 marble-widget-qt6-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/marble-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "72ebb1efd8c5c5308f3c7f6d7af886a98f2056b6cc71f7e42745b8cc0e49286e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble;unpack=0"
SRC_URI[x86_64_v2_marble.sha256sum] = "fab3b19d48017079e291273bde02a96fc16ff237ab162ab3447dffb24f5ad70a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-astro-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-astro;unpack=0"
SRC_URI[x86_64_v2_marble-astro.sha256sum] = "b49d8a6c75e83a9f041fe23fe179f261c81c52dc95ec877908e97f3cbef862af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-astro-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-astro-devel;unpack=0"
SRC_URI[x86_64_v2_marble-astro-devel.sha256sum] = "df577b3dc0f02aa9476f6175e6049099cf243960816bff8f0366cc7ac482a5a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-common-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_marble-common;unpack=0"
SRC_URI[x86_64_v2_marble-common.sha256sum] = "7c630a8c69328cc5fcb9a3e938936ec6bfd4bba82b90fcfc9507d23bb67080b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-plasma-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-plasma;unpack=0"
SRC_URI[x86_64_v2_marble-plasma.sha256sum] = "abe51d973d8a51c84b02ccc36132c8aaf5bbbf10a3d842ae05acb495e1c68a64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-qt-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-qt;unpack=0"
SRC_URI[x86_64_v2_marble-qt.sha256sum] = "e4e8ab53634b38e3e9f7002e73dfe6e8946c599596ee7aa66d42a3daa47bdf5e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-data-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_marble-widget-data;unpack=0"
SRC_URI[x86_64_v2_marble-widget-data.sha256sum] = "e4bc431f619539587897967fc8dbac8c5d951a8c1f2b0f5bda8b931a6cacb506"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-qt6-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-widget-qt6;unpack=0"
SRC_URI[x86_64_v2_marble-widget-qt6.sha256sum] = "6672f7ec6cecb0a0a372ee9dccbced8aa7713eb17e49f22f49910a81769e229c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-qt6-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-widget-qt6-devel;unpack=0"
SRC_URI[x86_64_v2_marble-widget-qt6-devel.sha256sum] = "1335c4efc6638c63ef1b4e8c47770e8cc331f421f83ded014b66474496d5a77f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/marble-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_marble;unpack=0"
SRC_URI[aarch64_marble.sha256sum] = "a095bcffc56b755ec3a3bd2744c381a2ced395ddc23387f26119d117da3a9260"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/marble-astro-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_marble-astro;unpack=0"
SRC_URI[aarch64_marble-astro.sha256sum] = "1ba0dde77e5520a2b570981741fd6332d12304af26437c9c396aabb8a68b831d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/marble-astro-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_marble-astro-devel;unpack=0"
SRC_URI[aarch64_marble-astro-devel.sha256sum] = "1c129246e3b4b4f727850ba4eb6fc25c01f1538077267eeda2c2122a21d47db7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/marble-common-26.08.1-1.el10_3.noarch.rpm;name=aarch64_marble-common;unpack=0"
SRC_URI[aarch64_marble-common.sha256sum] = "d1652c601767ab789b5d502f4588870dcc4f8e07e3e2ba5910b91e27f69370d5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/marble-plasma-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_marble-plasma;unpack=0"
SRC_URI[aarch64_marble-plasma.sha256sum] = "797f67c53caf2b485ea3afa4bfe592dd4f0f9235361a85f93cd443252a91e02d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/marble-qt-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_marble-qt;unpack=0"
SRC_URI[aarch64_marble-qt.sha256sum] = "227c9f7874383baf12e5c18c93ac635efdc63397486998e00da4e74acf9552b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-data-26.08.1-1.el10_3.noarch.rpm;name=aarch64_marble-widget-data;unpack=0"
SRC_URI[aarch64_marble-widget-data.sha256sum] = "9c6bfc3810dcafc6135765026fe8b46f61fd43bc11f5ab68413620ab13f1596d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-qt6-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_marble-widget-qt6;unpack=0"
SRC_URI[aarch64_marble-widget-qt6.sha256sum] = "31c98ed74f61da3b8fc6cf9fc6519bfa1a51dc2ee2acce8953e824275d83132e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-qt6-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_marble-widget-qt6-devel;unpack=0"
SRC_URI[aarch64_marble-widget-qt6-devel.sha256sum] = "904430303f593c3b51932cae2223842225d1764784203e67bc99f7c8af4cfd57"

RDEPENDS:marble = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
RDEPENDS:marble-astro = " \
 glibc \
 libstdc++ \
 marble-common \
 "
RDEPENDS:marble-astro-devel = " \
 cmake-filesystem \
 marble-astro \
 "
RDEPENDS:marble-common = " \
 "
RDEPENDS:marble-plasma = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-krunner \
 libstdc++ \
 marble-common \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:marble-qt = " \
 glibc \
 libstdc++ \
 marble-common \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:marble-widget-data = " \
 marble-common \
 "
RDEPENDS:marble-widget-qt6 = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 marble-astro \
 marble-widget-data \
 phonon-qt6 \
 protobuf \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 qt6-qtserialport \
 qt6-qtsvg \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 shapelib \
 zlib-ng-compat \
 "
RDEPENDS:marble-widget-qt6-devel = " \
 cmake-filesystem \
 marble-widget-qt6 \
 qt6-qt5compat-devel \
 qt6-qtbase-devel \
 qt6-qtwebengine-devel \
 "
