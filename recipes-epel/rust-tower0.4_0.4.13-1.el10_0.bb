# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower0.4"
PV = "0.4.13"
PR = "1.el10_0"
PACKAGES = " \
 rust-tower0.4+__common-devel \
 rust-tower0.4+balance-devel \
 rust-tower0.4+buffer-devel \
 rust-tower0.4+default-devel \
 rust-tower0.4+discover-devel \
 rust-tower0.4+filter-devel \
 rust-tower0.4+full-devel \
 rust-tower0.4+futures-core-devel \
 rust-tower0.4+futures-util-devel \
 rust-tower0.4+hdrhistogram-devel \
 rust-tower0.4+hedge-devel \
 rust-tower0.4+indexmap-devel \
 rust-tower0.4+limit-devel \
 rust-tower0.4+load-devel \
 rust-tower0.4+load-shed-devel \
 rust-tower0.4+log-devel \
 rust-tower0.4+make-devel \
 rust-tower0.4+pin-project-devel \
 rust-tower0.4+pin-project-lite-devel \
 rust-tower0.4+rand-devel \
 rust-tower0.4+ready-cache-devel \
 rust-tower0.4+reconnect-devel \
 rust-tower0.4+retry-devel \
 rust-tower0.4+slab-devel \
 rust-tower0.4+spawn-ready-devel \
 rust-tower0.4+steer-devel \
 rust-tower0.4+timeout-devel \
 rust-tower0.4+tokio-devel \
 rust-tower0.4+tokio-stream-devel \
 rust-tower0.4+tokio-util-devel \
 rust-tower0.4+tracing-devel \
 rust-tower0.4+util-devel \
 rust-tower0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tower0.4-0.4.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4504eb0350f6d57b456c063fe7ae08619649fca114b938a1a5f60873d26286ef"

URI_x86_64_v2_rust-tower0.4+__common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+__common-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+__common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+__common-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+__common-devel.sha256sum] = "99e54cd54aac5f27fadc98cdd1315894945a08198868dbf1378e429854110ae0"

URI_x86_64_v2_rust-tower0.4+balance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+balance-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+balance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+balance-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+balance-devel.sha256sum] = "dbf3f24bf7fb474b9282ec41335b7ecd6f4400e9b91782166794c74608c8e66e"

URI_x86_64_v2_rust-tower0.4+buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+buffer-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+buffer-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+buffer-devel.sha256sum] = "448c48a911b2b818fcc8d630593aff3e66f0a7b8dc170259d5cd126a8ca58a05"

URI_x86_64_v2_rust-tower0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+default-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+default-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+default-devel.sha256sum] = "364dc215d205f823f26ee6904448a17b48c601bd28f00d30975982b49cbd325e"

URI_x86_64_v2_rust-tower0.4+discover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+discover-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+discover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+discover-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+discover-devel.sha256sum] = "cfd43eda247aa54e2fac096333f16f11a33c694b9834e3c5a0ce301a91ab23d8"

URI_x86_64_v2_rust-tower0.4+filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+filter-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+filter-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+filter-devel.sha256sum] = "705c94b2972d0f676f4cb1eb76ff67ecd9792384b28c58e75a06f44b62a3e7f9"

URI_x86_64_v2_rust-tower0.4+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+full-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+full-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+full-devel.sha256sum] = "50567c637ef2a35c3ba22259dbf193492f2ff01e4f239b9bc9e8289cc456f7b9"

URI_x86_64_v2_rust-tower0.4+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+futures-core-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+futures-core-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+futures-core-devel.sha256sum] = "9754087474e74a95faa12f0cd664378bfb01b17b7269cb77479e753b13f23ad6"

URI_x86_64_v2_rust-tower0.4+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+futures-util-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+futures-util-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+futures-util-devel.sha256sum] = "738c27e250b770e58448ed4da899e1d96227eee847e7e1fd57bcddf45e4c83fa"

URI_x86_64_v2_rust-tower0.4+hdrhistogram-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+hdrhistogram-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+hdrhistogram-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+hdrhistogram-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+hdrhistogram-devel.sha256sum] = "b3f674bd407f0b6cb133393e40799d9719725af4db0644edda9566ff090b9823"

URI_x86_64_v2_rust-tower0.4+hedge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+hedge-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+hedge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+hedge-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+hedge-devel.sha256sum] = "4c7a046310d0f1297b3d880e96824ed56c434dbb981e3e5d978c50e95252a3fb"

URI_x86_64_v2_rust-tower0.4+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+indexmap-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+indexmap-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+indexmap-devel.sha256sum] = "ba155cb60d7510fdc9b78cc80aa5c61d5dc88706b5b8689df7ec8e94aac6b25e"

URI_x86_64_v2_rust-tower0.4+limit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+limit-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+limit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+limit-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+limit-devel.sha256sum] = "6781761340985de80a044daeb249a1c27a3b6bd4e19b9d96a7942721c94646e9"

URI_x86_64_v2_rust-tower0.4+load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+load-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+load-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+load-devel.sha256sum] = "5e45185d984ed3389ff2579824fbcb00cce9ab4e0c687ad43f20c07ffecc3888"

URI_x86_64_v2_rust-tower0.4+load-shed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+load-shed-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+load-shed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+load-shed-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+load-shed-devel.sha256sum] = "c4bd92d27f78f4cbe19d41c476f4c7dd0db7062e91a0a0e15635fbafa13849ab"

URI_x86_64_v2_rust-tower0.4+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+log-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+log-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+log-devel.sha256sum] = "d031ffc9eb0fa5eff5060168399a3f50eaeea127415794f013b7bff83d1da924"

URI_x86_64_v2_rust-tower0.4+make-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+make-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+make-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+make-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+make-devel.sha256sum] = "e4cdd690982bad1a44341e6577f910b23589f0da46d21e25217a99f38f181f2b"

URI_x86_64_v2_rust-tower0.4+pin-project-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+pin-project-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+pin-project-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+pin-project-devel.sha256sum] = "cf2a23c2eb07a88f00ee6487147bb70bae6155c2449fc25619dc3ae3fe0bfc49"

URI_x86_64_v2_rust-tower0.4+pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+pin-project-lite-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+pin-project-lite-devel.sha256sum] = "3c77a202c0a5a750090fa8c9912db5e54eb79922ae0e4b3faef18b89c1639193"

URI_x86_64_v2_rust-tower0.4+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+rand-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+rand-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+rand-devel.sha256sum] = "39c7c7a851e9827c35fe4e6cd47c32d0afcae047035e30250d5315bf5fa50bc8"

URI_x86_64_v2_rust-tower0.4+ready-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+ready-cache-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+ready-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+ready-cache-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+ready-cache-devel.sha256sum] = "fc3191ebe2b7b068be88954b89efd234d022a8402dd9a0b80cb0144a32db628e"

URI_x86_64_v2_rust-tower0.4+reconnect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+reconnect-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+reconnect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+reconnect-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+reconnect-devel.sha256sum] = "fc303ea21df28034d8199b43e72a237c0c0b4d089e71ab03e8feb3382e3d2f85"

URI_x86_64_v2_rust-tower0.4+retry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+retry-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+retry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+retry-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+retry-devel.sha256sum] = "8335f7f7ee39f33b7c839d057d461387d376e5e96d9ab3f57d9468878d6739fb"

URI_x86_64_v2_rust-tower0.4+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+slab-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+slab-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+slab-devel.sha256sum] = "7038f65af70c515b3d2067027e90475e3d8f7dc9bc6a7709e05afcf9bbfc2594"

URI_x86_64_v2_rust-tower0.4+spawn-ready-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+spawn-ready-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+spawn-ready-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+spawn-ready-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+spawn-ready-devel.sha256sum] = "1016288b81a2d318c14b7215e1ad9f826e59ce46931d0cc0474e78d8737d3ec3"

URI_x86_64_v2_rust-tower0.4+steer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+steer-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+steer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+steer-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+steer-devel.sha256sum] = "8827e47d401c3bd3ae2175cfb94f2f692668ae88d2216923ea0be2ef1988f574"

URI_x86_64_v2_rust-tower0.4+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+timeout-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+timeout-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+timeout-devel.sha256sum] = "02238ee4ed9797d52649907a8a7bd134b05d74caebbf18552896f63a0742bfd2"

URI_x86_64_v2_rust-tower0.4+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+tokio-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+tokio-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+tokio-devel.sha256sum] = "dc645416eb41eeeaf03a23adff993e06fa4b54f3dec9b1e0aa55acde260b443e"

URI_x86_64_v2_rust-tower0.4+tokio-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+tokio-stream-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+tokio-stream-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+tokio-stream-devel.sha256sum] = "84a042ddecb8c5850e1d7ec54e92c7c7b7b0dc7e6f0f06d07a746ce0714fd1f4"

URI_x86_64_v2_rust-tower0.4+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+tokio-util-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+tokio-util-devel.sha256sum] = "55034f22fc4a8e299f6d4385dea4e2de37073d8a531ffc3982512a4df4350a9b"

URI_x86_64_v2_rust-tower0.4+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+tracing-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+tracing-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+tracing-devel.sha256sum] = "b84d288d79963b6a2d811fda9f4040ac9258fa42ac1e1957a93f1378d3f13268"

URI_x86_64_v2_rust-tower0.4+util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4+util-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4+util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4+util-devel}"
SRC_URI[x86_64_v2_rust-tower0.4+util-devel.sha256sum] = "2e8740a208979d8c70787b3efbd02e05592e2cd39188505f21c511f03beefcf2"

URI_x86_64_v2_rust-tower0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower0.4-devel-0.4.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower0.4-devel}"
SRC_URI[x86_64_v2_rust-tower0.4-devel.sha256sum] = "3f7d485508a32fa944ad24c10709184b32415462e561aeb7fe315de0c886dde1"

URI_aarch64_rust-tower0.4+__common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+__common-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+__common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+__common-devel}"
SRC_URI[aarch64_rust-tower0.4+__common-devel.sha256sum] = "d8f07f5e43f40f3f007f15465e180c926b1302feb5048b8aa8bba4a950f92401"

URI_aarch64_rust-tower0.4+balance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+balance-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+balance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+balance-devel}"
SRC_URI[aarch64_rust-tower0.4+balance-devel.sha256sum] = "c68dbbfa8dbd0161ea919cdb36d94f484f5e812620b2047d270564e14f5fa552"

URI_aarch64_rust-tower0.4+buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+buffer-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+buffer-devel}"
SRC_URI[aarch64_rust-tower0.4+buffer-devel.sha256sum] = "4d1dcd538cb1b32d23da0f7126569578f4e668b68347f6bcc8d501124441c4ee"

URI_aarch64_rust-tower0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+default-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+default-devel}"
SRC_URI[aarch64_rust-tower0.4+default-devel.sha256sum] = "7d82fa6d8fa13ab10590f6b032108c7b33aabbd9a202247c1e273c73ed42d15a"

URI_aarch64_rust-tower0.4+discover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+discover-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+discover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+discover-devel}"
SRC_URI[aarch64_rust-tower0.4+discover-devel.sha256sum] = "9c6c45a0b4337cd426a2e00f88362c34ed6c8e908fa09bb9ff0d7c5b2f1f384f"

URI_aarch64_rust-tower0.4+filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+filter-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+filter-devel}"
SRC_URI[aarch64_rust-tower0.4+filter-devel.sha256sum] = "78ed38cfd43c89a89426e9f2a83c8ca09ca71a55a2a60e784dff4aba76732bb9"

URI_aarch64_rust-tower0.4+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+full-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+full-devel}"
SRC_URI[aarch64_rust-tower0.4+full-devel.sha256sum] = "963e968339b9c74971cd3e4e8010cfd607dac4a5926338d3f176e070162e48c7"

URI_aarch64_rust-tower0.4+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+futures-core-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+futures-core-devel}"
SRC_URI[aarch64_rust-tower0.4+futures-core-devel.sha256sum] = "7aac97f897783fa2b3f0d8e6b14af4d7df35711c6ada0c6ee537214a3998ec72"

URI_aarch64_rust-tower0.4+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+futures-util-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+futures-util-devel}"
SRC_URI[aarch64_rust-tower0.4+futures-util-devel.sha256sum] = "6c473c3440faa54469cb9b3ab64aa467124ec6a2c0466ac80a41f5d0b3726dc1"

URI_aarch64_rust-tower0.4+hdrhistogram-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+hdrhistogram-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+hdrhistogram-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+hdrhistogram-devel}"
SRC_URI[aarch64_rust-tower0.4+hdrhistogram-devel.sha256sum] = "f0a813e597b3c6a566fd85ca65ca3062ee0e0be5417c34523a65f8db6d55d5a5"

URI_aarch64_rust-tower0.4+hedge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+hedge-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+hedge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+hedge-devel}"
SRC_URI[aarch64_rust-tower0.4+hedge-devel.sha256sum] = "3ceb0779c3d2e0a174687ca14ebc4fc18dd936d83a687b00419b2b5002545eb7"

URI_aarch64_rust-tower0.4+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+indexmap-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+indexmap-devel}"
SRC_URI[aarch64_rust-tower0.4+indexmap-devel.sha256sum] = "30f73d367e0d56b01d199455dd6b5dc76c7d3447ab145f7e3b5bd85674144b0c"

URI_aarch64_rust-tower0.4+limit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+limit-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+limit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+limit-devel}"
SRC_URI[aarch64_rust-tower0.4+limit-devel.sha256sum] = "d66ecc7d672e8a9d020f1222fb7fda48979f2b7956c6050e71756178b22a4968"

URI_aarch64_rust-tower0.4+load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+load-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+load-devel}"
SRC_URI[aarch64_rust-tower0.4+load-devel.sha256sum] = "ec7a146d5731f67df3d05d8b394521e0a8f69ba68f5e0da10277109e94e97421"

URI_aarch64_rust-tower0.4+load-shed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+load-shed-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+load-shed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+load-shed-devel}"
SRC_URI[aarch64_rust-tower0.4+load-shed-devel.sha256sum] = "ff53ad9c3111f171219575fc222c93a25f9045788d09286127d72d3b3abe4ca2"

URI_aarch64_rust-tower0.4+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+log-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+log-devel}"
SRC_URI[aarch64_rust-tower0.4+log-devel.sha256sum] = "530662cd0f475ada50ac8a55d0bff47d64a59a2d5c4964ee4791ee516698aba5"

URI_aarch64_rust-tower0.4+make-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+make-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+make-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+make-devel}"
SRC_URI[aarch64_rust-tower0.4+make-devel.sha256sum] = "d705544453250af4cd413c700fd55daec053ae6c0a94d2ab47d2d6f6c1985f76"

URI_aarch64_rust-tower0.4+pin-project-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+pin-project-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+pin-project-devel}"
SRC_URI[aarch64_rust-tower0.4+pin-project-devel.sha256sum] = "25e84459c72b82b010ab40790300da8b54933f292cf72d7e9e70049e010cff0c"

URI_aarch64_rust-tower0.4+pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+pin-project-lite-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+pin-project-lite-devel}"
SRC_URI[aarch64_rust-tower0.4+pin-project-lite-devel.sha256sum] = "9ebd7c5e7f9377c32948c156c388fdbfbfb81cc733af03cb0b50c97b418ba7e0"

URI_aarch64_rust-tower0.4+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+rand-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+rand-devel}"
SRC_URI[aarch64_rust-tower0.4+rand-devel.sha256sum] = "3bdf7bcf90d28d5ddce05752c3c8ac1143ed71ab3ba8351876503fdbc3a983de"

URI_aarch64_rust-tower0.4+ready-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+ready-cache-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+ready-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+ready-cache-devel}"
SRC_URI[aarch64_rust-tower0.4+ready-cache-devel.sha256sum] = "e50e39dab3f920496e8c4a230beb7b92e3eb81f77ed25b647016e2d99441da06"

URI_aarch64_rust-tower0.4+reconnect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+reconnect-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+reconnect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+reconnect-devel}"
SRC_URI[aarch64_rust-tower0.4+reconnect-devel.sha256sum] = "3505062be95e7ad47849f518508239c9cf8bbff45a8a7bb6cda0524a942b9e4d"

URI_aarch64_rust-tower0.4+retry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+retry-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+retry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+retry-devel}"
SRC_URI[aarch64_rust-tower0.4+retry-devel.sha256sum] = "bdc3e9374e03ffd09bdf64d80b8343020c740c103b50e0560f23623d0825ca7e"

URI_aarch64_rust-tower0.4+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+slab-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+slab-devel}"
SRC_URI[aarch64_rust-tower0.4+slab-devel.sha256sum] = "4003d30107bc1656d26d99e38955c0136b1f6889e54468aa3cd43ce5b26da554"

URI_aarch64_rust-tower0.4+spawn-ready-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+spawn-ready-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+spawn-ready-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+spawn-ready-devel}"
SRC_URI[aarch64_rust-tower0.4+spawn-ready-devel.sha256sum] = "312d52b57cb586942e151f043d687191740d2f056e802dbacc8107f1c233872e"

URI_aarch64_rust-tower0.4+steer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+steer-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+steer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+steer-devel}"
SRC_URI[aarch64_rust-tower0.4+steer-devel.sha256sum] = "edb6a7bf367e683c69a62937b88e5c6b8fbf39e695c28da6dd3dc6ffa11ac8ea"

URI_aarch64_rust-tower0.4+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+timeout-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+timeout-devel}"
SRC_URI[aarch64_rust-tower0.4+timeout-devel.sha256sum] = "364f6b7b4f53abd3cb639f9c0f2e845e26c89f7548ac7e7884b37d6918a1d89b"

URI_aarch64_rust-tower0.4+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+tokio-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+tokio-devel}"
SRC_URI[aarch64_rust-tower0.4+tokio-devel.sha256sum] = "f04db27a233a78faeb4420c8858bcadad973aa8b4809bb2a962788b5897723d4"

URI_aarch64_rust-tower0.4+tokio-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+tokio-stream-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+tokio-stream-devel}"
SRC_URI[aarch64_rust-tower0.4+tokio-stream-devel.sha256sum] = "d630630febe7fab85ca3fc78c1d74a68d997fb222adb732523b26d8946351418"

URI_aarch64_rust-tower0.4+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+tokio-util-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+tokio-util-devel}"
SRC_URI[aarch64_rust-tower0.4+tokio-util-devel.sha256sum] = "e42de57e52e32c195f9fa8d1a3766429c598a8cd54c230909791c858d10901e3"

URI_aarch64_rust-tower0.4+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+tracing-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+tracing-devel}"
SRC_URI[aarch64_rust-tower0.4+tracing-devel.sha256sum] = "9134ac49586ac157adc3cdf961255c03c8fc5f03c58b4d27dcc594c94cd535a3"

URI_aarch64_rust-tower0.4+util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4+util-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4+util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4+util-devel}"
SRC_URI[aarch64_rust-tower0.4+util-devel.sha256sum] = "ed93c052a6621c888f0bcf1d49e4aad58a8155cc51b55b4826442383a5d1b7e9"

URI_aarch64_rust-tower0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower0.4-devel-0.4.13-1.el10_0.noarch.rpm;name=aarch64_rust-tower0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower0.4-devel}"
SRC_URI[aarch64_rust-tower0.4-devel.sha256sum] = "5c9ee9eabd86ffe2b829884d51b89453326d31fb7995f9df688e2354abcb7ce7"

RDEPENDS:rust-tower0.4+__common-devel = " \
 cargo \
 rust-tower0.4+futures-core-devel \
 rust-tower0.4+pin-project-lite-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+balance-devel = " \
 cargo \
 rust-tower0.4+discover-devel \
 rust-tower0.4+load-devel \
 rust-tower0.4+make-devel \
 rust-tower0.4+rand-devel \
 rust-tower0.4+ready-cache-devel \
 rust-tower0.4+slab-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+buffer-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tower0.4+__common-devel \
 rust-tower0.4+tokio-util-devel \
 rust-tower0.4+tracing-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+default-devel = " \
 cargo \
 rust-tower0.4+log-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+discover-devel = " \
 cargo \
 rust-tower0.4+__common-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+filter-devel = " \
 cargo \
 rust-tower0.4+__common-devel \
 rust-tower0.4+futures-util-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+full-devel = " \
 cargo \
 rust-tower0.4+balance-devel \
 rust-tower0.4+buffer-devel \
 rust-tower0.4+discover-devel \
 rust-tower0.4+filter-devel \
 rust-tower0.4+hedge-devel \
 rust-tower0.4+limit-devel \
 rust-tower0.4+load-devel \
 rust-tower0.4+load-shed-devel \
 rust-tower0.4+make-devel \
 rust-tower0.4+ready-cache-devel \
 rust-tower0.4+reconnect-devel \
 rust-tower0.4+retry-devel \
 rust-tower0.4+spawn-ready-devel \
 rust-tower0.4+steer-devel \
 rust-tower0.4+timeout-devel \
 rust-tower0.4+util-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+futures-core-devel = " \
 cargo \
 rust-futures-core+default-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+futures-util-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+hdrhistogram-devel = " \
 cargo \
 rust-hdrhistogram-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+hedge-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower0.4+filter-devel \
 rust-tower0.4+futures-util-devel \
 rust-tower0.4+hdrhistogram-devel \
 rust-tower0.4+tracing-devel \
 rust-tower0.4+util-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+indexmap-devel = " \
 cargo \
 rust-indexmap1+default-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+limit-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower0.4+__common-devel \
 rust-tower0.4+tokio-util-devel \
 rust-tower0.4+tracing-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+load-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower0.4+__common-devel \
 rust-tower0.4+tracing-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+load-shed-devel = " \
 cargo \
 rust-tower0.4+__common-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+log-devel = " \
 cargo \
 rust-tower0.4-devel \
 rust-tracing+log-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tower0.4+make-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+io-std-devel \
 rust-tokio+sync-devel \
 rust-tower0.4+futures-util-devel \
 rust-tower0.4+pin-project-lite-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+pin-project-devel = " \
 cargo \
 rust-pin-project+default-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+pin-project-lite-devel = " \
 cargo \
 rust-pin-project-lite+default-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+rand-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 rust-rand0.8+small_rng-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+ready-cache-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tower0.4+futures-core-devel \
 rust-tower0.4+futures-util-devel \
 rust-tower0.4+indexmap-devel \
 rust-tower0.4+pin-project-lite-devel \
 rust-tower0.4+tracing-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+reconnect-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+io-std-devel \
 rust-tokio+sync-devel \
 rust-tower0.4+make-devel \
 rust-tower0.4+tracing-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+retry-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower0.4+__common-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+slab-devel = " \
 cargo \
 rust-slab+default-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+spawn-ready-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tower0.4+__common-devel \
 rust-tower0.4+futures-util-devel \
 rust-tower0.4+tracing-devel \
 rust-tower0.4+util-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+steer-devel = " \
 cargo \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+timeout-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tower0.4+pin-project-lite-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+tokio-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+tokio-stream-devel = " \
 cargo \
 rust-tokio-stream+default-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+tokio-util-devel = " \
 cargo \
 rust-tokio-util-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4+tracing-devel = " \
 cargo \
 rust-tower0.4-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tower0.4+util-devel = " \
 cargo \
 rust-tower0.4+__common-devel \
 rust-tower0.4+futures-util-devel \
 rust-tower0.4+pin-project-devel \
 rust-tower0.4-devel \
 "
RDEPENDS:rust-tower0.4-devel = " \
 cargo \
 rust \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
