# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs22"
PE = "1"
PV = "22.23.1"
PR = "6.el10_2"
PACKAGES = " \
 nodejs \
 nodejs-devel \
 nodejs-docs \
 nodejs-full-i18n \
 nodejs-libs \
 nodejs-npm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs22-22.23.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c13c480e8f44a2d21032771cac298d7640f9ab497fb1474773c0962b3b73d08"

URI_x86_64_v2_nodejs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-22.23.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs}"
SRC_URI[x86_64_v2_nodejs.sha256sum] = "1d81480579b1d97b87baed29114425b3d4063d304eae795c88c787e9f333e5c1"
RPROVIDES:nodejs:x86_64_v2 = "virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_x86_64_v2_nodejs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-devel-22.23.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-devel}"
SRC_URI[x86_64_v2_nodejs-devel.sha256sum] = "20e7d0b162e1705cef23eb08b0595d5aa499ca3b47446aa5ade00575fa19eaab"

URI_x86_64_v2_nodejs-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-docs-22.23.1-6.el10_2.noarch.rpm;name=x86_64_v2_nodejs-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-docs}"
SRC_URI[x86_64_v2_nodejs-docs.sha256sum] = "a4cf7db461223295f0f82718617815510079e00e6e5e5f79921d8490e5169df3"

URI_x86_64_v2_nodejs-full-i18n = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-full-i18n-22.23.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs-full-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-full-i18n}"
SRC_URI[x86_64_v2_nodejs-full-i18n.sha256sum] = "32a5a1c0b0a211874bfa51d4ba4383cdd3c617c5dd2aa429b22886aee3efcf9d"

URI_x86_64_v2_nodejs-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-libs-22.23.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-libs}"
SRC_URI[x86_64_v2_nodejs-libs.sha256sum] = "fb8cf43a2a9123b2cd4a3dabc06cc42e0988ad6422dd8b47711e57b8d99c3c32"

URI_x86_64_v2_nodejs-npm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-npm-10.9.8-1.22.23.1.6.el10_2.x86_64_v2.rpm;name=x86_64_v2_nodejs-npm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-npm}"
SRC_URI[x86_64_v2_nodejs-npm.sha256sum] = "8681340e29bdc0982accc334dd523c61391e518ed1450a93c4efbe98f823ed0e"

URI_aarch64_nodejs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-22.23.1-6.el10_2.aarch64.rpm;name=aarch64_nodejs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs}"
SRC_URI[aarch64_nodejs.sha256sum] = "04066b532b8828ca7825c8edd3c2db8e4022b3b292a1b01a4bc6e45e891985b8"
RPROVIDES:nodejs:aarch64 = "virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

URI_aarch64_nodejs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-devel-22.23.1-6.el10_2.aarch64.rpm;name=aarch64_nodejs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-devel}"
SRC_URI[aarch64_nodejs-devel.sha256sum] = "081fb502f810304d9cfd46d300e377bf9efffb74005c04c8a54cd2b4430d3805"

URI_aarch64_nodejs-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-docs-22.23.1-6.el10_2.noarch.rpm;name=aarch64_nodejs-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-docs}"
SRC_URI[aarch64_nodejs-docs.sha256sum] = "a4cf7db461223295f0f82718617815510079e00e6e5e5f79921d8490e5169df3"

URI_aarch64_nodejs-full-i18n = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-full-i18n-22.23.1-6.el10_2.aarch64.rpm;name=aarch64_nodejs-full-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-full-i18n}"
SRC_URI[aarch64_nodejs-full-i18n.sha256sum] = "72031ffa645716c6768e9c4efe56c7d8b71367aad7f9ea4e0b0957e74652a74c"

URI_aarch64_nodejs-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-libs-22.23.1-6.el10_2.aarch64.rpm;name=aarch64_nodejs-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-libs}"
SRC_URI[aarch64_nodejs-libs.sha256sum] = "6a582967d11ffd10a365ad594763231e9e826eb19920e15741112d1a496a6bfe"

URI_aarch64_nodejs-npm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-npm-10.9.8-1.22.23.1.6.el10_2.aarch64.rpm;name=aarch64_nodejs-npm;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-npm}"
SRC_URI[aarch64_nodejs-npm.sha256sum] = "3e5649a5e0dd1b8d56a47412fe55b73e96be6e51ce4cd951987cc04ef950bc17"

RDEPENDS:nodejs = " \
 ca-certificates \
 glibc \
 libuv \
 nodejs-libs \
 openssl \
 "
RDEPENDS:nodejs-devel = " \
 bash \
 brotli-devel \
 libuv-devel \
 nodejs \
 nodejs-libs \
 nodejs-packaging \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs-docs = " \
 nodejs \
 "
RDEPENDS:nodejs-full-i18n = " \
 nodejs \
 "
RDEPENDS:nodejs-libs = " \
 c-ares \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 libuv \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs-npm = " \
 bash \
 nodejs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nodejs_engine_ rpm/virtual/nodejs_engine__ge_0.8.0"

PROVIDES:append:aarch64 = " rpm/virtual/nodejs_engine_ rpm/virtual/nodejs_engine__ge_0.8.0"
