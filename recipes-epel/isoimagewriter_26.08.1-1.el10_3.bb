# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isoimagewriter"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 isoimagewriter \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/isoimagewriter-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "80df786883e6cdf7419d3f50f5a42176984acaef3030b2f6fd4046edf7a4f997"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isoimagewriter-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isoimagewriter;unpack=0"
SRC_URI[x86_64_v2_isoimagewriter.sha256sum] = "871f1a3aca1ba4bfbec88787adfc5ffeb0d1502d6c831d17371bf4c791bd57f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/isoimagewriter-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_isoimagewriter;unpack=0"
SRC_URI[aarch64_isoimagewriter.sha256sum] = "d105059ff6edd31f7fc4958ff033b129b00597ef785bb6ae05e7fd1254d00489"

RDEPENDS:isoimagewriter = " \
 glibc \
 gpgme2pp \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-solid \
 libgcc \
 libstdc++ \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
