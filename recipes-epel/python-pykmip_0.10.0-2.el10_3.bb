# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pykmip"
PV = "0.10.0"
PR = "2.el10_3"
PACKAGES = " \
 python3-pykmip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pykmip-0.10.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c63a3ea693552003e8aaebb2f1a476ac7b6c9316684053136426a0c7b386e486"

URI_x86_64_v2_python3-pykmip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pykmip-0.10.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pykmip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pykmip}"
SRC_URI[x86_64_v2_python3-pykmip.sha256sum] = "7d5e0bb64667805e823ea86a397f31579d94ea404294c5811fa7591d07e58c17"

URI_aarch64_python3-pykmip = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pykmip-0.10.0-2.el10_3.noarch.rpm;name=aarch64_python3-pykmip;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pykmip}"
SRC_URI[aarch64_python3-pykmip.sha256sum] = "982c9f2afd3c78bd74dfa8652bb4c29347ab39b47eaf5f66302ad473d73df7cb"

RDEPENDS:python3-pykmip = " \
 python3 \
 python3-cryptography \
 python3-requests \
 python3-six \
 python3-sqlalchemy \
 "
