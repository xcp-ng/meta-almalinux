# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-b3sum"
PV = "1.8.2"
PR = "3.el10_0"
PACKAGES = " \
 b3sum \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-b3sum-1.8.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fab56e5f0b2526a36d772caab10fb5dcbee84f69a5879dde0df18a1e9e3448f"

URI_x86_64_v2_b3sum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/b3sum-1.8.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_b3sum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_b3sum}"
SRC_URI[x86_64_v2_b3sum.sha256sum] = "74ef3fef55c54ffc4e26b71a3561bf1bc58d419ebb25c361312fcb69d70fa9f7"

URI_aarch64_b3sum = "${EPEL_MIRROR}/aarch64/Packages/b/b3sum-1.8.2-3.el10_0.aarch64.rpm;name=aarch64_b3sum;unpack=0"
SRC_URI:append = " ${URI_aarch64_b3sum}"
SRC_URI[aarch64_b3sum.sha256sum] = "c0b4789e52f80393f63055d343be77f2296e807514ad9d785ee21e4ac883d1d5"

RDEPENDS:b3sum = " \
 glibc \
 libgcc \
 "
