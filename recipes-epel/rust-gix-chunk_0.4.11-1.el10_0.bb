# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-chunk"
PV = "0.4.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-chunk+default-devel \
 rust-gix-chunk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-chunk-0.4.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb2c13088bf0c99fc53ea3b76ab8cf46730bb02bef540e8a72c31817961f8a94"

URI_x86_64_v2_rust-gix-chunk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-chunk+default-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-chunk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-chunk+default-devel}"
SRC_URI[x86_64_v2_rust-gix-chunk+default-devel.sha256sum] = "8d5062b3c840691f2b7b89820288de543c57f4d702868f71d6f648f2168401fb"

URI_x86_64_v2_rust-gix-chunk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-chunk-devel-0.4.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-chunk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-chunk-devel}"
SRC_URI[x86_64_v2_rust-gix-chunk-devel.sha256sum] = "470fde7401a4c35143f4879b6e5ac45be02a8340b8fa527d683cddc764a6ec5b"

URI_aarch64_rust-gix-chunk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-chunk+default-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-gix-chunk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-chunk+default-devel}"
SRC_URI[aarch64_rust-gix-chunk+default-devel.sha256sum] = "129225b407351ed5dd1efae16696f15d7cb6af756833e006d6914f6058c7464d"

URI_aarch64_rust-gix-chunk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-chunk-devel-0.4.11-1.el10_0.noarch.rpm;name=aarch64_rust-gix-chunk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-chunk-devel}"
SRC_URI[aarch64_rust-gix-chunk-devel.sha256sum] = "a4965ae38337f67b375628a1203799c3b130e34f8f0230d0bb3ab773aa6ebe86"

RDEPENDS:rust-gix-chunk+default-devel = " \
 cargo \
 rust-gix-chunk-devel \
 "
RDEPENDS:rust-gix-chunk-devel = " \
 cargo \
 rust \
 rust-thiserror+default-devel \
 "
