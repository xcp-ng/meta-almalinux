# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Float"
PV = "0.015"
PR = "2.el10_1"
PACKAGES = " \
 perl-Data-Float \
 perl-Data-Float-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Float-0.015-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77146db93b7a9e358aa0799ab0e47b6b63e2fe403ed6f915c0845c36b97da7eb"

URI_x86_64_v2_perl-Data-Float = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Float-0.015-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Float;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Float}"
SRC_URI[x86_64_v2_perl-Data-Float.sha256sum] = "c9773326cb06f419b1e779b8c03fe34bd01d82091099e0c8dff9c8f0e517c95f"

URI_x86_64_v2_perl-Data-Float-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Float-tests-0.015-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Float-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Float-tests}"
SRC_URI[x86_64_v2_perl-Data-Float-tests.sha256sum] = "f45eb4aaa196630ce107a1f7da2f86cb3245b8620110e10bfca62a5a073bddf9"

URI_aarch64_perl-Data-Float = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Float-0.015-2.el10_1.noarch.rpm;name=aarch64_perl-Data-Float;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Float}"
SRC_URI[aarch64_perl-Data-Float.sha256sum] = "394dd6fd75a9eefdd68e045f58b870d37ce68e4ab893edff5f82870388cb8cf3"

URI_aarch64_perl-Data-Float-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Float-tests-0.015-2.el10_1.noarch.rpm;name=aarch64_perl-Data-Float-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Float-tests}"
SRC_URI[aarch64_perl-Data-Float-tests.sha256sum] = "ad038a31ff74a2f9ff8420a793d4960a101c3d6bdd875bdeab314e8801f4d108"

RDEPENDS:perl-Data-Float = " \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Data-Float-tests = " \
 bash \
 perl-Data-Float \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-libs \
 "
