# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bindgen"
PV = "0.72.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-bindgen+__cli-devel \
 rust-bindgen+__testing_only_extra_assertions-devel \
 rust-bindgen+__testing_only_libclang_16-devel \
 rust-bindgen+__testing_only_libclang_9-devel \
 rust-bindgen+default-devel \
 rust-bindgen+experimental-devel \
 rust-bindgen+logging-devel \
 rust-bindgen+prettyplease-devel \
 rust-bindgen+runtime-devel \
 rust-bindgen+static-devel \
 rust-bindgen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bindgen-0.72.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d49bf558d4c9605f1194844f6ce617907377cb464916a1150a1bf2b8e9ef08e"

URI_x86_64_v2_rust-bindgen+__cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__cli-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__cli-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__cli-devel.sha256sum] = "8e8f10b559b4c8ad59bea18e44c7f24aceaaa77d8bdf92dbab7e0b9836737251"

URI_x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__testing_only_extra_assertions-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel.sha256sum] = "a14a96ec54b3ca70ed01b0f8ef7ddc584cefa4fb5efdadffd806056a54933774"

URI_x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__testing_only_libclang_16-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel.sha256sum] = "b3a3dc1b0ee510006e5d9ce32e9356a4b6cb1915d8c6303c5d773972264c009b"

URI_x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__testing_only_libclang_9-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel.sha256sum] = "e03618829c20d42b87bb30c3617919dff101cccb7af585cee8aa4e8a21ef9310"

URI_x86_64_v2_rust-bindgen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+default-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+default-devel}"
SRC_URI[x86_64_v2_rust-bindgen+default-devel.sha256sum] = "79f2fd2526df9c95bc23ebd6e1300fb177b16d0e06f09fdf50ba79a2f89d0b29"

URI_x86_64_v2_rust-bindgen+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+experimental-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+experimental-devel}"
SRC_URI[x86_64_v2_rust-bindgen+experimental-devel.sha256sum] = "7be54550bbeb2f6a3dd24e070c8950f057a1e1ce02817abf9ae1eb7ab36b0bf1"

URI_x86_64_v2_rust-bindgen+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+logging-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+logging-devel}"
SRC_URI[x86_64_v2_rust-bindgen+logging-devel.sha256sum] = "220cc8d68e33d946363b1d3879739364769da778ff5793f8055c38b5de151e4e"

URI_x86_64_v2_rust-bindgen+prettyplease-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+prettyplease-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+prettyplease-devel}"
SRC_URI[x86_64_v2_rust-bindgen+prettyplease-devel.sha256sum] = "3a969427a8100448702126eb31416b40c349fedc333f1b0ab5a63340bee846be"

URI_x86_64_v2_rust-bindgen+runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+runtime-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+runtime-devel}"
SRC_URI[x86_64_v2_rust-bindgen+runtime-devel.sha256sum] = "572149a7aa4a372ac6dfa7674b425fe724efe6ce65f8a88a6cbe4119c8423d72"

URI_x86_64_v2_rust-bindgen+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+static-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+static-devel}"
SRC_URI[x86_64_v2_rust-bindgen+static-devel.sha256sum] = "01ac5b5961916cf9e766d0d2ff93995697bc83eaf2caf6f7eec4b3576f84e405"

URI_x86_64_v2_rust-bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen-devel-0.72.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen-devel}"
SRC_URI[x86_64_v2_rust-bindgen-devel.sha256sum] = "386a0b7c2c4562618fe07d7d783416415fc9e92351c1d995e32987712ade0b9e"

URI_aarch64_rust-bindgen+__cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__cli-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen+__cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__cli-devel}"
SRC_URI[aarch64_rust-bindgen+__cli-devel.sha256sum] = "0d4400bc62a6f784e9fd95a141d673f1d2f6cfbe71d9815acb3ddd919fcd2793"

URI_aarch64_rust-bindgen+__testing_only_extra_assertions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__testing_only_extra_assertions-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen+__testing_only_extra_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__testing_only_extra_assertions-devel}"
SRC_URI[aarch64_rust-bindgen+__testing_only_extra_assertions-devel.sha256sum] = "361211a2cca1bf68c4b8877721be35f36dc015096aaf9fe9664996500d5a98a4"

URI_aarch64_rust-bindgen+__testing_only_libclang_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__testing_only_libclang_16-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen+__testing_only_libclang_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__testing_only_libclang_16-devel}"
SRC_URI[aarch64_rust-bindgen+__testing_only_libclang_16-devel.sha256sum] = "573a0151c13020ff866efe06a420c072d52c7b38b82e488431720565c90d990b"

URI_aarch64_rust-bindgen+__testing_only_libclang_9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__testing_only_libclang_9-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen+__testing_only_libclang_9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__testing_only_libclang_9-devel}"
SRC_URI[aarch64_rust-bindgen+__testing_only_libclang_9-devel.sha256sum] = "eab3f3dbcd677b6547ae5858a48b5cbbdda50cedf1be89a3476c61856f7d441a"

URI_aarch64_rust-bindgen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+default-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+default-devel}"
SRC_URI[aarch64_rust-bindgen+default-devel.sha256sum] = "d06ccabe53200da14073e2e25e7e7bd63cda16f97f8795a8301776d2e2e6a616"

URI_aarch64_rust-bindgen+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+experimental-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+experimental-devel}"
SRC_URI[aarch64_rust-bindgen+experimental-devel.sha256sum] = "b50c7565a2d25004fc5614ee82ac9708886d7989b4f0c920cb4addbae5f56f8f"

URI_aarch64_rust-bindgen+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+logging-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+logging-devel}"
SRC_URI[aarch64_rust-bindgen+logging-devel.sha256sum] = "0d1c1b52901b018ca135ea92f9e3e62e7b08c5f3ed72c8dc3e6ac854aa278701"

URI_aarch64_rust-bindgen+prettyplease-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+prettyplease-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen+prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+prettyplease-devel}"
SRC_URI[aarch64_rust-bindgen+prettyplease-devel.sha256sum] = "fdee34956c764712653cff5bae5271ef67a99bdfd2eda48d82c80378b730ea85"

URI_aarch64_rust-bindgen+runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+runtime-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+runtime-devel}"
SRC_URI[aarch64_rust-bindgen+runtime-devel.sha256sum] = "14d81e4685e8b5e994386ec96c166a01fe54456ff1058550b977c63d7b30d10c"

URI_aarch64_rust-bindgen+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+static-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+static-devel}"
SRC_URI[aarch64_rust-bindgen+static-devel.sha256sum] = "58a47422918f354d6e03a0dc3401163089b35339b6bb9eba9fa46a665081e08a"

URI_aarch64_rust-bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen-devel-0.72.1-1.el10_2.noarch.rpm;name=aarch64_rust-bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen-devel}"
SRC_URI[aarch64_rust-bindgen-devel.sha256sum] = "c08cb4924d868f7e59ce0547ffae4068a19f6716261d1d22f7923b98302d5200"

RDEPENDS:rust-bindgen+__cli-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap_complete+default-devel \
 "
RDEPENDS:rust-bindgen+__testing_only_extra_assertions-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+__testing_only_libclang_16-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+__testing_only_libclang_9-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+default-devel = " \
 cargo \
 rust-bindgen+logging-devel \
 rust-bindgen+prettyplease-devel \
 rust-bindgen+runtime-devel \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+experimental-devel = " \
 cargo \
 rust-annotate-snippets0.11+default-devel \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+logging-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-bindgen+prettyplease-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-prettyplease+default-devel \
 rust-prettyplease+verbatim-devel \
 "
RDEPENDS:rust-bindgen+runtime-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-clang-sys+runtime-devel \
 "
RDEPENDS:rust-bindgen+static-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-clang-sys+static-devel \
 "
RDEPENDS:rust-bindgen-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cexpr+default-devel \
 rust-clang-sys+clang_11_0-devel \
 rust-clang-sys+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote-devel \
 rust-regex+std-devel \
 rust-regex+unicode-perl-devel \
 rust-regex-devel \
 rust-rustc-hash+default-devel \
 rust-shlex+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-mut-devel \
 virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.14.0~ \
 "
