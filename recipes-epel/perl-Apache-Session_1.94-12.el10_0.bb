# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Apache-Session"
PV = "1.94"
PR = "12.el10_0"
PACKAGES = " \
 perl-Apache-Session \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Apache-Session-1.94-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "041a482e6403a0a153a60356d5df0a729b468f51cd9c049fc1f58eb154b130ec"

URI_x86_64_v2_perl-Apache-Session = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Apache-Session-1.94-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Apache-Session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Apache-Session}"
SRC_URI[x86_64_v2_perl-Apache-Session.sha256sum] = "850c69b30989bc653dabd916ef04038e82c495090a0a1cfefdfbd2de6095a8d6"

URI_aarch64_perl-Apache-Session = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Apache-Session-1.94-12.el10_0.noarch.rpm;name=aarch64_perl-Apache-Session;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Apache-Session}"
SRC_URI[aarch64_perl-Apache-Session.sha256sum] = "1f03e9554953e0b193a1e3caad11fd39dc4764148f674570390e780f301d17bb"

RDEPENDS:perl-Apache-Session = " \
 perl-Apache-Session \
 perl-CGI \
 perl-Carp \
 perl-DBI \
 perl-DB_File \
 perl-Digest-MD5 \
 perl-Fcntl \
 perl-IO \
 perl-IPC-SysV \
 perl-MIME-Base64 \
 perl-Storable \
 perl-Symbol \
 perl-constant \
 perl-libs \
 perl-vars \
 "
