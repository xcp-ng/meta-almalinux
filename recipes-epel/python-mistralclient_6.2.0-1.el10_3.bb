# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mistralclient"
PV = "6.2.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-mistralclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mistralclient-6.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77e5c4f57fd657413b3b7c5c9453016d2d4372e2d14f959ce2b62bb834ea0577"

URI_x86_64_v2_python3-mistralclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mistralclient-6.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mistralclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mistralclient}"
SRC_URI[x86_64_v2_python3-mistralclient.sha256sum] = "a0a116b47b782d352c471e66e39d9ae97d455d2385b2e70301418d0a0bbd08bc"

URI_aarch64_python3-mistralclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mistralclient-6.2.0-1.el10_3.noarch.rpm;name=aarch64_python3-mistralclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mistralclient}"
SRC_URI[aarch64_python3-mistralclient.sha256sum] = "5bad387ae1819cb0e3698de9cb0626fa83cfe5b2a8fba0b00f47e15dc8cc6605"

RDEPENDS:python3-mistralclient = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-pyyaml \
 python3-requests \
 python3-stevedore \
 "
