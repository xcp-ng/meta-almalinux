# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum_macros0.26"
PV = "0.26.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-strum_macros0.26+default-devel \
 rust-strum_macros0.26-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum_macros0.26-0.26.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11fc6863c73867a8fa65e3710b3ffcd9e4372e31f8f6e7284cb4975437fc0633"

URI_x86_64_v2_rust-strum_macros0.26+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros0.26+default-devel-0.26.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros0.26+default-devel}"
SRC_URI[x86_64_v2_rust-strum_macros0.26+default-devel.sha256sum] = "f9052fa307efa719fa2fb24a9becba37dc1b4c43ff6424bd3239e1d2535f67e5"

URI_x86_64_v2_rust-strum_macros0.26-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros0.26-devel-0.26.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros0.26-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros0.26-devel}"
SRC_URI[x86_64_v2_rust-strum_macros0.26-devel.sha256sum] = "c4f2d900b6b8bed6f92af298d05656610efafdd46819523e98bd6136341cabe1"

URI_aarch64_rust-strum_macros0.26+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros0.26+default-devel-0.26.4-1.el10_1.noarch.rpm;name=aarch64_rust-strum_macros0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros0.26+default-devel}"
SRC_URI[aarch64_rust-strum_macros0.26+default-devel.sha256sum] = "aa09949f1e8d00bf53f1602ce2a54eaaf736dcec3746d80f8fcc0aab7bad75f3"

URI_aarch64_rust-strum_macros0.26-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros0.26-devel-0.26.4-1.el10_1.noarch.rpm;name=aarch64_rust-strum_macros0.26-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros0.26-devel}"
SRC_URI[aarch64_rust-strum_macros0.26-devel.sha256sum] = "6839368d26c7b75a2b76d19d3336001a0ffef3c558b52fa9b137a73ba88e818f"

RDEPENDS:rust-strum_macros0.26+default-devel = " \
 cargo \
 rust-strum_macros0.26-devel \
 "
RDEPENDS:rust-strum_macros0.26-devel = " \
 cargo \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-rustversion+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+parsing-devel \
 "
