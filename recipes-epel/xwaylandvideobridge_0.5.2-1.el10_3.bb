# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xwaylandvideobridge"
PV = "0.5.2"
PR = "1.el10_3"
PACKAGES = " \
 xwaylandvideobridge \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/x/xwaylandvideobridge-0.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dcb9cd0dadf2450f04cc4a94fb1cfb3e4c7760fa512d12f4fc80e58b45861a8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xwaylandvideobridge-0.5.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xwaylandvideobridge;unpack=0"
SRC_URI[x86_64_v2_xwaylandvideobridge.sha256sum] = "103c042706e86141783b11208993e36de3a27a304b0cfbc231cfccc0359d43b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xwaylandvideobridge-0.5.2-1.el10_3.aarch64.rpm;name=aarch64_xwaylandvideobridge;unpack=0"
SRC_URI[aarch64_xwaylandvideobridge.sha256sum] = "1000714b94e1510bf507cd8dfd55bf6639ca93093657cf06ba0ed941bf4fdf3c"

RDEPENDS:xwaylandvideobridge = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kpipewire \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
