# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fapolicyd"
PV = "1.6"
PR = "1.el10"
PACKAGES = " \
 fapolicyd \
 fapolicyd-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fapolicyd-1.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fef3968429c662d9ae3ee60dd8fc12fee34e0c9067300b2eff1ec435a1c7d733"

URI_x86_64_v2_fapolicyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fapolicyd-1.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_fapolicyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicyd}"
SRC_URI[x86_64_v2_fapolicyd.sha256sum] = "9c348a3198729422a2e1c18740f7e428f0c47a9efaa79f44e8668411e9dccca7"

URI_x86_64_v2_fapolicyd-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fapolicyd-selinux-1.6-1.el10.noarch.rpm;name=x86_64_v2_fapolicyd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicyd-selinux}"
SRC_URI[x86_64_v2_fapolicyd-selinux.sha256sum] = "6a55baf78d01506a5a3e31af4680b8ea5d9a72bd61a80fe5723fc77d11a7bbe5"

URI_aarch64_fapolicyd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fapolicyd-1.6-1.el10.aarch64.rpm;name=aarch64_fapolicyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicyd}"
SRC_URI[aarch64_fapolicyd.sha256sum] = "ee4869565d43c5e108530552ac10765c3baf56bff30adb0cd984b531291692c2"

URI_aarch64_fapolicyd-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fapolicyd-selinux-1.6-1.el10.noarch.rpm;name=aarch64_fapolicyd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicyd-selinux}"
SRC_URI[aarch64_fapolicyd-selinux.sha256sum] = "6a55baf78d01506a5a3e31af4680b8ea5d9a72bd61a80fe5723fc77d11a7bbe5"

RDEPENDS:fapolicyd = " \
 bash \
 file-libs \
 glibc \
 libcap-ng \
 libseccomp \
 lmdb-libs \
 openssl-libs \
 rpm-libs \
 rpm-plugin-fapolicyd \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:fapolicyd-selinux = " \
 bash \
 fapolicyd \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
