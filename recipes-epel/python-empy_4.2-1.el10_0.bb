# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-empy"
PV = "4.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-empy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-empy-4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ace1efc9bef0f90ee973e9d885a75440d232f0d16b21c906c87155f5b041ae6"

URI_x86_64_v2_python3-empy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-empy-4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-empy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-empy}"
SRC_URI[x86_64_v2_python3-empy.sha256sum] = "6ed85bc0a33669321318109c77ce74a30efe4f8d4f415ffbd8aab697973866ff"

URI_aarch64_python3-empy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-empy-4.2-1.el10_0.noarch.rpm;name=aarch64_python3-empy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-empy}"
SRC_URI[aarch64_python3-empy.sha256sum] = "01712bdeb457a33695c60f8b90fcf75ac74558edf8a943662f7ff424f39ac734"

RDEPENDS:python3-empy = " \
 python3 \
 "
