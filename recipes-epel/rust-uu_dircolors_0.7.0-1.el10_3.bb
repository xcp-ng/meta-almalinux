# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_dircolors"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_dircolors+default-devel \
 rust-uu_dircolors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_dircolors-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8975b2891f8f7ac41facf7f6edb75cc82b8f2d1532ad77f525545e905ac0fcf"

URI_x86_64_v2_rust-uu_dircolors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_dircolors+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_dircolors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_dircolors+default-devel}"
SRC_URI[x86_64_v2_rust-uu_dircolors+default-devel.sha256sum] = "f6eb637ec9911d11b4e4165e1d6b8b08706602efa11fb95b6e29eab5570f51c3"

URI_x86_64_v2_rust-uu_dircolors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_dircolors-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_dircolors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_dircolors-devel}"
SRC_URI[x86_64_v2_rust-uu_dircolors-devel.sha256sum] = "f355bd74af2cabbcaf8d3242a9f9ff16add9b97a16ce4f1d319ad4a6d02b7772"

URI_aarch64_rust-uu_dircolors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_dircolors+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_dircolors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_dircolors+default-devel}"
SRC_URI[aarch64_rust-uu_dircolors+default-devel.sha256sum] = "6e0dc077ddcfd81fb6c8e9c96e0cb8136953165e6355121153b61d84abeaf8ed"

URI_aarch64_rust-uu_dircolors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_dircolors-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_dircolors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_dircolors-devel}"
SRC_URI[aarch64_rust-uu_dircolors-devel.sha256sum] = "45605aed388ec752ca97ea3bc395bac7bb39fbbac4951e581500494702c43662"

RDEPENDS:rust-uu_dircolors+default-devel = " \
 cargo \
 rust-uu_dircolors-devel \
 "
RDEPENDS:rust-uu_dircolors-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+colors-devel \
 rust-uucore+default-devel \
 rust-uucore+parser-devel \
 "
