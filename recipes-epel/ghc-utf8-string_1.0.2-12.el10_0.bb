# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-utf8-string"
PV = "1.0.2"
PR = "12.el10_0"
PACKAGES = " \
 ghc-utf8-string \
 ghc-utf8-string-devel \
 ghc-utf8-string-doc \
 ghc-utf8-string-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-utf8-string-1.0.2-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "206223923c28269d0959cc892e06cc9db06d80bc606db22801f08669fe9c048e"

URI_x86_64_v2_ghc-utf8-string = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-utf8-string-1.0.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-utf8-string;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-utf8-string}"
SRC_URI[x86_64_v2_ghc-utf8-string.sha256sum] = "5afc92cc4913f03912d34af79e33760b97446a0ecccb13342f5bb5bba59da63e"

URI_x86_64_v2_ghc-utf8-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-utf8-string-devel-1.0.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-utf8-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-utf8-string-devel}"
SRC_URI[x86_64_v2_ghc-utf8-string-devel.sha256sum] = "d16ab35136ec308af5378c7dc8601625ab6a0f51fd70f07904eb94fa19638a95"

URI_x86_64_v2_ghc-utf8-string-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-utf8-string-doc-1.0.2-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-utf8-string-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-utf8-string-doc}"
SRC_URI[x86_64_v2_ghc-utf8-string-doc.sha256sum] = "8f28ec41738235fc3701e05e9111be1b8f4dc2add856ba88c052355dd842e3a8"

URI_x86_64_v2_ghc-utf8-string-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-utf8-string-prof-1.0.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-utf8-string-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-utf8-string-prof}"
SRC_URI[x86_64_v2_ghc-utf8-string-prof.sha256sum] = "ea223351c53556fcbeb30b5e13974ed811f6f8731bda9b95eb11d73263a83e06"

URI_aarch64_ghc-utf8-string = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-utf8-string-1.0.2-12.el10_0.aarch64.rpm;name=aarch64_ghc-utf8-string;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-utf8-string}"
SRC_URI[aarch64_ghc-utf8-string.sha256sum] = "ccbeca6bcf4e34e91d37805322e5a767740d8ac80ce7db089806ce9c6ca92aca"

URI_aarch64_ghc-utf8-string-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-utf8-string-devel-1.0.2-12.el10_0.aarch64.rpm;name=aarch64_ghc-utf8-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-utf8-string-devel}"
SRC_URI[aarch64_ghc-utf8-string-devel.sha256sum] = "9f1e9f0a4d8704d861e41aabbdfa34ff6305dc5c0445f1ee5f59e42e06988302"

URI_aarch64_ghc-utf8-string-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-utf8-string-doc-1.0.2-12.el10_0.noarch.rpm;name=aarch64_ghc-utf8-string-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-utf8-string-doc}"
SRC_URI[aarch64_ghc-utf8-string-doc.sha256sum] = "4cd554cfb5594e5405a1d5361657a7370ddadd1d6ac3c86b83c9fd92017b18a9"

URI_aarch64_ghc-utf8-string-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-utf8-string-prof-1.0.2-12.el10_0.aarch64.rpm;name=aarch64_ghc-utf8-string-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-utf8-string-prof}"
SRC_URI[aarch64_ghc-utf8-string-prof.sha256sum] = "834abbd0f6b4517cd8c31f007583ffeb307745c925b1884777b13c5aa9ddac66"

RDEPENDS:ghc-utf8-string = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-utf8-string-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-utf8-string \
 "
RDEPENDS:ghc-utf8-string-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-utf8-string-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-utf8-string-devel \
 "
