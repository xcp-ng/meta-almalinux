# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-appender"
PV = "0.2.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-tracing-appender+default-devel \
 rust-tracing-appender+parking_lot-devel \
 rust-tracing-appender-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-appender-0.2.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20d3eba0e8ef1d1d479df0f321cd8aa1ebd75b0d935c4d1fcb17d19270f98538"

URI_x86_64_v2_rust-tracing-appender+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-appender+default-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-appender+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-appender+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-appender+default-devel.sha256sum] = "760973836d91d1502eddf7396adb8e6519720ab6375fce25f7cc233efb816352"

URI_x86_64_v2_rust-tracing-appender+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-appender+parking_lot-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-appender+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-appender+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-tracing-appender+parking_lot-devel.sha256sum] = "1ee571d08971f5cdfe5bae141eaa53b3a69bf57b7d1e87d664b502c825071639"

URI_x86_64_v2_rust-tracing-appender-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-appender-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-appender-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-appender-devel}"
SRC_URI[x86_64_v2_rust-tracing-appender-devel.sha256sum] = "6fc1852d3e918fe99388827a784adbd3321c5f772572b2950b8a95243500f766"

URI_aarch64_rust-tracing-appender+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-appender+default-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-appender+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-appender+default-devel}"
SRC_URI[aarch64_rust-tracing-appender+default-devel.sha256sum] = "81a10df5fb9a097d579f3b83c7c9e8558bc71e880ddc232389b013a796f6c876"

URI_aarch64_rust-tracing-appender+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-appender+parking_lot-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-appender+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-appender+parking_lot-devel}"
SRC_URI[aarch64_rust-tracing-appender+parking_lot-devel.sha256sum] = "b74cc2a7786575f12b41233904475d1585c0b6079590027882f200cc432defb8"

URI_aarch64_rust-tracing-appender-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-appender-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-appender-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-appender-devel}"
SRC_URI[aarch64_rust-tracing-appender-devel.sha256sum] = "80276d8961f1f611d1951844fafddba3bf54098452b03552c769a499b1305fbb"

RDEPENDS:rust-tracing-appender+default-devel = " \
 cargo \
 rust-tracing-appender-devel \
 "
RDEPENDS:rust-tracing-appender+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-tracing-appender-devel \
 "
RDEPENDS:rust-tracing-appender-devel = " \
 cargo \
 rust \
 rust-crossbeam-channel+default-devel \
 rust-thiserror+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
