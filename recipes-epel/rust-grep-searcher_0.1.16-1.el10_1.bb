# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-searcher"
PV = "0.1.16"
PR = "1.el10_1"
PACKAGES = " \
 rust-grep-searcher+default-devel \
 rust-grep-searcher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-searcher-0.1.16-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15f1212e6fb0a147ec2cb1572c7de39822d0c7c9180261725ef6f6dc2f4b09e9"

URI_x86_64_v2_rust-grep-searcher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-searcher+default-devel-0.1.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-searcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-searcher+default-devel}"
SRC_URI[x86_64_v2_rust-grep-searcher+default-devel.sha256sum] = "1c2586e8a3cfdf56402f7efd824bf3ff2461abe16628169bb1f1beeeb08e2da4"

URI_x86_64_v2_rust-grep-searcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-searcher-devel-0.1.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-searcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-searcher-devel}"
SRC_URI[x86_64_v2_rust-grep-searcher-devel.sha256sum] = "5cfb81f564cec02f0c625116fa422e453df9f063a9f797c9feb91d43393df2e1"

URI_aarch64_rust-grep-searcher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-searcher+default-devel-0.1.16-1.el10_1.noarch.rpm;name=aarch64_rust-grep-searcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-searcher+default-devel}"
SRC_URI[aarch64_rust-grep-searcher+default-devel.sha256sum] = "604770c9280909524493371de364c4bea88370fef59dbf2d798f5786f2da4e59"

URI_aarch64_rust-grep-searcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-searcher-devel-0.1.16-1.el10_1.noarch.rpm;name=aarch64_rust-grep-searcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-searcher-devel}"
SRC_URI[aarch64_rust-grep-searcher-devel.sha256sum] = "2be34ac9ba57e522464d246ca2a340849083a1250e8b5cdc0f3e734438cc6b64"

RDEPENDS:rust-grep-searcher+default-devel = " \
 cargo \
 rust-grep-searcher-devel \
 "
RDEPENDS:rust-grep-searcher-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-encoding_rs+default-devel \
 rust-encoding_rs_io+default-devel \
 rust-grep-matcher+default-devel \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-memmap2+default-devel \
 "
