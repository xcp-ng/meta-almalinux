# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling_macro"
PV = "0.21.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-darling_macro+default-devel \
 rust-darling_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling_macro-0.21.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d2e1737b351a33fb50009404296ae54b47c5624351dddeb1c95c75408d91e97"

URI_x86_64_v2_rust-darling_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_macro+default-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_macro+default-devel}"
SRC_URI[x86_64_v2_rust-darling_macro+default-devel.sha256sum] = "ba2fe162dcf4bf33f6e6e8b19e873dbc3a6864abd07fa76099e672f32bd47941"

URI_x86_64_v2_rust-darling_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_macro-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_macro-devel}"
SRC_URI[x86_64_v2_rust-darling_macro-devel.sha256sum] = "76ee18dff2ce6f8e4214c820ccb0564a2b535e7af1c25532dadfb43f26b33fab"

URI_aarch64_rust-darling_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_macro+default-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_macro+default-devel}"
SRC_URI[aarch64_rust-darling_macro+default-devel.sha256sum] = "4be5d5233d0352822035a1fe8bc69ed3dbeba5d3dd7c2d52a8060e7830b6d874"

URI_aarch64_rust-darling_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_macro-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-darling_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_macro-devel}"
SRC_URI[aarch64_rust-darling_macro-devel.sha256sum] = "7d1a1d89bf0365ae503a1e66610de65bc4499a8c7b727b8a98a0724f5eb2e799"

RDEPENDS:rust-darling_macro+default-devel = " \
 cargo \
 rust-darling_macro-devel \
 "
RDEPENDS:rust-darling_macro-devel = " \
 cargo \
 rust \
 rust-darling_core+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
