# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opensmtpd"
PV = "7.8.0p1"
PR = "1.el10_3"
PACKAGES = " \
 opensmtpd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opensmtpd-7.8.0p1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67280bd6ff2a9b2027aa15c7c42677714080f5a3c0fe68c84a217e10dda46e75"

URI_x86_64_v2_opensmtpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opensmtpd-7.8.0p1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opensmtpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opensmtpd}"
SRC_URI[x86_64_v2_opensmtpd.sha256sum] = "56427a9d86d0bd3ad82de42821e7f1d59b016882cfea3d948cbe7008ad41798e"
RPROVIDES:opensmtpd:x86_64_v2 = "virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

URI_aarch64_opensmtpd = "${EPEL_MIRROR}/aarch64/Packages/o/opensmtpd-7.8.0p1-1.el10_3.aarch64.rpm;name=aarch64_opensmtpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_opensmtpd}"
SRC_URI[aarch64_opensmtpd.sha256sum] = "68d3809c430e04839e2dea00f27ed8bfbf31059195231538718e0775e1dab9e0"
RPROVIDES:opensmtpd:aarch64 = "virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

RDEPENDS:opensmtpd = " \
 bash \
 glibc \
 libdb \
 libevent \
 libxcrypt \
 openssl-libs \
 pam-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/mailq rpm/virtual//usr/sbin/sendmail rpm/virtual/smtpdaemon"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/mailq rpm/virtual//usr/sbin/sendmail rpm/virtual/smtpdaemon"
