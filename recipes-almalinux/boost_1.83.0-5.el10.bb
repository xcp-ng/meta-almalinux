# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "boost"
PV = "1.83.0"
PR = "5.el10"
PACKAGES = " \
 boost \
 boost-atomic \
 boost-b2 \
 boost-build \
 boost-chrono \
 boost-container \
 boost-context \
 boost-contract \
 boost-coroutine \
 boost-date-time \
 boost-devel \
 boost-doc \
 boost-doctools \
 boost-examples \
 boost-fiber \
 boost-filesystem \
 boost-graph \
 boost-graph-mpich \
 boost-graph-openmpi \
 boost-iostreams \
 boost-json \
 boost-locale \
 boost-log \
 boost-math \
 boost-mpich \
 boost-mpich-devel \
 boost-mpich-python3 \
 boost-nowide \
 boost-numpy3 \
 boost-openmpi \
 boost-openmpi-devel \
 boost-openmpi-python3 \
 boost-program-options \
 boost-python3 \
 boost-random \
 boost-regex \
 boost-serialization \
 boost-stacktrace \
 boost-static \
 boost-system \
 boost-test \
 boost-thread \
 boost-timer \
 boost-type_erasure \
 boost-wave \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/boost-1.83.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "544d76f20ac6c4d3e4cb3a785ff631a640b506d2f409bc239da2a80bf2733d8c"

URI_x86_64_v2_boost = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost}"
SRC_URI[x86_64_v2_boost.sha256sum] = "3f2fccf305080d32d4b3b8e488ec6018386538da810b031915441fe95472af90"

URI_x86_64_v2_boost-atomic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-atomic-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-atomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-atomic}"
SRC_URI[x86_64_v2_boost-atomic.sha256sum] = "b881a7e871679376b4af88daec7a00d9e5df8c06b8d40bf032948c6928f84170"

URI_x86_64_v2_boost-b2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-b2-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-b2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-b2}"
SRC_URI[x86_64_v2_boost-b2.sha256sum] = "da23a31b4af45a759b288d396077c8c0c320547184317503767f3c0041925776"

URI_x86_64_v2_boost-build = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-build-1.83.0-5.el10.noarch.rpm;name=x86_64_v2_boost-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-build}"
SRC_URI[x86_64_v2_boost-build.sha256sum] = "215c8352ca171d8fab43323c2bdbe1c81b3ffa5b150996da707a36dacbe1f8c3"

URI_x86_64_v2_boost-chrono = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-chrono-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-chrono;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-chrono}"
SRC_URI[x86_64_v2_boost-chrono.sha256sum] = "2514b4882459d9651bbb0cc6aad6f189287957f5ffe0b15420c89981e5e5156d"

URI_x86_64_v2_boost-container = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-container-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-container;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-container}"
SRC_URI[x86_64_v2_boost-container.sha256sum] = "9d54f99adb6cf7a70d7f8a4a605cafb8a594afed2d73c7d8b0f0d8d6ceb26c12"

URI_x86_64_v2_boost-context = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-context-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-context;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-context}"
SRC_URI[x86_64_v2_boost-context.sha256sum] = "ffeb29c5d7d6cb3cde117a2045d70cfbb8cc297d470e82882c7cc2ec31882976"

URI_x86_64_v2_boost-contract = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-contract-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-contract;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-contract}"
SRC_URI[x86_64_v2_boost-contract.sha256sum] = "2838ad1c291210e905e6baad1d79cb699b3ab65da287a1f1a9527bae36e1215a"

URI_x86_64_v2_boost-coroutine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-coroutine-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-coroutine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-coroutine}"
SRC_URI[x86_64_v2_boost-coroutine.sha256sum] = "b0e694e7362f3b3b07c6d56e38ffb508fe99fc49a21960070cf64dc74c16067b"

URI_x86_64_v2_boost-date-time = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-date-time-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-date-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-date-time}"
SRC_URI[x86_64_v2_boost-date-time.sha256sum] = "0cadf394666c8886cdd0504dd128865a1941ab221504a3c2131e1f10ee494cb3"

URI_x86_64_v2_boost-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-devel-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-devel}"
SRC_URI[x86_64_v2_boost-devel.sha256sum] = "23097f333447163909baadc295303f839b8c8d8ef0f407dd56bf8e4c483a0122"

URI_x86_64_v2_boost-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-doc-1.83.0-5.el10.noarch.rpm;name=x86_64_v2_boost-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-doc}"
SRC_URI[x86_64_v2_boost-doc.sha256sum] = "114bcbe588d75f01cb108a2c4f41b2de81530234fc88ac28deabb8e031aa9930"

URI_x86_64_v2_boost-doctools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-doctools-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-doctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-doctools}"
SRC_URI[x86_64_v2_boost-doctools.sha256sum] = "3b77fc924c08013c36172eef7a164e7b54729203baa5d15b9be8c9a510dfd4e7"

URI_x86_64_v2_boost-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-examples-1.83.0-5.el10.noarch.rpm;name=x86_64_v2_boost-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-examples}"
SRC_URI[x86_64_v2_boost-examples.sha256sum] = "31ce38d7432c449a531fd9eb4dfbba6c12842da0db66b8b8b2ed804941e6fe84"

URI_x86_64_v2_boost-fiber = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-fiber-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-fiber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-fiber}"
SRC_URI[x86_64_v2_boost-fiber.sha256sum] = "b299c4fbca9f46b5f9ec9433bd06d62a6c5c82c83045f518366cb8f62580ae2b"

URI_x86_64_v2_boost-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-filesystem-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-filesystem}"
SRC_URI[x86_64_v2_boost-filesystem.sha256sum] = "d39ca3e645c63c74eb7197db7f383c951eefdb1cd1039f6a3f10ef3a5b0277f0"

URI_x86_64_v2_boost-graph = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-graph-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-graph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-graph}"
SRC_URI[x86_64_v2_boost-graph.sha256sum] = "3576b512c1fd42bdb0005ab69af8cf5ea81e6c20e476980017ae497e18fb8674"

URI_x86_64_v2_boost-graph-mpich = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-graph-mpich-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-graph-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-graph-mpich}"
SRC_URI[x86_64_v2_boost-graph-mpich.sha256sum] = "3507d05d3344017d42fb64c1010475d7b0ce92d0829c331fd61e079710bb4f9b"

URI_x86_64_v2_boost-graph-openmpi = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-graph-openmpi-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-graph-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-graph-openmpi}"
SRC_URI[x86_64_v2_boost-graph-openmpi.sha256sum] = "7fec08a9863be59f7bfc1be262676f3d2dc76f06225e0b640744280879fad6eb"

URI_x86_64_v2_boost-iostreams = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-iostreams-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-iostreams;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-iostreams}"
SRC_URI[x86_64_v2_boost-iostreams.sha256sum] = "f130b0096b5de0d5b9e6608dc18d2ed18962d37a79c695d40def5e9ef8047908"

URI_x86_64_v2_boost-json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-json-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-json}"
SRC_URI[x86_64_v2_boost-json.sha256sum] = "5b844fbd2434f1dc28447457c111c79f73087f5f3069e44d2bfb6209aac03542"

URI_x86_64_v2_boost-locale = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-locale-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-locale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-locale}"
SRC_URI[x86_64_v2_boost-locale.sha256sum] = "7ef52ceb41f0f1185ebe09423bbd6e58e8a198968d4f838fa722ff6d06551c1b"

URI_x86_64_v2_boost-log = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-log-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-log}"
SRC_URI[x86_64_v2_boost-log.sha256sum] = "6e0bb89be533eed4c243c49e8aa7f2f686dc572f0d50b327a14364cd95258c84"

URI_x86_64_v2_boost-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-math-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-math}"
SRC_URI[x86_64_v2_boost-math.sha256sum] = "dd24b60512c9d6fe3685b87bd42bacfa70b0f7b8b0a1a07e2053b959636570d8"

URI_x86_64_v2_boost-mpich = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-mpich-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-mpich}"
SRC_URI[x86_64_v2_boost-mpich.sha256sum] = "d45c153f8df234201c3aa0f39387a685aa471e1ce95dfc690fb89ffc6e0e716b"

URI_x86_64_v2_boost-mpich-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-mpich-devel-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-mpich-devel}"
SRC_URI[x86_64_v2_boost-mpich-devel.sha256sum] = "85a3e47bf5a15802ac5113cd0d62d2d39a8813db60f0175a8bec624bd2e33608"

URI_x86_64_v2_boost-mpich-python3 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-mpich-python3-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-mpich-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-mpich-python3}"
SRC_URI[x86_64_v2_boost-mpich-python3.sha256sum] = "ae3d93fc5feb952bcf713928825c86b975fda7dcff42ffe12f55feab0cbb26b9"

URI_x86_64_v2_boost-nowide = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-nowide-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-nowide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-nowide}"
SRC_URI[x86_64_v2_boost-nowide.sha256sum] = "34e3c7a0d91f6d523d6a1bc74246794d0cacc61426167e2cca66404c04959b6b"

URI_x86_64_v2_boost-numpy3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-numpy3-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-numpy3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-numpy3}"
SRC_URI[x86_64_v2_boost-numpy3.sha256sum] = "12b5c2fca8a5408d85d91f0bc0a6aa28b77a3062aef35b72bc5cc257cc1e5f21"

URI_x86_64_v2_boost-openmpi = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-openmpi-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-openmpi}"
SRC_URI[x86_64_v2_boost-openmpi.sha256sum] = "a4c6c5f08cebaa67c340433ddff701ce9c2f9a48e38974d363f4fa1b314db882"

URI_x86_64_v2_boost-openmpi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-openmpi-devel-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-openmpi-devel}"
SRC_URI[x86_64_v2_boost-openmpi-devel.sha256sum] = "7bea1e7103bdd81bb45886adcf27bbb773c3886fb829a53f99206c900e786ab9"

URI_x86_64_v2_boost-openmpi-python3 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-openmpi-python3-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-openmpi-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-openmpi-python3}"
SRC_URI[x86_64_v2_boost-openmpi-python3.sha256sum] = "7de24de4bb756019aa809ee375146e86226d75bddf8a94b95171fdd59269fa6a"

URI_x86_64_v2_boost-program-options = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-program-options-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-program-options;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-program-options}"
SRC_URI[x86_64_v2_boost-program-options.sha256sum] = "6ea3a5157c7ab3611b1afa4794f76c69043ce29f668ed8f155cc904a7de8d722"

URI_x86_64_v2_boost-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-python3-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-python3}"
SRC_URI[x86_64_v2_boost-python3.sha256sum] = "030f680be399fc9d8de487e8df8d3ca9c7c0318795282185634e0610209c7c59"

URI_x86_64_v2_boost-random = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-random-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-random;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-random}"
SRC_URI[x86_64_v2_boost-random.sha256sum] = "5a21e19f823ff9c60e0632be4ddca97737fe93b72e0ca441df60bd3816f37116"

URI_x86_64_v2_boost-regex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-regex-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-regex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-regex}"
SRC_URI[x86_64_v2_boost-regex.sha256sum] = "72b7ace0a88b7bc4af8b1f86870ecdee0ad9ebc0fbe4c15e1eb7109f9803f28b"

URI_x86_64_v2_boost-serialization = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-serialization-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-serialization;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-serialization}"
SRC_URI[x86_64_v2_boost-serialization.sha256sum] = "313c0228949e7fac5513a99132d299d9745dcaba90b70adb39a65f34cee68343"

URI_x86_64_v2_boost-stacktrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-stacktrace-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-stacktrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-stacktrace}"
SRC_URI[x86_64_v2_boost-stacktrace.sha256sum] = "e283154fb361ad346492eea84d88dc9ec9573fc3d3647450f6449e7cc0676272"

URI_x86_64_v2_boost-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/boost-static-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-static}"
SRC_URI[x86_64_v2_boost-static.sha256sum] = "8525bb65dea18755d3454017d4c7d02ffdfc788158e0de8f71cc1323a28fd690"

URI_x86_64_v2_boost-system = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/boost-system-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-system}"
SRC_URI[x86_64_v2_boost-system.sha256sum] = "d67a0f420212d1b8c0d95a85752558b97933e4e9ba2f9db761b230bf9a3bce49"

URI_x86_64_v2_boost-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-test-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-test}"
SRC_URI[x86_64_v2_boost-test.sha256sum] = "a0fabafc708aa133e9bfe08d9b2b2f00cee54e9e5421cfedb9fffc74ef1c763b"

URI_x86_64_v2_boost-thread = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-thread-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-thread;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-thread}"
SRC_URI[x86_64_v2_boost-thread.sha256sum] = "66a761734fad97232183e59894e6fd5bb42a58e066629d92f2be82bc989526c3"

URI_x86_64_v2_boost-timer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-timer-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-timer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-timer}"
SRC_URI[x86_64_v2_boost-timer.sha256sum] = "0c30a0719406c04570df5d19123e6c2f080ba4196cc95724bedecc5c3cca366d"

URI_x86_64_v2_boost-type_erasure = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-type_erasure-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-type_erasure;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-type_erasure}"
SRC_URI[x86_64_v2_boost-type_erasure.sha256sum] = "8ba2d06ab29cbd376cf9f96bbd23bafba8e6eef676eaec76b31798ab6209c094"

URI_x86_64_v2_boost-wave = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boost-wave-1.83.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_boost-wave;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boost-wave}"
SRC_URI[x86_64_v2_boost-wave.sha256sum] = "5582f362a9b54ce47bf0e568de52f56dc1edad8338724adecdeafdae4b035c3a"

URI_aarch64_boost = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost}"
SRC_URI[aarch64_boost.sha256sum] = "6609fc7472f648d032ed55e7d3c7d1664ba4c72dfff122d491964dd4826f2b57"

URI_aarch64_boost-atomic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-atomic-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-atomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-atomic}"
SRC_URI[aarch64_boost-atomic.sha256sum] = "b60476986486de9f01b81202b1da74b2015722604e8dc142c34fcb4a7268ce64"

URI_aarch64_boost-b2 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-b2-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-b2;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-b2}"
SRC_URI[aarch64_boost-b2.sha256sum] = "5897a50e2f0b1f713fcd92bc29088b979a9825125ef428bdef84220169d51185"

URI_aarch64_boost-build = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-build-1.83.0-5.el10.noarch.rpm;name=aarch64_boost-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-build}"
SRC_URI[aarch64_boost-build.sha256sum] = "215c8352ca171d8fab43323c2bdbe1c81b3ffa5b150996da707a36dacbe1f8c3"

URI_aarch64_boost-chrono = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-chrono-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-chrono;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-chrono}"
SRC_URI[aarch64_boost-chrono.sha256sum] = "b88dee64b4557f1e357f91fd0caec6b0a0fbb76a1aa440dd23c0db3878abd26f"

URI_aarch64_boost-container = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-container-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-container;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-container}"
SRC_URI[aarch64_boost-container.sha256sum] = "035e6019033268c256329f89118ca21400ce937dad3c0ec48f1049b8535f104f"

URI_aarch64_boost-context = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-context-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-context;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-context}"
SRC_URI[aarch64_boost-context.sha256sum] = "2031002d68755fa8311bdc47b6e2489616ec7245a8d9c9052642c4ce2ed72cbe"

URI_aarch64_boost-contract = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-contract-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-contract;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-contract}"
SRC_URI[aarch64_boost-contract.sha256sum] = "4dfdcd32631467747102e944bc0190790d97e76576d7d3d38ca96c9f74df2738"

URI_aarch64_boost-coroutine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-coroutine-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-coroutine;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-coroutine}"
SRC_URI[aarch64_boost-coroutine.sha256sum] = "c0672c1c5ed8599f69d0ab4d045606ab2731d798e910543b2f276acc565aac0b"

URI_aarch64_boost-date-time = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-date-time-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-date-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-date-time}"
SRC_URI[aarch64_boost-date-time.sha256sum] = "392585246b0f358e37796dbec5c45164a178b2cf9078cb7d9b5ae78740d24c40"

URI_aarch64_boost-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-devel-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-devel}"
SRC_URI[aarch64_boost-devel.sha256sum] = "62a37787d0dfdc6ae31f72a97eea7de34c90e760f002fc579998ceb2e25d2f65"

URI_aarch64_boost-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-doc-1.83.0-5.el10.noarch.rpm;name=aarch64_boost-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-doc}"
SRC_URI[aarch64_boost-doc.sha256sum] = "114bcbe588d75f01cb108a2c4f41b2de81530234fc88ac28deabb8e031aa9930"

URI_aarch64_boost-doctools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-doctools-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-doctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-doctools}"
SRC_URI[aarch64_boost-doctools.sha256sum] = "d6a33c913a7934d6e4af7a69d70a49a70bca0d2052cf7ea8a81ef29044bb4e6a"

URI_aarch64_boost-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-examples-1.83.0-5.el10.noarch.rpm;name=aarch64_boost-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-examples}"
SRC_URI[aarch64_boost-examples.sha256sum] = "31ce38d7432c449a531fd9eb4dfbba6c12842da0db66b8b8b2ed804941e6fe84"

URI_aarch64_boost-fiber = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-fiber-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-fiber;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-fiber}"
SRC_URI[aarch64_boost-fiber.sha256sum] = "16e62ce6cfa5317879df7eca28d94a6fb680f32d90095ea9eb8f89feedd1cd18"

URI_aarch64_boost-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-filesystem-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-filesystem}"
SRC_URI[aarch64_boost-filesystem.sha256sum] = "6053f21e34dd61a0f062350eecc573e5b8c76275c484c05f9959525923f4fe04"

URI_aarch64_boost-graph = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-graph-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-graph;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-graph}"
SRC_URI[aarch64_boost-graph.sha256sum] = "02e9c3d0758d9c1f74f2320f45399d0136835fbb688ac0272be88464da4c328f"

URI_aarch64_boost-graph-mpich = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-graph-mpich-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-graph-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-graph-mpich}"
SRC_URI[aarch64_boost-graph-mpich.sha256sum] = "0b0ed24ab9e5f849a828e636f27749c611a8c781689081637a9e268d8394e485"

URI_aarch64_boost-graph-openmpi = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-graph-openmpi-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-graph-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-graph-openmpi}"
SRC_URI[aarch64_boost-graph-openmpi.sha256sum] = "1b1d0ccc64ac14f3c261e42157bbed6b2d02c5812ee6673496d1d9dbe89ee453"

URI_aarch64_boost-iostreams = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-iostreams-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-iostreams;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-iostreams}"
SRC_URI[aarch64_boost-iostreams.sha256sum] = "75199f2331ca7387680a3483f07157c54b9857101c747814dc179db89a1d0ac7"

URI_aarch64_boost-json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-json-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-json}"
SRC_URI[aarch64_boost-json.sha256sum] = "db02a80b653688fe89a4bb0d9fd73ab2fc5822ac9d7ff8165e7598b885edef2a"

URI_aarch64_boost-locale = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-locale-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-locale;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-locale}"
SRC_URI[aarch64_boost-locale.sha256sum] = "d220b66f347a633b1f389a1b50c5afb13f1dccf142c369c9982eab170466c6ad"

URI_aarch64_boost-log = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-log-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-log}"
SRC_URI[aarch64_boost-log.sha256sum] = "c8ed21928a77e39f9ef9ab73a744466c4103f85d50dc82b91b2a1e9df08ee60c"

URI_aarch64_boost-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-math-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-math}"
SRC_URI[aarch64_boost-math.sha256sum] = "97d243815ef9134b867335cf7b99d98e41fc053f7db6f3bdc01c1cbb61517c30"

URI_aarch64_boost-mpich = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-mpich-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-mpich}"
SRC_URI[aarch64_boost-mpich.sha256sum] = "0a1c44a6aa98c290d5be970e81cd35cb555b306f895c7f9990e95f2d0aaf9b9a"

URI_aarch64_boost-mpich-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-mpich-devel-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-mpich-devel}"
SRC_URI[aarch64_boost-mpich-devel.sha256sum] = "8da97c331a159b1cb2d5f0264a0a4be817a80923708ebc54e6dc6324a6b821b6"

URI_aarch64_boost-mpich-python3 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-mpich-python3-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-mpich-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-mpich-python3}"
SRC_URI[aarch64_boost-mpich-python3.sha256sum] = "dfced9ecbceb2f77434f7c3072813e1e6965f503bd2475b83823cd3895e67ee6"

URI_aarch64_boost-nowide = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-nowide-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-nowide;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-nowide}"
SRC_URI[aarch64_boost-nowide.sha256sum] = "1fc0da2978bfdc695d2f595c3f8e5f6945d0f7fe1214c1eff0a6e26ac40b9a93"

URI_aarch64_boost-numpy3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-numpy3-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-numpy3;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-numpy3}"
SRC_URI[aarch64_boost-numpy3.sha256sum] = "9ffdf248e26cc774b0af650a28bb157901342376c96f5d9da8a6b979fd8fe879"

URI_aarch64_boost-openmpi = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-openmpi-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-openmpi}"
SRC_URI[aarch64_boost-openmpi.sha256sum] = "9f745ace9d1aab4adddc03443d2ef1b6402d1f673e2169ac5fabab31da6d0af9"

URI_aarch64_boost-openmpi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-openmpi-devel-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-openmpi-devel}"
SRC_URI[aarch64_boost-openmpi-devel.sha256sum] = "2f3d29d14498890bbb2466506b20d5b3508655064c9d4a79efb5147edb08292b"

URI_aarch64_boost-openmpi-python3 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-openmpi-python3-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-openmpi-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-openmpi-python3}"
SRC_URI[aarch64_boost-openmpi-python3.sha256sum] = "52c655afaf03252cd5ad560d2819f82c5fc63c8801f50394abbbb16dee0115a7"

URI_aarch64_boost-program-options = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-program-options-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-program-options;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-program-options}"
SRC_URI[aarch64_boost-program-options.sha256sum] = "55b5ad0624b79fe1c2bd4d30e93995ddbb03c29944aa45870d15c2c0b7e91252"

URI_aarch64_boost-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-python3-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-python3}"
SRC_URI[aarch64_boost-python3.sha256sum] = "db899354e8b175896e22f8683b87a9eb0f19f1162a082a15b17c3751ba0d02af"

URI_aarch64_boost-random = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-random-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-random;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-random}"
SRC_URI[aarch64_boost-random.sha256sum] = "1526d502aeef3efc4e9efb3d5f2f74fb55553c12ca732e964af1147a1bd5cd92"

URI_aarch64_boost-regex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-regex-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-regex;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-regex}"
SRC_URI[aarch64_boost-regex.sha256sum] = "709c545064740788d3783e9d251a0384e7614143af8f851dda5fd855ec89a529"

URI_aarch64_boost-serialization = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-serialization-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-serialization;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-serialization}"
SRC_URI[aarch64_boost-serialization.sha256sum] = "368d781dd4d4358afdf62d6a158c402d59db693362dd264c982eae9c17f366e0"

URI_aarch64_boost-stacktrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-stacktrace-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-stacktrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-stacktrace}"
SRC_URI[aarch64_boost-stacktrace.sha256sum] = "501853cb7de8dd70eef9de9c23d991be7a513c2031bbcad361490c6fed1b32f3"

URI_aarch64_boost-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/boost-static-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-static}"
SRC_URI[aarch64_boost-static.sha256sum] = "c13460caf223500f9e47df64e7a2804b2a3eae098a97e70fd35839959ca83016"

URI_aarch64_boost-system = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/boost-system-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-system}"
SRC_URI[aarch64_boost-system.sha256sum] = "c95a5e7ffbbed4458a4657141c633fafbdac6dc17c9102139eaa4bafc2bdd479"

URI_aarch64_boost-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-test-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-test}"
SRC_URI[aarch64_boost-test.sha256sum] = "32d7993a484d933e2c48a004d56aa0841f9f2d2a6d361d6c87bb49a877e321e1"

URI_aarch64_boost-thread = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-thread-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-thread;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-thread}"
SRC_URI[aarch64_boost-thread.sha256sum] = "9d58d0f6d0f1c8b7efe77bc52e5f8c7e3c9b69c8876b5132ebbce9fa0a9caf29"

URI_aarch64_boost-timer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-timer-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-timer;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-timer}"
SRC_URI[aarch64_boost-timer.sha256sum] = "751bb0df0ef366e57f247715d41a717faea6c856b0d5d8d66148b94180ee44bd"

URI_aarch64_boost-type_erasure = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-type_erasure-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-type_erasure;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-type_erasure}"
SRC_URI[aarch64_boost-type_erasure.sha256sum] = "6161042f3880cd5e58738c3d28e830c66d50f8b7cdec0c61fa628042ea818f5a"

URI_aarch64_boost-wave = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boost-wave-1.83.0-5.el10.aarch64.rpm;name=aarch64_boost-wave;unpack=0"
SRC_URI:append = " ${URI_aarch64_boost-wave}"
SRC_URI[aarch64_boost-wave.sha256sum] = "a4ee5279774368817586da476cc87b2881f9991864a4609ccd20b3b1da538765"

RDEPENDS:boost = " \
 boost-atomic \
 boost-chrono \
 boost-container \
 boost-context \
 boost-contract \
 boost-coroutine \
 boost-date-time \
 boost-fiber \
 boost-filesystem \
 boost-graph \
 boost-iostreams \
 boost-json \
 boost-locale \
 boost-log \
 boost-math \
 boost-nowide \
 boost-program-options \
 boost-python3 \
 boost-random \
 boost-regex \
 boost-serialization \
 boost-stacktrace \
 boost-system \
 boost-test \
 boost-thread \
 boost-timer \
 boost-type_erasure \
 boost-wave \
 "
RDEPENDS:boost-atomic = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:boost-b2 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-build = " \
 boost-b2 \
 python3 \
 "
RDEPENDS:boost-chrono = " \
 boost-system \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-container = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-context = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:boost-contract = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-coroutine = " \
 boost-context \
 glibc \
 libstdc++ \
 "
RDEPENDS:boost-date-time = " \
 glibc \
 "
RDEPENDS:boost-devel:x86_64_v2 = " \
 boost \
 boost-numpy3 \
 libicu-devel \
 libquadmath-devel \
"
RDEPENDS:boost-devel:aarch64 = " \
 boost \
 boost-numpy3 \
 libicu-devel \
"
RDEPENDS:boost-doc = " \
 "
RDEPENDS:boost-doctools = " \
 bash \
 docbook-dtds \
 docbook-style-xsl \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-examples = " \
 boost-devel \
 "
RDEPENDS:boost-fiber = " \
 boost-context \
 boost-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-filesystem = " \
 boost-atomic \
 boost-system \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-graph = " \
 boost-regex \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:boost-graph-mpich = " \
 boost-mpich \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 mpich \
 "
RDEPENDS:boost-graph-openmpi = " \
 boost-openmpi \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 openmpi \
 "
RDEPENDS:boost-iostreams = " \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:boost-json = " \
 boost-container \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-locale = " \
 boost-chrono \
 boost-system \
 boost-thread \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:boost-log = " \
 boost-atomic \
 boost-chrono \
 boost-filesystem \
 boost-regex \
 boost-thread \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:boost-math = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-mpich = " \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 mpich \
 "
RDEPENDS:boost-mpich-devel = " \
 boost-devel \
 boost-graph-mpich \
 boost-mpich \
 "
RDEPENDS:boost-mpich-python3 = " \
 boost-mpich \
 boost-python3 \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 mpich \
 python3 \
 python3-mpich \
 "
RDEPENDS:boost-nowide = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-numpy3 = " \
 boost-python3 \
 glibc \
 libgcc \
 libstdc++ \
 python3-numpy \
 "
RDEPENDS:boost-openmpi = " \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 openmpi \
 "
RDEPENDS:boost-openmpi-devel = " \
 boost-devel \
 boost-graph-openmpi \
 boost-openmpi \
 "
RDEPENDS:boost-openmpi-python3 = " \
 boost-openmpi \
 boost-python3 \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 openmpi \
 python3 \
 python3-openmpi \
 "
RDEPENDS:boost-program-options = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-python3 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:boost-random = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-regex = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:boost-serialization = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-stacktrace = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-static = " \
 boost-devel \
 "
RDEPENDS:boost-system = " \
 glibc \
 "
RDEPENDS:boost-test = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-thread = " \
 boost-system \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-timer = " \
 boost-chrono \
 boost-system \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-type_erasure = " \
 boost-chrono \
 boost-system \
 boost-thread \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:boost-wave = " \
 boost-chrono \
 boost-date-time \
 boost-filesystem \
 boost-system \
 boost-thread \
 glibc \
 libgcc \
 libstdc++ \
 "
