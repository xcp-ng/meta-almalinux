# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libexif"
PV = "0.6.24"
PR = "9.el10_2.1"
PACKAGES = " \
 libexif \
 libexif-devel \
 libexif-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libexif-0.6.24-9.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab235cc566a7ea7a5f570dff68e98d63f17a0e7c7d3600724814fb173b818264"

URI_x86_64_v2_libexif = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libexif-0.6.24-9.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libexif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libexif}"
SRC_URI[x86_64_v2_libexif.sha256sum] = "0d50d21906a522e5f5fd70df329f88cca1e24320cb67ada110564e059c3f6548"

URI_x86_64_v2_libexif-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libexif-devel-0.6.24-9.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libexif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libexif-devel}"
SRC_URI[x86_64_v2_libexif-devel.sha256sum] = "3cac9419ce3fa53f2813a874580c6d6f91405064ad47e7ebff8a53f76ed17f1a"

URI_x86_64_v2_libexif-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libexif-doc-0.6.24-9.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libexif-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libexif-doc}"
SRC_URI[x86_64_v2_libexif-doc.sha256sum] = "ef265122d8026e9e048e07a2bfea0f59340d0010a9c2d5d36eee7fe774a8854e"

URI_aarch64_libexif = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libexif-0.6.24-9.el10_2.1.aarch64.rpm;name=aarch64_libexif;unpack=0"
SRC_URI:append = " ${URI_aarch64_libexif}"
SRC_URI[aarch64_libexif.sha256sum] = "f38688d10fe25c063e7cd04c007d20123685adb00f19f912751976e9ec104e35"

URI_aarch64_libexif-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libexif-devel-0.6.24-9.el10_2.1.aarch64.rpm;name=aarch64_libexif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libexif-devel}"
SRC_URI[aarch64_libexif-devel.sha256sum] = "7d5ff2d356841b5891a305d4e9bedba4b746b551c79355b378525dc224d2319b"

URI_aarch64_libexif-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libexif-doc-0.6.24-9.el10_2.1.aarch64.rpm;name=aarch64_libexif-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libexif-doc}"
SRC_URI[aarch64_libexif-doc.sha256sum] = "a0ea5b4f4f226913da9195c619f62b81a6f3a30a95ced40f3bc3b6ed2ef24b81"

RDEPENDS:libexif = " \
 glibc \
 "
RDEPENDS:libexif-devel = " \
 libexif \
 pkgconf-pkg-config \
 "
RDEPENDS:libexif-doc = " \
 libexif \
 "
