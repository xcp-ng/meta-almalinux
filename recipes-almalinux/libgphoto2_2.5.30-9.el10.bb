# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgphoto2"
PV = "2.5.30"
PR = "9.el10"
PACKAGES = " \
 libgphoto2 \
 libgphoto2-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libgphoto2-2.5.30-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6233367f3d425c637dc90f478f705e3113f5ed1a76af31e0b3ed33e9bfe99729"

URI_x86_64_v2_libgphoto2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgphoto2-2.5.30-9.el10.x86_64_v2.rpm;name=x86_64_v2_libgphoto2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgphoto2}"
SRC_URI[x86_64_v2_libgphoto2.sha256sum] = "d50f9a7b7ce7fbc0b854a71147b57ddb84699314bd323866ea98937da8cad880"

URI_x86_64_v2_libgphoto2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgphoto2-devel-2.5.30-9.el10.x86_64_v2.rpm;name=x86_64_v2_libgphoto2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgphoto2-devel}"
SRC_URI[x86_64_v2_libgphoto2-devel.sha256sum] = "3d5858c9755c9a85e1adaac7197c76d3d98655b4c430f66c10d2f5f3f029eed7"

URI_aarch64_libgphoto2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgphoto2-2.5.30-9.el10.aarch64.rpm;name=aarch64_libgphoto2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgphoto2}"
SRC_URI[aarch64_libgphoto2.sha256sum] = "af8e43d9b7146a3207793ddf765981a5e3062721f489029d901c6da1d1e1a5ea"

URI_aarch64_libgphoto2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgphoto2-devel-2.5.30-9.el10.aarch64.rpm;name=aarch64_libgphoto2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgphoto2-devel}"
SRC_URI[aarch64_libgphoto2-devel.sha256sum] = "1c32ccb98a313ef148e35648921c59df4d71f1ac72cfea0240d9ee6f7b1f9ad4"

RDEPENDS:libgphoto2 = " \
 bash \
 gd \
 glibc \
 libexif \
 libjpeg-turbo \
 libtool-ltdl \
 libusb1 \
 libxml2 \
 lockdev \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libgphoto2-devel = " \
 bash \
 libexif-devel \
 libgphoto2 \
 libgphoto2-devel \
 pkgconf-pkg-config \
 "
