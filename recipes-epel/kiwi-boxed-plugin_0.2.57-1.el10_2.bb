# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi-boxed-plugin"
PV = "0.2.57"
PR = "1.el10_2"
PACKAGES = " \
 kiwi-boxed-plugin \
 python3-kiwi-boxed-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiwi-boxed-plugin-0.2.57-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2f1a0dacb6527c89e24ccfeb1c356d34604bb34f15c1615f77b7d462e987e37"

URI_x86_64_v2_kiwi-boxed-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-boxed-plugin-0.2.57-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-boxed-plugin}"
SRC_URI[x86_64_v2_kiwi-boxed-plugin.sha256sum] = "a62171a2157737b0d396dc75f4f1a2191720671ac2fb5712ec9793b9723fab3a"

URI_x86_64_v2_python3-kiwi-boxed-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-boxed-plugin-0.2.57-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kiwi-boxed-plugin}"
SRC_URI[x86_64_v2_python3-kiwi-boxed-plugin.sha256sum] = "4d91d2624f0b7b94512f053c706f9c27aaca5259be1a3171dc44f8ab3598c88d"

URI_aarch64_kiwi-boxed-plugin = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-boxed-plugin-0.2.57-1.el10_2.noarch.rpm;name=aarch64_kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-boxed-plugin}"
SRC_URI[aarch64_kiwi-boxed-plugin.sha256sum] = "3eba6d896b4b5814eab04a614b85514ab22557a6a02139b7e89686abb70a976d"

URI_aarch64_python3-kiwi-boxed-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-boxed-plugin-0.2.57-1.el10_2.noarch.rpm;name=aarch64_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kiwi-boxed-plugin}"
SRC_URI[aarch64_python3-kiwi-boxed-plugin.sha256sum] = "a110bd23b13036126bb86bf54af45af80e7c5106103acf52c5f9317bc51c3f41"

RDEPENDS:kiwi-boxed-plugin = " \
 python3-kiwi-boxed-plugin \
 "
RDEPENDS:python3-kiwi-boxed-plugin = " \
 python3 \
 python3-cerberus \
 python3-docopt-ng \
 python3-kiwi \
 python3-progressbar2 \
 python3-pyyaml \
 python3-requests \
 qemu-kvm \
 "
