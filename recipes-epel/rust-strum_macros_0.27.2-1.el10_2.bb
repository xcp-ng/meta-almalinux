# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum_macros"
PV = "0.27.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-strum_macros+default-devel \
 rust-strum_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum_macros-0.27.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaf25682c12ad593d0c79cec762bcebd423a69d117b35d97e3e2fe5c3f8e0c3b"

URI_x86_64_v2_rust-strum_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros+default-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros+default-devel}"
SRC_URI[x86_64_v2_rust-strum_macros+default-devel.sha256sum] = "1e2a0f0839567df4a3cd8dfbbfb864d95f3585b265fedb916fc505fd18a97d6d"

URI_x86_64_v2_rust-strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum_macros-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum_macros-devel.sha256sum] = "26df7f4b093a5921364dbcb9d554782b20bec05d745125881f8a0ea4550b0c96"

URI_aarch64_rust-strum_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros+default-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-strum_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros+default-devel}"
SRC_URI[aarch64_rust-strum_macros+default-devel.sha256sum] = "ff25ba7de4b391ef28796bbc2062ec6f71b3777d05ecc433c6f0328efa38a8a1"

URI_aarch64_rust-strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum_macros-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum_macros-devel}"
SRC_URI[aarch64_rust-strum_macros-devel.sha256sum] = "f2c7cf0bde1638ef33cf7dd99d906ac88745ebae591822ec00ce1cea9e1d75e1"

RDEPENDS:rust-strum_macros+default-devel = " \
 cargo \
 rust-strum_macros-devel \
 "
RDEPENDS:rust-strum_macros-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+parsing-devel \
 "
