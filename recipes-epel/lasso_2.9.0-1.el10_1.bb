# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lasso"
PV = "2.9.0"
PR = "1.el10_1"
PACKAGES = " \
 lasso \
 lasso-devel \
 perl-lasso \
 python3-lasso \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lasso-2.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62b902b84ab1d46bbf371be413d0f9a6aa29458146e7cc7e1f52dbb3db911118"

URI_x86_64_v2_lasso = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lasso-2.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lasso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lasso}"
SRC_URI[x86_64_v2_lasso.sha256sum] = "4b604fa1385cdc300dab9b8f77ed4d24569e1e7130a7838dada0d83517a6fd7c"

URI_x86_64_v2_lasso-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lasso-devel-2.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lasso-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lasso-devel}"
SRC_URI[x86_64_v2_lasso-devel.sha256sum] = "81c89416014ba1a02b731329606b71c2370c926bf39f93dfa500b3eeb419070b"

URI_x86_64_v2_perl-lasso = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-lasso-2.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-lasso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-lasso}"
SRC_URI[x86_64_v2_perl-lasso.sha256sum] = "2c29eab89ae7f7dbb487d88d1ecac1513364155636be2d505cbdf4e99aefbb99"

URI_x86_64_v2_python3-lasso = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lasso-2.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lasso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lasso}"
SRC_URI[x86_64_v2_python3-lasso.sha256sum] = "14298400e64fc102aea45838105a752e51c12f50308c8c5996ace35ca7bdfe4b"

URI_aarch64_lasso = "${EPEL_MIRROR}/aarch64/Packages/l/lasso-2.9.0-1.el10_1.aarch64.rpm;name=aarch64_lasso;unpack=0"
SRC_URI:append = " ${URI_aarch64_lasso}"
SRC_URI[aarch64_lasso.sha256sum] = "2d6c21f838a740ce10010d2b1f0adccedadd9faa72c6c5281b046d5c245d1b4f"

URI_aarch64_lasso-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lasso-devel-2.9.0-1.el10_1.aarch64.rpm;name=aarch64_lasso-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lasso-devel}"
SRC_URI[aarch64_lasso-devel.sha256sum] = "eba0876276f307471fced5eabc8c49b2aafd06fc75382f846281fedbd8582ca1"

URI_aarch64_perl-lasso = "${EPEL_MIRROR}/aarch64/Packages/p/perl-lasso-2.9.0-1.el10_1.aarch64.rpm;name=aarch64_perl-lasso;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-lasso}"
SRC_URI[aarch64_perl-lasso.sha256sum] = "cdb12df442482ff7e063dc87520285f43392432ad84ad61fdf30f04c5d339825"

URI_aarch64_python3-lasso = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lasso-2.9.0-1.el10_1.aarch64.rpm;name=aarch64_python3-lasso;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lasso}"
SRC_URI[aarch64_python3-lasso.sha256sum] = "0dbcff11cb9592e841790f703761a2b6ef1f093606b0638ad393443f9dbbc554"

RDEPENDS:lasso = " \
 glib2 \
 glibc \
 libtool-ltdl \
 libxml2 \
 libxslt \
 openssl-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:lasso-devel = " \
 glib2-devel \
 lasso \
 libxml2-devel \
 libxslt-devel \
 pkgconf-pkg-config \
 xmlsec1-devel \
 "
RDEPENDS:perl-lasso = " \
 glib2 \
 glibc \
 lasso \
 libxml2 \
 perl-libs \
 "
RDEPENDS:python3-lasso = " \
 glib2 \
 glibc \
 lasso \
 libtool-ltdl \
 libxml2 \
 libxslt \
 openssl-libs \
 python3 \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
