# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lazarus"
PV = "4.2"
PR = "2.el10_1"
PACKAGES = " \
 lazarus \
 lazarus-doc \
 lazarus-ide \
 lazarus-lcl \
 lazarus-lcl-gtk2 \
 lazarus-lcl-gtk3 \
 lazarus-lcl-nogui \
 lazarus-lcl-qt5 \
 lazarus-lcl-qt6 \
 lazarus-tools \
 qt5pas \
 qt5pas-devel \
 qt6pas \
 qt6pas-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lazarus-4.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf44b03d2f7386d258b93aa5d5a11b54efe8ff3cfd47aa55a4a17f6b910537dd"

URI_aarch64_lazarus = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-4.2-2.el10_1.aarch64.rpm;name=aarch64_lazarus;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus}"
SRC_URI[aarch64_lazarus.sha256sum] = "6103ffe235df4538959b6caa222bc8e94ec120bba5440934785e3caaf0a98565"

URI_aarch64_lazarus-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-doc-4.2-2.el10_1.aarch64.rpm;name=aarch64_lazarus-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-doc}"
SRC_URI[aarch64_lazarus-doc.sha256sum] = "4d1231c1d472c0e33df3e14fb0f2bccc0a6e34ba6f424089437c14640b480c7e"

URI_aarch64_lazarus-ide = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-ide-4.2-2.el10_1.aarch64.rpm;name=aarch64_lazarus-ide;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-ide}"
SRC_URI[aarch64_lazarus-ide.sha256sum] = "605d6996df993899b686e5836519a68fe6ea0fc81c7ae597a5d67f1e224746ac"

URI_aarch64_lazarus-lcl = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-4.2-2.el10_1.aarch64.rpm;name=aarch64_lazarus-lcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl}"
SRC_URI[aarch64_lazarus-lcl.sha256sum] = "4494ac1794704be2190b3a7e2c98aa9b2275c0c40156981278fc583ae58ba122"

URI_aarch64_lazarus-lcl-gtk2 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-gtk2-4.2-2.el10_1.aarch64.rpm;name=aarch64_lazarus-lcl-gtk2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-gtk2}"
SRC_URI[aarch64_lazarus-lcl-gtk2.sha256sum] = "905ea7128a8a0d025ac0e9b49004b7f4bd4499d93f3be078f7ee6ee9cf0babe5"

URI_aarch64_lazarus-lcl-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-gtk3-4.2-2.el10_1.aarch64.rpm;name=aarch64_lazarus-lcl-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-gtk3}"
SRC_URI[aarch64_lazarus-lcl-gtk3.sha256sum] = "27481542c88eed5207b355b050181e03f5cb14a7bb726ebaebf549ef01f03841"

URI_aarch64_lazarus-lcl-nogui = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-nogui-4.2-2.el10_1.aarch64.rpm;name=aarch64_lazarus-lcl-nogui;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-nogui}"
SRC_URI[aarch64_lazarus-lcl-nogui.sha256sum] = "5ffccf4397c74edd5a02d761486e4ee5486609342a53fe25a759769440d0d117"

URI_aarch64_lazarus-lcl-qt5 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-qt5-4.2-2.el10_1.aarch64.rpm;name=aarch64_lazarus-lcl-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-qt5}"
SRC_URI[aarch64_lazarus-lcl-qt5.sha256sum] = "eafd897218af7c4d9f6273039eed8a235216772a98166b7fc2ca33274f892155"

URI_aarch64_lazarus-lcl-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-lcl-qt6-4.2-2.el10_1.aarch64.rpm;name=aarch64_lazarus-lcl-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-lcl-qt6}"
SRC_URI[aarch64_lazarus-lcl-qt6.sha256sum] = "54d5d0e3539966a00a25477bd0f178731eb8f25fad15389392d4e7db9a928dd3"

URI_aarch64_lazarus-tools = "${EPEL_MIRROR}/aarch64/Packages/l/lazarus-tools-4.2-2.el10_1.aarch64.rpm;name=aarch64_lazarus-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_lazarus-tools}"
SRC_URI[aarch64_lazarus-tools.sha256sum] = "0a2c84b72c3e2814002e1b59cc57342ecb612e8dddd1ab456af1b4a5abace74e"

URI_aarch64_qt5pas = "${EPEL_MIRROR}/aarch64/Packages/q/qt5pas-2.16-40202.el10_1.aarch64.rpm;name=aarch64_qt5pas;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5pas}"
SRC_URI[aarch64_qt5pas.sha256sum] = "8e3ac81057e894d9a29061b6cbeffde5cba76811a28d6f93ff7fe99206fa93ae"

URI_aarch64_qt5pas-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5pas-devel-2.16-40202.el10_1.aarch64.rpm;name=aarch64_qt5pas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5pas-devel}"
SRC_URI[aarch64_qt5pas-devel.sha256sum] = "216e2343ea5bf65fd242275c030a66661092e46b6520c9263d986598ee9d6bee"

URI_aarch64_qt6pas = "${EPEL_MIRROR}/aarch64/Packages/q/qt6pas-6.2.10-40202.el10_1.aarch64.rpm;name=aarch64_qt6pas;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6pas}"
SRC_URI[aarch64_qt6pas.sha256sum] = "b88eed35b2a0c0ab797ca5515dbb65713aaa9452b3294e4fdd117ff71ef588c0"

URI_aarch64_qt6pas-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6pas-devel-6.2.10-40202.el10_1.aarch64.rpm;name=aarch64_qt6pas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6pas-devel}"
SRC_URI[aarch64_qt6pas-devel.sha256sum] = "41935aaf9e1740c00d8d290630afc52b5227d0dac762bfdd95c15bf8267866ac"

RDEPENDS:lazarus = " \
 lazarus-ide \
 lazarus-lcl \
 lazarus-lcl-gtk2 \
 lazarus-lcl-nogui \
 lazarus-tools \
 "
RDEPENDS:lazarus-doc = " \
 bash \
 perl-File-Basename \
 perl-File-Find \
 perl-Getopt-Std \
 perl-interpreter \
 perl-vars \
 "
RDEPENDS:lazarus-ide = " \
 atk \
 bash \
 cairo \
 fpc-src \
 gdb \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 hicolor-icon-theme \
 lazarus-lcl \
 lazarus-tools \
 libX11 \
 make \
 pango \
 "
RDEPENDS:lazarus-lcl = " \
 atk \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 libX11 \
 pango \
 "
RDEPENDS:lazarus-lcl-gtk2 = " \
 gtk2-devel \
 lazarus-lcl \
 "
RDEPENDS:lazarus-lcl-gtk3 = " \
 gtk3-devel \
 lazarus-lcl \
 "
RDEPENDS:lazarus-lcl-nogui = " \
 lazarus-lcl \
 "
RDEPENDS:lazarus-lcl-qt5 = " \
 lazarus-lcl \
 qt5pas \
 qt5pas-devel \
 "
RDEPENDS:lazarus-lcl-qt6 = " \
 lazarus-lcl \
 qt6pas \
 qt6pas-devel \
 "
RDEPENDS:lazarus-tools = " \
 bash \
 binutils \
 fpc \
 glibc \
 glibc-devel \
 lazarus-lcl \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
 perl-vars \
 "
RDEPENDS:qt5pas = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtx11extras \
 "
RDEPENDS:qt5pas-devel = " \
 qt5-qtbase-devel \
 qt5-qtx11extras-devel \
 qt5pas \
 "
RDEPENDS:qt6pas = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6pas-devel = " \
 qt6-qtbase-devel \
 qt6pas \
 "
