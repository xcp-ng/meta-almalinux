# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-tools"
PV = "2025.08"
PR = "1.el10_2"
PACKAGES = " \
 git-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/git-tools-2025.08-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9b6212452011a9faa8a39b9f72bd1bebe67fd3b477ac3afe276195fa107c0c44"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-tools-2025.08-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_git-tools;unpack=0"
SRC_URI[x86_64_v2_git-tools.sha256sum] = "4b189de08f73d529223c3a63de099a4810f73eb0bdfc6fa6051aa07850f35839"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/git-tools-2025.08-1.el10_2.noarch.rpm;name=aarch64_git-tools;unpack=0"
SRC_URI[aarch64_git-tools.sha256sum] = "a71911125dea73c7a372cd60068e791b667c99229ee14613dc133ec11907d7f4"

RDEPENDS:git-tools = " \
 bash \
 git \
 python3 \
 "
