# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "suricata"
PV = "8.0.6"
PR = "1.el10_3"
PACKAGES = " \
 suricata \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/suricata-8.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9618389439a13b8157499f388c2ca9188f2a610863e66b85d41b95d755d38bd6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suricata-8.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suricata;unpack=0"
SRC_URI[x86_64_v2_suricata.sha256sum] = "91cac6faaf28f4d08af8716802120299e49d6f386a55215457fc33fab2e47040"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suricata-8.0.6-1.el10_3.aarch64.rpm;name=aarch64_suricata;unpack=0"
SRC_URI[aarch64_suricata.sha256sum] = "8fdf20ed2a56a52f0447c54523437f1dcc0c16159a338b94dfdca4ee5676106b"

RDEPENDS:suricata:x86_64_v2 = " \
 bash \
 file-libs \
 glibc \
 hiredis \
 jansson \
 libcap-ng \
 libevent \
 libgcc \
 libmaxminddb \
 libnet \
 libnetfilter_queue \
 libnfnetlink \
 libpcap \
 libyaml \
 lz4-libs \
 pcre2 \
 python3 \
 python3-pyyaml \
 shadow-utils \
 systemd \
 vectorscan \
 zlib-ng-compat \
"
RDEPENDS:suricata:aarch64 = " \
 bash \
 file-libs \
 glibc \
 hiredis \
 jansson \
 libcap-ng \
 libevent \
 libgcc \
 libmaxminddb \
 libnet \
 libnetfilter_queue \
 libnfnetlink \
 libpcap \
 libyaml \
 lz4-libs \
 pcre2 \
 python3 \
 python3-pyyaml \
 shadow-utils \
 systemd \
 zlib-ng-compat \
"
