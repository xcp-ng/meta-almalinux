# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ldc"
PE = "1"
PV = "1.42.0"
PR = "2.el10_3"
PACKAGES = " \
 ldc \
 ldc-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/ldc-1.42.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e899dc4061b850c3ff9ed918bb7127b640dd011226f447f4340b28bba572171"

URI_x86_64_v2_ldc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ldc-1.42.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ldc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldc}"
SRC_URI[x86_64_v2_ldc.sha256sum] = "566b23836d79709edbfd40b4555c70689f10fe291a19235e36e4e6b2fead3043"

URI_x86_64_v2_ldc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ldc-libs-1.42.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ldc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldc-libs}"
SRC_URI[x86_64_v2_ldc-libs.sha256sum] = "faf80778e3f29c119aaa8b771a05c24afff518589f3eb79a6d1d82df00c3f49f"

URI_aarch64_ldc = "${EPEL_MIRROR}/aarch64/Packages/l/ldc-1.42.0-2.el10_3.aarch64.rpm;name=aarch64_ldc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldc}"
SRC_URI[aarch64_ldc.sha256sum] = "800903d31944eb8f18fd55a9e4a3e83b2d678e40012f6ccb2713705ad6cec443"

URI_aarch64_ldc-libs = "${EPEL_MIRROR}/aarch64/Packages/l/ldc-libs-1.42.0-2.el10_3.aarch64.rpm;name=aarch64_ldc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldc-libs}"
SRC_URI[aarch64_ldc-libs.sha256sum] = "d2e2a22c198a54d96a20b37f9f0b7a0ecbbb2ee25f5694ea8d8d67499f3f8f77"

RDEPENDS:ldc = " \
 gcc \
 glibc \
 ldc-libs \
 libgcc \
 libstdc++ \
 llvm20-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:ldc-libs = " \
 glibc \
 libgcc \
 zlib-ng-compat \
 "
