# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "guidelines-support-library"
PV = "4.2.0"
PR = "4.el10_2"
PACKAGES = " \
 guidelines-support-library-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/guidelines-support-library-4.2.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "495570bcfcfeef82c1494a08ec3a0525abd03d7a0c6b9e41f47b13ea1817271c"

URI_x86_64_v2_guidelines-support-library-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/guidelines-support-library-devel-4.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_guidelines-support-library-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guidelines-support-library-devel}"
SRC_URI[x86_64_v2_guidelines-support-library-devel.sha256sum] = "7f8e2d76c892cb9983d35acebc38c5b6b22b8a74ff8c9451c864271d139a95e4"

URI_aarch64_guidelines-support-library-devel = "${EPEL_MIRROR}/aarch64/Packages/g/guidelines-support-library-devel-4.2.0-4.el10_2.noarch.rpm;name=aarch64_guidelines-support-library-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_guidelines-support-library-devel}"
SRC_URI[aarch64_guidelines-support-library-devel.sha256sum] = "1e467b2f8b5bdd06b2ce5023bbb573577ebe3a99570ad15563bf41fde5376455"

RDEPENDS:guidelines-support-library-devel = " \
 cmake-filesystem \
 "
