# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bit-set"
PV = "0.8.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-bit-set+default-devel \
 rust-bit-set+serde-devel \
 rust-bit-set+std-devel \
 rust-bit-set-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bit-set-0.8.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8dd049e01723765b463fdee4e6e7d4f781c87cdba708a91f854440a62aac16cc"

URI_x86_64_v2_rust-bit-set+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-set+default-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-set+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-set+default-devel}"
SRC_URI[x86_64_v2_rust-bit-set+default-devel.sha256sum] = "a5f62fadeb84c4970b217d4ff3cbf35b25d593bd2468aa7c85ddc647cdf2d01e"

URI_x86_64_v2_rust-bit-set+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-set+serde-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-set+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-set+serde-devel}"
SRC_URI[x86_64_v2_rust-bit-set+serde-devel.sha256sum] = "9b5774c05606fb386ad892131dc3d748946149ce3e3f9f50a81d193ec9670057"

URI_x86_64_v2_rust-bit-set+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-set+std-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-set+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-set+std-devel}"
SRC_URI[x86_64_v2_rust-bit-set+std-devel.sha256sum] = "7b507fda379a249855a30f3e96ee0a59d157873a67d7b9d31d5325d07dc23461"

URI_x86_64_v2_rust-bit-set-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-set-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-set-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-set-devel}"
SRC_URI[x86_64_v2_rust-bit-set-devel.sha256sum] = "24ebe33d58cd8beb370339a3d9a50dbf9102815c05f2182bf111840930dcbcec"

URI_aarch64_rust-bit-set+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-set+default-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_rust-bit-set+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-set+default-devel}"
SRC_URI[aarch64_rust-bit-set+default-devel.sha256sum] = "c134af801d12bbba7eeff5a465f97744f661492984827d57b9260926b79708f9"

URI_aarch64_rust-bit-set+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-set+serde-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_rust-bit-set+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-set+serde-devel}"
SRC_URI[aarch64_rust-bit-set+serde-devel.sha256sum] = "9bcc86e8e1cbefb68e0fc46bd9fe75dd7f5b923160181cf85699317b842199b4"

URI_aarch64_rust-bit-set+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-set+std-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_rust-bit-set+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-set+std-devel}"
SRC_URI[aarch64_rust-bit-set+std-devel.sha256sum] = "e2d8a36ce7b3afde1f5c3126f7c8a15262a22f99b90f1b9b8f9e857609c9ecb0"

URI_aarch64_rust-bit-set-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-set-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_rust-bit-set-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-set-devel}"
SRC_URI[aarch64_rust-bit-set-devel.sha256sum] = "12af6e3e4fe1869e30fa1b517d6a993f295b18f83ca7223a6e58208f996ebb8f"

RDEPENDS:rust-bit-set+default-devel = " \
 cargo \
 rust-bit-set+std-devel \
 rust-bit-set-devel \
 "
RDEPENDS:rust-bit-set+serde-devel = " \
 cargo \
 rust-bit-set-devel \
 rust-bit-vec+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-bit-set+std-devel = " \
 cargo \
 rust-bit-set-devel \
 rust-bit-vec+std-devel \
 "
RDEPENDS:rust-bit-set-devel = " \
 cargo \
 rust-bit-vec-devel \
 "
