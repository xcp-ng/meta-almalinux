# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rhel-system-roles"
PV = "1.108.6"
PR = "0.1.el10"
PACKAGES = " \
 rhel-system-roles \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rhel-system-roles-1.108.6-0.1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cd42369d8e7b40419b81649572bc7eb4d1b4f354b03f130ab848b2f1734060a"

URI_x86_64_v2_rhel-system-roles = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rhel-system-roles-1.108.6-0.1.el10.noarch.rpm;name=x86_64_v2_rhel-system-roles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rhel-system-roles}"
SRC_URI[x86_64_v2_rhel-system-roles.sha256sum] = "c0fd22872f690d015da57d7e70e9cd01bab5d3c8c0b425b73eef5122e089fe3c"

URI_aarch64_rhel-system-roles = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rhel-system-roles-1.108.6-0.1.el10.noarch.rpm;name=aarch64_rhel-system-roles;unpack=0"
SRC_URI:append = " ${URI_aarch64_rhel-system-roles}"
SRC_URI[aarch64_rhel-system-roles.sha256sum] = "c0fd22872f690d015da57d7e70e9cd01bab5d3c8c0b425b73eef5122e089fe3c"

RDEPENDS:rhel-system-roles = " \
 ansible-core \
 bash \
 python-unversioned-command \
 virtual//usr/bin/env \
 "
