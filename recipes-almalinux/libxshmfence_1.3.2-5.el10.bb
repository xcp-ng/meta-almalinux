# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxshmfence"
PV = "1.3.2"
PR = "5.el10"
PACKAGES = " \
 libxshmfence \
 libxshmfence-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libxshmfence-1.3.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "670581bf10f7043772a252c4b73bfdbb039c488d8e5c204941ca1ce36572b49b"

URI_x86_64_v2_libxshmfence = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxshmfence-1.3.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libxshmfence;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxshmfence}"
SRC_URI[x86_64_v2_libxshmfence.sha256sum] = "a4e1da66f4497b4080cbefd0ac99b6049c14e810bbf234528b38e212b69b9d3f"

URI_x86_64_v2_libxshmfence-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxshmfence-devel-1.3.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libxshmfence-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxshmfence-devel}"
SRC_URI[x86_64_v2_libxshmfence-devel.sha256sum] = "4aa1b8e649cfa3a31f1025746d7888aa029d81fd7ae6761c449bfe792a9ced70"

URI_aarch64_libxshmfence = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxshmfence-1.3.2-5.el10.aarch64.rpm;name=aarch64_libxshmfence;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxshmfence}"
SRC_URI[aarch64_libxshmfence.sha256sum] = "c0507386f7a2ae9de6e6934befa39b11971b8bcfd7ada91a4b6d9077c7ecb60b"

URI_aarch64_libxshmfence-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxshmfence-devel-1.3.2-5.el10.aarch64.rpm;name=aarch64_libxshmfence-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxshmfence-devel}"
SRC_URI[aarch64_libxshmfence-devel.sha256sum] = "404b25f2419628eb37ccdc01254bbaa32f5ca5813128035c6846744557ff4262"

RDEPENDS:libxshmfence = " \
 glibc \
 "
RDEPENDS:libxshmfence-devel = " \
 libxshmfence \
 pkgconf-pkg-config \
 "
