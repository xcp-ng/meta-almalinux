# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipsolver"
PV = "7.2.0"
PR = "4.el10_3"
PACKAGES:x86_64_v2 = " \
 hipsolver \
 hipsolver-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipsolver-7.2.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d7a791d19cfb35db8ee2b84d92f406f56f8c7da188e38dde473f969ad914294"

URI_x86_64_v2_hipsolver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsolver-7.2.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsolver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsolver}"
SRC_URI[x86_64_v2_hipsolver.sha256sum] = "d7c21d1cd06252f1a06cefeb587448cd994d145260a213af6ef51c617aa577f7"

URI_x86_64_v2_hipsolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsolver-devel-7.2.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsolver-devel}"
SRC_URI[x86_64_v2_hipsolver-devel.sha256sum] = "318cacad81ad39b8ee1ade8354bb9ddc4b059954e0895d179bc7a7a646c8b519"

RDEPENDS:hipsolver = " \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocm-hip \
 rocsolver \
 "
RDEPENDS:hipsolver-devel = " \
 cmake-filesystem \
 hipsolver \
 "
