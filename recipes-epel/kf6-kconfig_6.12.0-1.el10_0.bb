# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kconfig"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kconfig \
 kf6-kconfig-devel \
 kf6-kconfig-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kconfig-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffaa163dedb810b9ead26b6de67044b527c58b645a7cb7845a75282b9669137f"

URI_x86_64_v2_kf6-kconfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig}"
SRC_URI[x86_64_v2_kf6-kconfig.sha256sum] = "ee61c0f5202fcd33439427e5e180c198a9385cf3f3ecebf11d0edb9039d325ec"

URI_x86_64_v2_kf6-kconfig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-devel}"
SRC_URI[x86_64_v2_kf6-kconfig-devel.sha256sum] = "a293643be0c7c39997e3f39e3d4269583ebbdffe0ba141cda65a0b9c514647b1"

URI_x86_64_v2_kf6-kconfig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-doc}"
SRC_URI[x86_64_v2_kf6-kconfig-doc.sha256sum] = "e424d977121b85a42f17db657912e3e8bac5f1370d34b704cf33449eb0715ce0"

URI_aarch64_kf6-kconfig = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig}"
SRC_URI[aarch64_kf6-kconfig.sha256sum] = "a51630cde852464a33e6b235e19b0bf603a6baa32d077ebbbb1866a18a671a4d"

URI_aarch64_kf6-kconfig-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-devel}"
SRC_URI[aarch64_kf6-kconfig-devel.sha256sum] = "c3bd87194f9eb5f99fc11ba337fbe7fe84e0570a74a24ad9a1954604ea4d372f"

URI_aarch64_kf6-kconfig-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kconfig-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-doc}"
SRC_URI[aarch64_kf6-kconfig-doc.sha256sum] = "acdd4b97ace8f1b2a60123559916ab2a525457bb6bf1ffc38b9cfcc360f27c44"

RDEPENDS:kf6-kconfig = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kconfig-devel = " \
 cmake-filesystem \
 kf6-kconfig \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kconfig-doc = " \
 "
