# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Pencil2D"
PV = "0.7.2"
PR = "1.el10_1"
PACKAGES = " \
 Pencil2D \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/Pencil2D-0.7.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d967da56f819bc438226f64c2ad63fade9ae2c814f49ab4416ac3ed8e0a82a85"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - Pencil2D: /usr/bin/ffmpeg

URI_x86_64_v2_Pencil2D = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/Pencil2D-0.7.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_Pencil2D;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Pencil2D}"
SRC_URI[x86_64_v2_Pencil2D.sha256sum] = "5b68d3980b46bd6d6978987ddf1b878a721484ed5d848ec8b3ccb1d2a331d47c"

URI_aarch64_Pencil2D = "${EPEL_MIRROR}/aarch64/Packages/p/Pencil2D-0.7.2-1.el10_1.aarch64.rpm;name=aarch64_Pencil2D;unpack=0"
SRC_URI:append = " ${URI_aarch64_Pencil2D}"
SRC_URI[aarch64_Pencil2D.sha256sum] = "7100d0b2af1397ad32d9769ffc18b10ac94f7856c62767473da510b91e5d6ac6"

RDEPENDS:Pencil2D:x86_64_v2 = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 miniz \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
"
RDEPENDS:Pencil2D:aarch64 = " \
 ffmpeg-free \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 miniz \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
"
