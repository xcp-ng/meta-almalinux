# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qtkeychain"
PV = "0.16.0"
PR = "1.el10_3"
PACKAGES = " \
 qtkeychain-qt5 \
 qtkeychain-qt5-devel \
 qtkeychain-qt6 \
 qtkeychain-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qtkeychain-0.16.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73435f71629a2410bf7f1ab99e15514d39bb553618bd7b71411b3e1e8dcc01c6"

URI_x86_64_v2_qtkeychain-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt5-0.16.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt5}"
SRC_URI[x86_64_v2_qtkeychain-qt5.sha256sum] = "5238f0e19d285ea42404b1c8f23ba7120def8999f35ce0ce4f4439e97194236f"

URI_x86_64_v2_qtkeychain-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt5-devel-0.16.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt5-devel}"
SRC_URI[x86_64_v2_qtkeychain-qt5-devel.sha256sum] = "769019961aff9b2e39c2af8726045be1142eb6a18b7f4686781bcea2a93fda4a"

URI_x86_64_v2_qtkeychain-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt6-0.16.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt6}"
SRC_URI[x86_64_v2_qtkeychain-qt6.sha256sum] = "72481de2c88a8cdea8d9aee9a23ae3957176a9288c211162a10092958965f38b"

URI_x86_64_v2_qtkeychain-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt6-devel-0.16.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt6-devel}"
SRC_URI[x86_64_v2_qtkeychain-qt6-devel.sha256sum] = "7928ac90739908522c219054483ef2accde85869c96ddd4496950c5e8f1b9256"

URI_aarch64_qtkeychain-qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt5-0.16.0-1.el10_3.aarch64.rpm;name=aarch64_qtkeychain-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt5}"
SRC_URI[aarch64_qtkeychain-qt5.sha256sum] = "6f389b5e1f1801a9a1d4b615b391158c0dee719cc872a642809bc8c841d21181"

URI_aarch64_qtkeychain-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt5-devel-0.16.0-1.el10_3.aarch64.rpm;name=aarch64_qtkeychain-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt5-devel}"
SRC_URI[aarch64_qtkeychain-qt5-devel.sha256sum] = "3f8048b59d2d2def7243e90e0db52537658b0225c2759d0c3db97aa2bc983d6c"

URI_aarch64_qtkeychain-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt6-0.16.0-1.el10_3.aarch64.rpm;name=aarch64_qtkeychain-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt6}"
SRC_URI[aarch64_qtkeychain-qt6.sha256sum] = "12d9eb17fb1a6c760dd47bef1176688c90d73f90389be965ccc6f2df31f83bc2"

URI_aarch64_qtkeychain-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt6-devel-0.16.0-1.el10_3.aarch64.rpm;name=aarch64_qtkeychain-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt6-devel}"
SRC_URI[aarch64_qtkeychain-qt6-devel.sha256sum] = "944604142dc595f558ad761e1d76acab571e1b861eecb1328b12c7788099fe1d"

RDEPENDS:qtkeychain-qt5 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qtkeychain-qt5-devel = " \
 cmake-filesystem \
 libsecret-devel \
 qt5-qtbase-devel \
 qtkeychain-qt5 \
 "
RDEPENDS:qtkeychain-qt6 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qtkeychain-qt6-devel = " \
 cmake-filesystem \
 libsecret-devel \
 qt6-qtbase-devel \
 qtkeychain-qt6 \
 "
