# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arm-none-eabi-binutils-cs"
PE = "1"
PV = "2.44"
PR = "2.el10_1"
PACKAGES = " \
 arm-none-eabi-binutils-cs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/arm-none-eabi-binutils-cs-2.44-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91d80e93ad1753750f354f10c427ec08b3cdb3b86f6a2af1ce420f134b155c32"

URI_x86_64_v2_arm-none-eabi-binutils-cs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arm-none-eabi-binutils-cs-2.44-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arm-none-eabi-binutils-cs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arm-none-eabi-binutils-cs}"
SRC_URI[x86_64_v2_arm-none-eabi-binutils-cs.sha256sum] = "17eab2e99bfa4ae114fa393061501624ac23158b7d29d6150fc1b243c058dc18"

URI_aarch64_arm-none-eabi-binutils-cs = "${EPEL_MIRROR}/aarch64/Packages/a/arm-none-eabi-binutils-cs-2.44-2.el10_1.aarch64.rpm;name=aarch64_arm-none-eabi-binutils-cs;unpack=0"
SRC_URI:append = " ${URI_aarch64_arm-none-eabi-binutils-cs}"
SRC_URI[aarch64_arm-none-eabi-binutils-cs.sha256sum] = "4f036778c6c16fba0709a095141628794967782e6a6765139c41d3ae076be45f"

RDEPENDS:arm-none-eabi-binutils-cs = " \
 glibc \
 zlib-ng-compat \
 "
