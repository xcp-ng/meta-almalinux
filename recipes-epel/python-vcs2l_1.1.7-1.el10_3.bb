# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-vcs2l"
PV = "1.1.7"
PR = "1.el10_3"
PACKAGES = " \
 python3-vcs2l \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-vcs2l-1.1.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c0a59290426c005836e22d5f947786288a00a4ebf82697f996e5fbea395013f"

URI_x86_64_v2_python3-vcs2l = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vcs2l-1.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-vcs2l;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vcs2l}"
SRC_URI[x86_64_v2_python3-vcs2l.sha256sum] = "bb71225cb2495d3cf6e9891fd4a7561c23aed4e02430a33e93adf5b42ff84671"

URI_aarch64_python3-vcs2l = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vcs2l-1.1.7-1.el10_3.noarch.rpm;name=aarch64_python3-vcs2l;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vcs2l}"
SRC_URI[aarch64_python3-vcs2l.sha256sum] = "29b901e988b255546e9815c52adc962f96be4d5eb386c2f83160a860ce642a40"

RDEPENDS:python3-vcs2l = " \
 python3 \
 python3-pyyaml \
 "
