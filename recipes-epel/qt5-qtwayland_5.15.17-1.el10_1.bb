# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtwayland"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtwayland \
 qt5-qtwayland-devel \
 qt5-qtwayland-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtwayland-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "057189cbf3da11ce19ddc0d40cd161b139e460559958730b9a618f1833b8abdf"

URI_x86_64_v2_qt5-qtwayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland}"
SRC_URI[x86_64_v2_qt5-qtwayland.sha256sum] = "33185c60de733184a011dc8340821a229cbb5e016526b864453a3bfd8f82946f"

URI_x86_64_v2_qt5-qtwayland-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland-devel}"
SRC_URI[x86_64_v2_qt5-qtwayland-devel.sha256sum] = "94d9889ef0e30ba0859982061fc2d9007216193fe7181509a559ca172e57d8af"

URI_x86_64_v2_qt5-qtwayland-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland-examples}"
SRC_URI[x86_64_v2_qt5-qtwayland-examples.sha256sum] = "db6908be55e3b0ef5c8b25906ebdf3b2ecf2c3b3bd9988c590642a026de127b4"

URI_aarch64_qt5-qtwayland = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland}"
SRC_URI[aarch64_qt5-qtwayland.sha256sum] = "7e014ccc6060baa2ca43d56cc748178e9d2057292e5dac485a3c68d7fd6e3b7c"

URI_aarch64_qt5-qtwayland-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland-devel}"
SRC_URI[aarch64_qt5-qtwayland-devel.sha256sum] = "58bf563fa926dc7ed6416c56a0ad247b55f90332995e554bf771c9cff426b28f"

URI_aarch64_qt5-qtwayland-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland-examples}"
SRC_URI[aarch64_qt5-qtwayland-examples.sha256sum] = "4c35447d996649a57be1ccd03af051ce5ee4d81e0b1ec6ad76f8699c06177d23"

RDEPENDS:qt5-qtwayland = " \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 libX11 \
 libXcomposite \
 libglvnd-egl \
 libglvnd-glx \
 libstdc++ \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 libxkbcommon \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtwayland-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtwayland \
 "
RDEPENDS:qt5-qtwayland-examples = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwayland \
 "
