# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-winrm"
PV = "0.5.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-winrm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-winrm-0.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e62d5bbc85684fd4892bf4e1b2ece3beba38b0a190426607e5aadcd6fbc0fe7b"

URI_x86_64_v2_python3-winrm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-winrm-0.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-winrm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-winrm}"
SRC_URI[x86_64_v2_python3-winrm.sha256sum] = "623d1288e6a0c5bd48b995a2f279fd657e1d3a789b5f5ca50fffb21ad0a668ff"

URI_aarch64_python3-winrm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-winrm-0.5.0-1.el10_0.noarch.rpm;name=aarch64_python3-winrm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-winrm}"
SRC_URI[aarch64_python3-winrm.sha256sum] = "15434694dd9f70282f2e824a3c2ecab38cd614a0260f42e5239d2f6dcc11d193"

RDEPENDS:python3-winrm = " \
 python3 \
 python3-requests \
 python3-requests_ntlm \
 python3-xmltodict \
 "
