# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-oxygen"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 oxygen-cursor-themes \
 plasma-oxygen \
 plasma-oxygen-qt6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-oxygen-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b7e05c5bd65aeecb80d450a68a779db0965acd08f2e9f30fe34b49dd20a9cd9"

URI_x86_64_v2_oxygen-cursor-themes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-cursor-themes-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-cursor-themes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxygen-cursor-themes}"
SRC_URI[x86_64_v2_oxygen-cursor-themes.sha256sum] = "6bdebd4c9543c50b4b47ae7c3a64820dc2f40df7a058f5b98581fc82484bc69d"

URI_x86_64_v2_plasma-oxygen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-oxygen-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-oxygen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-oxygen}"
SRC_URI[x86_64_v2_plasma-oxygen.sha256sum] = "0e0fec0718aef3e750fc8f4b27553e361b38583d3b4500c48ab85c5f32aace1e"

URI_x86_64_v2_plasma-oxygen-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-oxygen-qt6-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-oxygen-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-oxygen-qt6}"
SRC_URI[x86_64_v2_plasma-oxygen-qt6.sha256sum] = "0a6debb050fd0e2048cccb6f85487cd378585c4f6b42277a26391ba57f308b01"

URI_aarch64_oxygen-cursor-themes = "${EPEL_MIRROR}/aarch64/Packages/o/oxygen-cursor-themes-6.6.4-1.el10_2.noarch.rpm;name=aarch64_oxygen-cursor-themes;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxygen-cursor-themes}"
SRC_URI[aarch64_oxygen-cursor-themes.sha256sum] = "ff42bc5a43f804eec53f35a64212f1c50892d81c5f41bb37ead0c32da41ce502"

URI_aarch64_plasma-oxygen = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-oxygen-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-oxygen;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-oxygen}"
SRC_URI[aarch64_plasma-oxygen.sha256sum] = "2f71d5ac1dc402a5c068cb12c23d1bba79eabc0af4f035e9f4c7f94b55c569f3"

URI_aarch64_plasma-oxygen-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-oxygen-qt6-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-oxygen-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-oxygen-qt6}"
SRC_URI[aarch64_plasma-oxygen-qt6.sha256sum] = "2e705e5d07f60c6d56e12d4e1a14a3de91d1a20fe294467a6fac40b71c9e9d51"

RDEPENDS:oxygen-cursor-themes = " \
 "
RDEPENDS:plasma-oxygen = " \
 glibc \
 kdecoration \
 kf6-filesystem \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 libstdc++ \
 libxcb \
 oxygen-cursor-themes \
 oxygen-icon-theme \
 oxygen-sounds \
 plasma-oxygen-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-oxygen-qt6 = " \
 glibc \
 kf6-frameworkintegration-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
