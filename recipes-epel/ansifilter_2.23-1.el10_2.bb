# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansifilter"
PV = "2.23"
PR = "1.el10_2"
PACKAGES = " \
 ansifilter \
 ansifilter-gui \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/ansifilter-2.23-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "008e854ba3c8dea171396b4dee527dca810cc67fedd8186b1904fb9ea8da6287"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansifilter-2.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ansifilter;unpack=0"
SRC_URI[x86_64_v2_ansifilter.sha256sum] = "a3d2ac730d095da984ca6b74eda33678fae427f60954bff6948a837e828e5d61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansifilter-gui-2.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ansifilter-gui;unpack=0"
SRC_URI[x86_64_v2_ansifilter-gui.sha256sum] = "92ddc8eee765e91283e074d95dec41a2661c8d5f20d5a60dea799d6c4e3a652e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/ansifilter-2.23-1.el10_2.aarch64.rpm;name=aarch64_ansifilter;unpack=0"
SRC_URI[aarch64_ansifilter.sha256sum] = "694ec8bcca123ec5d013347664025e6feff75ce135ae48b413e12cbea4dc4fb5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/ansifilter-gui-2.23-1.el10_2.aarch64.rpm;name=aarch64_ansifilter-gui;unpack=0"
SRC_URI[aarch64_ansifilter-gui.sha256sum] = "2d8aac3a2cdbb4418f33d081da4f5c1e65303a14307897710dcebbd26b92c28c"

RDEPENDS:ansifilter = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:ansifilter-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
