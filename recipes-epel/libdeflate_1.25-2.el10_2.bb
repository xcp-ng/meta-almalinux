# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdeflate"
PV = "1.25"
PR = "2.el10_2"
PACKAGES = " \
 libdeflate \
 libdeflate-devel \
 libdeflate-utils \
 mingw32-libdeflate \
 mingw32-libdeflate-utils \
 mingw64-libdeflate \
 mingw64-libdeflate-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdeflate-1.25-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caa37283cb3df89dca489067731b87ea752a2959d3e7e51a1cb1cac9eb55096b"

URI_x86_64_v2_libdeflate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-1.25-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdeflate}"
SRC_URI[x86_64_v2_libdeflate.sha256sum] = "bff83a8c4702416f6ff48ad06fa20fb4ffa288f2960bebf81aec1652f296cd54"

URI_x86_64_v2_libdeflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-devel-1.25-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdeflate-devel}"
SRC_URI[x86_64_v2_libdeflate-devel.sha256sum] = "8c74b94d6bcd2df6e322585bcc8c7f0a9350548632f0d0cb988e10c425940998"

URI_x86_64_v2_libdeflate-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-utils-1.25-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdeflate-utils}"
SRC_URI[x86_64_v2_libdeflate-utils.sha256sum] = "e7dc59293e4b9557f3a83439280d4dcdc14433f87795a0f46bcf9e545baf319d"

URI_x86_64_v2_mingw32-libdeflate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libdeflate-1.25-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libdeflate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libdeflate}"
SRC_URI[x86_64_v2_mingw32-libdeflate.sha256sum] = "9242c29f0837dc606608513c67b605b1c478927e3b088581920123934e669d39"

URI_x86_64_v2_mingw32-libdeflate-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libdeflate-utils-1.25-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libdeflate-utils}"
SRC_URI[x86_64_v2_mingw32-libdeflate-utils.sha256sum] = "f202d385dec14e52994063623b65c0e4d5dbe977de573d65bd0b71ffd10fd407"

URI_x86_64_v2_mingw64-libdeflate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libdeflate-1.25-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libdeflate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libdeflate}"
SRC_URI[x86_64_v2_mingw64-libdeflate.sha256sum] = "5a18d9074bd01bf2e3791954535ee1b3bf5dd118ecd68903ac22050f748dc67a"

URI_x86_64_v2_mingw64-libdeflate-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libdeflate-utils-1.25-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libdeflate-utils}"
SRC_URI[x86_64_v2_mingw64-libdeflate-utils.sha256sum] = "e8a1a4006fb821a9bbe5b19eb8e8e3d6ec2471d2cd27732aef87c84b2c153f35"

URI_aarch64_libdeflate = "${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-1.25-2.el10_2.aarch64.rpm;name=aarch64_libdeflate;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdeflate}"
SRC_URI[aarch64_libdeflate.sha256sum] = "911c32f83d35530f88ee6aad4e2512b45cd9f17d99072f5ba0bbc65dba8cb567"

URI_aarch64_libdeflate-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-devel-1.25-2.el10_2.aarch64.rpm;name=aarch64_libdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdeflate-devel}"
SRC_URI[aarch64_libdeflate-devel.sha256sum] = "4737a4d958fe63ed90fff657543ae2d4de9af26cc40576028ad981b71a7fa11c"

URI_aarch64_libdeflate-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-utils-1.25-2.el10_2.aarch64.rpm;name=aarch64_libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdeflate-utils}"
SRC_URI[aarch64_libdeflate-utils.sha256sum] = "dd2e8dd4a5e30416f9c9d29e2ff14324a3930cecdc2c6cdc805f8bbc5c1e1830"

URI_aarch64_mingw32-libdeflate = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-libdeflate-1.25-2.el10_2.noarch.rpm;name=aarch64_mingw32-libdeflate;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-libdeflate}"
SRC_URI[aarch64_mingw32-libdeflate.sha256sum] = "659718480027cdf99e30845278788c626a2d6b153e6506b06d435218794fe7bf"

URI_aarch64_mingw32-libdeflate-utils = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-libdeflate-utils-1.25-2.el10_2.noarch.rpm;name=aarch64_mingw32-libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-libdeflate-utils}"
SRC_URI[aarch64_mingw32-libdeflate-utils.sha256sum] = "390ccda8ed068a966e813415a3a824780be94ef1881eb3c6b67819cd75f41948"

URI_aarch64_mingw64-libdeflate = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-libdeflate-1.25-2.el10_2.noarch.rpm;name=aarch64_mingw64-libdeflate;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-libdeflate}"
SRC_URI[aarch64_mingw64-libdeflate.sha256sum] = "da6dae7129c3a7638b608f2b018b6719623ec89ac04896a0c6bd779b5591498a"

URI_aarch64_mingw64-libdeflate-utils = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-libdeflate-utils-1.25-2.el10_2.noarch.rpm;name=aarch64_mingw64-libdeflate-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-libdeflate-utils}"
SRC_URI[aarch64_mingw64-libdeflate-utils.sha256sum] = "2f9f251fadef5dd319a424496a8fe09e080267e1c5220023489b3c377377a5d7"

RDEPENDS:libdeflate = " \
 glibc \
 "
RDEPENDS:libdeflate-devel = " \
 cmake-filesystem \
 libdeflate \
 pkgconf-pkg-config \
 "
RDEPENDS:libdeflate-utils = " \
 glibc \
 libdeflate \
 "
RDEPENDS:mingw32-libdeflate = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw32-libdeflate-utils = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libdeflate \
 "
RDEPENDS:mingw64-libdeflate = " \
 mingw64-crt \
 mingw64-filesystem \
 "
RDEPENDS:mingw64-libdeflate-utils = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libdeflate \
 "
