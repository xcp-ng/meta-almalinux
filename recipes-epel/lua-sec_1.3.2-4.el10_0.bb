# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-sec"
PV = "1.3.2"
PR = "4.el10_0"
PACKAGES = " \
 lua-sec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-sec-1.3.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab497b288a9174f0064be4b5eca0fef08e86c4f7d7e39ca1eca166db6f08a07d"

URI_x86_64_v2_lua-sec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-sec-1.3.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-sec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-sec}"
SRC_URI[x86_64_v2_lua-sec.sha256sum] = "34e0ec85b465061076fb944354345c759762b1f1c4d09dc9874322ad0f55a99c"

URI_aarch64_lua-sec = "${EPEL_MIRROR}/aarch64/Packages/l/lua-sec-1.3.2-4.el10_0.aarch64.rpm;name=aarch64_lua-sec;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-sec}"
SRC_URI[aarch64_lua-sec.sha256sum] = "66151f511b6a069f663b7fe5f0d82569cdbeedce61111c8cc20899f5339a2400"

RDEPENDS:lua-sec = " \
 glibc \
 lua-libs \
 lua-socket \
 openssl-libs \
 "
