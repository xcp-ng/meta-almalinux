# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-top"
PV = "1.1.1"
PR = "21.el10.alma.1"
PACKAGES = " \
 virt-top \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-top-1.1.1-21.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac752afef5d1f70662b89cf84406411b54bf4987ee44223d5e7e8c7da5a1196b"

URI_x86_64_v2_virt-top = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-top-1.1.1-21.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_virt-top;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-top}"
SRC_URI[x86_64_v2_virt-top.sha256sum] = "1696494e8e23df8f49dc12a3aff530449aff7111f7debf3acd43cadec150ea8f"

URI_aarch64_virt-top = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-top-1.1.1-21.el10.alma.1.aarch64.rpm;name=aarch64_virt-top;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-top}"
SRC_URI[aarch64_virt-top.sha256sum] = "bcdb67b3af0ab1322277e3fa2ceef80bfc00f3c59114db08f117c96996ef59f6"

RDEPENDS:virt-top = " \
 glibc \
 libvirt-libs \
 libxml2 \
 ncurses-libs \
 python3 \
 "
