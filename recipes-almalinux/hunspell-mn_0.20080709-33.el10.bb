# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-mn"
PV = "0.20080709"
PR = "33.el10"
PACKAGES = " \
 hunspell-mn \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-mn-0.20080709-33.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d0dddec5ad99121340cc917e5470de3b0af9dcf09d23aab8b7e85363243ba226"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-mn-0.20080709-33.el10.noarch.rpm;name=x86_64_v2_hunspell-mn;unpack=0"
SRC_URI[x86_64_v2_hunspell-mn.sha256sum] = "50f9b80d631efc14ee175010d97311084de205cd00cedd10c03e61e78a7471ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-mn-0.20080709-33.el10.noarch.rpm;name=aarch64_hunspell-mn;unpack=0"
SRC_URI[aarch64_hunspell-mn.sha256sum] = "50f9b80d631efc14ee175010d97311084de205cd00cedd10c03e61e78a7471ca"

RDEPENDS:hunspell-mn = " \
 hunspell-filesystem \
 "
