# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samtools"
PV = "1.24"
PR = "2.el10_2"
PACKAGES = " \
 samtools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/samtools-1.24-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7ded52839f5e3a30606a19f2f5e16314671aa29dd9f356db84345f4709491a49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/samtools-1.24-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_samtools;unpack=0"
SRC_URI[x86_64_v2_samtools.sha256sum] = "c203adb0658e2609045bbb916afc90fd12e7f2ecb3135e85319642de2028738b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/samtools-1.24-2.el10_2.aarch64.rpm;name=aarch64_samtools;unpack=0"
SRC_URI[aarch64_samtools.sha256sum] = "085793a61ad48575cef6fae259d347d818ac60350433757d57ddf6bf9d8642b7"

RDEPENDS:samtools = " \
 glibc \
 htslib \
 ncurses-libs \
 perl-File-Find \
 perl-interpreter \
 python3 \
 zlib-ng-compat \
 "
