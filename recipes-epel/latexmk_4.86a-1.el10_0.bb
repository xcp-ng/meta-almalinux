# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "latexmk"
PV = "4.86a"
PR = "1.el10_0"
PACKAGES = " \
 latexmk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/latexmk-4.86a-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9b68252107168621a6b60445716410f3edaa0f8f29803867682f0b1e412c3e8"

URI_x86_64_v2_latexmk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/latexmk-4.86a-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_latexmk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_latexmk}"
SRC_URI[x86_64_v2_latexmk.sha256sum] = "6760b39263263a1b796bc42cdb64e0c4a4c52f998f5ab82a986245ee0debfbf9"

URI_aarch64_latexmk = "${EPEL_MIRROR}/aarch64/Packages/l/latexmk-4.86a-1.el10_0.noarch.rpm;name=aarch64_latexmk;unpack=0"
SRC_URI:append = " ${URI_aarch64_latexmk}"
SRC_URI[aarch64_latexmk.sha256sum] = "7445489f5cedb52781148dbbb0c976b1837e193c78cab0d2ea19ef9e55e2c317"

RDEPENDS:latexmk = " \
 ghostscript \
 perl-Digest-MD5 \
 perl-Encode \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-FileHandle \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-Unicode-Normalize \
 perl-interpreter \
 perl-libs \
 perl-sigtrap \
 texlive-latex \
 xdg-utils \
 "
