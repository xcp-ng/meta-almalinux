# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "futuresql"
PV = "0.1.1"
PR = "4.el10_0"
PACKAGES = " \
 futuresql-qt5 \
 futuresql-qt5-devel \
 futuresql-qt6 \
 futuresql-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/futuresql-0.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "639e2abb70a3e8dff57b7ed75ebbbec31e831bb7df9aadcc043f6b369f8f5de3"

URI_x86_64_v2_futuresql-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/futuresql-qt5-0.1.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_futuresql-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_futuresql-qt5}"
SRC_URI[x86_64_v2_futuresql-qt5.sha256sum] = "1c7e027fcb5eeb5ab509b1b32bee50e0331c926992877dbda7d01ffc47e95f77"

URI_x86_64_v2_futuresql-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/futuresql-qt5-devel-0.1.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_futuresql-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_futuresql-qt5-devel}"
SRC_URI[x86_64_v2_futuresql-qt5-devel.sha256sum] = "3c3735f98b147627df70581c1b6aec39dc1603ea226f35a4129f1128ac24e246"

URI_x86_64_v2_futuresql-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/futuresql-qt6-0.1.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_futuresql-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_futuresql-qt6}"
SRC_URI[x86_64_v2_futuresql-qt6.sha256sum] = "5f0b30d8e00423ed1179bf672170d3d4762774aa515c07fe8c5644f9a837bec7"

URI_x86_64_v2_futuresql-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/futuresql-qt6-devel-0.1.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_futuresql-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_futuresql-qt6-devel}"
SRC_URI[x86_64_v2_futuresql-qt6-devel.sha256sum] = "3c00f37762b1fd6a9111022b25dd0d79d0a12005cc3a98cabaadc6c8747af199"

URI_aarch64_futuresql-qt5 = "${EPEL_MIRROR}/aarch64/Packages/f/futuresql-qt5-0.1.1-4.el10_0.aarch64.rpm;name=aarch64_futuresql-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_futuresql-qt5}"
SRC_URI[aarch64_futuresql-qt5.sha256sum] = "2a0448ed4660a57c6e2be3d1d949fc2511fe89fabd8fa1f0b6d16267fdda18de"

URI_aarch64_futuresql-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/f/futuresql-qt5-devel-0.1.1-4.el10_0.aarch64.rpm;name=aarch64_futuresql-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_futuresql-qt5-devel}"
SRC_URI[aarch64_futuresql-qt5-devel.sha256sum] = "5280d0a10156e8c146e565a9866b0ee2e6814a04dd76bc11ab3968bd64473401"

URI_aarch64_futuresql-qt6 = "${EPEL_MIRROR}/aarch64/Packages/f/futuresql-qt6-0.1.1-4.el10_0.aarch64.rpm;name=aarch64_futuresql-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_futuresql-qt6}"
SRC_URI[aarch64_futuresql-qt6.sha256sum] = "a8361fa7dec03b82bc39135d4bcbb1cd4410847b339a759b979bad0955b77ede"

URI_aarch64_futuresql-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/f/futuresql-qt6-devel-0.1.1-4.el10_0.aarch64.rpm;name=aarch64_futuresql-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_futuresql-qt6-devel}"
SRC_URI[aarch64_futuresql-qt6-devel.sha256sum] = "8cc8b414f6fb2e40fec566d22e21ab0c242f644ae871da6cb3aa54383d84f101"

RDEPENDS:futuresql-qt5 = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:futuresql-qt5-devel = " \
 cmake-filesystem \
 futuresql-qt5 \
 qt5-qtbase-devel \
 "
RDEPENDS:futuresql-qt6 = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:futuresql-qt6-devel = " \
 cmake-filesystem \
 futuresql-qt6 \
 qt6-qtbase-devel \
 "
