# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sblim-sfcb"
PV = "1.4.9"
PR = "34.el10"
PACKAGES = " \
 sblim-sfcb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sblim-sfcb-1.4.9-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d646ac12ed7d2990ab0591575ed882b24b99e102af223b755f0f5f405b73433"

URI_x86_64_v2_sblim-sfcb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sblim-sfcb-1.4.9-34.el10.x86_64_v2.rpm;name=x86_64_v2_sblim-sfcb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sblim-sfcb}"
SRC_URI[x86_64_v2_sblim-sfcb.sha256sum] = "3930d66493360a86dddc729544d1dff2a1703e50e7018aaf810070fabece9ab6"
RPROVIDES:sblim-sfcb:x86_64_v2 = "virtual/cim-server"

URI_aarch64_sblim-sfcb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sblim-sfcb-1.4.9-34.el10.aarch64.rpm;name=aarch64_sblim-sfcb;unpack=0"
SRC_URI:append = " ${URI_aarch64_sblim-sfcb}"
SRC_URI[aarch64_sblim-sfcb.sha256sum] = "f1351dfc157a93437205fd56dbe345d66e023c39d57ef21adc0cab858d36523f"
RPROVIDES:sblim-sfcb:aarch64 = "virtual/cim-server"

RDEPENDS:sblim-sfcb = " \
 bash \
 cim-schema \
 glibc \
 openslp \
 openssl-libs \
 pam-libs \
 perl-Getopt-Long \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 sblim-sfcCommon \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/cim-server"

PROVIDES:append:aarch64 = " rpm/virtual/cim-server"
