# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpcsvc-proto"
PV = "1.4"
PR = "17.el10"
PACKAGES = " \
 rpcgen \
 rpcsvc-proto-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rpcsvc-proto-1.4-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b63396890f3320842b96facedb38a8e953c51b157e86803e10e8d72157847ff"

URI_x86_64_v2_rpcgen = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpcgen-1.4-17.el10.x86_64_v2.rpm;name=x86_64_v2_rpcgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpcgen}"
SRC_URI[x86_64_v2_rpcgen.sha256sum] = "b000137be7eb148e527f0640f92cbd590113dbb476080a41294cf822e041268d"

URI_x86_64_v2_rpcsvc-proto-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rpcsvc-proto-devel-1.4-17.el10.x86_64_v2.rpm;name=x86_64_v2_rpcsvc-proto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpcsvc-proto-devel}"
SRC_URI[x86_64_v2_rpcsvc-proto-devel.sha256sum] = "f0ec4ded0855d6bdd8393b4a893839494952879631fdc3e043ac030cbc17447b"

URI_aarch64_rpcgen = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpcgen-1.4-17.el10.aarch64.rpm;name=aarch64_rpcgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpcgen}"
SRC_URI[aarch64_rpcgen.sha256sum] = "9bdec37ec7ae0664f0e6feb6a96fbac141c0f9f2891a2406d9c11003b04e043c"

URI_aarch64_rpcsvc-proto-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rpcsvc-proto-devel-1.4-17.el10.aarch64.rpm;name=aarch64_rpcsvc-proto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpcsvc-proto-devel}"
SRC_URI[aarch64_rpcsvc-proto-devel.sha256sum] = "1b13dfc7eb67ad0b689ae394b494cf4f725802dc7b98f2d82c83279280a5d745"

RDEPENDS:rpcgen = " \
 glibc \
 "
RDEPENDS:rpcsvc-proto-devel = " \
 "
