# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kuserfeedback"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kuserfeedback \
 kf6-kuserfeedback-console \
 kf6-kuserfeedback-devel \
 kf6-kuserfeedback-doc \
 kf6-kuserfeedback-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kuserfeedback-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4622e0ac1500f87074ad8ad54e5542d4685fde36ac48fb99b22cc29d390374c8"

URI_x86_64_v2_kf6-kuserfeedback = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback}"
SRC_URI[x86_64_v2_kf6-kuserfeedback.sha256sum] = "b89259ea845dee3faafff7b420ea38ed6e4a501d7fc17feba9d776bbf2657591"

URI_x86_64_v2_kf6-kuserfeedback-console = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-console-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-console}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-console.sha256sum] = "ec830ecd8089b5a899fab24d60a7607d30b4c33c62614395687390f8c600cf2d"

URI_x86_64_v2_kf6-kuserfeedback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kuserfeedback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-devel}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-devel.sha256sum] = "32b60044269df270771d298fb71353107e3bca91f9c5b4d5c6359199db501b56"

URI_x86_64_v2_kf6-kuserfeedback-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kuserfeedback-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-doc}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-doc.sha256sum] = "99e5bf735b61d5914748f63df4e01d16ee25799933d58769d0a6ad6646ab57ef"

URI_x86_64_v2_kf6-kuserfeedback-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kuserfeedback-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kuserfeedback-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kuserfeedback-html}"
SRC_URI[x86_64_v2_kf6-kuserfeedback-html.sha256sum] = "9bff74c57ca3d8cca7dcb19e589588d767e2918a7a388dd8c70e83f5dfe44d40"

URI_aarch64_kf6-kuserfeedback = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kuserfeedback;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback}"
SRC_URI[aarch64_kf6-kuserfeedback.sha256sum] = "9357dd9f1cb1f8f129d97841103216250fd518514dd4dbd1d3bcfe394e4e041d"

URI_aarch64_kf6-kuserfeedback-console = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-console-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kuserfeedback-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-console}"
SRC_URI[aarch64_kf6-kuserfeedback-console.sha256sum] = "f1e434bba58f593786fbda9ececddd7b609b2ef8b272603d71eb55b399629809"

URI_aarch64_kf6-kuserfeedback-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kuserfeedback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-devel}"
SRC_URI[aarch64_kf6-kuserfeedback-devel.sha256sum] = "f92a2b6615e48a61f7b57225846f36913edd076168bcb5e75c73e96ccd3abcec"

URI_aarch64_kf6-kuserfeedback-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kuserfeedback-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-doc}"
SRC_URI[aarch64_kf6-kuserfeedback-doc.sha256sum] = "7fb06de67074a21decc858c44beba287659c862d1f1845a2f32c8fb3fe045cc7"

URI_aarch64_kf6-kuserfeedback-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kuserfeedback-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kuserfeedback-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kuserfeedback-html}"
SRC_URI[aarch64_kf6-kuserfeedback-html.sha256sum] = "d49b559546c20584157cd6e356e1b429109c74e90dc0fdf1e3399929b338d5ab"

RDEPENDS:kf6-kuserfeedback = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kuserfeedback-console = " \
 glibc \
 kf6-kuserfeedback \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtsvg \
 "
RDEPENDS:kf6-kuserfeedback-devel = " \
 cmake-filesystem \
 kf6-kuserfeedback \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kuserfeedback-doc = " \
 "
RDEPENDS:kf6-kuserfeedback-html = " \
 "
