# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ldapvi"
PV = "1.7"
PR = "52.el10_2"
PACKAGES = " \
 ldapvi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/ldapvi-1.7-52.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fa22b6ded9918c4fb87a8170d90285007ea94a6dbd57dae5812d92336b8b244"

URI_x86_64_v2_ldapvi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ldapvi-1.7-52.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ldapvi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldapvi}"
SRC_URI[x86_64_v2_ldapvi.sha256sum] = "48944626a6d6ee16aff5f450c8641a7308fc5c505e03286ba1ad06d40d9593c4"

URI_aarch64_ldapvi = "${EPEL_MIRROR}/aarch64/Packages/l/ldapvi-1.7-52.el10_2.aarch64.rpm;name=aarch64_ldapvi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldapvi}"
SRC_URI[aarch64_ldapvi.sha256sum] = "ea174c27858dc9dfd79ccecec642e13d8da00be42cbc6c1d3faa523922bddc8c"

RDEPENDS:ldapvi = " \
 glib2 \
 glibc \
 libxcrypt \
 ncurses-libs \
 openldap \
 openssl-libs \
 popt \
 readline \
 "
