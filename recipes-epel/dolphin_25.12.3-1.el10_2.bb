# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dolphin"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 dolphin \
 dolphin-devel \
 dolphin-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dolphin-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c90135b86874853454b6dcb548de7439f995198ea849a969545dcb390eddcf9a"

URI_x86_64_v2_dolphin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin}"
SRC_URI[x86_64_v2_dolphin.sha256sum] = "ae9b87000ff4a0379faf56952ac3269b927340b3a7eaf8ac2f6a3a4d9444ee3a"

URI_x86_64_v2_dolphin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin-devel}"
SRC_URI[x86_64_v2_dolphin-devel.sha256sum] = "c5ccc4c34628eb94f6b494d3514ae26c0c523678627ae601236244c3985011da"

URI_x86_64_v2_dolphin-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin-libs}"
SRC_URI[x86_64_v2_dolphin-libs.sha256sum] = "9aabcba583f4f99f072901987fb5737a5fdfeea7cde796a4cbe65a095f24f454"

URI_aarch64_dolphin = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_dolphin;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin}"
SRC_URI[aarch64_dolphin.sha256sum] = "e9be1e44062dbac0a8adc2857b100a93c6b65efdbcd8be010a79ddf5925fef0f"

URI_aarch64_dolphin-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_dolphin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin-devel}"
SRC_URI[aarch64_dolphin-devel.sha256sum] = "5841abb18d26a68bc8e7f049f36598256443e3aa802eed8faa329f75f7876d36"

URI_aarch64_dolphin-libs = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_dolphin-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin-libs}"
SRC_URI[aarch64_dolphin-libs.sha256sum] = "8fc78f6f8811d71fe81fc2853c62a64c0ba95e70e9b15cdd7815d4f196af6038"

RDEPENDS:dolphin = " \
 PackageKit-Qt6 \
 baloo-widgets \
 dolphin-libs \
 glibc \
 kf6-baloo-libs \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kparts \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
RDEPENDS:dolphin-devel = " \
 cmake-filesystem \
 dolphin-libs \
 kf6-kio-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:dolphin-libs = " \
 baloo-widgets \
 glibc \
 kf6-baloo-libs \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
