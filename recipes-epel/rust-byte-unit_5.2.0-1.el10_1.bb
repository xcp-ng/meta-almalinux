# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-byte-unit"
PV = "5.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-byte-unit+bit-devel \
 rust-byte-unit+byte-devel \
 rust-byte-unit+default-devel \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit+schemars-devel \
 rust-byte-unit+serde-devel \
 rust-byte-unit+std-devel \
 rust-byte-unit+u128-devel \
 rust-byte-unit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-byte-unit-5.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaf6b9eb689e9f6ac319fcc104d3f262689c13f6098b4830bd377ad1d83a25eb"

URI_x86_64_v2_rust-byte-unit+bit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+bit-devel-5.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+bit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+bit-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+bit-devel.sha256sum] = "b9c9fe630840f8b98ef43f88a31a76ad06e804e7f62cf0ffc854fb89a6318197"

URI_x86_64_v2_rust-byte-unit+byte-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+byte-devel-5.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+byte-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+byte-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+byte-devel.sha256sum] = "2135c5f8bbfc05bf63e876a85c05bfea6e5627037621a9ff09aa4f47603a9ec5"

URI_x86_64_v2_rust-byte-unit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+default-devel-5.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+default-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+default-devel.sha256sum] = "76cb07b87c9915896f95b05499a32a9a71a6c46ac9cd86fad957090079d0d2b9"

URI_x86_64_v2_rust-byte-unit+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+rust_decimal-devel-5.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+rust_decimal-devel.sha256sum] = "2cdd48243373b125223ba1bbfad3ea3d24da3a84ccd30f033c4c8da4c068cb0d"

URI_x86_64_v2_rust-byte-unit+schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+schemars-devel-5.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+schemars-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+schemars-devel.sha256sum] = "a69f70d5083e9cf7851e0ff94e583c4743f487d0b924d9c5615756b63b47479c"

URI_x86_64_v2_rust-byte-unit+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+serde-devel-5.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+serde-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+serde-devel.sha256sum] = "d38bb19e0a098dbf0731bc300660bfa1e189e28679a53ee0af5d934f08e691e4"

URI_x86_64_v2_rust-byte-unit+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+std-devel-5.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+std-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+std-devel.sha256sum] = "6f0cdf65bf46cf44108dd6570b5e1f86ea931416dd3427f7d261fe15b1a7ae5e"

URI_x86_64_v2_rust-byte-unit+u128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+u128-devel-5.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+u128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+u128-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+u128-devel.sha256sum] = "25a9812093c96dcb8f5f12e692b498efd3366d7a5d2456a28cb57c9380ac4f55"

URI_x86_64_v2_rust-byte-unit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit-devel-5.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit-devel}"
SRC_URI[x86_64_v2_rust-byte-unit-devel.sha256sum] = "a60fb7409fe216c3ed72039ff32b29c1ee9d15ddac9ddb50bed4a95701a1cc72"

URI_aarch64_rust-byte-unit+bit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+bit-devel-5.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-byte-unit+bit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+bit-devel}"
SRC_URI[aarch64_rust-byte-unit+bit-devel.sha256sum] = "7f0e191697a491c1c091fe8bcad5ddc6134cfe07c3fc101b547dfde6ea93e963"

URI_aarch64_rust-byte-unit+byte-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+byte-devel-5.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-byte-unit+byte-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+byte-devel}"
SRC_URI[aarch64_rust-byte-unit+byte-devel.sha256sum] = "aa12644d2f6bf8e61935c19264682decc1ce20fa4cb2bfbcdc179cf42b193800"

URI_aarch64_rust-byte-unit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+default-devel-5.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-byte-unit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+default-devel}"
SRC_URI[aarch64_rust-byte-unit+default-devel.sha256sum] = "0660cf205f6fa71751b6fe9905f7e4ad59f077e5e96a2e6607d47c883edb99db"

URI_aarch64_rust-byte-unit+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+rust_decimal-devel-5.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-byte-unit+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+rust_decimal-devel}"
SRC_URI[aarch64_rust-byte-unit+rust_decimal-devel.sha256sum] = "633b4d230a1c1970c38a8a4147b11c214019b130436ea1d3df824a3b688afa9c"

URI_aarch64_rust-byte-unit+schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+schemars-devel-5.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-byte-unit+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+schemars-devel}"
SRC_URI[aarch64_rust-byte-unit+schemars-devel.sha256sum] = "0a8e68f0b69ec3efabeb0f1d3fdcd978ff1fe5ae5200839360d389bef58d842a"

URI_aarch64_rust-byte-unit+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+serde-devel-5.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-byte-unit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+serde-devel}"
SRC_URI[aarch64_rust-byte-unit+serde-devel.sha256sum] = "8af6e3ed9b7c63fad5d332e94aaaa9552cfd6679ac4f2e64246a6432ac888958"

URI_aarch64_rust-byte-unit+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+std-devel-5.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-byte-unit+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+std-devel}"
SRC_URI[aarch64_rust-byte-unit+std-devel.sha256sum] = "6b46afbe04b54f77de6170df932a1946a0ffdc8d564dfbb00e70502b57a536ad"

URI_aarch64_rust-byte-unit+u128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+u128-devel-5.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-byte-unit+u128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+u128-devel}"
SRC_URI[aarch64_rust-byte-unit+u128-devel.sha256sum] = "9bad9a5ea0d1d8f2b7f2005e6c6d0e647fa81ef9784860e5c093c5254206890c"

URI_aarch64_rust-byte-unit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit-devel-5.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-byte-unit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit-devel}"
SRC_URI[aarch64_rust-byte-unit-devel.sha256sum] = "683ed10f5a916d3d6d7fef4a222046989d2303d881a5dbce56254ecdc4677373"

RDEPENDS:rust-byte-unit+bit-devel = " \
 cargo \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+byte-devel = " \
 cargo \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+default-devel = " \
 cargo \
 rust-byte-unit+byte-devel \
 rust-byte-unit+std-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+rust_decimal-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-byte-unit+schemars-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-byte-unit+serde-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-byte-unit+std-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 rust-schemars+std-devel \
 rust-schemars-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-byte-unit+u128-devel = " \
 cargo \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit-devel = " \
 cargo \
 rust \
 rust-utf8-width+default-devel \
 "
