# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aggregate6"
PV = "1.0.15"
PR = "1.el10_2"
PACKAGES = " \
 aggregate6 \
 python3-aggregate6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aggregate6-1.0.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ff948525efa3a26148d78f90d5ff6567d553ced4e758f6527b4b49066853fe2"

URI_x86_64_v2_aggregate6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aggregate6-1.0.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_aggregate6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aggregate6}"
SRC_URI[x86_64_v2_aggregate6.sha256sum] = "457b4f0a41eaea2ad0289da6d564ec377376e5b4f4c92d4f45d60359a8329254"

URI_x86_64_v2_python3-aggregate6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aggregate6-1.0.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aggregate6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aggregate6}"
SRC_URI[x86_64_v2_python3-aggregate6.sha256sum] = "fd9254ac4fd806a74831981fbb326bd7a3ae76633dae074f1b7b0f5dd17fd83d"

URI_aarch64_aggregate6 = "${EPEL_MIRROR}/aarch64/Packages/a/aggregate6-1.0.15-1.el10_2.noarch.rpm;name=aarch64_aggregate6;unpack=0"
SRC_URI:append = " ${URI_aarch64_aggregate6}"
SRC_URI[aarch64_aggregate6.sha256sum] = "1934be81e53d3dc1e1445c20b16cfd0c8972aaaf3770e2175c2705dae692f8ee"

URI_aarch64_python3-aggregate6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aggregate6-1.0.15-1.el10_2.noarch.rpm;name=aarch64_python3-aggregate6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aggregate6}"
SRC_URI[aarch64_python3-aggregate6.sha256sum] = "d71dbb41f95d65fe2f5d3c1f55677b683e4eb4084e08409a56fd357504128013"

RDEPENDS:aggregate6 = " \
 python3 \
 python3-aggregate6 \
 "
RDEPENDS:python3-aggregate6 = " \
 python3 \
 python3-py-radix \
 "
