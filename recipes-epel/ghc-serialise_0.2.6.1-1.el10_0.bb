# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-serialise"
PV = "0.2.6.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-serialise \
 ghc-serialise-devel \
 ghc-serialise-doc \
 ghc-serialise-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-serialise-0.2.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2ffaf3c504013f61eb187a19a4e8acd3f81cf7f9561af2ebc0d4657594b1af6"

URI_x86_64_v2_ghc-serialise = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-serialise-0.2.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-serialise;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-serialise}"
SRC_URI[x86_64_v2_ghc-serialise.sha256sum] = "7e3e703a85fa234be162e34e93bbaa777f500cd07d5f41dedc9069c70d945e76"

URI_x86_64_v2_ghc-serialise-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-serialise-devel-0.2.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-serialise-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-serialise-devel}"
SRC_URI[x86_64_v2_ghc-serialise-devel.sha256sum] = "1f7bcf64d34198e5d3d3279fd8ba77fa37ea8de5fc9cdbd26143dbc684cd2797"

URI_x86_64_v2_ghc-serialise-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-serialise-doc-0.2.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-serialise-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-serialise-doc}"
SRC_URI[x86_64_v2_ghc-serialise-doc.sha256sum] = "bcb4b9fa20c4c91588f08f0783f978e13efb479c092363f10772c2e2dcb660dc"

URI_x86_64_v2_ghc-serialise-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-serialise-prof-0.2.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-serialise-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-serialise-prof}"
SRC_URI[x86_64_v2_ghc-serialise-prof.sha256sum] = "11ce560ad3dba4b3e8ad38ea0d5b448195bde44c4959d56b13526865cccc6915"

URI_aarch64_ghc-serialise = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-serialise-0.2.6.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-serialise;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-serialise}"
SRC_URI[aarch64_ghc-serialise.sha256sum] = "9ce9629aa5c2bde0dc85be825bd52876446011f1d6e86c44ae279e592ebe42ef"

URI_aarch64_ghc-serialise-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-serialise-devel-0.2.6.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-serialise-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-serialise-devel}"
SRC_URI[aarch64_ghc-serialise-devel.sha256sum] = "351a7ad9e78df0c5c875a83b9c37005bd12b3ccf74963d21b9f4f5b80497401e"

URI_aarch64_ghc-serialise-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-serialise-doc-0.2.6.1-1.el10_0.noarch.rpm;name=aarch64_ghc-serialise-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-serialise-doc}"
SRC_URI[aarch64_ghc-serialise-doc.sha256sum] = "46dd8030c1ce2ebd5136ccfae9337485fb824df3c6b9b17367efdaaec56758da"

URI_aarch64_ghc-serialise-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-serialise-prof-0.2.6.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-serialise-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-serialise-prof}"
SRC_URI[aarch64_ghc-serialise-prof.sha256sum] = "1e204cd93d996496e0bfc2002bf9234a8da4db1c5909742f61fe3250f41edf8e"

RDEPENDS:ghc-serialise = " \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-cborg \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-half \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-stm \
 ghc-strict \
 ghc-template-haskell \
 ghc-text \
 ghc-these \
 ghc-time \
 ghc-transformers \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-serialise-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cborg-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-half-devel \
 ghc-hashable-devel \
 ghc-primitive-devel \
 ghc-serialise \
 ghc-strict-devel \
 ghc-text-devel \
 ghc-these-devel \
 ghc-time-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-serialise-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-serialise-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cborg-prof \
 ghc-containers-prof \
 ghc-half-prof \
 ghc-hashable-prof \
 ghc-primitive-prof \
 ghc-serialise-devel \
 ghc-strict-prof \
 ghc-text-prof \
 ghc-these-prof \
 ghc-time-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
