# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getrandom"
PV = "0.3.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-getrandom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getrandom-0.3.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efcd24c569a2aeeabf01d46c7dcb03d16907e459fe3d02f52cd85427b8a40860"

URI_x86_64_v2_rust-getrandom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom+default-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom+default-devel}"
SRC_URI[x86_64_v2_rust-getrandom+default-devel.sha256sum] = "793763227523858fb46590aceba3f05a37cf3c5c9739fea5df1439797d4c6ca8"

URI_x86_64_v2_rust-getrandom+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom+std-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom+std-devel}"
SRC_URI[x86_64_v2_rust-getrandom+std-devel.sha256sum] = "c4bad27b89dd31060043251c66b57f9f1eb99cfab4aa601637dcbb6c74c94f11"

URI_x86_64_v2_rust-getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom-devel}"
SRC_URI[x86_64_v2_rust-getrandom-devel.sha256sum] = "7a415369c72a3660da5fb4ef589b3a000759ac03253a013d5548ac5cbdc4a7b4"

URI_aarch64_rust-getrandom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom+default-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-getrandom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom+default-devel}"
SRC_URI[aarch64_rust-getrandom+default-devel.sha256sum] = "358ffd3a829217dc56739f7bd2b25c7c62bc384e7d21b013d816184a1516e6da"

URI_aarch64_rust-getrandom+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom+std-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-getrandom+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom+std-devel}"
SRC_URI[aarch64_rust-getrandom+std-devel.sha256sum] = "bd66cbbfadfb352d68a0d092dab80eef72ec54ebae42a5156224fd58709c24f0"

URI_aarch64_rust-getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom-devel}"
SRC_URI[aarch64_rust-getrandom-devel.sha256sum] = "29f822a2e836b81e6c6c6bcfe128d476f1e683d7e079face32d9e8fcfb4bfa78"

RDEPENDS:rust-getrandom+default-devel = " \
 cargo \
 rust-getrandom-devel \
 "
RDEPENDS:rust-getrandom+std-devel = " \
 cargo \
 rust-getrandom-devel \
 "
RDEPENDS:rust-getrandom-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
