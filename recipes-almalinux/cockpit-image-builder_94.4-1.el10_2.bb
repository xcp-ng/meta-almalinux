# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-image-builder"
PV = "94.4"
PR = "1.el10_2"
PACKAGES = " \
 cockpit-image-builder \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-image-builder-94.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "00aceb2413798b6f66d416f13a9665a61be328936bcf2fffa2e3e880db23ea05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-image-builder-94.4-1.el10_2.noarch.rpm;name=x86_64_v2_cockpit-image-builder;unpack=0"
SRC_URI[x86_64_v2_cockpit-image-builder.sha256sum] = "6d46bc65678588738897e9833c8b0821f6f410eb59d37f70469150a20636cb8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-image-builder-94.4-1.el10_2.noarch.rpm;name=aarch64_cockpit-image-builder;unpack=0"
SRC_URI[aarch64_cockpit-image-builder.sha256sum] = "6d46bc65678588738897e9833c8b0821f6f410eb59d37f70469150a20636cb8a"

RDEPENDS:cockpit-image-builder = " \
 cockpit \
 cockpit-files \
 osbuild-composer \
 "
