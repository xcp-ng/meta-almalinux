# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mime_guess"
PV = "2.0.5"
PR = "2.el10_0"
PACKAGES = " \
 rust-mime_guess+default-devel \
 rust-mime_guess+rev-mappings-devel \
 rust-mime_guess-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-mime_guess-2.0.5-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f97d1ca172d761a65721e6d1fe57c632305d12d2fc7533bf5c1337043c5cf766"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mime_guess+default-devel-2.0.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mime_guess+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mime_guess+default-devel.sha256sum] = "a18b0c26303167779d67795710ff0cae0c0b2ecc3655c11eda9b1434bccadf47"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mime_guess+rev-mappings-devel-2.0.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mime_guess+rev-mappings-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mime_guess+rev-mappings-devel.sha256sum] = "2e5645d9a861bad5f604af8eddd87b84594698f8349d12e4732d703c0863af2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mime_guess-devel-2.0.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mime_guess-devel;unpack=0"
SRC_URI[x86_64_v2_rust-mime_guess-devel.sha256sum] = "8aada138dfeb837220babfd1fff99af5cfd62cccf6aed0e04d32ceb2ddeb6c50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mime_guess+default-devel-2.0.5-2.el10_0.noarch.rpm;name=aarch64_rust-mime_guess+default-devel;unpack=0"
SRC_URI[aarch64_rust-mime_guess+default-devel.sha256sum] = "10808fb77fc50e903802300e2648637223fd9b87ea5b59a21a8eef48d78678d1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mime_guess+rev-mappings-devel-2.0.5-2.el10_0.noarch.rpm;name=aarch64_rust-mime_guess+rev-mappings-devel;unpack=0"
SRC_URI[aarch64_rust-mime_guess+rev-mappings-devel.sha256sum] = "0b810c60b6e2fc4bf98a036b55a8017e706d9e75b578b0a1e7cee830e83adc5b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-mime_guess-devel-2.0.5-2.el10_0.noarch.rpm;name=aarch64_rust-mime_guess-devel;unpack=0"
SRC_URI[aarch64_rust-mime_guess-devel.sha256sum] = "eeb0edfec7df2008fa344eb6322ea2032c8379295ef76c61e1b693356e45c36b"

RDEPENDS:rust-mime_guess+default-devel = " \
 cargo \
 rust-mime_guess+rev-mappings-devel \
 rust-mime_guess-devel \
 "
RDEPENDS:rust-mime_guess+rev-mappings-devel = " \
 cargo \
 rust-mime_guess-devel \
 "
RDEPENDS:rust-mime_guess-devel = " \
 cargo \
 rust-mime+default-devel \
 rust-unicase+default-devel \
 "
