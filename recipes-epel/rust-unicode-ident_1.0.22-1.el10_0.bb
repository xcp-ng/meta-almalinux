# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-ident"
PV = "1.0.22"
PR = "1.el10_0"
PACKAGES = " \
 rust-unicode-ident+default-devel \
 rust-unicode-ident-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-ident-1.0.22-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c99ca56fec3a402518abde8db82294c0f6b27de8cff63d197a79d2b7fd6fd6e1"

URI_x86_64_v2_rust-unicode-ident+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-ident+default-devel-1.0.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-ident+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-ident+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-ident+default-devel.sha256sum] = "41332e1218385ec8949abe4e46118e02cb410030e1b5087fd77cb3936de2eb9a"

URI_x86_64_v2_rust-unicode-ident-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-ident-devel-1.0.22-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-ident-devel}"
SRC_URI[x86_64_v2_rust-unicode-ident-devel.sha256sum] = "ce6c391548be64c96643298f6cd374e7556b1f6d4edbaffbe894c89675b893be"

URI_aarch64_rust-unicode-ident+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-ident+default-devel-1.0.22-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-ident+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-ident+default-devel}"
SRC_URI[aarch64_rust-unicode-ident+default-devel.sha256sum] = "8771d432f42f35b70000c91c412ffef0cbeae7c5af44d5fb1ed5ebd069c46d1b"

URI_aarch64_rust-unicode-ident-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-ident-devel-1.0.22-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-ident-devel}"
SRC_URI[aarch64_rust-unicode-ident-devel.sha256sum] = "1c2aa70529a55433abf3a6f41c95581ec8a6c2ba27b0da19126548cadf3f5260"

RDEPENDS:rust-unicode-ident+default-devel = " \
 cargo \
 rust-unicode-ident-devel \
 "
RDEPENDS:rust-unicode-ident-devel = " \
 cargo \
 rust \
 "
