# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "asahi-plymouth"
PV = "0.2"
PR = "1.el10_1"
PACKAGES = " \
 plymouth-theme-asahi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/asahi-plymouth-0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fd3653c999d2e0e4d7e2b1cf0d9cf1bf0b559370633a348e6bed2630a8639c9"

URI_x86_64_v2_plymouth-theme-asahi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-theme-asahi-0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plymouth-theme-asahi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-asahi}"
SRC_URI[x86_64_v2_plymouth-theme-asahi.sha256sum] = "21b6dbe418621e2232131668e4f87343020ef30256f885a1da84bb7c17e303a2"

URI_aarch64_plymouth-theme-asahi = "${EPEL_MIRROR}/aarch64/Packages/p/plymouth-theme-asahi-0.2-1.el10_1.noarch.rpm;name=aarch64_plymouth-theme-asahi;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-asahi}"
SRC_URI[aarch64_plymouth-theme-asahi.sha256sum] = "9aab7b58e54cd640e4a8f95a53488b823f95f5758a3d280c48923685ff8a61c2"

RDEPENDS:plymouth-theme-asahi = " \
 plymouth \
 "
