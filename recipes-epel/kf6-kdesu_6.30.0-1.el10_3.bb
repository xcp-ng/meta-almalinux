# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdesu"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdesu \
 kf6-kdesu-devel \
 kf6-kdesu-doc \
 kf6-kdesu-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kdesu-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "45eb0d9f40c9ffcad43e6b22bf1ce41d751a6bc7d00b6e2679e4b616d2cf92de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdesu;unpack=0"
SRC_URI[x86_64_v2_kf6-kdesu.sha256sum] = "281dcbdf1051fc3ceb57964a670b8667e8bfa3a97edc5b344b0a88b268734e3d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdesu-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kdesu-devel.sha256sum] = "ab4d45f04fba0696b2a54d27f71e80385489169a9426bc2b681ece6b93ce86fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdesu-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kdesu-doc.sha256sum] = "1db9972b8730e74eb107b86fe3d28ff6aeb9d0156f2ae8d209fefaf61b01d786"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdesu-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kdesu-html.sha256sum] = "906e13c5e3519b038c0c069a28d413c0ea914ae48c960a44f139abacbe688c81"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdesu;unpack=0"
SRC_URI[aarch64_kf6-kdesu.sha256sum] = "9e9d4bb13c4dc1e6a9bcccb789ad59a356ae9a5fe487395855f71953c3114005"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdesu-devel;unpack=0"
SRC_URI[aarch64_kf6-kdesu-devel.sha256sum] = "db8d499d2cc57285ccd536c781f599f7e82366f9cb28a0a6cc32049307748db3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdesu-doc;unpack=0"
SRC_URI[aarch64_kf6-kdesu-doc.sha256sum] = "9da074a0c03729626c1904cf6f794ea948fbcbc43347fb96d871535f16a7d623"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdesu-html;unpack=0"
SRC_URI[aarch64_kf6-kdesu-html.sha256sum] = "795fb78b3283d9e0a64cc2f61b94a5f4fafb20eeac87c3efb901a402180700ca"

RDEPENDS:kf6-kdesu = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpty \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 sudo \
 "
RDEPENDS:kf6-kdesu-devel = " \
 cmake-filesystem \
 kf6-kdesu \
 kf6-kpty-devel \
 "
RDEPENDS:kf6-kdesu-doc = " \
 "
RDEPENDS:kf6-kdesu-html = " \
 "
