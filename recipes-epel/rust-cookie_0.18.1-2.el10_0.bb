# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cookie"
PV = "0.18.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-cookie+aes-gcm-devel \
 rust-cookie+base64-devel \
 rust-cookie+default-devel \
 rust-cookie+hkdf-devel \
 rust-cookie+hmac-devel \
 rust-cookie+key-expansion-devel \
 rust-cookie+percent-encode-devel \
 rust-cookie+percent-encoding-devel \
 rust-cookie+private-devel \
 rust-cookie+rand-devel \
 rust-cookie+secure-devel \
 rust-cookie+sha2-devel \
 rust-cookie+signed-devel \
 rust-cookie+subtle-devel \
 rust-cookie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cookie-0.18.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b031046be47bdacfe449ebd54744cb96ef9d7ec9f65538a284869a4c8d52285e"

URI_x86_64_v2_rust-cookie+aes-gcm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+aes-gcm-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+aes-gcm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+aes-gcm-devel}"
SRC_URI[x86_64_v2_rust-cookie+aes-gcm-devel.sha256sum] = "fc39aef7acd36f3313617f995f13b486a06eee9728d34e20c6d940b0590373f5"

URI_x86_64_v2_rust-cookie+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+base64-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+base64-devel}"
SRC_URI[x86_64_v2_rust-cookie+base64-devel.sha256sum] = "e2ead5094d16d76e617d1ddc4e188b4f3ae590268a808c6e81a106834565f6c5"

URI_x86_64_v2_rust-cookie+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+default-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+default-devel}"
SRC_URI[x86_64_v2_rust-cookie+default-devel.sha256sum] = "35c4d9f127d4a292e0d0ea3136b69e764652b46063d4d46fd96ddb835e816fb0"

URI_x86_64_v2_rust-cookie+hkdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+hkdf-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+hkdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+hkdf-devel}"
SRC_URI[x86_64_v2_rust-cookie+hkdf-devel.sha256sum] = "80aa81f580166d7367c7b0870f72b3c8358d18fa5ee04fe573ff25e359a80c08"

URI_x86_64_v2_rust-cookie+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+hmac-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+hmac-devel}"
SRC_URI[x86_64_v2_rust-cookie+hmac-devel.sha256sum] = "fdbca8f0f53960d2419d188e61e22f8bd62f87bd5eba731f2866cd737ba12431"

URI_x86_64_v2_rust-cookie+key-expansion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+key-expansion-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+key-expansion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+key-expansion-devel}"
SRC_URI[x86_64_v2_rust-cookie+key-expansion-devel.sha256sum] = "3b2a87e1e258d249760439b9efc99fcb89a85ab5d47027206f0b0e0e891934b1"

URI_x86_64_v2_rust-cookie+percent-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+percent-encode-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+percent-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+percent-encode-devel}"
SRC_URI[x86_64_v2_rust-cookie+percent-encode-devel.sha256sum] = "52fddb744410dd3fb4eae8f29eb2963834adbcc71f60c7a02fec258fb257e0c2"

URI_x86_64_v2_rust-cookie+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+percent-encoding-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-cookie+percent-encoding-devel.sha256sum] = "b91a38ee64e22f5045fbb530e1894bfa9d52b47684ed3d2a5682a4af34130000"

URI_x86_64_v2_rust-cookie+private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+private-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+private-devel}"
SRC_URI[x86_64_v2_rust-cookie+private-devel.sha256sum] = "2ee6483f00270321599e3ffc43229fc255ad3ed1e40c7da1370ab1bbc972ffbb"

URI_x86_64_v2_rust-cookie+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+rand-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+rand-devel}"
SRC_URI[x86_64_v2_rust-cookie+rand-devel.sha256sum] = "aa2cea45314566d2e8b2f1c7f18fd6e5f5d9861d466b58092b7ad5b4d9914510"

URI_x86_64_v2_rust-cookie+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+secure-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+secure-devel}"
SRC_URI[x86_64_v2_rust-cookie+secure-devel.sha256sum] = "eacfece17807e5b22dd624f01e5825aaf1af01a7bbe6119736d5a4e693a99f8f"

URI_x86_64_v2_rust-cookie+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+sha2-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+sha2-devel}"
SRC_URI[x86_64_v2_rust-cookie+sha2-devel.sha256sum] = "434b201d88357bfa9148fdc05f64adb1db07d3c09ce9384ba8aa68c162fcc77b"

URI_x86_64_v2_rust-cookie+signed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+signed-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+signed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+signed-devel}"
SRC_URI[x86_64_v2_rust-cookie+signed-devel.sha256sum] = "1f45f753b56d35806072a6533116e89eeb14977c144d0d64792a655441df4fd9"

URI_x86_64_v2_rust-cookie+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+subtle-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+subtle-devel}"
SRC_URI[x86_64_v2_rust-cookie+subtle-devel.sha256sum] = "fbc43b4480851dcc1001f8521419f11c13b2f878a55e083d5ddcc8de5da0713a"

URI_x86_64_v2_rust-cookie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-devel-0.18.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-devel}"
SRC_URI[x86_64_v2_rust-cookie-devel.sha256sum] = "af71ff7de8aeee3543e879c281b144aa6e5456208a48a863d47e6268c4fa1e4b"

URI_aarch64_rust-cookie+aes-gcm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+aes-gcm-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+aes-gcm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+aes-gcm-devel}"
SRC_URI[aarch64_rust-cookie+aes-gcm-devel.sha256sum] = "5203a95bf09e2e52cf6acfbb73cbf2fd3251175b75c042647f5965a9a6900165"

URI_aarch64_rust-cookie+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+base64-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+base64-devel}"
SRC_URI[aarch64_rust-cookie+base64-devel.sha256sum] = "8d8bba7ddcd4b03409902e50a9759f958812c8ea441ec0d9982aa8ca20f86715"

URI_aarch64_rust-cookie+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+default-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+default-devel}"
SRC_URI[aarch64_rust-cookie+default-devel.sha256sum] = "583e20f12d8548abc79c6441d4c489d3a5e6ee7ee51e12e6e56cfeb54f7fe37a"

URI_aarch64_rust-cookie+hkdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+hkdf-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+hkdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+hkdf-devel}"
SRC_URI[aarch64_rust-cookie+hkdf-devel.sha256sum] = "d9e84bf5dc022549cc71df6a05e7b5d84c09ac709afceb3540faa80646f063dc"

URI_aarch64_rust-cookie+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+hmac-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+hmac-devel}"
SRC_URI[aarch64_rust-cookie+hmac-devel.sha256sum] = "f844fe15ec9305e5b46d8734df8ed803fac423e0c1d5d93cf7fafc1240b2d45f"

URI_aarch64_rust-cookie+key-expansion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+key-expansion-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+key-expansion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+key-expansion-devel}"
SRC_URI[aarch64_rust-cookie+key-expansion-devel.sha256sum] = "0dcc5175970905d43de4020c13fdfc13df3e1b5b5277b2c3d459afaaeec7e547"

URI_aarch64_rust-cookie+percent-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+percent-encode-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+percent-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+percent-encode-devel}"
SRC_URI[aarch64_rust-cookie+percent-encode-devel.sha256sum] = "d77cee1f87d11a7c9f25c91a19f5673ca00495352ef547b9a19b3ffb357f6267"

URI_aarch64_rust-cookie+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+percent-encoding-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+percent-encoding-devel}"
SRC_URI[aarch64_rust-cookie+percent-encoding-devel.sha256sum] = "f3bc7e129e836c297b1318d55cec8b2376a51656d2ff64bd86fa4fd6c62ee568"

URI_aarch64_rust-cookie+private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+private-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+private-devel}"
SRC_URI[aarch64_rust-cookie+private-devel.sha256sum] = "186d647a87b484002211c7324e282ec78b5942a8eb77a5750f8bccfb751c8422"

URI_aarch64_rust-cookie+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+rand-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+rand-devel}"
SRC_URI[aarch64_rust-cookie+rand-devel.sha256sum] = "8dbc28905c522ba45dc80cbdaf8374c0093b610ea21d23c12d89fa57e3850898"

URI_aarch64_rust-cookie+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+secure-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+secure-devel}"
SRC_URI[aarch64_rust-cookie+secure-devel.sha256sum] = "428002be03a3b4cb7d9671847dd89360a375525c7016b0593e3bce32d30cdf53"

URI_aarch64_rust-cookie+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+sha2-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+sha2-devel}"
SRC_URI[aarch64_rust-cookie+sha2-devel.sha256sum] = "13fc777a6f0cf7bd35b2ec884d2de2e4f34382fef3eaa630acb336ee827b8bd3"

URI_aarch64_rust-cookie+signed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+signed-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+signed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+signed-devel}"
SRC_URI[aarch64_rust-cookie+signed-devel.sha256sum] = "0010507c36875cde779d098a480c9b0c608ec54907e0c29f56692aef79b51bde"

URI_aarch64_rust-cookie+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+subtle-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+subtle-devel}"
SRC_URI[aarch64_rust-cookie+subtle-devel.sha256sum] = "534b29612a09f6089d7ba60e318a82ae5481384e9915d671ff4d55ec3d591c03"

URI_aarch64_rust-cookie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-devel-0.18.1-2.el10_0.noarch.rpm;name=aarch64_rust-cookie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-devel}"
SRC_URI[aarch64_rust-cookie-devel.sha256sum] = "31e1097a073a8d0f2c7e6c3d6ea5d1848def49bbfc2e24837fc9688627beb3db"

RDEPENDS:rust-cookie+aes-gcm-devel = " \
 cargo \
 rust-aes-gcm+default-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+default-devel = " \
 cargo \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+hkdf-devel = " \
 cargo \
 rust-cookie-devel \
 rust-hkdf+default-devel \
 "
RDEPENDS:rust-cookie+hmac-devel = " \
 cargo \
 rust-cookie-devel \
 rust-hmac+default-devel \
 "
RDEPENDS:rust-cookie+key-expansion-devel = " \
 cargo \
 rust-cookie+hkdf-devel \
 rust-cookie+sha2-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+percent-encode-devel = " \
 cargo \
 rust-cookie+percent-encoding-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+percent-encoding-devel = " \
 cargo \
 rust-cookie-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-cookie+private-devel = " \
 cargo \
 rust-cookie+aes-gcm-devel \
 rust-cookie+base64-devel \
 rust-cookie+rand-devel \
 rust-cookie+subtle-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+rand-devel = " \
 cargo \
 rust-cookie-devel \
 rust-rand0.8+default-devel \
 "
RDEPENDS:rust-cookie+secure-devel = " \
 cargo \
 rust-cookie+key-expansion-devel \
 rust-cookie+private-devel \
 rust-cookie+signed-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+sha2-devel = " \
 cargo \
 rust-cookie-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-cookie+signed-devel = " \
 cargo \
 rust-cookie+base64-devel \
 rust-cookie+hmac-devel \
 rust-cookie+rand-devel \
 rust-cookie+sha2-devel \
 rust-cookie+subtle-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+subtle-devel = " \
 cargo \
 rust-cookie-devel \
 rust-subtle+default-devel \
 "
RDEPENDS:rust-cookie-devel = " \
 bash \
 cargo \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 rust-time+std-devel \
 rust-time-devel \
 rust-version_check+default-devel \
 "
