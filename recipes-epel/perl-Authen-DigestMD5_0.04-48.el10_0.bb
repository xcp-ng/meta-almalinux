# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Authen-DigestMD5"
PV = "0.04"
PR = "48.el10_0"
PACKAGES = " \
 perl-Authen-DigestMD5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Authen-DigestMD5-0.04-48.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb93a40f04e3d77fed9631ac046cd54596ae274d908ba32831fb9b26ed9a388c"

URI_x86_64_v2_perl-Authen-DigestMD5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Authen-DigestMD5-0.04-48.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Authen-DigestMD5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Authen-DigestMD5}"
SRC_URI[x86_64_v2_perl-Authen-DigestMD5.sha256sum] = "7db254530238d19fb044c51c424b579043e99d0de7f6068b55aa8c1612a87c9b"

URI_aarch64_perl-Authen-DigestMD5 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Authen-DigestMD5-0.04-48.el10_0.noarch.rpm;name=aarch64_perl-Authen-DigestMD5;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Authen-DigestMD5}"
SRC_URI[aarch64_perl-Authen-DigestMD5.sha256sum] = "1bc09be984514fa46ddf17d2f01d99e5db82a27df0f8362675e2515a4ab013e5"

RDEPENDS:perl-Authen-DigestMD5 = " \
 perl-Carp \
 perl-Digest-MD5 \
 perl-libs \
 "
