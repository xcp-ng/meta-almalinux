# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rgb"
PV = "0.8.53"
PR = "1.el10_1"
PACKAGES = " \
 rust-rgb+argb-devel \
 rust-rgb+as-bytes-devel \
 rust-rgb+bytemuck-devel \
 rust-rgb+checked_fns-devel \
 rust-rgb+default-devel \
 rust-rgb+grb-devel \
 rust-rgb+serde-devel \
 rust-rgb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rgb-0.8.53-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f92d5e858d5f82a8b4304ca86659677c72ef2c344de8040f14fea45833edf8a6"

URI_x86_64_v2_rust-rgb+argb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+argb-devel-0.8.53-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+argb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+argb-devel}"
SRC_URI[x86_64_v2_rust-rgb+argb-devel.sha256sum] = "c1e4a0614dcd386595bee16fa1ee362c95a58305aac32087040269fc074a1701"

URI_x86_64_v2_rust-rgb+as-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+as-bytes-devel-0.8.53-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+as-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+as-bytes-devel}"
SRC_URI[x86_64_v2_rust-rgb+as-bytes-devel.sha256sum] = "c0ac46cf9bd74d664244f7a953bfbc8e414087988d3b3f04e743e187a3f00ebd"

URI_x86_64_v2_rust-rgb+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+bytemuck-devel-0.8.53-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-rgb+bytemuck-devel.sha256sum] = "d43eaf1977129a595ef612defd613dc9017eab0756bf622eb085fe4502e022de"

URI_x86_64_v2_rust-rgb+checked_fns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+checked_fns-devel-0.8.53-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+checked_fns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+checked_fns-devel}"
SRC_URI[x86_64_v2_rust-rgb+checked_fns-devel.sha256sum] = "1f2a920244d52224c1a40e9109fcdf81f7ce870d4cc09288d15b036e811868d9"

URI_x86_64_v2_rust-rgb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+default-devel-0.8.53-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+default-devel}"
SRC_URI[x86_64_v2_rust-rgb+default-devel.sha256sum] = "b1c56ba6e6d3df1bc1c56233c56aa50adf4a11772e7382bb17223e95abe0da72"

URI_x86_64_v2_rust-rgb+grb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+grb-devel-0.8.53-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+grb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+grb-devel}"
SRC_URI[x86_64_v2_rust-rgb+grb-devel.sha256sum] = "23a837dd608e1b45dfcd75c7f220deeae00208ef29bf5ddd99bdc39a163e892f"

URI_x86_64_v2_rust-rgb+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+serde-devel-0.8.53-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+serde-devel}"
SRC_URI[x86_64_v2_rust-rgb+serde-devel.sha256sum] = "3aebe49cca66b353b0dff24fc01e06d76019d0097b52383ae0be4589bfe4bfe6"

URI_x86_64_v2_rust-rgb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb-devel-0.8.53-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb-devel}"
SRC_URI[x86_64_v2_rust-rgb-devel.sha256sum] = "cb87e41a1379db731669f09f39542ae4efd43e6b7420da6a2f2253623046db3c"

URI_aarch64_rust-rgb+argb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+argb-devel-0.8.53-1.el10_1.noarch.rpm;name=aarch64_rust-rgb+argb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+argb-devel}"
SRC_URI[aarch64_rust-rgb+argb-devel.sha256sum] = "86f79afe563ba7a544091c6d1618d7a1d070b82c235c154a9ae7e8f2a597260d"

URI_aarch64_rust-rgb+as-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+as-bytes-devel-0.8.53-1.el10_1.noarch.rpm;name=aarch64_rust-rgb+as-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+as-bytes-devel}"
SRC_URI[aarch64_rust-rgb+as-bytes-devel.sha256sum] = "92c31074b6d726dd2877dbc89aa24402c85226437ae725dd134c04e20ac07ea4"

URI_aarch64_rust-rgb+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+bytemuck-devel-0.8.53-1.el10_1.noarch.rpm;name=aarch64_rust-rgb+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+bytemuck-devel}"
SRC_URI[aarch64_rust-rgb+bytemuck-devel.sha256sum] = "ffa57904446cc5470af13faed55249e9170495a061b068bb282cf7329b6c9b33"

URI_aarch64_rust-rgb+checked_fns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+checked_fns-devel-0.8.53-1.el10_1.noarch.rpm;name=aarch64_rust-rgb+checked_fns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+checked_fns-devel}"
SRC_URI[aarch64_rust-rgb+checked_fns-devel.sha256sum] = "8182db694a5b60af9106d9fd1c5a4441a98f6688c39af325420043c508f57a8d"

URI_aarch64_rust-rgb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+default-devel-0.8.53-1.el10_1.noarch.rpm;name=aarch64_rust-rgb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+default-devel}"
SRC_URI[aarch64_rust-rgb+default-devel.sha256sum] = "50a87f545b98784c6773f9e6bf2802bf5a2ba21837146ccb5ed41ff41ed4607c"

URI_aarch64_rust-rgb+grb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+grb-devel-0.8.53-1.el10_1.noarch.rpm;name=aarch64_rust-rgb+grb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+grb-devel}"
SRC_URI[aarch64_rust-rgb+grb-devel.sha256sum] = "4f4d4af6c102451ca6b3124aeff0eb2bb8feb4a82549927ba3acd9152f557db2"

URI_aarch64_rust-rgb+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+serde-devel-0.8.53-1.el10_1.noarch.rpm;name=aarch64_rust-rgb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+serde-devel}"
SRC_URI[aarch64_rust-rgb+serde-devel.sha256sum] = "bbfc06310f0de9380124ca3c45d059e0b1597bcaedf6a07da82a2f186713fae7"

URI_aarch64_rust-rgb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb-devel-0.8.53-1.el10_1.noarch.rpm;name=aarch64_rust-rgb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb-devel}"
SRC_URI[aarch64_rust-rgb-devel.sha256sum] = "ed3fe97ed13c3a4973acd53f33389241a247986de324db0ad4bf0446e6de0155"

RDEPENDS:rust-rgb+argb-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+as-bytes-devel = " \
 cargo \
 rust-rgb+bytemuck-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+checked_fns-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+default-devel = " \
 cargo \
 rust-rgb+argb-devel \
 rust-rgb+as-bytes-devel \
 rust-rgb+grb-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+grb-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+serde-devel = " \
 cargo \
 rust-rgb-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rgb-devel = " \
 cargo \
 rust \
 "
