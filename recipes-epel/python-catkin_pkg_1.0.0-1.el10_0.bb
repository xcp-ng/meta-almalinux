# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-catkin_pkg"
PV = "1.0.0"
PR = "1.el10_0"
PACKAGES = " \
 python-catkin_pkg-doc \
 python3-catkin_pkg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-catkin_pkg-1.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27fd60f8a36ba679cdffca107499b483d89ef261798bfd4103c8d5d6816d40b4"

URI_x86_64_v2_python-catkin_pkg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-catkin_pkg-doc-1.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-catkin_pkg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-catkin_pkg-doc}"
SRC_URI[x86_64_v2_python-catkin_pkg-doc.sha256sum] = "0035eb5af4478834ac3e87dac44af5e85d707e82bdad0a6ac346a022a70b2508"

URI_x86_64_v2_python3-catkin_pkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-catkin_pkg-1.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-catkin_pkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-catkin_pkg}"
SRC_URI[x86_64_v2_python3-catkin_pkg.sha256sum] = "9ea9fad2c07a4d5e1d6b27af804968df90967f9762b202a0e765798f64314df1"

URI_aarch64_python-catkin_pkg-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-catkin_pkg-doc-1.0.0-1.el10_0.noarch.rpm;name=aarch64_python-catkin_pkg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-catkin_pkg-doc}"
SRC_URI[aarch64_python-catkin_pkg-doc.sha256sum] = "00884817ff117d740ce812692f9fca3f5ff57436a7efc7d75fb11f81eaae1df6"

URI_aarch64_python3-catkin_pkg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-catkin_pkg-1.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-catkin_pkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-catkin_pkg}"
SRC_URI[aarch64_python3-catkin_pkg.sha256sum] = "73a0263eab77b7f484c5be75bf106ac5075b5ea561d5f8704d468715ab52cf14"

RDEPENDS:python-catkin_pkg-doc = " \
 "
RDEPENDS:python3-catkin_pkg = " \
 python3 \
 python3-dateutil \
 python3-docutils \
 python3-pyparsing \
 python3-setuptools \
 "
