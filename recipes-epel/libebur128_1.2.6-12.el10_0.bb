# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libebur128"
PV = "1.2.6"
PR = "12.el10_0"
PACKAGES = " \
 libebur128 \
 libebur128-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libebur128-1.2.6-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b57c9dff56394b2df4d355e99946949b11fb9fe6f2ca4f344ffa5044ae8d38c"

URI_x86_64_v2_libebur128 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libebur128-1.2.6-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libebur128;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libebur128}"
SRC_URI[x86_64_v2_libebur128.sha256sum] = "6ce395fb8b8121cf5e46fd41cfc0d2f703b8913dd40ea60dee0875ee639e77c1"

URI_x86_64_v2_libebur128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libebur128-devel-1.2.6-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libebur128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libebur128-devel}"
SRC_URI[x86_64_v2_libebur128-devel.sha256sum] = "2eb5f2e1faa395dcc047eabb48197fef94a84accf2076f7bd17a6f9498512071"

URI_aarch64_libebur128 = "${EPEL_MIRROR}/aarch64/Packages/l/libebur128-1.2.6-12.el10_0.aarch64.rpm;name=aarch64_libebur128;unpack=0"
SRC_URI:append = " ${URI_aarch64_libebur128}"
SRC_URI[aarch64_libebur128.sha256sum] = "efc86bf6ebd0d5a016c5674da542d0136d5af6b52c820c0e3032e4e767a30774"

URI_aarch64_libebur128-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libebur128-devel-1.2.6-12.el10_0.aarch64.rpm;name=aarch64_libebur128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libebur128-devel}"
SRC_URI[aarch64_libebur128-devel.sha256sum] = "8d4e2c460eec3c3498b9cc6e0b9fdbb2dc0fae6a440470d94466895ad21385a2"

RDEPENDS:libebur128 = " \
 glibc \
 "
RDEPENDS:libebur128-devel = " \
 libebur128 \
 pkgconf-pkg-config \
 "
