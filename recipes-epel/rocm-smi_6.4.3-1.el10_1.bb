# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-smi"
PV = "6.4.3"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 rocm-smi \
 rocm-smi-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-smi-6.4.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8c4e46fbc35162ab502368a0759ef3cdf67a6691460caa8f56458a04afdcc17"

URI_x86_64_v2_rocm-smi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-smi-6.4.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-smi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-smi}"
SRC_URI[x86_64_v2_rocm-smi.sha256sum] = "60c6da4a07b34af7018e5481bd92ac8bbac1494dcd30d53970f888ecc13168c1"

URI_x86_64_v2_rocm-smi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-smi-devel-6.4.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-smi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-smi-devel}"
SRC_URI[x86_64_v2_rocm-smi-devel.sha256sum] = "35150765816ee624e3d6127ab8498019f48782d6a3828568fd07e578e7e7969b"

RDEPENDS:rocm-smi = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:rocm-smi-devel = " \
 cmake-filesystem \
 libdrm-devel \
 rocm-smi \
 "
