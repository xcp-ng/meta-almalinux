# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mlmmj"
PV = "2.1.0"
PR = "1.el10_3"
PACKAGES = " \
 mlmmj \
 mlmmj-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mlmmj-2.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a496529f6bbb6bf401a5c27bfec150bfda14e138dc88bbb335ed91f3da5ea225"

URI_x86_64_v2_mlmmj = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlmmj-2.1.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mlmmj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlmmj}"
SRC_URI[x86_64_v2_mlmmj.sha256sum] = "9f72e21498b22a298ce5a98c767c1913391deb45d2665e04bdaa782610d826fa"

URI_x86_64_v2_mlmmj-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlmmj-selinux-2.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mlmmj-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlmmj-selinux}"
SRC_URI[x86_64_v2_mlmmj-selinux.sha256sum] = "50967e97abe989416f4907981c51dd940f0a58252d11e29818dc779eb9d28c71"

URI_aarch64_mlmmj = "${EPEL_MIRROR}/aarch64/Packages/m/mlmmj-2.1.0-1.el10_3.aarch64.rpm;name=aarch64_mlmmj;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlmmj}"
SRC_URI[aarch64_mlmmj.sha256sum] = "edc1ecbd275aeb224d60f1f374f17e7dd542a5de1aaecdca083c2e9f1ff67443"

URI_aarch64_mlmmj-selinux = "${EPEL_MIRROR}/aarch64/Packages/m/mlmmj-selinux-2.1.0-1.el10_3.noarch.rpm;name=aarch64_mlmmj-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlmmj-selinux}"
SRC_URI[aarch64_mlmmj-selinux.sha256sum] = "67d2dfeb872fd681aff36107929243bba1b4a8090e9310819145b6abd20d5d1f"

RDEPENDS:mlmmj = " \
 bash \
 glibc \
 "
RDEPENDS:mlmmj-selinux = " \
 bash \
 mlmmj \
 selinux-policy-targeted \
 "
