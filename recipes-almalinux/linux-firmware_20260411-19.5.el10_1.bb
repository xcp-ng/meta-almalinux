# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linux-firmware"
PV = "20260411"
PR = "19.5.el10_1"
PACKAGES = " \
 amd-gpu-firmware \
 amd-ucode-firmware \
 atheros-firmware \
 brcmfmac-firmware \
 cirrus-audio-firmware \
 dvb-firmware \
 intel-audio-firmware \
 intel-gpu-firmware \
 intel-vsc-firmware \
 iwlegacy-firmware \
 iwlwifi-dvm-firmware \
 iwlwifi-mvm-firmware \
 libertas-firmware \
 linux-firmware \
 linux-firmware-whence \
 mlxsw_spectrum-firmware \
 mrvlprestera-firmware \
 mt7xxx-firmware \
 netronome-firmware \
 nvidia-gpu-firmware \
 nxpwireless-firmware \
 qcom-firmware \
 realtek-firmware \
 tiwilink-firmware \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/linux-firmware-20260411-19.5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0f71ba594b53ad4e4ba5dd1341b7e97d46ea44fe10d5375970bf6a2120ac7829"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/amd-gpu-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_amd-gpu-firmware;unpack=0"
SRC_URI[x86_64_v2_amd-gpu-firmware.sha256sum] = "c5177e615f07798a193446932d0fdd9ab3f8c1709b740622d36573cc8a1d6c7e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/amd-ucode-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_amd-ucode-firmware;unpack=0"
SRC_URI[x86_64_v2_amd-ucode-firmware.sha256sum] = "8e7f29a94c44c1d238d1b2804200bbd6a47c60e76d7c611ec73ae8ede4b7efd7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/atheros-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_atheros-firmware;unpack=0"
SRC_URI[x86_64_v2_atheros-firmware.sha256sum] = "ab5c269e9a27c9ce7458896f31d482d9e6332ac14753a93229a85f139608fee3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/brcmfmac-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_brcmfmac-firmware;unpack=0"
SRC_URI[x86_64_v2_brcmfmac-firmware.sha256sum] = "a6f24651ee8287d33c94d6b6fbb1e5c1bb16dd09c6c3508648999397dfcd9d77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cirrus-audio-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_cirrus-audio-firmware;unpack=0"
SRC_URI[x86_64_v2_cirrus-audio-firmware.sha256sum] = "0238875c9e539ed7ff8ed1e02bed5e845598463636b0c0f831b79d248444382f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dvb-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_dvb-firmware;unpack=0"
SRC_URI[x86_64_v2_dvb-firmware.sha256sum] = "8e79cbe037f7c9abe27cce0d861382c0b497ac9f17dfb7a66c155228ea0c9882"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-audio-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_intel-audio-firmware;unpack=0"
SRC_URI[x86_64_v2_intel-audio-firmware.sha256sum] = "2f3a199632674d6d30c2a9b84299976b86c22be8a63b7f708cc7abfa18c5e435"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/intel-gpu-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_intel-gpu-firmware;unpack=0"
SRC_URI[x86_64_v2_intel-gpu-firmware.sha256sum] = "f4f5e51dd4be9005e2e6c5a48e1415c00d310d001a39dcb38bc762e979fb0d96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-vsc-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_intel-vsc-firmware;unpack=0"
SRC_URI[x86_64_v2_intel-vsc-firmware.sha256sum] = "e93fbe6160bb58fc9aad5760d76bbc1caf23ad93e188fc7882e0614c85d8e9e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlegacy-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_iwlegacy-firmware;unpack=0"
SRC_URI[x86_64_v2_iwlegacy-firmware.sha256sum] = "f97981f822020ffcf2f4ac0ebbc92dd525a3a1eaacc42b6b41d18162ae427e94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-dvm-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_iwlwifi-dvm-firmware;unpack=0"
SRC_URI[x86_64_v2_iwlwifi-dvm-firmware.sha256sum] = "4ed289408d529201499396cef39226ab6f05d0548b924c2029caf369a87904ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-mvm-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_iwlwifi-mvm-firmware;unpack=0"
SRC_URI[x86_64_v2_iwlwifi-mvm-firmware.sha256sum] = "f91893771ad8d63e82c5e8afa5168bb51ff0afafbea4c831b171d242c46e2635"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libertas-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_libertas-firmware;unpack=0"
SRC_URI[x86_64_v2_libertas-firmware.sha256sum] = "be6e1c8d60411657ba3f5dfd167be712f4e1b4d747307ec69dba4e688a35790f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_linux-firmware;unpack=0"
SRC_URI[x86_64_v2_linux-firmware.sha256sum] = "cc07043231d44c50e8fb48522bc32d893e2cefcbb814dc8ca716ac8a51f94216"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-whence-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_linux-firmware-whence;unpack=0"
SRC_URI[x86_64_v2_linux-firmware-whence.sha256sum] = "08b1faae20e992091cd8b47c216c48c6424409d2e21f2016b193b05da1b5642e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mlxsw_spectrum-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_mlxsw_spectrum-firmware;unpack=0"
SRC_URI[x86_64_v2_mlxsw_spectrum-firmware.sha256sum] = "90e83badd0c5f325eef1ac662f0e5a0aba77dc3a4a66aadf0f9c122363e027f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mrvlprestera-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_mrvlprestera-firmware;unpack=0"
SRC_URI[x86_64_v2_mrvlprestera-firmware.sha256sum] = "1d5deefde9ab3a2e8221d5664667e2df2f59ef9e547ff47cb69638727a8a7f5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mt7xxx-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_mt7xxx-firmware;unpack=0"
SRC_URI[x86_64_v2_mt7xxx-firmware.sha256sum] = "fc82bd7c215d887d0e1fd0092f9e489204bfb22e65d6d05df9ea8fb220430e40"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/netronome-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_netronome-firmware;unpack=0"
SRC_URI[x86_64_v2_netronome-firmware.sha256sum] = "aefd3c47922852b2f116b4816f87bacee9282271a8315f884f5c46a43b709b54"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nvidia-gpu-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_nvidia-gpu-firmware;unpack=0"
SRC_URI[x86_64_v2_nvidia-gpu-firmware.sha256sum] = "520248eb9b15cc4419d3ab730bafc2236f16b8adc084b276849efb8e5260421a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nxpwireless-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_nxpwireless-firmware;unpack=0"
SRC_URI[x86_64_v2_nxpwireless-firmware.sha256sum] = "ba6e3f898ae4460828da3bbdfad284a33292be953af9e05a385dc1f562efd433"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/qcom-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_qcom-firmware;unpack=0"
SRC_URI[x86_64_v2_qcom-firmware.sha256sum] = "49ec8e23b36fd04437c9335691a40e47455dbc54d13d43129d990952c9dd1551"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/realtek-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_realtek-firmware;unpack=0"
SRC_URI[x86_64_v2_realtek-firmware.sha256sum] = "0ad8c9ece6e8e9fb34387da252b1f77899e6b91da1c4f325769537182a610dd4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tiwilink-firmware-20260411-19.5.el10_1.noarch.rpm;name=x86_64_v2_tiwilink-firmware;unpack=0"
SRC_URI[x86_64_v2_tiwilink-firmware.sha256sum] = "0d141a762ab1452cee088102aad0c70fe239ba45f28d3cb4cf9deac4d0f59b73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/amd-gpu-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_amd-gpu-firmware;unpack=0"
SRC_URI[aarch64_amd-gpu-firmware.sha256sum] = "c5177e615f07798a193446932d0fdd9ab3f8c1709b740622d36573cc8a1d6c7e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/amd-ucode-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_amd-ucode-firmware;unpack=0"
SRC_URI[aarch64_amd-ucode-firmware.sha256sum] = "8e7f29a94c44c1d238d1b2804200bbd6a47c60e76d7c611ec73ae8ede4b7efd7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/atheros-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_atheros-firmware;unpack=0"
SRC_URI[aarch64_atheros-firmware.sha256sum] = "ab5c269e9a27c9ce7458896f31d482d9e6332ac14753a93229a85f139608fee3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/brcmfmac-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_brcmfmac-firmware;unpack=0"
SRC_URI[aarch64_brcmfmac-firmware.sha256sum] = "a6f24651ee8287d33c94d6b6fbb1e5c1bb16dd09c6c3508648999397dfcd9d77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cirrus-audio-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_cirrus-audio-firmware;unpack=0"
SRC_URI[aarch64_cirrus-audio-firmware.sha256sum] = "0238875c9e539ed7ff8ed1e02bed5e845598463636b0c0f831b79d248444382f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dvb-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_dvb-firmware;unpack=0"
SRC_URI[aarch64_dvb-firmware.sha256sum] = "8e79cbe037f7c9abe27cce0d861382c0b497ac9f17dfb7a66c155228ea0c9882"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-audio-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_intel-audio-firmware;unpack=0"
SRC_URI[aarch64_intel-audio-firmware.sha256sum] = "2f3a199632674d6d30c2a9b84299976b86c22be8a63b7f708cc7abfa18c5e435"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/intel-gpu-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_intel-gpu-firmware;unpack=0"
SRC_URI[aarch64_intel-gpu-firmware.sha256sum] = "f4f5e51dd4be9005e2e6c5a48e1415c00d310d001a39dcb38bc762e979fb0d96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-vsc-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_intel-vsc-firmware;unpack=0"
SRC_URI[aarch64_intel-vsc-firmware.sha256sum] = "e93fbe6160bb58fc9aad5760d76bbc1caf23ad93e188fc7882e0614c85d8e9e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlegacy-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_iwlegacy-firmware;unpack=0"
SRC_URI[aarch64_iwlegacy-firmware.sha256sum] = "f97981f822020ffcf2f4ac0ebbc92dd525a3a1eaacc42b6b41d18162ae427e94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-dvm-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_iwlwifi-dvm-firmware;unpack=0"
SRC_URI[aarch64_iwlwifi-dvm-firmware.sha256sum] = "4ed289408d529201499396cef39226ab6f05d0548b924c2029caf369a87904ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-mvm-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_iwlwifi-mvm-firmware;unpack=0"
SRC_URI[aarch64_iwlwifi-mvm-firmware.sha256sum] = "f91893771ad8d63e82c5e8afa5168bb51ff0afafbea4c831b171d242c46e2635"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libertas-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_libertas-firmware;unpack=0"
SRC_URI[aarch64_libertas-firmware.sha256sum] = "be6e1c8d60411657ba3f5dfd167be712f4e1b4d747307ec69dba4e688a35790f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_linux-firmware;unpack=0"
SRC_URI[aarch64_linux-firmware.sha256sum] = "cc07043231d44c50e8fb48522bc32d893e2cefcbb814dc8ca716ac8a51f94216"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-whence-20260411-19.5.el10_1.noarch.rpm;name=aarch64_linux-firmware-whence;unpack=0"
SRC_URI[aarch64_linux-firmware-whence.sha256sum] = "08b1faae20e992091cd8b47c216c48c6424409d2e21f2016b193b05da1b5642e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mlxsw_spectrum-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_mlxsw_spectrum-firmware;unpack=0"
SRC_URI[aarch64_mlxsw_spectrum-firmware.sha256sum] = "90e83badd0c5f325eef1ac662f0e5a0aba77dc3a4a66aadf0f9c122363e027f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mrvlprestera-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_mrvlprestera-firmware;unpack=0"
SRC_URI[aarch64_mrvlprestera-firmware.sha256sum] = "1d5deefde9ab3a2e8221d5664667e2df2f59ef9e547ff47cb69638727a8a7f5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mt7xxx-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_mt7xxx-firmware;unpack=0"
SRC_URI[aarch64_mt7xxx-firmware.sha256sum] = "fc82bd7c215d887d0e1fd0092f9e489204bfb22e65d6d05df9ea8fb220430e40"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/netronome-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_netronome-firmware;unpack=0"
SRC_URI[aarch64_netronome-firmware.sha256sum] = "aefd3c47922852b2f116b4816f87bacee9282271a8315f884f5c46a43b709b54"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nvidia-gpu-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_nvidia-gpu-firmware;unpack=0"
SRC_URI[aarch64_nvidia-gpu-firmware.sha256sum] = "520248eb9b15cc4419d3ab730bafc2236f16b8adc084b276849efb8e5260421a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nxpwireless-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_nxpwireless-firmware;unpack=0"
SRC_URI[aarch64_nxpwireless-firmware.sha256sum] = "ba6e3f898ae4460828da3bbdfad284a33292be953af9e05a385dc1f562efd433"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/qcom-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_qcom-firmware;unpack=0"
SRC_URI[aarch64_qcom-firmware.sha256sum] = "49ec8e23b36fd04437c9335691a40e47455dbc54d13d43129d990952c9dd1551"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/realtek-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_realtek-firmware;unpack=0"
SRC_URI[aarch64_realtek-firmware.sha256sum] = "0ad8c9ece6e8e9fb34387da252b1f77899e6b91da1c4f325769537182a610dd4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tiwilink-firmware-20260411-19.5.el10_1.noarch.rpm;name=aarch64_tiwilink-firmware;unpack=0"
SRC_URI[aarch64_tiwilink-firmware.sha256sum] = "0d141a762ab1452cee088102aad0c70fe239ba45f28d3cb4cf9deac4d0f59b73"

RDEPENDS:amd-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:amd-ucode-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:atheros-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:brcmfmac-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:cirrus-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:dvb-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-vsc-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlegacy-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-dvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-mvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:libertas-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware-whence = " \
 "
RDEPENDS:mlxsw_spectrum-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mrvlprestera-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mt7xxx-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:netronome-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:nvidia-gpu-firmware = " \
 linux-firmware \
 linux-firmware-whence \
 "
RDEPENDS:nxpwireless-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:qcom-firmware = " \
 atheros-firmware \
 linux-firmware-whence \
 "
RDEPENDS:realtek-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:tiwilink-firmware = " \
 linux-firmware-whence \
 "
