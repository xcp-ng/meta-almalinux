# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyqt6-webengine"
PV = "6.9.0"
PR = "0.1.el10_1"
PACKAGES = " \
 python3-pyqt6-webengine \
 python3-pyqt6-webengine-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyqt6-webengine-6.9.0-0.1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "564e31692dec196ce734fb30124e43ce798f7e41c868e31807d315302e4ef892"

URI_x86_64_v2_python3-pyqt6-webengine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyqt6-webengine-6.9.0-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6-webengine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6-webengine}"
SRC_URI[x86_64_v2_python3-pyqt6-webengine.sha256sum] = "461cf21c1de9b9bb90570e23809e7b325375ef24e5830385127e5d89322902a0"

URI_x86_64_v2_python3-pyqt6-webengine-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyqt6-webengine-devel-6.9.0-0.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6-webengine-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6-webengine-devel}"
SRC_URI[x86_64_v2_python3-pyqt6-webengine-devel.sha256sum] = "7cc55a9b4f375d9a431879e73924d6689f09c8317f1a4edf21c84e78b3e23dee"

URI_aarch64_python3-pyqt6-webengine = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyqt6-webengine-6.9.0-0.1.el10_1.aarch64.rpm;name=aarch64_python3-pyqt6-webengine;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6-webengine}"
SRC_URI[aarch64_python3-pyqt6-webengine.sha256sum] = "b6ad2d694eea6eedd7b485f2debf475c3e583aaa1ea0b203f9ea7cf63c1fe28b"

URI_aarch64_python3-pyqt6-webengine-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyqt6-webengine-devel-6.9.0-0.1.el10_1.aarch64.rpm;name=aarch64_python3-pyqt6-webengine-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6-webengine-devel}"
SRC_URI[aarch64_python3-pyqt6-webengine-devel.sha256sum] = "d53fdf1fcc955e3855f55e9b67a5e6255f67eeae70d052de63ec461b7ad231b4"

RDEPENDS:python3-pyqt6-webengine = " \
 glibc \
 libstdc++ \
 python3 \
 python3-pyqt6 \
 python3-pyqt6-base \
 python3-pyqt6-sip \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:python3-pyqt6-webengine-devel = " \
 python3-pyqt6-devel \
 python3-pyqt6-webengine \
 "
