# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc-plugin-bittorrent"
PV = "2.14"
PR = "8.el10_0"
PACKAGES = " \
 vlc-plugin-bittorrent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vlc-plugin-bittorrent-2.14-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7a64dc71bbbceba902bdfb4a945b534903021fa9256404292c68c1a75d030a7"

URI_x86_64_v2_vlc-plugin-bittorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-bittorrent-2.14-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-bittorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-bittorrent}"
SRC_URI[x86_64_v2_vlc-plugin-bittorrent.sha256sum] = "5d9d49369e0270ad571c78735360cef47ea8b7922e787edc6dc448c1fb72196c"

URI_aarch64_vlc-plugin-bittorrent = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-bittorrent-2.14-8.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-bittorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-bittorrent}"
SRC_URI[aarch64_vlc-plugin-bittorrent.sha256sum] = "0c7dc282d1dca565ecccf3aca630edafcd0ef7fe125bd4c68d99479dc58b4d4b"

RDEPENDS:vlc-plugin-bittorrent = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 rb_libtorrent \
 vlc-libs \
 vlc-plugins-base \
 "
