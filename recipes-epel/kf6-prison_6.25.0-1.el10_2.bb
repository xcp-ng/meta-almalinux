# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-prison"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-prison \
 kf6-prison-devel \
 kf6-prison-doc \
 kf6-prison-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-prison-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "193fa4a60ee1d2705ec6001a8ca354db223574f771c6418f94adac8d0ab40c98"

URI_x86_64_v2_kf6-prison = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-prison;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison}"
SRC_URI[x86_64_v2_kf6-prison.sha256sum] = "dd1fc522c2fa74f03425372c5f53a48a1c5d37ed8aadc9cb7a79a1dfbc318cf7"

URI_x86_64_v2_kf6-prison-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-prison-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-devel}"
SRC_URI[x86_64_v2_kf6-prison-devel.sha256sum] = "17401525fe8274a460eda6a3696ffb00d54249a89ef231bd1725c7613e0796b5"

URI_x86_64_v2_kf6-prison-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-prison-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-doc}"
SRC_URI[x86_64_v2_kf6-prison-doc.sha256sum] = "e6787609e15390729da67465a843c48cddff30e4a7c321c712f04fcf363988b1"

URI_x86_64_v2_kf6-prison-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-prison-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-html}"
SRC_URI[x86_64_v2_kf6-prison-html.sha256sum] = "d76baba29da59a571a0eeb6198b8ade9cacd73d50d80f19b6e3f0e31ab274063"

URI_aarch64_kf6-prison = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-prison;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison}"
SRC_URI[aarch64_kf6-prison.sha256sum] = "3bede0f0a558b51ac17a49683822d167e1db34e76f73eeb513d1322246ef1d47"

URI_aarch64_kf6-prison-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-prison-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-devel}"
SRC_URI[aarch64_kf6-prison-devel.sha256sum] = "b04cab6384427be447f6bfc77ca87bf2e5240718b052b75791902a898267daff"

URI_aarch64_kf6-prison-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-prison-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-doc}"
SRC_URI[aarch64_kf6-prison-doc.sha256sum] = "b41667fab2a53862daabe2990286f2eef124ee68af5d4c017654fa2b183957ea"

URI_aarch64_kf6-prison-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-prison-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-html}"
SRC_URI[aarch64_kf6-prison-html.sha256sum] = "ef153b61574aa7298bb5d1c244e553640330626ac4227b6ed07383c770b22623"

RDEPENDS:kf6-prison = " \
 glibc \
 kf6-filesystem \
 libdmtx \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 zxing-cpp \
 "
RDEPENDS:kf6-prison-devel = " \
 cmake-filesystem \
 kf6-prison \
 "
RDEPENDS:kf6-prison-doc = " \
 "
RDEPENDS:kf6-prison-html = " \
 "
