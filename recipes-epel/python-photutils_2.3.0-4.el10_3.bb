# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-photutils"
PV = "2.3.0"
PR = "4.el10_3"
PACKAGES = " \
 python3-photutils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-photutils-2.3.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "636f88d08027b7ed29bc33b69495adb525c2f97dc012106dff85d661f52e40b5"

URI_x86_64_v2_python3-photutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-photutils-2.3.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-photutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-photutils}"
SRC_URI[x86_64_v2_python3-photutils.sha256sum] = "ff4c7c7638e6305ac613b6e2a99c8b777be93d2f6cbbf881cd407d0e05ddde53"

URI_aarch64_python3-photutils = "${EPEL_MIRROR}/aarch64/Packages/p/python3-photutils-2.3.0-4.el10_3.aarch64.rpm;name=aarch64_python3-photutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-photutils}"
SRC_URI[aarch64_python3-photutils.sha256sum] = "56f2d04621bbf01a4a981ccb1a49b23546a591d75034ae81b5a4b70fe6c6ab1a"

RDEPENDS:python3-photutils = " \
 glibc \
 python3 \
 python3-astropy \
 python3-numpy \
 python3-scipy \
 "
