# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustix"
PV = "1.1.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustix+all-apis-devel \
 rust-rustix+alloc-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+libc-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix+linux_4_11-devel \
 rust-rustix+linux_5_1-devel \
 rust-rustix+linux_5_11-devel \
 rust-rustix+linux_latest-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+std-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix+try_close-devel \
 rust-rustix+use-explicitly-provided-auxv-devel \
 rust-rustix+use-libc-auxv-devel \
 rust-rustix+use-libc-devel \
 rust-rustix-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustix-1.1.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d8c170ae434195f64da36cbd047f21906210b7b082456f64dcc8ab1057214e32"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+all-apis-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+all-apis-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+all-apis-devel.sha256sum] = "532398a210108420618af688b4efc27053bc6c2c1c5aa87b4bea1c27034aa7b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+alloc-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+alloc-devel.sha256sum] = "076a61ccc9a35d83a450393180ded70d7e538a5dff776cb98df9a03942e80336"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+default-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+default-devel.sha256sum] = "757b8c712df021f18542e2096cade0193dab4accd48be7b4cd085a402ed958f6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+event-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+event-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+event-devel.sha256sum] = "9c505c3d6d8c42914c840da56b787b68bb1fc6ad6721608ddfbaffd02141d2eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+fs-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+fs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+fs-devel.sha256sum] = "1644ae71669edc60063a10d6ed66bb5ee5112c49e26b833aace31d6a6d5b757b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+io_uring-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+io_uring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+io_uring-devel.sha256sum] = "bf41a1c5e1f493ac5b809e2d0fb261bed6efd123e622655efed2cdcae22f244e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+libc-devel.sha256sum] = "3c93839ba3e3dbdd128bdaee009e1548a75e3eac28d1bb07a916056712e596ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc_errno-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+libc_errno-devel.sha256sum] = "498f89a9beeccd503c110b59d1d7449f710d65d850b64ac7ac378c94e86821e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_4_11-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+linux_4_11-devel.sha256sum] = "b6883be4ff83215eab89bcfd23ea630e29b53875aa1e0e16554d6c9f74c4318e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_5_1-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_5_1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+linux_5_1-devel.sha256sum] = "924286f08ba2775883f54d8e9a8ab540233ece723ea7fa36e71585dd9156544a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_5_11-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_5_11-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+linux_5_11-devel.sha256sum] = "5a978d579a33ea5f9775c2846b903567eb4e22b3eeee99c7434ffd3fac4878ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_latest-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+linux_latest-devel.sha256sum] = "888b865a2ac07d7738c0093cc074a20303e7236ff07917508e35fb913f145583"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mm-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mm-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+mm-devel.sha256sum] = "a81ce6affab218c062206f12de16329f98583fa7f5404c130d75557142673697"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mount-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mount-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+mount-devel.sha256sum] = "f1db09bb7ff41378da50d0cad014ee0782155abb2459cab705652c617b309775"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+net-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+net-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+net-devel.sha256sum] = "81b0f29e892a91974148827bb2de8f6323084e99657e13f9060c2b042d37c6c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+param-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+param-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+param-devel.sha256sum] = "ef31f19613ea3d3ffd60827d8e12273fa1ba98cc2a3623bad69ba6ed45b40eb6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pipe-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pipe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+pipe-devel.sha256sum] = "0f12f330f54849d323c31543e4996712b4a18965e9550720fbdfca38a84f1e0c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+process-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+process-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+process-devel.sha256sum] = "9ba51c2b2fa19e4433ed895f6b0c748ed3ecc7ae7627b9380f2c174d453cb75f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pty-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pty-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+pty-devel.sha256sum] = "ae7494f0c437bf1d391c5092b4d01ff4e3316fecfcb1452f02ba49888bad5105"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+rand-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+rand-devel.sha256sum] = "dccf540afa7c3f4631d686d67247bb44875b4208d130b845f838cf6297c949fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+runtime-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+runtime-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+runtime-devel.sha256sum] = "b4e83ed77dcbac3c0f05394fd4dffb8690a7a13155a5961b532cb57ae5945c45"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+shm-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+shm-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+shm-devel.sha256sum] = "478978c8c4f173f91db69cb6217558624986214d1ba795136c371be5988d9344"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+std-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+std-devel.sha256sum] = "cc5c95440ef42e56246c5d27e72d593d5f54b56e49825954e65c599c4e757af3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+stdio-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+stdio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+stdio-devel.sha256sum] = "f2c4d098abc6bcd20a2b6f605e492457f14f5b238eaf22fef1bc7c0acfc0b786"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+system-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+system-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+system-devel.sha256sum] = "b79bf55bc7ccbfbc20cc58249ae04c066ebbff577988c6e8018bf5dcae58a0e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+termios-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+termios-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+termios-devel.sha256sum] = "4f1bf1177814897e4f31c0c7f0e9c70f26b30a2404ef2d276c577c39e3a6ac1f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+thread-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+thread-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+thread-devel.sha256sum] = "444ece12777bb9bf6731f65b4c2ea71a0da5bf3fd1a084a501a7d6efa9844906"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+time-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+time-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+time-devel.sha256sum] = "282d3d39c23f84574343cfe7a49bed00f177fb97ed1100c3636293b1f8680673"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+try_close-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+try_close-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+try_close-devel.sha256sum] = "b83a44f7de9bd3a173043bb66d2978fd9f431a31260f894b4e2fcc8b13b47bbb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-explicitly-provided-auxv-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "f0d5df22049782d163600052d6bbd0794a73c5c08c7adbc13551a4fcd793afaa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-auxv-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+use-libc-auxv-devel.sha256sum] = "4463cd1f6c915a358576c7945bb03ceb257e7c62b08794394ada837fe20d0b50"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix+use-libc-devel.sha256sum] = "0e82dbe543ee5926c052d6fb33cbf077600faf06cd4d0723831f23ea5ea9fceb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustix-devel.sha256sum] = "d3499f6c1e67d5c9bc4da88094cce56ae51c1a6e6587f94809901ba10a3c2cc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+all-apis-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+all-apis-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+all-apis-devel.sha256sum] = "b69b30e468966d86603bed2125cbf88ae050f7d9ce9c575493107c314f38b4f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+alloc-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+alloc-devel.sha256sum] = "a08b941fca1d8e3a01efc75990ade7f6b745976a811656fbc647329896200414"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+default-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+default-devel.sha256sum] = "8270f505aae1eefbb331eb127e2a143307540c6dd8493b6bb397c0da6163d091"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+event-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+event-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+event-devel.sha256sum] = "f1b148c5303f7168ce183ecbfec3baccf40f5d6e664f9d59367a82c288d6fa91"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+fs-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+fs-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+fs-devel.sha256sum] = "8344156bc227981302b44e7dd0201b90437fc017a584a0b6b80676b2987088f3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+io_uring-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+io_uring-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+io_uring-devel.sha256sum] = "781be4ba3e97a4e8b3df513204fd5fb5cf4cc4b1926c7a8055c5a21d6c81f700"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+libc-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+libc-devel.sha256sum] = "a190dccf20bba4d784133966740f6bab2f646aefe93766dd9a8c9f6c09bee080"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc_errno-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+libc_errno-devel.sha256sum] = "fe684832b21821f1ee24b51c7e5fc8957a8e50e2efbdfeaefb3153cf2cf22093"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_4_11-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+linux_4_11-devel.sha256sum] = "6b9635fd1d66c24119639e62e7cfeee48b1c068d8346505cca86e47989dd3d21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_5_1-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+linux_5_1-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+linux_5_1-devel.sha256sum] = "521e22f168b62126d6b9fe7527ba340b7fedf744803e8e8cb62c3b278cd5eeca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_5_11-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+linux_5_11-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+linux_5_11-devel.sha256sum] = "e4d680ed9aacfc5246d9a860d4e227c38557b258395ce1d387676d0105c172cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_latest-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+linux_latest-devel.sha256sum] = "b437cf65d275a9bd1e7e528899b8c4e17ec93af89ae08e22a6c08032e7669a2e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mm-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+mm-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+mm-devel.sha256sum] = "ea03a4878ecdcbdb491fa3063dc828d25d98b7e91e094f3a1fb75857e3ab43b8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mount-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+mount-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+mount-devel.sha256sum] = "d8f94aac53ac23aec27007dfab8fbdd2776310ec56d1cbda8d0958f127c21528"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+net-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+net-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+net-devel.sha256sum] = "38b9aeac08bc38310e7a34de29d76a6fcfc6ddcb5b732b0864669c064adde15d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+param-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+param-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+param-devel.sha256sum] = "cb5b330b65ab7b06422e159da01052093b9d0bf8e2e9972f49242e7fbb7afc33"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pipe-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+pipe-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+pipe-devel.sha256sum] = "3943ae264d458c2d1029280f89eb03d2f1720f8535930cb7cfefc1764532a6c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+process-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+process-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+process-devel.sha256sum] = "fb8d93d7f7dff2710f8c514bd8efa4025ba474075ce5cdbec4503ee13c71549b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pty-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+pty-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+pty-devel.sha256sum] = "165988c1abdc06172e4be0ca8beb146087781cde1664124c69e7ad65adc1078a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+rand-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+rand-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+rand-devel.sha256sum] = "e1671931256bbd5f6022fc4d051d63b2d1f5f605c360b79a2415f25bb7a8a758"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+runtime-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+runtime-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+runtime-devel.sha256sum] = "932109f0efb076a107e14b4000c957b2bcc4284e8e3876db071fb0fd728e7bf9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+shm-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+shm-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+shm-devel.sha256sum] = "837987a3d026146629db85d58b15733e13505eec7ad44242fb47f509a9377093"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+std-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+std-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+std-devel.sha256sum] = "e295592217dd8f6c94185dfe3880e22bf61a42b8c88b82a68bd073dc15074db7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+stdio-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+stdio-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+stdio-devel.sha256sum] = "c8a9f244ed332841902fb851826fcc8cb95ca610558ed2e8007a9540d8a06aab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+system-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+system-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+system-devel.sha256sum] = "02a078bca382fccd02f759ee4f018dbd6ec27322e81280528b8f5fe4dfb78766"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+termios-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+termios-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+termios-devel.sha256sum] = "9573d7580103fae190210ba287c6684b02dee7bc57970c5e7bdf4e885148d26e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+thread-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+thread-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+thread-devel.sha256sum] = "19910bfb1d69a93c5a4d4f83069b53601ef6106d583f3fd1c3323d0efdaaec13"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+time-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+time-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+time-devel.sha256sum] = "fdd73a4d2adb34640447259728b05311253afc66c7f7242248532af059dcc370"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+try_close-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+try_close-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+try_close-devel.sha256sum] = "ad5abda7cdc743aa398b9bc1233018aabb764ae0340bd0b0eb65990d80f3ef17"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-explicitly-provided-auxv-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "6c9e728da3a8ce1655c47aebb63e275db3fd6f8223745ee51f41e4c32a93d7f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-auxv-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+use-libc-auxv-devel.sha256sum] = "f042c1ca67d8c233e73271cae9a51438ad31e2dd611646e2a4b7feefe9b69dd2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix+use-libc-devel;unpack=0"
SRC_URI[aarch64_rust-rustix+use-libc-devel.sha256sum] = "05c0eaf7b2f2f270734ffcce8c9f31a7257e394acc2ac73995f280bc38e7fac8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-rustix-devel;unpack=0"
SRC_URI[aarch64_rust-rustix-devel.sha256sum] = "b62678109fcca701e05450175657510d6d8751bb35a990bd45c81a7f9bf6dba1"

RDEPENDS:rust-rustix+all-apis-devel = " \
 cargo \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+alloc-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+default-devel = " \
 cargo \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+event-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+fs-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys+io_uring-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+thread-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc_errno-devel = " \
 cargo \
 rust-errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_4_11-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_5_1-devel = " \
 cargo \
 rust-rustix+linux_4_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_5_11-devel = " \
 cargo \
 rust-rustix+linux_5_1-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_latest-devel = " \
 cargo \
 rust-rustix+linux_5_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mm-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mount-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+net-devel = " \
 cargo \
 rust-linux-raw-sys+if_ether-devel \
 rust-linux-raw-sys+net-devel \
 rust-linux-raw-sys+netlink-devel \
 rust-linux-raw-sys+xdp-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+param-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pipe-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+process-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pty-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+rand-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+runtime-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+shm-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+std-devel = " \
 cargo \
 rust-bitflags+std-devel \
 rust-errno+std-devel \
 rust-errno-devel \
 rust-libc+std-devel \
 rust-libc-devel \
 rust-rustix+alloc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+stdio-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+system-devel = " \
 cargo \
 rust-linux-raw-sys+system-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+termios-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+thread-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+time-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+try_close-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-explicitly-provided-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-devel = " \
 cargo \
 rust-rustix+libc-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix-devel = " \
 cargo \
 rust \
 rust-bitflags-devel \
 rust-errno-devel \
 rust-libc-devel \
 rust-linux-raw-sys+auxvec-devel \
 rust-linux-raw-sys+elf-devel \
 rust-linux-raw-sys+errno-devel \
 rust-linux-raw-sys+general-devel \
 rust-linux-raw-sys+ioctl-devel \
 rust-linux-raw-sys+no_std-devel \
 rust-linux-raw-sys-devel \
 "
