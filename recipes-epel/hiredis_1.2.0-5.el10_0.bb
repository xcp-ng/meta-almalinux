# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hiredis"
PV = "1.2.0"
PR = "5.el10_0"
PACKAGES = " \
 hiredis \
 hiredis-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hiredis-1.2.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e392c560c7c8feb8b33540f683c6e570881713b3aef30617ff315e713f77383"

URI_x86_64_v2_hiredis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hiredis-1.2.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hiredis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hiredis}"
SRC_URI[x86_64_v2_hiredis.sha256sum] = "ba2c64f10fa106c5ad882ad2de9bc3c4fa925c0fd7f6cffe214efa3089c612ce"

URI_x86_64_v2_hiredis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hiredis-devel-1.2.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hiredis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hiredis-devel}"
SRC_URI[x86_64_v2_hiredis-devel.sha256sum] = "684894413593eef76e22d952ddd300f9fb69eb54d9b5763ebb1c4e721555bf0b"

URI_aarch64_hiredis = "${EPEL_MIRROR}/aarch64/Packages/h/hiredis-1.2.0-5.el10_0.aarch64.rpm;name=aarch64_hiredis;unpack=0"
SRC_URI:append = " ${URI_aarch64_hiredis}"
SRC_URI[aarch64_hiredis.sha256sum] = "8ed5d76daf9593411b6732894b37b711d48a8f848f418fabfedab797b3b0a256"

URI_aarch64_hiredis-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hiredis-devel-1.2.0-5.el10_0.aarch64.rpm;name=aarch64_hiredis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hiredis-devel}"
SRC_URI[aarch64_hiredis-devel.sha256sum] = "91ddb6ca9f047bbfa66e91401e2a1e3b5ef7e997b68e61851e15332e31ff03ad"

RDEPENDS:hiredis = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:hiredis-devel = " \
 hiredis \
 hiredis-devel \
 pkgconf-pkg-config \
 "
