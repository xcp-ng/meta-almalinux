# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-resctrlfs"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-resctrlfs+default-devel \
 rust-resctrlfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-resctrlfs-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09aba6f6cdbe92def6895fe13c7161e31112e077cd5d83c1bc195184709f8fd7"

URI_x86_64_v2_rust-resctrlfs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resctrlfs+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resctrlfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-resctrlfs+default-devel}"
SRC_URI[x86_64_v2_rust-resctrlfs+default-devel.sha256sum] = "f51796bcb7cd7c5491c711670dbc3bf60dc22fe8de2997d6756481d32f37032f"

URI_x86_64_v2_rust-resctrlfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resctrlfs-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resctrlfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-resctrlfs-devel}"
SRC_URI[x86_64_v2_rust-resctrlfs-devel.sha256sum] = "c34c48f7632f967ccfd75daf44a07e4f8c3ea0b147ba38e5908a4849d53cee6c"

URI_aarch64_rust-resctrlfs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-resctrlfs+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-resctrlfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-resctrlfs+default-devel}"
SRC_URI[aarch64_rust-resctrlfs+default-devel.sha256sum] = "96ae2fe379d9b9cda9a1f5d3bfe17d16b8dc33ceedc9d4370c41fdc11929d791"

URI_aarch64_rust-resctrlfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-resctrlfs-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-resctrlfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-resctrlfs-devel}"
SRC_URI[aarch64_rust-resctrlfs-devel.sha256sum] = "68a6dfda4ffd1716dea2d438b801b4b26c8ad314f0c3dfc7aca0c418bc91d16d"

RDEPENDS:rust-resctrlfs+default-devel = " \
 cargo \
 rust-resctrlfs-devel \
 "
RDEPENDS:rust-resctrlfs-devel = " \
 cargo \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+event-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+net-devel \
 rust-nix+poll-devel \
 rust-nix+ptrace-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-openat+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-thiserror+default-devel \
 "
