# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-p384"
PV = "0.13.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-p384+alloc-devel \
 rust-p384+arithmetic-devel \
 rust-p384+bits-devel \
 rust-p384+default-devel \
 rust-p384+digest-devel \
 rust-p384+ecdh-devel \
 rust-p384+ecdsa-core-devel \
 rust-p384+ecdsa-devel \
 rust-p384+expose-field-devel \
 rust-p384+hash2curve-devel \
 rust-p384+hex-literal-devel \
 rust-p384+jwk-devel \
 rust-p384+pem-devel \
 rust-p384+pkcs8-devel \
 rust-p384+serde-devel \
 rust-p384+serdect-devel \
 rust-p384+sha2-devel \
 rust-p384+sha384-devel \
 rust-p384+std-devel \
 rust-p384+test-vectors-devel \
 rust-p384+voprf-devel \
 rust-p384-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-p384-0.13.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "338ef8b8464b75e16f2d6642283903e3ed3ba57da1e55bbba9cf463bdbd17019"

URI_x86_64_v2_rust-p384+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+alloc-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+alloc-devel}"
SRC_URI[x86_64_v2_rust-p384+alloc-devel.sha256sum] = "036b36cde0eee1612126b05fc509c682f6e4f446679fb6a2ceddb3b383cfba41"

URI_x86_64_v2_rust-p384+arithmetic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+arithmetic-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+arithmetic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+arithmetic-devel}"
SRC_URI[x86_64_v2_rust-p384+arithmetic-devel.sha256sum] = "7a944c7bbd93dbdfc0871c2490f9e813e1dc4ee298b563b57fa2af9de23bdcb8"

URI_x86_64_v2_rust-p384+bits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+bits-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+bits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+bits-devel}"
SRC_URI[x86_64_v2_rust-p384+bits-devel.sha256sum] = "57bcdd81e6cd6b9d6151189c01e18bbc2e8660e8d4e05f574e774ef4d64c37a7"

URI_x86_64_v2_rust-p384+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+default-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+default-devel}"
SRC_URI[x86_64_v2_rust-p384+default-devel.sha256sum] = "10629dcb94482b90a770d044b61fcd6366e01e7d4a887699f420262aaddcd447"

URI_x86_64_v2_rust-p384+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+digest-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+digest-devel}"
SRC_URI[x86_64_v2_rust-p384+digest-devel.sha256sum] = "fe107dd8be086b74077cb8c7dad2093803f23398ca7f0bf3b12e9ec0a56d27f8"

URI_x86_64_v2_rust-p384+ecdh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+ecdh-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+ecdh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+ecdh-devel}"
SRC_URI[x86_64_v2_rust-p384+ecdh-devel.sha256sum] = "a76dd2b03e89e8d6468513c769bf60065d8b86f89edc700ff9d0bcf0f1d4dedc"

URI_x86_64_v2_rust-p384+ecdsa-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+ecdsa-core-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+ecdsa-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+ecdsa-core-devel}"
SRC_URI[x86_64_v2_rust-p384+ecdsa-core-devel.sha256sum] = "affcdfe54370b59d53a02e898c37c2f906bf19afb0ae1bd13e306bfd7115a000"

URI_x86_64_v2_rust-p384+ecdsa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+ecdsa-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+ecdsa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+ecdsa-devel}"
SRC_URI[x86_64_v2_rust-p384+ecdsa-devel.sha256sum] = "3bf38cae9d3938f77b74839d31dc1087808854610164cfd62e40de7baacfeca6"

URI_x86_64_v2_rust-p384+expose-field-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+expose-field-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+expose-field-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+expose-field-devel}"
SRC_URI[x86_64_v2_rust-p384+expose-field-devel.sha256sum] = "f500ee4fa9bfc0bb6a45717acd985032ebb448b4c51d23f59c25baf5824ba616"

URI_x86_64_v2_rust-p384+hash2curve-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+hash2curve-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+hash2curve-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+hash2curve-devel}"
SRC_URI[x86_64_v2_rust-p384+hash2curve-devel.sha256sum] = "c51c72be8ef56dc5738c98702365ea6434383dde3df0f5eb3d198e29cb5074e0"

URI_x86_64_v2_rust-p384+hex-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+hex-literal-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+hex-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+hex-literal-devel}"
SRC_URI[x86_64_v2_rust-p384+hex-literal-devel.sha256sum] = "fdfaee9ba598450fba7c83f838753d1a75caadc2ca17a2d524ad862d94690870"

URI_x86_64_v2_rust-p384+jwk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+jwk-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+jwk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+jwk-devel}"
SRC_URI[x86_64_v2_rust-p384+jwk-devel.sha256sum] = "aaf223ed3d023cfdf1ab36424a34ba60fb2659a85568fc96dc12a510884c4288"

URI_x86_64_v2_rust-p384+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+pem-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+pem-devel}"
SRC_URI[x86_64_v2_rust-p384+pem-devel.sha256sum] = "0250bdee8e4065c866fbe94eb619cd7b6284a7454dfaf290153c8faeb82da340"

URI_x86_64_v2_rust-p384+pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+pkcs8-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+pkcs8-devel}"
SRC_URI[x86_64_v2_rust-p384+pkcs8-devel.sha256sum] = "a627fa1e69d0b508fb5b71d621df7aaff60516256f69213e2227ab5a6cc86954"

URI_x86_64_v2_rust-p384+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+serde-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+serde-devel}"
SRC_URI[x86_64_v2_rust-p384+serde-devel.sha256sum] = "4098efc0d7cd646301f2601ec49e9edbf901a5cf1b645ca8db1595d554a83eda"

URI_x86_64_v2_rust-p384+serdect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+serdect-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+serdect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+serdect-devel}"
SRC_URI[x86_64_v2_rust-p384+serdect-devel.sha256sum] = "12e25eeecfbf42b2b60e0a42c242f22f9b55ef07666a9e1070fcc97d1374498e"

URI_x86_64_v2_rust-p384+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+sha2-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+sha2-devel}"
SRC_URI[x86_64_v2_rust-p384+sha2-devel.sha256sum] = "b183d36269aab416268af40155c19e03567a95ab664a9923826c3010c434c8d6"

URI_x86_64_v2_rust-p384+sha384-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+sha384-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+sha384-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+sha384-devel}"
SRC_URI[x86_64_v2_rust-p384+sha384-devel.sha256sum] = "e7939bcb9d1ab4888e6fb80309ec761de95aae10dce248a0dbd566792a27429b"

URI_x86_64_v2_rust-p384+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+std-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+std-devel}"
SRC_URI[x86_64_v2_rust-p384+std-devel.sha256sum] = "9d6b00a1cd1d0d7b126d0cafb3c710a4785c5001a33744f0ac91b75bd5af7bfe"

URI_x86_64_v2_rust-p384+test-vectors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+test-vectors-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+test-vectors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+test-vectors-devel}"
SRC_URI[x86_64_v2_rust-p384+test-vectors-devel.sha256sum] = "7aacffb1abd86082ee4c553daaa210a324163623201186ca60897cde5a369e6c"

URI_x86_64_v2_rust-p384+voprf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384+voprf-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384+voprf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384+voprf-devel}"
SRC_URI[x86_64_v2_rust-p384+voprf-devel.sha256sum] = "6e619320519ac590db0c185e5ab74b99d8a1a1cdf70aaab5e409f11689d883f1"

URI_x86_64_v2_rust-p384-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-p384-devel-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-p384-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-p384-devel}"
SRC_URI[x86_64_v2_rust-p384-devel.sha256sum] = "78b4f458d68517016846a48da4c008a27def32aaaa4b07d37f3410f4aad3c370"

URI_aarch64_rust-p384+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+alloc-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+alloc-devel}"
SRC_URI[aarch64_rust-p384+alloc-devel.sha256sum] = "bde536d4bfce44f0c01c0d69c9d1c016afa32eaaeeab693c26490a5e0a189557"

URI_aarch64_rust-p384+arithmetic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+arithmetic-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+arithmetic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+arithmetic-devel}"
SRC_URI[aarch64_rust-p384+arithmetic-devel.sha256sum] = "e70daddcafc36e3c668315705d24db926cfa2df097228af5330c3dffa5823fcf"

URI_aarch64_rust-p384+bits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+bits-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+bits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+bits-devel}"
SRC_URI[aarch64_rust-p384+bits-devel.sha256sum] = "7e3e701dbb7e55856af7efd6e923477575402a5090c92a2e1a95d293d853c537"

URI_aarch64_rust-p384+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+default-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+default-devel}"
SRC_URI[aarch64_rust-p384+default-devel.sha256sum] = "3d10b10ac88874c55b19d750298f5ccc96996f783767e32907a4fed49cc01d25"

URI_aarch64_rust-p384+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+digest-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+digest-devel}"
SRC_URI[aarch64_rust-p384+digest-devel.sha256sum] = "06e6bfdda7e237535d02cf536250ba185beed6585ad552e6eaaaf0cd3a551ba8"

URI_aarch64_rust-p384+ecdh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+ecdh-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+ecdh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+ecdh-devel}"
SRC_URI[aarch64_rust-p384+ecdh-devel.sha256sum] = "9f26c7198662e962c258fcdab03e4269665d5d4d7f7b8d50a3a200d0f2c15b6c"

URI_aarch64_rust-p384+ecdsa-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+ecdsa-core-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+ecdsa-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+ecdsa-core-devel}"
SRC_URI[aarch64_rust-p384+ecdsa-core-devel.sha256sum] = "ef3b10fe9c633a778c0d4c6bafe8535f2be9ad9c0b33dc53e8318f4172545bd9"

URI_aarch64_rust-p384+ecdsa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+ecdsa-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+ecdsa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+ecdsa-devel}"
SRC_URI[aarch64_rust-p384+ecdsa-devel.sha256sum] = "a95ded37b3c80e05dd9456852e81d6106f17a383bb4e90db7db25cae2f0436fa"

URI_aarch64_rust-p384+expose-field-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+expose-field-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+expose-field-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+expose-field-devel}"
SRC_URI[aarch64_rust-p384+expose-field-devel.sha256sum] = "491b172dfa63c82d76fb2e3068b227b934f83e6815dcdbdca6e66cd2777387db"

URI_aarch64_rust-p384+hash2curve-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+hash2curve-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+hash2curve-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+hash2curve-devel}"
SRC_URI[aarch64_rust-p384+hash2curve-devel.sha256sum] = "77ff31a996250530f26949c14cd6cb7f4c5a1f2a403aaebee211401de319f4fe"

URI_aarch64_rust-p384+hex-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+hex-literal-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+hex-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+hex-literal-devel}"
SRC_URI[aarch64_rust-p384+hex-literal-devel.sha256sum] = "d0aa52274c4b497a5fd669f3de1bbf32131e16bee91c139a3fad2f2835df50b2"

URI_aarch64_rust-p384+jwk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+jwk-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+jwk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+jwk-devel}"
SRC_URI[aarch64_rust-p384+jwk-devel.sha256sum] = "a363b44cb709c7d7bbdf7b9a98562a4407d25356e7d753becca8b1b28d8fe94c"

URI_aarch64_rust-p384+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+pem-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+pem-devel}"
SRC_URI[aarch64_rust-p384+pem-devel.sha256sum] = "f9c53d341bcdc172e42c6a756d8cf3cc05cb038b023d20a846edc491df7b585c"

URI_aarch64_rust-p384+pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+pkcs8-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+pkcs8-devel}"
SRC_URI[aarch64_rust-p384+pkcs8-devel.sha256sum] = "aba551cf5c21fd8dded488ea11295c344e6eca76e18457ac02d78f83a01acec7"

URI_aarch64_rust-p384+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+serde-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+serde-devel}"
SRC_URI[aarch64_rust-p384+serde-devel.sha256sum] = "17411e03e5d9cdd0dd47071bc2627410688d17a44af08ecabfb527805210c9d2"

URI_aarch64_rust-p384+serdect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+serdect-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+serdect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+serdect-devel}"
SRC_URI[aarch64_rust-p384+serdect-devel.sha256sum] = "2cba653f7bbd87f9b0e36bf68099e734b5ed31238046cc634856a0c039aa5cb9"

URI_aarch64_rust-p384+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+sha2-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+sha2-devel}"
SRC_URI[aarch64_rust-p384+sha2-devel.sha256sum] = "52d3fbd797676c4c2ebd48267a61d0c3a517e01db91aec58a7d0ab397bd1f5af"

URI_aarch64_rust-p384+sha384-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+sha384-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+sha384-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+sha384-devel}"
SRC_URI[aarch64_rust-p384+sha384-devel.sha256sum] = "dd7fcb76af6a47dfc2f5fdb2ca9a7cd4b2757d5533ef6eef23ac90894974bb43"

URI_aarch64_rust-p384+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+std-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+std-devel}"
SRC_URI[aarch64_rust-p384+std-devel.sha256sum] = "a5c970dbe00d9c514e6db6228115dbe92fde09a46444ea999caf6f7eb1a6aebf"

URI_aarch64_rust-p384+test-vectors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+test-vectors-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+test-vectors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+test-vectors-devel}"
SRC_URI[aarch64_rust-p384+test-vectors-devel.sha256sum] = "f5cfabefd115ea0f727bb7819039a3689ff0ccff78fa23d4f4c6e0c522486016"

URI_aarch64_rust-p384+voprf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384+voprf-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384+voprf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384+voprf-devel}"
SRC_URI[aarch64_rust-p384+voprf-devel.sha256sum] = "5415e97451e0ce84a1b9dc5cc678725fe4fd8c0ebc52946a6661dc16d8adeb83"

URI_aarch64_rust-p384-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-p384-devel-0.13.1-1.el10_0.noarch.rpm;name=aarch64_rust-p384-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-p384-devel}"
SRC_URI[aarch64_rust-p384-devel.sha256sum] = "7856b2e4cbca13c155fd070037bc05907d452db922dee4e4ab349eb607d9c904"

RDEPENDS:rust-p384+alloc-devel = " \
 cargo \
 rust-ecdsa+alloc-devel \
 rust-ecdsa+der-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+alloc-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+arithmetic-devel = " \
 cargo \
 rust-elliptic-curve+arithmetic-devel \
 rust-elliptic-curve+digest-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+bits-devel = " \
 cargo \
 rust-elliptic-curve+bits-devel \
 rust-p384+arithmetic-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+default-devel = " \
 cargo \
 rust-p384+arithmetic-devel \
 rust-p384+ecdh-devel \
 rust-p384+ecdsa-devel \
 rust-p384+pem-devel \
 rust-p384+std-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+digest-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+digest-devel \
 rust-ecdsa+hazmat-devel \
 rust-ecdsa-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+ecdh-devel = " \
 cargo \
 rust-elliptic-curve+ecdh-devel \
 rust-p384+arithmetic-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+ecdsa-core-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+ecdsa-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+signing-devel \
 rust-ecdsa+verifying-devel \
 rust-ecdsa-devel \
 rust-p384+arithmetic-devel \
 rust-p384+sha384-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+expose-field-devel = " \
 cargo \
 rust-p384+arithmetic-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+hash2curve-devel = " \
 cargo \
 rust-elliptic-curve+hash2curve-devel \
 rust-p384+arithmetic-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+hex-literal-devel = " \
 cargo \
 rust-hex-literal0.3+default-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+jwk-devel = " \
 cargo \
 rust-elliptic-curve+jwk-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+pem-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+pem-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+pem-devel \
 rust-p384+pkcs8-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+pkcs8-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+pkcs8-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+pkcs8-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+serde-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+serde-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+serde-devel \
 rust-p384+serdect-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+serdect-devel = " \
 cargo \
 rust-p384-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-p384+sha2-devel = " \
 cargo \
 rust-p384-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-p384+sha384-devel = " \
 cargo \
 rust-p384+digest-devel \
 rust-p384+sha2-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+std-devel = " \
 cargo \
 rust-ecdsa+der-devel \
 rust-ecdsa+std-devel \
 rust-ecdsa-devel \
 rust-elliptic-curve+std-devel \
 rust-p384+alloc-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+test-vectors-devel = " \
 cargo \
 rust-p384+hex-literal-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384+voprf-devel = " \
 cargo \
 rust-elliptic-curve+voprf-devel \
 rust-p384+sha2-devel \
 rust-p384-devel \
 "
RDEPENDS:rust-p384-devel = " \
 cargo \
 rust \
 rust-elliptic-curve+hazmat-devel \
 rust-elliptic-curve+sec1-devel \
 rust-elliptic-curve-devel \
 rust-primeorder+default-devel \
 "
