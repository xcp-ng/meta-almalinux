# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-cryptography"
PV = "45.0.4"
PR = "5.el10"
PACKAGES = " \
 python3.14-cryptography \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-cryptography-45.0.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ff5d523ee6bfb4579903bc32757a6e744698f89f52fc7fdb9cdfe8e8a7664ed3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-cryptography-45.0.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-cryptography;unpack=0"
SRC_URI[x86_64_v2_python3.14-cryptography.sha256sum] = "f0c5f181fa49125028121b764464eb1f0e633d2ecaca3c5eca5fc683f00d5bea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-cryptography-45.0.4-5.el10.aarch64.rpm;name=aarch64_python3.14-cryptography;unpack=0"
SRC_URI[aarch64_python3.14-cryptography.sha256sum] = "1293315cd6c632ff65fa6118b76e5d49375dc27685721c31be3c14cf9b7045bc"

RDEPENDS:python3.14-cryptography = " \
 glibc \
 libgcc \
 openssl-libs \
 python3.14 \
 python3.14-cffi \
 "
