# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-self_cell"
PV = "1.3.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-self_cell+default-devel \
 rust-self_cell+old_rust-devel \
 rust-self_cell+rustversion-devel \
 rust-self_cell-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-self_cell-1.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6b46c666af3b358e3649abfab4adccf0b6c602eadaeef391fba9a6c07b93e90d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell+default-devel-1.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-self_cell+default-devel.sha256sum] = "4e01e8fe31fe2dd8d25af7be02891cb89bb49dd54e13f6649a35f8b09cf2ab55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell+old_rust-devel-1.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell+old_rust-devel;unpack=0"
SRC_URI[x86_64_v2_rust-self_cell+old_rust-devel.sha256sum] = "e8aca8bc959257a2253fb248f970e2c3df45a284ac40f31868a0601d6f842dbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell+rustversion-devel-1.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell+rustversion-devel;unpack=0"
SRC_URI[x86_64_v2_rust-self_cell+rustversion-devel.sha256sum] = "8954f13fb3bc8a9bb59a4a7d907135c52c2c0c0176f690af6c554eb776913a84"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell-devel-1.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell-devel;unpack=0"
SRC_URI[x86_64_v2_rust-self_cell-devel.sha256sum] = "56c49229707960a2aa505d2796c51e781b31e6af5da28fb1e662211a935ec376"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell+default-devel-1.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-self_cell+default-devel;unpack=0"
SRC_URI[aarch64_rust-self_cell+default-devel.sha256sum] = "a5cf9a0b07eda608e4e8937b252c819d4f8ec561fcf1e1b01be63699d15697de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell+old_rust-devel-1.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-self_cell+old_rust-devel;unpack=0"
SRC_URI[aarch64_rust-self_cell+old_rust-devel.sha256sum] = "8e34c5e31d2c713f2f1dc9c87813a2f465bf47559b7120c82d40b4c29c052ba5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell+rustversion-devel-1.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-self_cell+rustversion-devel;unpack=0"
SRC_URI[aarch64_rust-self_cell+rustversion-devel.sha256sum] = "b917be26b8f985207adf3b2326f0dded2e9ef81b591f9024abc8ca68d955c881"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell-devel-1.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-self_cell-devel;unpack=0"
SRC_URI[aarch64_rust-self_cell-devel.sha256sum] = "330300daaaa4875c228e1d96e448a508f15916afc6860cf3755b5cb7498ea9d3"

RDEPENDS:rust-self_cell+default-devel = " \
 cargo \
 rust-self_cell-devel \
 "
RDEPENDS:rust-self_cell+old_rust-devel = " \
 cargo \
 rust-self_cell+rustversion-devel \
 rust-self_cell-devel \
 "
RDEPENDS:rust-self_cell+rustversion-devel = " \
 cargo \
 rust-rustversion+default-devel \
 rust-self_cell-devel \
 "
RDEPENDS:rust-self_cell-devel = " \
 cargo \
 "
