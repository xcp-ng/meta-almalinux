# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dosfstools"
PV = "4.2"
PR = "12.el10"
PACKAGES = " \
 dosfstools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dosfstools-4.2-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94fce5a3eea9d7302198f7e81d9c332e532f4ce51a7d82877ec09a682f63bd10"

URI_x86_64_v2_dosfstools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dosfstools-4.2-12.el10.x86_64_v2.rpm;name=x86_64_v2_dosfstools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dosfstools}"
SRC_URI[x86_64_v2_dosfstools.sha256sum] = "17a84d8377810b755abd57014d27e31430d0ac95737d97bbd99f70deb3969a38"

URI_aarch64_dosfstools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dosfstools-4.2-12.el10.aarch64.rpm;name=aarch64_dosfstools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dosfstools}"
SRC_URI[aarch64_dosfstools.sha256sum] = "670183e5ea2c3c83b4353a700a6f13a4fe1a7ea9ca3f39429a2f29931db2f6d2"

RDEPENDS:dosfstools = " \
 glibc \
 "
