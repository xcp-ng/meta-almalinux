# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Requirements-Dynamic"
PV = "0.003"
PR = "1.el10_3"
PACKAGES = " \
 perl-CPAN-Requirements-Dynamic \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-CPAN-Requirements-Dynamic-0.003-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8f4ad8cbfb9414256a877232f04ba033d4febb77f00425ac0b4907859c77540c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-Requirements-Dynamic-0.003-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-Requirements-Dynamic;unpack=0"
SRC_URI[x86_64_v2_perl-CPAN-Requirements-Dynamic.sha256sum] = "dff2a9de1541bfdb37e01c5e4a69d9287f5a8338aa9e2fce65519126b5113de2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-Requirements-Dynamic-0.003-1.el10_3.noarch.rpm;name=aarch64_perl-CPAN-Requirements-Dynamic;unpack=0"
SRC_URI[aarch64_perl-CPAN-Requirements-Dynamic.sha256sum] = "d6f786386dcfb358c92add0dc955830eb9658dc8bbca7ceb133dc37cdcf2fcae"

RDEPENDS:perl-CPAN-Requirements-Dynamic = " \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-Carp \
 perl-ExtUtils-Config \
 perl-ExtUtils-HasCompiler \
 perl-IPC-Cmd \
 perl-Perl-OSType \
 perl-libs \
 "
