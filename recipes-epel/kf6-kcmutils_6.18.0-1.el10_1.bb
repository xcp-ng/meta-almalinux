# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcmutils"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kcmutils \
 kf6-kcmutils-devel \
 kf6-kcmutils-doc \
 kf6-kcmutils-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcmutils-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa395d40444d49f79f8933b1ec8a859d6ce95b0ec8e1a525c6fa0ffe5c96c7f4"

URI_x86_64_v2_kf6-kcmutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcmutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils}"
SRC_URI[x86_64_v2_kf6-kcmutils.sha256sum] = "adec2a62420057126f0105bd29388f157e4c8e4879e64bd7a44c8c845b83443d"

URI_x86_64_v2_kf6-kcmutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcmutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-devel}"
SRC_URI[x86_64_v2_kf6-kcmutils-devel.sha256sum] = "516bdb137a79fdfae5368c9bccc3918376f8aa3f356d1a133a6c3fd8ef33a809"

URI_x86_64_v2_kf6-kcmutils-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcmutils-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-doc}"
SRC_URI[x86_64_v2_kf6-kcmutils-doc.sha256sum] = "f601d05eeb6c2e2a897a8b06fad7a71d98e7a2ba1e611c512b4f12dbe536b194"

URI_x86_64_v2_kf6-kcmutils-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcmutils-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-html}"
SRC_URI[x86_64_v2_kf6-kcmutils-html.sha256sum] = "5a49648dda52fb314931ef30e48ba57bc0fe977ebe49321aa2ab089a34ab6062"

URI_aarch64_kf6-kcmutils = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcmutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils}"
SRC_URI[aarch64_kf6-kcmutils.sha256sum] = "84178a51c3312c813b496ef7181c35b65a6e2b104c0e9e8fbd5bf3f11c0d5d8b"

URI_aarch64_kf6-kcmutils-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcmutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-devel}"
SRC_URI[aarch64_kf6-kcmutils-devel.sha256sum] = "13a60881f48a232493692c658bad7ea15f9ceb3f16d9a9229331eda09d1cf6f3"

URI_aarch64_kf6-kcmutils-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcmutils-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-doc}"
SRC_URI[aarch64_kf6-kcmutils-doc.sha256sum] = "0a0f03a92e181f31b6d61297656ae6c91de007b9d3c8487c637d47d9d492557f"

URI_aarch64_kf6-kcmutils-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcmutils-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-html}"
SRC_URI[aarch64_kf6-kcmutils-html.sha256sum] = "5768c8e3e836208dbbc5897380f4ecdbc3b40e22f0a7c953e34d388011fdcf32"

RDEPENDS:kf6-kcmutils = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcmutils-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcmutils \
 kf6-kconfigwidgets-devel \
 kf6-kservice-devel \
 qt6-qtbase \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kcmutils-doc = " \
 "
RDEPENDS:kf6-kcmutils-html = " \
 "
