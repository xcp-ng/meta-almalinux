# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-base-compat"
PV = "0.13.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-base-compat \
 ghc-base-compat-devel \
 ghc-base-compat-doc \
 ghc-base-compat-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-base-compat-0.13.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e009b9ce2c94635c79067895c68d2ee45c18fade1831078b7f9bdadadc95673e"

URI_x86_64_v2_ghc-base-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-compat-0.13.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-compat}"
SRC_URI[x86_64_v2_ghc-base-compat.sha256sum] = "f8c8864f09e10af2d3a3e9a2c7c27987f14c6aad0efacda554f1bb20a96b5ef5"

URI_x86_64_v2_ghc-base-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-compat-devel-0.13.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-compat-devel}"
SRC_URI[x86_64_v2_ghc-base-compat-devel.sha256sum] = "33120ef36fdde66a860393515384309553c4e6fc236ceeec6db61aff3c10f1b2"

URI_x86_64_v2_ghc-base-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-compat-doc-0.13.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-base-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-compat-doc}"
SRC_URI[x86_64_v2_ghc-base-compat-doc.sha256sum] = "37153c12b8b7e543ad2497d419aebf00a145e7a48d9781822197e9a9d178abd5"

URI_x86_64_v2_ghc-base-compat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base-compat-prof-0.13.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base-compat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base-compat-prof}"
SRC_URI[x86_64_v2_ghc-base-compat-prof.sha256sum] = "79e42710ec88e52cef838e88345d7e40527688da922ac4f61973dd0c423be649"

URI_aarch64_ghc-base-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-compat-0.13.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-base-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-compat}"
SRC_URI[aarch64_ghc-base-compat.sha256sum] = "c219986a252660269fd846a3dd89b31c0b708c425bf18fccd134058aba99f896"

URI_aarch64_ghc-base-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-compat-devel-0.13.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-base-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-compat-devel}"
SRC_URI[aarch64_ghc-base-compat-devel.sha256sum] = "57d8711090ce9f4b3decde18762025de0dc6d199ef4ec711dce8d114aa6b102c"

URI_aarch64_ghc-base-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-compat-doc-0.13.1-1.el10_0.noarch.rpm;name=aarch64_ghc-base-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-compat-doc}"
SRC_URI[aarch64_ghc-base-compat-doc.sha256sum] = "ce1ed25a7abba350f4a333c4344920784001b85afc6b5a6d43d43e11fb2e194a"

URI_aarch64_ghc-base-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base-compat-prof-0.13.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-base-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base-compat-prof}"
SRC_URI[aarch64_ghc-base-compat-prof.sha256sum] = "c17a3c174af54ec9f395613e22a00e657b7ce729636b399a5b26542845ed205e"

RDEPENDS:ghc-base-compat = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-base-compat-devel = " \
 ghc-base-compat \
 ghc-base-devel \
 ghc-compiler \
 ghc-unix-devel \
 "
RDEPENDS:ghc-base-compat-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-base-compat-prof = " \
 ghc-base-compat-devel \
 ghc-base-prof \
 ghc-unix-prof \
 "
