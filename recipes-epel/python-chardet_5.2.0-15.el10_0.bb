# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-chardet"
PV = "5.2.0"
PR = "15.el10_0"
PACKAGES = " \
 python3-chardet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-chardet-5.2.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8657955a91f188bfd19c4afd4b719546ee2e6726bf0671feeb82420408d62bb"

URI_x86_64_v2_python3-chardet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-chardet-5.2.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-chardet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-chardet}"
SRC_URI[x86_64_v2_python3-chardet.sha256sum] = "06ee54f44d087ab6631a2f32b4fbc859c3695e43b15b4350e7fda4637569a675"

URI_aarch64_python3-chardet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-chardet-5.2.0-15.el10_0.noarch.rpm;name=aarch64_python3-chardet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-chardet}"
SRC_URI[aarch64_python3-chardet.sha256sum] = "0f521167dbc050f2a2f33b1def4bf40f31cc3360c16fd3c5927a1f15256c05c6"

RDEPENDS:python3-chardet = " \
 python3 \
 "
