# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "root"
PV = "6.40.02"
PR = "1.el10_3"
PACKAGES = " \
 python3-root \
 python3-root+distrdf \
 python3-root+jupyroot \
 root \
 root-cli \
 root-cling \
 root-core \
 root-fftw \
 root-foam \
 root-font-files \
 root-fumili \
 root-gdml \
 root-genetic \
 root-genvector \
 root-geom \
 root-geom-builder \
 root-geom-checker \
 root-geom-painter \
 root-geom-webviewer \
 root-graf \
 root-graf-asimage \
 root-graf-fitsio \
 root-graf-gpad \
 root-graf-gpadv7 \
 root-graf-gviz \
 root-graf-postscript \
 root-graf-primitives \
 root-graf-x11 \
 root-graf3d \
 root-graf3d-csg \
 root-graf3d-eve \
 root-graf3d-eve7 \
 root-graf3d-gl \
 root-graf3d-glad \
 root-graf3d-gviz3d \
 root-graf3d-x3d \
 root-gui \
 root-gui-browsable \
 root-gui-browsable-v7 \
 root-gui-browserv7 \
 root-gui-browserv7-v7 \
 root-gui-builder \
 root-gui-canvaspainter \
 root-gui-fitpanel \
 root-gui-fitpanelv7 \
 root-gui-ged \
 root-gui-html \
 root-gui-qt6webdisplay \
 root-gui-recorder \
 root-gui-treemap \
 root-gui-webdisplay \
 root-gui-webgui6 \
 root-hbook \
 root-hist \
 root-hist-factory \
 root-hist-painter \
 root-histv7 \
 root-histv7util \
 root-icons \
 root-io \
 root-io-dcache \
 root-io-sql \
 root-io-xml \
 root-io-xmlparser \
 root-mathcore \
 root-mathmore \
 root-matrix \
 root-minuit \
 root-minuit2 \
 root-mlp \
 root-montecarlo-eg \
 root-montecarlo-pythia8 \
 root-multiproc \
 root-net \
 root-net-auth \
 root-net-curl \
 root-net-davix \
 root-net-http \
 root-net-httpsniff \
 root-net-rpdutils \
 root-netx \
 root-physics \
 root-quadp \
 root-r \
 root-r-tools \
 root-roofit \
 root-roofit-batchcompute \
 root-roofit-codegen \
 root-roofit-core \
 root-roofit-hs3 \
 root-roofit-jsoninterface \
 root-roofit-more \
 root-roofit-multiprocess \
 root-roofit-zmq \
 root-roostats \
 root-smatrix \
 root-spectrum \
 root-spectrum-painter \
 root-splot \
 root-sql-sqlite \
 root-testsupport \
 root-tmva \
 root-tmva-gui \
 root-tmva-python \
 root-tmva-r \
 root-tmva-sofie \
 root-tmva-sofie-parser \
 root-tmva-sofie-parser-python \
 root-tmva-utils \
 root-tpython \
 root-tree \
 root-tree-dataframe \
 root-tree-ml \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 root-tree-ntuple-utils \
 root-tree-player \
 root-tree-viewer \
 root-tree-webviewer \
 root-tutorial \
 root-unfold \
 root-unuran \
 root-vecops \
 root-xroofit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/root-6.40.02-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a52578b3a753baae6c99a9e7d66bae3967efcbb9c5e478b95fbf1077fbbb92a4"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - root-netx: libXrdCl.so.6()(64bit)
# - root-netx: libXrdUtils.so.6()(64bit)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - root-graf-gviz: libcgraph.so.6()(64bit)
# - root-graf-gviz: libgvc.so.6()(64bit)

URI_x86_64_v2_python3-root = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-root}"
SRC_URI[x86_64_v2_python3-root.sha256sum] = "9a5885485a5386ad0972dbafd446ecbb3447f24d174d181aa72b0d021f5e3777"

URI_x86_64_v2_python3-root+distrdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root+distrdf-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root+distrdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-root+distrdf}"
SRC_URI[x86_64_v2_python3-root+distrdf.sha256sum] = "f0d02b0d001be9cd4e4100c678fd6a276cdb410751ed5f7803d14ca69a26a329"

URI_x86_64_v2_python3-root+jupyroot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root+jupyroot-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root+jupyroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-root+jupyroot}"
SRC_URI[x86_64_v2_python3-root+jupyroot.sha256sum] = "1298dcd494e1e36f3155dcd304b122b4a84ad8b204a524156649e5907cea21ae"

URI_x86_64_v2_root = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root}"
SRC_URI[x86_64_v2_root.sha256sum] = "5bab229471c50cf3573ad10d694d7a2b9f5464f84c54f801b289ace6a2390494"

URI_x86_64_v2_root-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-cli-6.40.02-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_root-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-cli}"
SRC_URI[x86_64_v2_root-cli.sha256sum] = "a57bbc3ab5a6512b45c5f0f8e7ed1d1b77587aba9b2e832fc021c5eebdcbd6d8"

URI_x86_64_v2_root-cling = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-cling-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-cling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-cling}"
SRC_URI[x86_64_v2_root-cling.sha256sum] = "ebf016fe2c86f4271a1f47ba1cff6c33c476803ac432a374ca680c24a0f3cfad"

URI_x86_64_v2_root-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-core-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-core}"
SRC_URI[x86_64_v2_root-core.sha256sum] = "d5991fb8f1b2d03b5c1072bc782b827a5520c8d24cdd9bbad4a9a44b9634e7d3"

URI_x86_64_v2_root-fftw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-fftw-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-fftw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-fftw}"
SRC_URI[x86_64_v2_root-fftw.sha256sum] = "84454bb6f0434b6ca63d0ff42c3fc05c0db80f9e05d0b4ac0c4c2415b03f5c0a"

URI_x86_64_v2_root-foam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-foam-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-foam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-foam}"
SRC_URI[x86_64_v2_root-foam.sha256sum] = "93725182e5dcdfb947039d3a6c566184d241ee316596f707e485dda7754febdf"

URI_x86_64_v2_root-font-files = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-font-files-6.40.02-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_root-font-files;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-font-files}"
SRC_URI[x86_64_v2_root-font-files.sha256sum] = "131ead6ee371b52565f03127450eb8f0ed3c498d5c95e1e435753ff1ac6e1b41"

URI_x86_64_v2_root-fumili = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-fumili-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-fumili;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-fumili}"
SRC_URI[x86_64_v2_root-fumili.sha256sum] = "76d874f691e6079c59d5f9d67ae538e5140ffe0e96c5f0bfb051ab107ef6351a"

URI_x86_64_v2_root-gdml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gdml-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gdml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gdml}"
SRC_URI[x86_64_v2_root-gdml.sha256sum] = "eb84ba88bac9ef6bc30c7cc068226e7d3d08ce4674d3776dd516501b8e1fcded"

URI_x86_64_v2_root-genetic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-genetic-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-genetic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-genetic}"
SRC_URI[x86_64_v2_root-genetic.sha256sum] = "275ec05209d81b922dfc5ae904fcd811a04e12652a4568060f86ac7c032ef8aa"

URI_x86_64_v2_root-genvector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-genvector-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-genvector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-genvector}"
SRC_URI[x86_64_v2_root-genvector.sha256sum] = "df13c6f418fb4a444f32e85ce25306fb94c8dfa202614519c992656e7971ae4f"

URI_x86_64_v2_root-geom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom}"
SRC_URI[x86_64_v2_root-geom.sha256sum] = "1c5c7b4f654f3ea597955580b90a63c394af4a68a64ea21e1106b434d77e4245"

URI_x86_64_v2_root-geom-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-builder-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-builder}"
SRC_URI[x86_64_v2_root-geom-builder.sha256sum] = "73d5de4ed49dccfe032fade5111bee5dfc548daa415040c8f6ca1b52127f1768"

URI_x86_64_v2_root-geom-checker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-checker-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-checker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-checker}"
SRC_URI[x86_64_v2_root-geom-checker.sha256sum] = "a8fed38d8bb7f92ec906582b2cdb10ec96fe641cca47bfaaf30be8e4b601ae16"

URI_x86_64_v2_root-geom-painter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-painter-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-painter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-painter}"
SRC_URI[x86_64_v2_root-geom-painter.sha256sum] = "c72a2179342d3e71c49f7c5939ac73b477be0458d997d90ed76cd47d73de5f76"

URI_x86_64_v2_root-geom-webviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-webviewer-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-webviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-webviewer}"
SRC_URI[x86_64_v2_root-geom-webviewer.sha256sum] = "2cb7b79d73e94770d4d0717076a401d68df97864aaaa397aa3c35f886ee34b3a"

URI_x86_64_v2_root-graf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf}"
SRC_URI[x86_64_v2_root-graf.sha256sum] = "2bd4f17937bea2142aaa449db8ebed8f3c76adf9eb77725e8330357ee0a0b18f"

URI_x86_64_v2_root-graf-asimage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-asimage-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-asimage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-asimage}"
SRC_URI[x86_64_v2_root-graf-asimage.sha256sum] = "dad3ef36cdb664e6b71f82de923de81dee975dfbefc86f5ec2afc790414794a5"

URI_x86_64_v2_root-graf-fitsio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-fitsio-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-fitsio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-fitsio}"
SRC_URI[x86_64_v2_root-graf-fitsio.sha256sum] = "17fee28d49839a1470bc8bf70838e1b74c60d1a558a2836accbedb3aa5bad0c8"

URI_x86_64_v2_root-graf-gpad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gpad-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gpad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-gpad}"
SRC_URI[x86_64_v2_root-graf-gpad.sha256sum] = "eeb732ee99b944caa812485439dfc531670b63cafd90487d90ea02971fa8e640"

URI_x86_64_v2_root-graf-gpadv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gpadv7-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gpadv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-gpadv7}"
SRC_URI[x86_64_v2_root-graf-gpadv7.sha256sum] = "cd09e362757e40337894710aeaa85ddc51fbd061c62699aa2749764d917a85b0"

URI_x86_64_v2_root-graf-gviz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gviz-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gviz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-gviz}"
SRC_URI[x86_64_v2_root-graf-gviz.sha256sum] = "2eedfe4c005906b33fe3dd24224c3e213a474e7fa86f32a762ac7783686af7b1"

URI_x86_64_v2_root-graf-postscript = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-postscript-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-postscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-postscript}"
SRC_URI[x86_64_v2_root-graf-postscript.sha256sum] = "dd907e8f3f850f7142c8050df20fa97ed50f8a282676e5fa5d7fdb0cffcfcc58"

URI_x86_64_v2_root-graf-primitives = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-primitives-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-primitives;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-primitives}"
SRC_URI[x86_64_v2_root-graf-primitives.sha256sum] = "d31bb781e6e35eac920b7ef173dfc410bc589829b42002409a0d15307f6b8ac0"

URI_x86_64_v2_root-graf-x11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-x11-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-x11}"
SRC_URI[x86_64_v2_root-graf-x11.sha256sum] = "fadc1806e0aee6a6887fc956517978d164f0ac163431073b4cfd92ddd47b4d27"

URI_x86_64_v2_root-graf3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d}"
SRC_URI[x86_64_v2_root-graf3d.sha256sum] = "d9020bfab1a44ed96172a4dc3d8834b1bb775faf4aa74be980258f466872ac71"

URI_x86_64_v2_root-graf3d-csg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-csg-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-csg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-csg}"
SRC_URI[x86_64_v2_root-graf3d-csg.sha256sum] = "c8eb64497e251077328b0633a92b71d21c04682b9880488f1d0601af846779f7"

URI_x86_64_v2_root-graf3d-eve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-eve-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-eve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-eve}"
SRC_URI[x86_64_v2_root-graf3d-eve.sha256sum] = "06d654c742dd49c00d9565b7c4a1d9d153518a65df0fd1b05a7b9ee9253261f3"

URI_x86_64_v2_root-graf3d-eve7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-eve7-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-eve7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-eve7}"
SRC_URI[x86_64_v2_root-graf3d-eve7.sha256sum] = "48e1cf65e4811ad9cd4c62e560e38143809ec57246f62daa551c537379e1ce82"

URI_x86_64_v2_root-graf3d-gl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-gl-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-gl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-gl}"
SRC_URI[x86_64_v2_root-graf3d-gl.sha256sum] = "dfa8591c8d62724d1e81594b82f7d35c9188635be7d312b0ea2c231d384e7c2e"

URI_x86_64_v2_root-graf3d-glad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-glad-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-glad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-glad}"
SRC_URI[x86_64_v2_root-graf3d-glad.sha256sum] = "73ae25593a98eace4aba4be8a71681a445aaf6d15614d51ecbb0be07282cb6dc"

URI_x86_64_v2_root-graf3d-gviz3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-gviz3d-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-gviz3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-gviz3d}"
SRC_URI[x86_64_v2_root-graf3d-gviz3d.sha256sum] = "97dbc5b8406b462187478fc8044a78aa15e609f1db6263babf23abc9c5511aed"

URI_x86_64_v2_root-graf3d-x3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-x3d-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-x3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-x3d}"
SRC_URI[x86_64_v2_root-graf3d-x3d.sha256sum] = "f298084a5d297b2863c706f0efaba4da8fa7f08e92b291afd059e138604a3fc5"

URI_x86_64_v2_root-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui}"
SRC_URI[x86_64_v2_root-gui.sha256sum] = "6f3bf30d5257d0536698c125e13f1998e9bbc9906a042112fc791aefd96765fd"

URI_x86_64_v2_root-gui-browsable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browsable-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browsable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browsable}"
SRC_URI[x86_64_v2_root-gui-browsable.sha256sum] = "df0cb0f4f102eaec9e5818d5c632a75976d2cbf8d1111a51cff1fb548339214f"

URI_x86_64_v2_root-gui-browsable-v7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browsable-v7-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browsable-v7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browsable-v7}"
SRC_URI[x86_64_v2_root-gui-browsable-v7.sha256sum] = "9286cdb12959798d239391ea40e07d37ff31eec2f11ee5d130d37b6ca67196e6"

URI_x86_64_v2_root-gui-browserv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browserv7-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browserv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browserv7}"
SRC_URI[x86_64_v2_root-gui-browserv7.sha256sum] = "2d573c462bccd7f42d8001fd462cc6f15150c718a2cd8298e1a69cd0d81bc4e5"

URI_x86_64_v2_root-gui-browserv7-v7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browserv7-v7-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browserv7-v7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browserv7-v7}"
SRC_URI[x86_64_v2_root-gui-browserv7-v7.sha256sum] = "a5e1f7950dc0fa2f670aee756c5a61715900623afa253f4a1a0e624f6b6575ff"

URI_x86_64_v2_root-gui-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-builder-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-builder}"
SRC_URI[x86_64_v2_root-gui-builder.sha256sum] = "93a1b2941a1caa14263648e220b1d253a0d30971f3650e3bff8b750bf4a804f8"

URI_x86_64_v2_root-gui-canvaspainter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-canvaspainter-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-canvaspainter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-canvaspainter}"
SRC_URI[x86_64_v2_root-gui-canvaspainter.sha256sum] = "4673dda0942fd57098de1dc5fbda4ed2f3fa6468797508cbaadfc03ffcf306b5"

URI_x86_64_v2_root-gui-fitpanel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-fitpanel-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-fitpanel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-fitpanel}"
SRC_URI[x86_64_v2_root-gui-fitpanel.sha256sum] = "f4aa906eacabd231ffedd1deb8bfe92f762616c4c51b9d0fd34616d0ceb3b6a4"

URI_x86_64_v2_root-gui-fitpanelv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-fitpanelv7-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-fitpanelv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-fitpanelv7}"
SRC_URI[x86_64_v2_root-gui-fitpanelv7.sha256sum] = "b2c240c1a47f52374aafc0ea1f8f14339e53e355ebbddacaf165f9f938aae9f3"

URI_x86_64_v2_root-gui-ged = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-ged-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-ged;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-ged}"
SRC_URI[x86_64_v2_root-gui-ged.sha256sum] = "7abee5f54bd213c19d05df67b64443b420bc3d6586dab501271efa4519033276"

URI_x86_64_v2_root-gui-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-html-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-html}"
SRC_URI[x86_64_v2_root-gui-html.sha256sum] = "fe708518a7790ec15693f2102d8ab857d5180c935196a6e8215563a62408d837"

URI_x86_64_v2_root-gui-qt6webdisplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-qt6webdisplay-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-qt6webdisplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-qt6webdisplay}"
SRC_URI[x86_64_v2_root-gui-qt6webdisplay.sha256sum] = "672ea23a9d98a4807413f678e37277b124a17acf2c58731781ab6d93f2152a37"

URI_x86_64_v2_root-gui-recorder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-recorder-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-recorder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-recorder}"
SRC_URI[x86_64_v2_root-gui-recorder.sha256sum] = "ff86bbbdf9b23d2cc0dc397c1cd994f31e3cc814ebfb7b2c51063c8aaa3fc4c9"

URI_x86_64_v2_root-gui-treemap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-treemap-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-treemap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-treemap}"
SRC_URI[x86_64_v2_root-gui-treemap.sha256sum] = "ded62f2b7dcc61a21c8132651b258f71fc592e0b25b0bd7f068a154dccb315ac"

URI_x86_64_v2_root-gui-webdisplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-webdisplay-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-webdisplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-webdisplay}"
SRC_URI[x86_64_v2_root-gui-webdisplay.sha256sum] = "30c9e2dc4fcb9a86a612c09f5c3a09bf4c93ba962eb6e067a55f7cca94d5babf"

URI_x86_64_v2_root-gui-webgui6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-webgui6-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-webgui6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-webgui6}"
SRC_URI[x86_64_v2_root-gui-webgui6.sha256sum] = "7bf1b8081e6ddb17a807ebd7090975aa606b554abce95469d53f6953f71fd2fc"

URI_x86_64_v2_root-hbook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hbook-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hbook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hbook}"
SRC_URI[x86_64_v2_root-hbook.sha256sum] = "c77ca000263c5b0a0b1ce5fa6479c90ec01573ebcde2db899f3eb348ff8a1252"

URI_x86_64_v2_root-hist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hist}"
SRC_URI[x86_64_v2_root-hist.sha256sum] = "0070977a0ea727e7ae61e567031bc834d5f05fc353a5697d92573f63b7c80f9b"

URI_x86_64_v2_root-hist-factory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-factory-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist-factory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hist-factory}"
SRC_URI[x86_64_v2_root-hist-factory.sha256sum] = "a2c488dfc3ef648fe674a310236351e9293cd47083929a7eda105e1f1a79e646"

URI_x86_64_v2_root-hist-painter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-painter-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist-painter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hist-painter}"
SRC_URI[x86_64_v2_root-hist-painter.sha256sum] = "8a290bfed3241148158b02a277045c30fc7e11c39983b98ccd7ab38d1362d28d"

URI_x86_64_v2_root-histv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-histv7-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-histv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-histv7}"
SRC_URI[x86_64_v2_root-histv7.sha256sum] = "b18033509d5c7ee46bdcd7c6aadafce7578986367d7d21d5eea2a1f3aebda2fd"

URI_x86_64_v2_root-histv7util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-histv7util-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-histv7util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-histv7util}"
SRC_URI[x86_64_v2_root-histv7util.sha256sum] = "cc563afbdf7a75a2e6a461ce4ef40a80581fef230c5d7a9a0eee409ad35240c1"

URI_x86_64_v2_root-icons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-icons-6.40.02-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_root-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-icons}"
SRC_URI[x86_64_v2_root-icons.sha256sum] = "3768dd4d8d1e3c69f4e9064b9cdf5d3028f689fa98745fc6c5edc9916f0be286"

URI_x86_64_v2_root-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io}"
SRC_URI[x86_64_v2_root-io.sha256sum] = "30ef235926377134e1e6334423fc86eb03d31daa51dd4510bfa4bee554104660"

URI_x86_64_v2_root-io-dcache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-dcache-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-dcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-dcache}"
SRC_URI[x86_64_v2_root-io-dcache.sha256sum] = "412b4a35c3aeb5fee163f1903ca7cb8ad51ae7def46f8a5bc3e73022fecfbe9b"

URI_x86_64_v2_root-io-sql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-sql-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-sql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-sql}"
SRC_URI[x86_64_v2_root-io-sql.sha256sum] = "d859f21127d509a61549ec50cff684ea373af7b3c0e968e15e12b7f013f2ae8d"

URI_x86_64_v2_root-io-xml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-xml-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-xml}"
SRC_URI[x86_64_v2_root-io-xml.sha256sum] = "61c11a1683422152999c3fa0ae9657fb851d0e786e8203bc057f12717e3ed391"

URI_x86_64_v2_root-io-xmlparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-xmlparser-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-xmlparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-xmlparser}"
SRC_URI[x86_64_v2_root-io-xmlparser.sha256sum] = "53392d597bdfaee331e59b49c8980bb1708f898bbc0056f5210f3692f16b93ac"

URI_x86_64_v2_root-mathcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mathcore-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mathcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-mathcore}"
SRC_URI[x86_64_v2_root-mathcore.sha256sum] = "5f7ea8b31eb14485def567ba8be53f6c1996a9ee3046211560ec7a6e4d249127"

URI_x86_64_v2_root-mathmore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mathmore-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mathmore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-mathmore}"
SRC_URI[x86_64_v2_root-mathmore.sha256sum] = "b699f7b8ee124c29e62a9bca0560d3e43b9aceeca2fce44175216549e40e5dfa"

URI_x86_64_v2_root-matrix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-matrix-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-matrix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-matrix}"
SRC_URI[x86_64_v2_root-matrix.sha256sum] = "2e7ecfef1e02159a0a5b70e5ce281608d6097ac4c4946e328e6816e4eca6f031"

URI_x86_64_v2_root-minuit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-minuit-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-minuit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-minuit}"
SRC_URI[x86_64_v2_root-minuit.sha256sum] = "65661b5abc7d0975de12b1193f7e11a415f0c4d3cf528965c1683553f977c6b6"

URI_x86_64_v2_root-minuit2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-minuit2-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-minuit2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-minuit2}"
SRC_URI[x86_64_v2_root-minuit2.sha256sum] = "94e7da755863dd22c6265340628bc06ce57295ca90b5ee13b3d3815cbfd0a321"

URI_x86_64_v2_root-mlp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mlp-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mlp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-mlp}"
SRC_URI[x86_64_v2_root-mlp.sha256sum] = "a10c2907cd3612e0812b456176003d177c3c5d74ebdc90ae3617f3a63bc3e0f0"

URI_x86_64_v2_root-montecarlo-eg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-montecarlo-eg-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-montecarlo-eg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-montecarlo-eg}"
SRC_URI[x86_64_v2_root-montecarlo-eg.sha256sum] = "d953a107305b8331343317a77ed1a8ed4806905fffbc3dc3f492afc61d804182"

URI_x86_64_v2_root-montecarlo-pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-montecarlo-pythia8-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-montecarlo-pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-montecarlo-pythia8}"
SRC_URI[x86_64_v2_root-montecarlo-pythia8.sha256sum] = "5b83a2701e10bd55835f1dce4546b90d94d7933e30d23a80a405b709f138f596"

URI_x86_64_v2_root-multiproc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-multiproc-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-multiproc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-multiproc}"
SRC_URI[x86_64_v2_root-multiproc.sha256sum] = "4aa14e4f7d565332ccee979b9925ed530b3ec8019a6839e692d4cd817171a2f3"

URI_x86_64_v2_root-net = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net}"
SRC_URI[x86_64_v2_root-net.sha256sum] = "ca0ed777dd5baf0565c7540fab2692164cb61875f5af349446b8c44d12bf427b"

URI_x86_64_v2_root-net-auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-auth-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-auth}"
SRC_URI[x86_64_v2_root-net-auth.sha256sum] = "5c89c09cf1f1d7b66e3973a7e82b8c6186418bc5f8ac26f488076a17e3289e54"

URI_x86_64_v2_root-net-curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-curl-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-curl}"
SRC_URI[x86_64_v2_root-net-curl.sha256sum] = "3abb7470c1a603d44988305592e581c0f219376f701fa7eb803727bba486b93c"

URI_x86_64_v2_root-net-davix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-davix-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-davix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-davix}"
SRC_URI[x86_64_v2_root-net-davix.sha256sum] = "c3d0b94b457f12b5b400bbe86b79ed796d7fc486a8abd76efd718bc412a11672"

URI_x86_64_v2_root-net-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-http-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-http}"
SRC_URI[x86_64_v2_root-net-http.sha256sum] = "05198c1d89c2afbff42bab62c4090eed657edf1bb6b56f4346e5ccf185a27389"

URI_x86_64_v2_root-net-httpsniff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-httpsniff-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-httpsniff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-httpsniff}"
SRC_URI[x86_64_v2_root-net-httpsniff.sha256sum] = "c967e676a8f376b74ab9fe9205327941ae2967a07bf307cf4983ff868f1ed6ff"

URI_x86_64_v2_root-net-rpdutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-rpdutils-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-rpdutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-rpdutils}"
SRC_URI[x86_64_v2_root-net-rpdutils.sha256sum] = "2ce5f44e8a5a5357cec5d4f25d68c143c3173eca034649cda7a401708b6b5405"

URI_x86_64_v2_root-netx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-netx-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-netx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-netx}"
SRC_URI[x86_64_v2_root-netx.sha256sum] = "d66b4b0ae34eee469918ba2e2a136fb00b2c161f4d4e23acf0fba8915bfd9e79"

URI_x86_64_v2_root-physics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-physics-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-physics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-physics}"
SRC_URI[x86_64_v2_root-physics.sha256sum] = "d24228ec327663e74e86e518cf4e06dd4768449a3cb188746263f08a3791c723"

URI_x86_64_v2_root-quadp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-quadp-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-quadp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-quadp}"
SRC_URI[x86_64_v2_root-quadp.sha256sum] = "63d8a5cb0153423e09b96fcc1b5a4a2578eb017b437dc7964fc5ec9cb76c6d68"

URI_x86_64_v2_root-r = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-r-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-r;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-r}"
SRC_URI[x86_64_v2_root-r.sha256sum] = "0dda66e4bec7d8202eeb1a59ec4ab9075c682b58bd77a438907342adebd2dfe9"

URI_x86_64_v2_root-r-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-r-tools-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-r-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-r-tools}"
SRC_URI[x86_64_v2_root-r-tools.sha256sum] = "433136869485022b198c5cd4848e62f325b5c62b19c2da13bbba23d0db0e6fda"

URI_x86_64_v2_root-roofit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit}"
SRC_URI[x86_64_v2_root-roofit.sha256sum] = "a2453256a84f0ecdc2a767e5151001481fc3a7dc5e782e489338f849798afed7"

URI_x86_64_v2_root-roofit-batchcompute = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-batchcompute-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-batchcompute;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-batchcompute}"
SRC_URI[x86_64_v2_root-roofit-batchcompute.sha256sum] = "a75e0d6404f5d7963d1d030478818adfebca289f2eddfbe8d0db9620a08abeb9"

URI_x86_64_v2_root-roofit-codegen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-codegen-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-codegen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-codegen}"
SRC_URI[x86_64_v2_root-roofit-codegen.sha256sum] = "8e99e70ff66bd321269cc56d95d573285a7fcfe90fa800784a73efad3f86bb92"

URI_x86_64_v2_root-roofit-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-core-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-core}"
SRC_URI[x86_64_v2_root-roofit-core.sha256sum] = "3faaa96e5a90819b68f04c3ce255256e3cc2465493fe0bb2ac457fff8ff494ca"

URI_x86_64_v2_root-roofit-hs3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-hs3-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-hs3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-hs3}"
SRC_URI[x86_64_v2_root-roofit-hs3.sha256sum] = "fb804ecc40c50e7b1a81506a9010581f942e2a7a16c5201a8311be82f20d3cf9"

URI_x86_64_v2_root-roofit-jsoninterface = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-jsoninterface-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-jsoninterface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-jsoninterface}"
SRC_URI[x86_64_v2_root-roofit-jsoninterface.sha256sum] = "4f283b9be51f464b3f9b5bf9bc3c832ff425cc6ebe1f30b660ac9bdd879b71fe"

URI_x86_64_v2_root-roofit-more = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-more-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-more;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-more}"
SRC_URI[x86_64_v2_root-roofit-more.sha256sum] = "c592baaa3e6db035c76a22bab9ee8b796bda717e8e7b7914f5915766d6dbb937"

URI_x86_64_v2_root-roofit-multiprocess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-multiprocess-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-multiprocess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-multiprocess}"
SRC_URI[x86_64_v2_root-roofit-multiprocess.sha256sum] = "62d545b1c7564c252d93fd8aec0627d406ffe9353833d4ff44e0252cf6c774a6"

URI_x86_64_v2_root-roofit-zmq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-zmq-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-zmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-zmq}"
SRC_URI[x86_64_v2_root-roofit-zmq.sha256sum] = "c46eb44b68a5cc458ec92fa20a15d9b128bb77ae2e3ad66bacdf70527f8b0175"

URI_x86_64_v2_root-roostats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roostats-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roostats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roostats}"
SRC_URI[x86_64_v2_root-roostats.sha256sum] = "86fe78631e17f00048a6898734c236eb4fb2808d58f278a3efcc5831d37fcd55"

URI_x86_64_v2_root-smatrix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-smatrix-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-smatrix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-smatrix}"
SRC_URI[x86_64_v2_root-smatrix.sha256sum] = "cb2554c780b2f153bceeddfdd279df120b588b440bee7fa4a4fc6db9eaae26ff"

URI_x86_64_v2_root-spectrum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-spectrum-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-spectrum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-spectrum}"
SRC_URI[x86_64_v2_root-spectrum.sha256sum] = "aaecdcaaf00cf5d31fba9e1664f89860e36cb82c3fb90f2a13cb0b07d1772379"

URI_x86_64_v2_root-spectrum-painter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-spectrum-painter-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-spectrum-painter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-spectrum-painter}"
SRC_URI[x86_64_v2_root-spectrum-painter.sha256sum] = "c851e1d8413a8d0b3a87df34ffa0c4bdd4ef0718f4201727da95ed519f6108a7"

URI_x86_64_v2_root-splot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-splot-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-splot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-splot}"
SRC_URI[x86_64_v2_root-splot.sha256sum] = "b04b279606910e08f67410c8a7ce68b6f239dddbb225d92ed59937033c4c2eb3"

URI_x86_64_v2_root-sql-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-sql-sqlite-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-sql-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-sql-sqlite}"
SRC_URI[x86_64_v2_root-sql-sqlite.sha256sum] = "af623bf01e0e49a842cb6ef09effafd085b41e3c82d6c61da3d3eaffaff40cd7"

URI_x86_64_v2_root-testsupport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-testsupport-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-testsupport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-testsupport}"
SRC_URI[x86_64_v2_root-testsupport.sha256sum] = "c3649cb2839ff5775a4325822373b86a3419d79b710f5da3247f56fe399c697d"

URI_x86_64_v2_root-tmva = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva}"
SRC_URI[x86_64_v2_root-tmva.sha256sum] = "389bec20f4c4722bba7b618a7e878759c3a2997a34f193137fcce2ae4ab3440f"

URI_x86_64_v2_root-tmva-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-gui-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-gui}"
SRC_URI[x86_64_v2_root-tmva-gui.sha256sum] = "ed18f46900ed1c8020b5f181c2984863700cde7a3473803b897afab65490d72b"

URI_x86_64_v2_root-tmva-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-python-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-python}"
SRC_URI[x86_64_v2_root-tmva-python.sha256sum] = "2e500e1cb2da488f7de4bd228d54eaed738cbb2f52ed3074c2df58418fbd20f9"

URI_x86_64_v2_root-tmva-r = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-r-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-r;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-r}"
SRC_URI[x86_64_v2_root-tmva-r.sha256sum] = "902e09b6f6f07a8183ad0e7cd47307e67535a8921ac3c33bf440c657518b4ab3"

URI_x86_64_v2_root-tmva-sofie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-sofie}"
SRC_URI[x86_64_v2_root-tmva-sofie.sha256sum] = "016e49203812bda6e4c371e950c797dd19214b9d294a8c3dbad2a42961d6591a"

URI_x86_64_v2_root-tmva-sofie-parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-parser-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie-parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-sofie-parser}"
SRC_URI[x86_64_v2_root-tmva-sofie-parser.sha256sum] = "426d9b204cf36242ecaaca9f424a103cb464810451ab954003a74216e5c69b8a"

URI_x86_64_v2_root-tmva-sofie-parser-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-parser-python-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie-parser-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-sofie-parser-python}"
SRC_URI[x86_64_v2_root-tmva-sofie-parser-python.sha256sum] = "8bc3ae4e2f84cc0850f2e566b3df84cacbe7fcdad1c9590e75e29b66449273fa"

URI_x86_64_v2_root-tmva-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-utils-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-utils}"
SRC_URI[x86_64_v2_root-tmva-utils.sha256sum] = "9d5f550a1b2bf01c143845de53e6bee1a431f42641a11a159d3ecf7ee0409207"

URI_x86_64_v2_root-tpython = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tpython-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tpython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tpython}"
SRC_URI[x86_64_v2_root-tpython.sha256sum] = "19225695b30f139e9b39a46bed00642a79f23c576c285ac659eb279994cb6ecf"

URI_x86_64_v2_root-tree = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree}"
SRC_URI[x86_64_v2_root-tree.sha256sum] = "1f476e6e273c826c042505d43d9d9c40e9942c46d63c30d44ee3996a9a40c5a8"

URI_x86_64_v2_root-tree-dataframe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-dataframe-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-dataframe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-dataframe}"
SRC_URI[x86_64_v2_root-tree-dataframe.sha256sum] = "95fcd868415371432752cfc24e77f3c6db5929f825ae8d440791ce612f395253"

URI_x86_64_v2_root-tree-ml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ml-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ml}"
SRC_URI[x86_64_v2_root-tree-ml.sha256sum] = "53d1ff53a8c6ec9ee3b0dcabea15a4a9b0fdb725a63dc012f8d625b8af9cf37b"

URI_x86_64_v2_root-tree-ntuple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ntuple}"
SRC_URI[x86_64_v2_root-tree-ntuple.sha256sum] = "ddb8067d003bfcebcccea23a6213985fab788d6e8f445d27b7f14841921696ac"

URI_x86_64_v2_root-tree-ntuple-browse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-browse-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple-browse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ntuple-browse}"
SRC_URI[x86_64_v2_root-tree-ntuple-browse.sha256sum] = "5a56aa3e932ee5ea6d0bfe338ff21ead7fc11af0c93578631ba6524ecacc2ed4"

URI_x86_64_v2_root-tree-ntuple-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-utils-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ntuple-utils}"
SRC_URI[x86_64_v2_root-tree-ntuple-utils.sha256sum] = "3b1cd53b92ae8f3031ebc33836dbc869e669ccedf3d478925620bab57bfdf23a"

URI_x86_64_v2_root-tree-player = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-player-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-player;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-player}"
SRC_URI[x86_64_v2_root-tree-player.sha256sum] = "92312f2daded3aa921052781ca9e389bbea993236d28b770e33c04b09490e1d6"

URI_x86_64_v2_root-tree-viewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-viewer-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-viewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-viewer}"
SRC_URI[x86_64_v2_root-tree-viewer.sha256sum] = "921420b360838cf86f894b8f644f0fc2851d402f7c37c123e3184a55df4dc56f"

URI_x86_64_v2_root-tree-webviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-webviewer-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-webviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-webviewer}"
SRC_URI[x86_64_v2_root-tree-webviewer.sha256sum] = "5d6c0fe922809ee2c34aa3dc229af330eef9fc47c0d12c91001e95adb150c932"

URI_x86_64_v2_root-tutorial = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tutorial-6.40.02-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_root-tutorial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tutorial}"
SRC_URI[x86_64_v2_root-tutorial.sha256sum] = "a555420dc370ddebb81afbbc49597c132bc4706195e90eaacb3b0fd217c6c065"

URI_x86_64_v2_root-unfold = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-unfold-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-unfold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-unfold}"
SRC_URI[x86_64_v2_root-unfold.sha256sum] = "606b62e43d1d74bf8173985ac0f65ba18484f031bd34e56ed004720bd249723f"

URI_x86_64_v2_root-unuran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-unuran-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-unuran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-unuran}"
SRC_URI[x86_64_v2_root-unuran.sha256sum] = "810bc24fd8e4b1c4a69abf19dafd180a2fec0b4039ff136388e760055edf24a2"

URI_x86_64_v2_root-vecops = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-vecops-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-vecops;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-vecops}"
SRC_URI[x86_64_v2_root-vecops.sha256sum] = "bb76f0989d5cab9366b66b4ae69de59dc74e57b3b4ce083bf82e14bb643c984d"

URI_x86_64_v2_root-xroofit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-xroofit-6.40.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-xroofit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-xroofit}"
SRC_URI[x86_64_v2_root-xroofit.sha256sum] = "27ee90477ee92b3ee43c46c617e5e9ce56f9741f9f40f22f7db5638f35bf42c8"

URI_aarch64_python3-root = "${EPEL_MIRROR}/aarch64/Packages/p/python3-root-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_python3-root;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-root}"
SRC_URI[aarch64_python3-root.sha256sum] = "52cfc30a229d0744663d48868319b5206209bdf5d24b6fea52c69fe801b51664"

URI_aarch64_python3-root+distrdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-root+distrdf-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_python3-root+distrdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-root+distrdf}"
SRC_URI[aarch64_python3-root+distrdf.sha256sum] = "b88a1b565ebac686d649e50dcaf1c8d6143d65b4d81ccd7f908b40d6287c7e75"

URI_aarch64_python3-root+jupyroot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-root+jupyroot-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_python3-root+jupyroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-root+jupyroot}"
SRC_URI[aarch64_python3-root+jupyroot.sha256sum] = "b25d36f4496c16893f3238bf2578157a7b03a827cc6c05b0870338c98bfa1461"

URI_aarch64_root = "${EPEL_MIRROR}/aarch64/Packages/r/root-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root;unpack=0"
SRC_URI:append = " ${URI_aarch64_root}"
SRC_URI[aarch64_root.sha256sum] = "3bcb235713387eb2dd23a0671386c08c16768a376dc1d59d9557007cf7f27b00"

URI_aarch64_root-cli = "${EPEL_MIRROR}/aarch64/Packages/r/root-cli-6.40.02-1.el10_3.noarch.rpm;name=aarch64_root-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-cli}"
SRC_URI[aarch64_root-cli.sha256sum] = "f1b19d12b62bc657c847c72bcfce78665ff7b3c51717daec1553dcef92cc2412"

URI_aarch64_root-cling = "${EPEL_MIRROR}/aarch64/Packages/r/root-cling-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-cling;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-cling}"
SRC_URI[aarch64_root-cling.sha256sum] = "5d62fe58119972a7dff28626b610933f037f3f3d5a2a5baa629837d0cd7336ac"

URI_aarch64_root-core = "${EPEL_MIRROR}/aarch64/Packages/r/root-core-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-core}"
SRC_URI[aarch64_root-core.sha256sum] = "fb803d275849ffa79bf2b74320f82f60dfb11d19e1defbdedb4cb1a674178443"

URI_aarch64_root-fftw = "${EPEL_MIRROR}/aarch64/Packages/r/root-fftw-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-fftw;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-fftw}"
SRC_URI[aarch64_root-fftw.sha256sum] = "27f57c64ab87fabd62a255748d41481e8c262a4c700eb838da90fb3ebedafe94"

URI_aarch64_root-foam = "${EPEL_MIRROR}/aarch64/Packages/r/root-foam-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-foam;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-foam}"
SRC_URI[aarch64_root-foam.sha256sum] = "a8d0b78e28eff0660668a59a5ac24a34f62b6369ba9d9fb11dd6a70135066fa1"

URI_aarch64_root-font-files = "${EPEL_MIRROR}/aarch64/Packages/r/root-font-files-6.40.02-1.el10_3.noarch.rpm;name=aarch64_root-font-files;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-font-files}"
SRC_URI[aarch64_root-font-files.sha256sum] = "1e23dd49102bb1b69a1f2a4f3ba8a8bddd2cb007e3bf8ac486e4f7ea20e6239d"

URI_aarch64_root-fumili = "${EPEL_MIRROR}/aarch64/Packages/r/root-fumili-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-fumili;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-fumili}"
SRC_URI[aarch64_root-fumili.sha256sum] = "52fb3000378f2ceca86d7067a28eda50f68cb1a547269c85dc075f71e3cf54d4"

URI_aarch64_root-gdml = "${EPEL_MIRROR}/aarch64/Packages/r/root-gdml-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gdml;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gdml}"
SRC_URI[aarch64_root-gdml.sha256sum] = "2ec89736ac77e8626f64832ddd1b32ad156057975d72d5800de93532710c2025"

URI_aarch64_root-genetic = "${EPEL_MIRROR}/aarch64/Packages/r/root-genetic-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-genetic;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-genetic}"
SRC_URI[aarch64_root-genetic.sha256sum] = "3599ffe087c79b937e486cef5e7566e4fb778d91a74e006a43d233d13aa0247a"

URI_aarch64_root-genvector = "${EPEL_MIRROR}/aarch64/Packages/r/root-genvector-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-genvector;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-genvector}"
SRC_URI[aarch64_root-genvector.sha256sum] = "af2f18378c68a84a227a03ddcb1d0b9152065977e1831e84903d4e0f3ff7a78b"

URI_aarch64_root-geom = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-geom;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom}"
SRC_URI[aarch64_root-geom.sha256sum] = "1bfa42d890457c4578d5d6c83372224e64e9ce67ac75db1c66237987f8ab0225"

URI_aarch64_root-geom-builder = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-builder-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-geom-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-builder}"
SRC_URI[aarch64_root-geom-builder.sha256sum] = "8b39a0e921de997f16bba47fe13b48dfbdfeb2b407a7ff41490f4cfa950c903f"

URI_aarch64_root-geom-checker = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-checker-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-geom-checker;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-checker}"
SRC_URI[aarch64_root-geom-checker.sha256sum] = "69ed7854fa585883ecf916f0c605a453ea854c59930e9c667bd5c921834845bf"

URI_aarch64_root-geom-painter = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-painter-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-geom-painter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-painter}"
SRC_URI[aarch64_root-geom-painter.sha256sum] = "8db89e783f44a52265fe93616578451e3c666f6fc8fea106b82ab5f6d3b6d037"

URI_aarch64_root-geom-webviewer = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-webviewer-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-geom-webviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-webviewer}"
SRC_URI[aarch64_root-geom-webviewer.sha256sum] = "7e4bb2f00fdfce6c38a5d18d97512112d02f8e615e26afd1e66b769311eacd0f"

URI_aarch64_root-graf = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf}"
SRC_URI[aarch64_root-graf.sha256sum] = "3a243b99b6504f8411e3c486e0597de14e1b0effbb808fa0d351cfbe9aaab077"

URI_aarch64_root-graf-asimage = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-asimage-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf-asimage;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-asimage}"
SRC_URI[aarch64_root-graf-asimage.sha256sum] = "a86a71c99be6b669485a2f4aa318a6a4602e9d36f94cd2dbed6226eb66f8f8ed"

URI_aarch64_root-graf-fitsio = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-fitsio-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf-fitsio;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-fitsio}"
SRC_URI[aarch64_root-graf-fitsio.sha256sum] = "a9f4ea822a921eece827efc563d047b8a046f91120a3c229f3ff3af0ce616d39"

URI_aarch64_root-graf-gpad = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gpad-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf-gpad;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-gpad}"
SRC_URI[aarch64_root-graf-gpad.sha256sum] = "2d3a007b1fdba7aa42a4fb91cb519551639f2f47c551657555e63cf818929457"

URI_aarch64_root-graf-gpadv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gpadv7-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf-gpadv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-gpadv7}"
SRC_URI[aarch64_root-graf-gpadv7.sha256sum] = "f12f3c9d505145090347663bd65854fa3d6a3197821b0183437aad7a7858476f"

URI_aarch64_root-graf-gviz = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gviz-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf-gviz;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-gviz}"
SRC_URI[aarch64_root-graf-gviz.sha256sum] = "79bc13923fbe42f20abbb52d66f04c3fce81bd727574e531f5b6b3159da27c45"

URI_aarch64_root-graf-postscript = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-postscript-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf-postscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-postscript}"
SRC_URI[aarch64_root-graf-postscript.sha256sum] = "70ecff40d2da577b24eff9fab5e6e9291db765c1e883638a585f4d9ad4c56bb3"

URI_aarch64_root-graf-primitives = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-primitives-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf-primitives;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-primitives}"
SRC_URI[aarch64_root-graf-primitives.sha256sum] = "eb9b514e19aaed1b06c95647bca326fd0702fb4da0d8bd3b56630f84276942d4"

URI_aarch64_root-graf-x11 = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-x11-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-x11}"
SRC_URI[aarch64_root-graf-x11.sha256sum] = "eeaa571e4648f1e48a3248c82afae89baabd6275e7c1d07d907a50904c1c6112"

URI_aarch64_root-graf3d = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d}"
SRC_URI[aarch64_root-graf3d.sha256sum] = "553fbe366537e50a992abd0523c68d2e356a1c5deb15768622ffdb3299a1cbd8"

URI_aarch64_root-graf3d-csg = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-csg-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-csg;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-csg}"
SRC_URI[aarch64_root-graf3d-csg.sha256sum] = "d92ffaba94e122df660007dbc235d893977fa536785e2fa0c7d796cc9d8ab647"

URI_aarch64_root-graf3d-eve = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-eve-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-eve;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-eve}"
SRC_URI[aarch64_root-graf3d-eve.sha256sum] = "670362dbdcdd2787813aa345501eaae5bf9b4a373a31d16404ba05e67648d4d1"

URI_aarch64_root-graf3d-eve7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-eve7-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-eve7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-eve7}"
SRC_URI[aarch64_root-graf3d-eve7.sha256sum] = "b5b01a55353069d0d163cab2c6626ba5dd322af5cd9b2f9819eb0e6b1ab26f30"

URI_aarch64_root-graf3d-gl = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-gl-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-gl;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-gl}"
SRC_URI[aarch64_root-graf3d-gl.sha256sum] = "8a8c4428cc9e6e0c7b29eb7f7e7679b79ee6ab85da849286096aca7bb70163e2"

URI_aarch64_root-graf3d-glad = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-glad-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-glad;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-glad}"
SRC_URI[aarch64_root-graf3d-glad.sha256sum] = "d5563cf3c029834dbf626f9e0ec808544b4da72c2c101799b23f70e36bfe3a26"

URI_aarch64_root-graf3d-gviz3d = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-gviz3d-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-gviz3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-gviz3d}"
SRC_URI[aarch64_root-graf3d-gviz3d.sha256sum] = "31003420f75207ebd5e1166b3636dd48b1873a6a75a590e3bab8725cce227004"

URI_aarch64_root-graf3d-x3d = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-x3d-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-graf3d-x3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-x3d}"
SRC_URI[aarch64_root-graf3d-x3d.sha256sum] = "08d087ac1b527dcc2fad20540b6233a1445d0a276d1794f5b8d65184580a172a"

URI_aarch64_root-gui = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui}"
SRC_URI[aarch64_root-gui.sha256sum] = "41541859aaffd4e65005a2acdd59278c8c2eca80448654b12289c569939a3ff2"

URI_aarch64_root-gui-browsable = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browsable-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-browsable;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browsable}"
SRC_URI[aarch64_root-gui-browsable.sha256sum] = "a38724261e254b7c9949244b14b4bab1a16d2796a3f72e57c07f2f93abefb77a"

URI_aarch64_root-gui-browsable-v7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browsable-v7-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-browsable-v7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browsable-v7}"
SRC_URI[aarch64_root-gui-browsable-v7.sha256sum] = "d5b49fe9b76be2b552cf090f81782d26ae53c3df0416d7d06aebdf0ae4635205"

URI_aarch64_root-gui-browserv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browserv7-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-browserv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browserv7}"
SRC_URI[aarch64_root-gui-browserv7.sha256sum] = "5be8d96e2bbb7557d5c1d2378547dace9bf3644e06ffac522b5ee02cbe627b05"

URI_aarch64_root-gui-browserv7-v7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browserv7-v7-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-browserv7-v7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browserv7-v7}"
SRC_URI[aarch64_root-gui-browserv7-v7.sha256sum] = "70988b1f563f122517c0490812fe0a19dc45919f5a5d7e8627a498c8a4c5b279"

URI_aarch64_root-gui-builder = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-builder-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-builder}"
SRC_URI[aarch64_root-gui-builder.sha256sum] = "9d92e93d33ad265d83c9eaf51a067f329fcd551ee212ed4c7b083e09462340c6"

URI_aarch64_root-gui-canvaspainter = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-canvaspainter-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-canvaspainter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-canvaspainter}"
SRC_URI[aarch64_root-gui-canvaspainter.sha256sum] = "bfc41bdf15b59c857b334e7bea36f2976c89ce41ee92d74c78460b52e7387af3"

URI_aarch64_root-gui-fitpanel = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-fitpanel-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-fitpanel;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-fitpanel}"
SRC_URI[aarch64_root-gui-fitpanel.sha256sum] = "950fade78598a89cb0bfd00c42445fed0ef31355166c22f15e6c82529febe2b8"

URI_aarch64_root-gui-fitpanelv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-fitpanelv7-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-fitpanelv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-fitpanelv7}"
SRC_URI[aarch64_root-gui-fitpanelv7.sha256sum] = "fcc201e95679012a2263fb98e24b6fcdc6b987670b5fae25ff17b35e280dd0bb"

URI_aarch64_root-gui-ged = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-ged-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-ged;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-ged}"
SRC_URI[aarch64_root-gui-ged.sha256sum] = "23daa70f69cbb5111093f767a9582af0ad4b2de31ab9506506769964d28484ab"

URI_aarch64_root-gui-html = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-html-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-html}"
SRC_URI[aarch64_root-gui-html.sha256sum] = "6186581ce2dc32b11874b1624b708d1e93410027a17e9f2800df46f4f9e7c937"

URI_aarch64_root-gui-qt6webdisplay = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-qt6webdisplay-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-qt6webdisplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-qt6webdisplay}"
SRC_URI[aarch64_root-gui-qt6webdisplay.sha256sum] = "4f50d5f3d9dd02561e5f1bca8cd8a757355ccd1fbb87ae833af8266418bb1b66"

URI_aarch64_root-gui-recorder = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-recorder-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-recorder;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-recorder}"
SRC_URI[aarch64_root-gui-recorder.sha256sum] = "db4311838cdc7a641e81c779744792f73775a0f13eb5f06e6647cdb7ea43b454"

URI_aarch64_root-gui-treemap = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-treemap-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-treemap;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-treemap}"
SRC_URI[aarch64_root-gui-treemap.sha256sum] = "84593da1732b579b8b7fec3bec8b379431186a48dae539ac0f7c2acffe84bae7"

URI_aarch64_root-gui-webdisplay = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-webdisplay-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-webdisplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-webdisplay}"
SRC_URI[aarch64_root-gui-webdisplay.sha256sum] = "075744c9f464ae2815296e48c202bebacd78b46737dcfc9f0aa78b0823ace491"

URI_aarch64_root-gui-webgui6 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-webgui6-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-gui-webgui6;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-webgui6}"
SRC_URI[aarch64_root-gui-webgui6.sha256sum] = "d927255e895af0c9979d212265c7465c82c4b00aec8da86657b2831b0062c683"

URI_aarch64_root-hbook = "${EPEL_MIRROR}/aarch64/Packages/r/root-hbook-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-hbook;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hbook}"
SRC_URI[aarch64_root-hbook.sha256sum] = "35729abcd2dcdef0c47be19d6b98023ccfd086ba15d62f60fd9c39f6d594dbcf"

URI_aarch64_root-hist = "${EPEL_MIRROR}/aarch64/Packages/r/root-hist-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-hist;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hist}"
SRC_URI[aarch64_root-hist.sha256sum] = "c05d60fed65af6c3f8a08e67c94368f91002afe4a2e1a25dc97f8d2a80b9a0f6"

URI_aarch64_root-hist-factory = "${EPEL_MIRROR}/aarch64/Packages/r/root-hist-factory-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-hist-factory;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hist-factory}"
SRC_URI[aarch64_root-hist-factory.sha256sum] = "ec9a7d1d9a6d7f6d7360c1e1d9a019f12e53940a2a559b945f4feda433826ab5"

URI_aarch64_root-hist-painter = "${EPEL_MIRROR}/aarch64/Packages/r/root-hist-painter-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-hist-painter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hist-painter}"
SRC_URI[aarch64_root-hist-painter.sha256sum] = "f863046c03dc7b6a47d616bbe7d05de0356f3fae6edea0956d29b5ea0fe23898"

URI_aarch64_root-histv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-histv7-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-histv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-histv7}"
SRC_URI[aarch64_root-histv7.sha256sum] = "29934b1304d8c6cddc8de16efacb59135680675ab6afaaf0f3396afdf0e2381b"

URI_aarch64_root-histv7util = "${EPEL_MIRROR}/aarch64/Packages/r/root-histv7util-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-histv7util;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-histv7util}"
SRC_URI[aarch64_root-histv7util.sha256sum] = "73a3049f6eb5f6e03a8a002a0124eae8a8ecc0d4bde072a33e08f019b14e5115"

URI_aarch64_root-icons = "${EPEL_MIRROR}/aarch64/Packages/r/root-icons-6.40.02-1.el10_3.noarch.rpm;name=aarch64_root-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-icons}"
SRC_URI[aarch64_root-icons.sha256sum] = "56831581e52a7300b5a9f6f1760b10a207abc89da9fd83267b3aef646de0efd3"

URI_aarch64_root-io = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io}"
SRC_URI[aarch64_root-io.sha256sum] = "fa5bd4389ad765b8dd816958a156ae0cc0943b23079e9d17eff769405a885ff7"

URI_aarch64_root-io-dcache = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-dcache-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-io-dcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-dcache}"
SRC_URI[aarch64_root-io-dcache.sha256sum] = "255fcdc76f780fcc76221a438219eaf7e66fc080fd2c2d64bfdd3c65a2ca2001"

URI_aarch64_root-io-sql = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-sql-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-io-sql;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-sql}"
SRC_URI[aarch64_root-io-sql.sha256sum] = "91e33565cebc9310067a23d4faeb26bc2d9016685dc174d08e1606cc62c762bc"

URI_aarch64_root-io-xml = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-xml-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-io-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-xml}"
SRC_URI[aarch64_root-io-xml.sha256sum] = "eeb3c6e3079cd19d4dc13749bff416a404c6f4d71b01628aa63a2754a2f00003"

URI_aarch64_root-io-xmlparser = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-xmlparser-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-io-xmlparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-xmlparser}"
SRC_URI[aarch64_root-io-xmlparser.sha256sum] = "acc9c77721f272934efdf93f7ba4aeb61f6912dbb8602c99e4695a7d4f374842"

URI_aarch64_root-mathcore = "${EPEL_MIRROR}/aarch64/Packages/r/root-mathcore-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-mathcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-mathcore}"
SRC_URI[aarch64_root-mathcore.sha256sum] = "3fee01e855c93a60f132a10ee107de960274c63f42d65e9f6f54795dc9ffef80"

URI_aarch64_root-mathmore = "${EPEL_MIRROR}/aarch64/Packages/r/root-mathmore-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-mathmore;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-mathmore}"
SRC_URI[aarch64_root-mathmore.sha256sum] = "dd4355d159dbd0596e8499819b79ec4256753f3e984b70e81286e13b5807bd39"

URI_aarch64_root-matrix = "${EPEL_MIRROR}/aarch64/Packages/r/root-matrix-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-matrix;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-matrix}"
SRC_URI[aarch64_root-matrix.sha256sum] = "d1b98eda62c535f5f9e1d6b2a944f03a1c54bae2d5866f31ede3bf4cb797c9ab"

URI_aarch64_root-minuit = "${EPEL_MIRROR}/aarch64/Packages/r/root-minuit-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-minuit;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-minuit}"
SRC_URI[aarch64_root-minuit.sha256sum] = "6770c491815c0135335e5f8d695a65a1bf1e7fbacda3bd48cbf8f464bf31d9f9"

URI_aarch64_root-minuit2 = "${EPEL_MIRROR}/aarch64/Packages/r/root-minuit2-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-minuit2;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-minuit2}"
SRC_URI[aarch64_root-minuit2.sha256sum] = "d35b527ffa616eddf8f9d469f749f1341bab77e1c74dc4be4f57d0506f0b31a6"

URI_aarch64_root-mlp = "${EPEL_MIRROR}/aarch64/Packages/r/root-mlp-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-mlp;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-mlp}"
SRC_URI[aarch64_root-mlp.sha256sum] = "a15c64f64e53a432359b284d1a9219d79249fb2f571f25c562ad56e266acb3c2"

URI_aarch64_root-montecarlo-eg = "${EPEL_MIRROR}/aarch64/Packages/r/root-montecarlo-eg-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-montecarlo-eg;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-montecarlo-eg}"
SRC_URI[aarch64_root-montecarlo-eg.sha256sum] = "b5f03de5cd2bd690deaeeb2bc28bdf5390e457f3e81b31cfad866ed12c19bb4d"

URI_aarch64_root-montecarlo-pythia8 = "${EPEL_MIRROR}/aarch64/Packages/r/root-montecarlo-pythia8-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-montecarlo-pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-montecarlo-pythia8}"
SRC_URI[aarch64_root-montecarlo-pythia8.sha256sum] = "60b30912edc05197e746bafd19f0927fdf98d098f5c51709b38e439cc5ad029f"

URI_aarch64_root-multiproc = "${EPEL_MIRROR}/aarch64/Packages/r/root-multiproc-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-multiproc;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-multiproc}"
SRC_URI[aarch64_root-multiproc.sha256sum] = "4e62b18f5dd34998d1a9a7c96ef38b1bbe1a3e23db5996b69437def0fc09627e"

URI_aarch64_root-net = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-net;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net}"
SRC_URI[aarch64_root-net.sha256sum] = "40f5c0ad477ff4173b0bdd9a6889f032c836b5c216ccddea677f9448f90f1d15"

URI_aarch64_root-net-auth = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-auth-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-net-auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-auth}"
SRC_URI[aarch64_root-net-auth.sha256sum] = "6396fa59bf2bab94375d437dfeb85f539e60bd1b1e032f2dcd9940c4a5bd2757"

URI_aarch64_root-net-curl = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-curl-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-net-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-curl}"
SRC_URI[aarch64_root-net-curl.sha256sum] = "f2f257c76a0bc1fb3faf368ddf1f0c77699c2c0c908095ce82059658adcbaf61"

URI_aarch64_root-net-davix = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-davix-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-net-davix;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-davix}"
SRC_URI[aarch64_root-net-davix.sha256sum] = "c5ddd7f71e4b8d881de438bbd102cee17326b616e65b99028cdf78a5f3932fc8"

URI_aarch64_root-net-http = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-http-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-net-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-http}"
SRC_URI[aarch64_root-net-http.sha256sum] = "e0e5dedf5f40c1e3415fbec01173681aab110042d2feec1dce37ee78f520803e"

URI_aarch64_root-net-httpsniff = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-httpsniff-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-net-httpsniff;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-httpsniff}"
SRC_URI[aarch64_root-net-httpsniff.sha256sum] = "cbccdd5cf4ac2e3ba5b43251d5776b6b33c2a4960e77bcf205f36ce2db322df5"

URI_aarch64_root-net-rpdutils = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-rpdutils-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-net-rpdutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-rpdutils}"
SRC_URI[aarch64_root-net-rpdutils.sha256sum] = "88179e316438a98b1239a3196f0f73c615707f52e6a95b76d0fb10d024403fa0"

URI_aarch64_root-netx = "${EPEL_MIRROR}/aarch64/Packages/r/root-netx-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-netx;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-netx}"
SRC_URI[aarch64_root-netx.sha256sum] = "2aa12eda0746badc0046a99b6743eb9b3ffe3c9fdf674d62acf9bd258e593313"

URI_aarch64_root-physics = "${EPEL_MIRROR}/aarch64/Packages/r/root-physics-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-physics;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-physics}"
SRC_URI[aarch64_root-physics.sha256sum] = "fa8ace970213c26fcc4d8da953551a65d7605b1a2c1cb459d371d6774179492f"

URI_aarch64_root-quadp = "${EPEL_MIRROR}/aarch64/Packages/r/root-quadp-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-quadp;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-quadp}"
SRC_URI[aarch64_root-quadp.sha256sum] = "462e386610e4157539fcb15af82e8f6f6bbb8c021abb1b98a90acff94fc65b91"

URI_aarch64_root-r = "${EPEL_MIRROR}/aarch64/Packages/r/root-r-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-r;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-r}"
SRC_URI[aarch64_root-r.sha256sum] = "fa13c19667ad75df40e2367bf32008163738da2ef534e9a7e96bffa19d8094dd"

URI_aarch64_root-r-tools = "${EPEL_MIRROR}/aarch64/Packages/r/root-r-tools-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-r-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-r-tools}"
SRC_URI[aarch64_root-r-tools.sha256sum] = "72243b522ffd0776af10d48e72a6ae04e796d819c09f314cb273f8b68c6b6d0a"

URI_aarch64_root-roofit = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-roofit;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit}"
SRC_URI[aarch64_root-roofit.sha256sum] = "e21d5e9e3fd0f3405c5f93027300e5fc7eff36c881dd91fe83f50852f2a01deb"

URI_aarch64_root-roofit-batchcompute = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-batchcompute-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-batchcompute;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-batchcompute}"
SRC_URI[aarch64_root-roofit-batchcompute.sha256sum] = "ac7940e44447feada5500b581830c001fadf62263a229eb77365d2167fc0249f"

URI_aarch64_root-roofit-codegen = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-codegen-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-codegen;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-codegen}"
SRC_URI[aarch64_root-roofit-codegen.sha256sum] = "f791d55969c9bc1b6f8a5f1bcfc4127886edf10a61118fea388177d04272ddfc"

URI_aarch64_root-roofit-core = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-core-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-core}"
SRC_URI[aarch64_root-roofit-core.sha256sum] = "ac6facdc8ae1fcf53384891237e541c8aa1a78136734a0f60c7959fb5f539f5c"

URI_aarch64_root-roofit-hs3 = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-hs3-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-hs3;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-hs3}"
SRC_URI[aarch64_root-roofit-hs3.sha256sum] = "db2dee6de17a8f45e78a0d0844d7f583ccec4c745c55d6e2b3ea8013e3a66e79"

URI_aarch64_root-roofit-jsoninterface = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-jsoninterface-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-jsoninterface;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-jsoninterface}"
SRC_URI[aarch64_root-roofit-jsoninterface.sha256sum] = "3b8452012ebe4afad2ff4481672b3db6e4a057afd92ba7f279c729c6d7e80569"

URI_aarch64_root-roofit-more = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-more-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-more;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-more}"
SRC_URI[aarch64_root-roofit-more.sha256sum] = "71916d9c6ce25292a8dfaa26ad310729e8831e372d24314a71464fb752e6c674"

URI_aarch64_root-roofit-multiprocess = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-multiprocess-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-multiprocess;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-multiprocess}"
SRC_URI[aarch64_root-roofit-multiprocess.sha256sum] = "2aaa3a543bb5ec5982185f497b18dccbf96285f4302c6036c739e5635b8ebe70"

URI_aarch64_root-roofit-zmq = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-zmq-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-roofit-zmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-zmq}"
SRC_URI[aarch64_root-roofit-zmq.sha256sum] = "d833a6faeafd21f3403b3df4fd1130e9654b854ac0fc1b2bc81e38638e95484f"

URI_aarch64_root-roostats = "${EPEL_MIRROR}/aarch64/Packages/r/root-roostats-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-roostats;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roostats}"
SRC_URI[aarch64_root-roostats.sha256sum] = "8a3feff486e4e69c08f4d3b88e283a71f5503cf31f08220970c92465c0788442"

URI_aarch64_root-smatrix = "${EPEL_MIRROR}/aarch64/Packages/r/root-smatrix-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-smatrix;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-smatrix}"
SRC_URI[aarch64_root-smatrix.sha256sum] = "7cb67a36cbb06a88099d691e44cd8e19c48b79dec85bb437d50534f57114258d"

URI_aarch64_root-spectrum = "${EPEL_MIRROR}/aarch64/Packages/r/root-spectrum-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-spectrum;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-spectrum}"
SRC_URI[aarch64_root-spectrum.sha256sum] = "9c1f67c345f7329fecdc4ed0ef87e68d27bc5354863555a20cf1f9d0fc20b675"

URI_aarch64_root-spectrum-painter = "${EPEL_MIRROR}/aarch64/Packages/r/root-spectrum-painter-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-spectrum-painter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-spectrum-painter}"
SRC_URI[aarch64_root-spectrum-painter.sha256sum] = "0405c8f44cad6c2f56f65f4888c7a480317ad5737b9e9f1d4440e22242fadc9b"

URI_aarch64_root-splot = "${EPEL_MIRROR}/aarch64/Packages/r/root-splot-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-splot;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-splot}"
SRC_URI[aarch64_root-splot.sha256sum] = "533eaad46a28299373fd8b0a3cc1f56c7206bb137b7943c52a9ccd708da1d1e7"

URI_aarch64_root-sql-sqlite = "${EPEL_MIRROR}/aarch64/Packages/r/root-sql-sqlite-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-sql-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-sql-sqlite}"
SRC_URI[aarch64_root-sql-sqlite.sha256sum] = "8576e9488ece1db136fc2d5aef6d634024f86c06fabba82f1a748e9c799ba6c1"

URI_aarch64_root-testsupport = "${EPEL_MIRROR}/aarch64/Packages/r/root-testsupport-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-testsupport;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-testsupport}"
SRC_URI[aarch64_root-testsupport.sha256sum] = "c5628869ecb88e8ab68ca42a8b9c4bd8f444f5f7fc6ac7093e369705c860627a"

URI_aarch64_root-tmva = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tmva;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva}"
SRC_URI[aarch64_root-tmva.sha256sum] = "544e74754377e908e94a17c65a15e3b96e0cd52980732eee837f099d52310047"

URI_aarch64_root-tmva-gui = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-gui-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-gui}"
SRC_URI[aarch64_root-tmva-gui.sha256sum] = "e393facd99db01ba0d0aff1e156df5d5a2a2af4fda08f70eb9694db9ed1f3c25"

URI_aarch64_root-tmva-python = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-python-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-python}"
SRC_URI[aarch64_root-tmva-python.sha256sum] = "9175fac9597dfb1ac4680f3c694d3a18c2f98d15d74ad68ae7c431cc3fb47d8f"

URI_aarch64_root-tmva-r = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-r-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-r;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-r}"
SRC_URI[aarch64_root-tmva-r.sha256sum] = "a5455cc52a66b827c696d128ab34cb3705db08e75c2175036b88f20a15a05c19"

URI_aarch64_root-tmva-sofie = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-sofie;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-sofie}"
SRC_URI[aarch64_root-tmva-sofie.sha256sum] = "c561cdcfdc70a5b033bfc4ce13081c357e52ba828006ba764e890fb81d5715fc"

URI_aarch64_root-tmva-sofie-parser = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-parser-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-sofie-parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-sofie-parser}"
SRC_URI[aarch64_root-tmva-sofie-parser.sha256sum] = "2c39243a4d679766252dae437e322251323ae47f613aba9060712a8356444072"

URI_aarch64_root-tmva-sofie-parser-python = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-parser-python-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-sofie-parser-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-sofie-parser-python}"
SRC_URI[aarch64_root-tmva-sofie-parser-python.sha256sum] = "18edb57897e5eb430831b2db118f4bbb13a09a9c07cd53e173d1149e3ad07832"

URI_aarch64_root-tmva-utils = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-utils-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tmva-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-utils}"
SRC_URI[aarch64_root-tmva-utils.sha256sum] = "ee1eb82a5b20774115545b44a7b60020fce0b768c2b04061b86f89293a2420d3"

URI_aarch64_root-tpython = "${EPEL_MIRROR}/aarch64/Packages/r/root-tpython-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tpython;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tpython}"
SRC_URI[aarch64_root-tpython.sha256sum] = "3dc7c3bd6f96172e289284b146a8a90f3f982a652e9d75f64bfa96ae7e663917"

URI_aarch64_root-tree = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tree;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree}"
SRC_URI[aarch64_root-tree.sha256sum] = "2e1542f9774a8b6f4eebf1e32487ad4094f0e319f663a8bc8b13166704159ddb"

URI_aarch64_root-tree-dataframe = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-dataframe-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tree-dataframe;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-dataframe}"
SRC_URI[aarch64_root-tree-dataframe.sha256sum] = "fb3a9ad304a754f7d8c2bdb74f83d984b66845cc1c6b46fd81a405f4aff7f6c3"

URI_aarch64_root-tree-ml = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ml-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tree-ml;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ml}"
SRC_URI[aarch64_root-tree-ml.sha256sum] = "70c45586a75c255eb2c049fce5ae63f3451f87d4144002dafbfd4a985c27f4f7"

URI_aarch64_root-tree-ntuple = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tree-ntuple;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ntuple}"
SRC_URI[aarch64_root-tree-ntuple.sha256sum] = "1719395ef98154df7ac4af92c9ac0ba175ad83055ca4ba788f11544771cffb66"

URI_aarch64_root-tree-ntuple-browse = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-browse-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tree-ntuple-browse;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ntuple-browse}"
SRC_URI[aarch64_root-tree-ntuple-browse.sha256sum] = "8dfc4dd3836bfb583dbbed1dae2e7c6351062847b25280c1507aafe4b78b616c"

URI_aarch64_root-tree-ntuple-utils = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-utils-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tree-ntuple-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ntuple-utils}"
SRC_URI[aarch64_root-tree-ntuple-utils.sha256sum] = "168f66fd82ed376adeebd60f08e82f801b76e88db0fa77a92db685ed2ec7a08a"

URI_aarch64_root-tree-player = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-player-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tree-player;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-player}"
SRC_URI[aarch64_root-tree-player.sha256sum] = "70014204b3fc445c8d0c07aa10d2f912d2da60226dad7b3a068f47417adf6219"

URI_aarch64_root-tree-viewer = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-viewer-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tree-viewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-viewer}"
SRC_URI[aarch64_root-tree-viewer.sha256sum] = "b32bfff0f74f1ef30cedcc1d8159e06c92db421574d9be610051e2420ac188b8"

URI_aarch64_root-tree-webviewer = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-webviewer-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-tree-webviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-webviewer}"
SRC_URI[aarch64_root-tree-webviewer.sha256sum] = "92afe21e277baac0556f6c377c5b0142dd5ecaa48ca7eff6cfb7c0321d606fc2"

URI_aarch64_root-tutorial = "${EPEL_MIRROR}/aarch64/Packages/r/root-tutorial-6.40.02-1.el10_3.noarch.rpm;name=aarch64_root-tutorial;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tutorial}"
SRC_URI[aarch64_root-tutorial.sha256sum] = "5d48dc8f4b1e1d6e71d893039aafeb56977ad414ab898e541b3464bd66867b84"

URI_aarch64_root-unfold = "${EPEL_MIRROR}/aarch64/Packages/r/root-unfold-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-unfold;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-unfold}"
SRC_URI[aarch64_root-unfold.sha256sum] = "5fc6be9472ebff892531e78c1f7acd7cd8f2613ef072051e0b197a1c03531780"

URI_aarch64_root-unuran = "${EPEL_MIRROR}/aarch64/Packages/r/root-unuran-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-unuran;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-unuran}"
SRC_URI[aarch64_root-unuran.sha256sum] = "e6eb4e9800f429e26d0da5c6fb671f73e0978c53c0bc041f6d0d0778dbf2658a"

URI_aarch64_root-vecops = "${EPEL_MIRROR}/aarch64/Packages/r/root-vecops-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-vecops;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-vecops}"
SRC_URI[aarch64_root-vecops.sha256sum] = "112130b88cf318c83f81380a027b86318515e4af9b73205bcd2f3c13fb0be830"

URI_aarch64_root-xroofit = "${EPEL_MIRROR}/aarch64/Packages/r/root-xroofit-6.40.02-1.el10_3.aarch64.rpm;name=aarch64_root-xroofit;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-xroofit}"
SRC_URI[aarch64_root-xroofit.sha256sum] = "8f82a19d8c5d5794484fbb7390884c7c6a7a913a0c0a736f1f7c01abf600e526"

RDEPENDS:python3-root = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 root-core \
 root-io \
 root-tree \
 "
RDEPENDS:python3-root+distrdf = " \
 python3 \
 python3-root \
 root-tree-dataframe \
 "
RDEPENDS:python3-root+jupyroot = " \
 bash \
 js-jsroot \
 python-jupyter-filesystem \
 python3 \
 python3-ipython \
 python3-metakernel \
 python3-notebook \
 python3-root \
 root-core \
 "
RDEPENDS:root = " \
 bash \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 root-multiproc \
 root-net \
 root-tree \
 root-tree-ntuple \
 root-tree-player \
 "
RDEPENDS:root-cli = " \
 python3 \
 python3-root \
 "
RDEPENDS:root-cling = " \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 python3 \
 redhat-rpm-config \
 root-core \
 root-io \
 zlib-ng-compat \
 "
RDEPENDS:root-core = " \
 bash \
 glibc \
 gnu-free-mono-fonts \
 gnu-free-sans-fonts \
 gnu-free-serif-fonts \
 google-droid-sans-fonts \
 json-devel \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 pcre2 \
 root-cling \
 root-font-files \
 root-graf \
 root-graf-asimage \
 root-graf-gpad \
 root-graf-postscript \
 root-graf3d \
 root-hist \
 root-icons \
 root-io \
 root-mathcore \
 root-matrix \
 root-multiproc \
 root-net \
 root-physics \
 root-tree \
 root-tree-dataframe \
 root-tree-ntuple \
 root-tree-ntuple-utils \
 root-tree-player \
 root-vecops \
 tbb \
 urw-base35-d050000l-fonts \
 urw-base35-standard-symbols-ps-fonts \
 urw-base35-z003-fonts \
 xorg-x11-fonts-ISO8859-1-75dpi \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:root-fftw = " \
 fftw-libs-double \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-foam = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-font-files = " \
 root-core \
 "
RDEPENDS:root-fumili = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-gdml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-hist \
 root-io-xml \
 "
RDEPENDS:root-genetic = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-tmva \
 "
RDEPENDS:root-genvector = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-geom = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-geom-builder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-gui \
 root-gui-ged \
 "
RDEPENDS:root-geom-checker = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 "
RDEPENDS:root-geom-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 "
RDEPENDS:root-geom-webviewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-painter \
 root-graf3d-csg \
 root-gui-webdisplay \
 root-io \
 "
RDEPENDS:root-graf = " \
 fontconfig \
 freetype \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-asimage = " \
 fontconfig \
 freetype \
 giflib \
 glibc \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf-postscript \
 root-gui \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-fitsio = " \
 cfitsio \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-matrix \
 "
RDEPENDS:root-graf-gpad = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-postscript \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-gpadv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-graf-gviz:x86_64_v2 = " \
 glibc \
 graphviz \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
"
RDEPENDS:root-graf-gviz:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
"
RDEPENDS:root-graf-postscript = " \
 fontconfig \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 zlib-ng-compat \
 "
RDEPENDS:root-graf-primitives = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 "
RDEPENDS:root-graf-x11 = " \
 freetype \
 glibc \
 libX11 \
 libXext \
 libXft \
 libXpm \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 "
RDEPENDS:root-graf3d = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-graf3d-csg = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-graf3d-eve = " \
 glibc \
 libgcc \
 libstdc++ \
 mesa-libGLU \
 root-core \
 root-geom \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-gl \
 root-graf3d-glad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-io \
 root-mathcore \
 root-montecarlo-eg \
 root-physics \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-graf3d-eve7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-webviewer \
 root-graf \
 root-graf3d \
 root-graf3d-csg \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-mathcore \
 root-montecarlo-eg \
 root-net-http \
 root-physics \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-graf3d-gl = " \
 fontconfig \
 ftgl \
 gl2ps \
 glibc \
 libX11 \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 mesa-libGLU \
 root-core \
 root-graf \
 root-graf-asimage \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-csg \
 root-graf3d-glad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-mathcore \
 root-tree \
 "
RDEPENDS:root-graf3d-glad = " \
 glibc \
 libX11 \
 root-core \
 "
RDEPENDS:root-graf3d-gviz3d = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-gl \
 root-gui \
 root-gui-ged \
 "
RDEPENDS:root-graf3d-x3d = " \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 root-core \
 root-graf3d \
 root-gui \
 "
RDEPENDS:root-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf-x11 \
 root-gui-ged \
 root-io \
 root-mathcore \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browsable = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-gui-treemap \
 root-hist \
 root-io \
 root-tree \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browsable-v7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-browsable \
 root-gui-treemap \
 root-hist \
 root-tree \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browserv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-webviewer \
 root-graf-gpad \
 root-gui-browsable \
 root-gui-webdisplay \
 root-gui-webgui6 \
 root-io \
 root-tree \
 root-tree-webviewer \
 "
RDEPENDS:root-gui-browserv7-v7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-browsable \
 root-gui-browserv7 \
 "
RDEPENDS:root-gui-builder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-gui \
 root-mathcore \
 "
RDEPENDS:root-gui-canvaspainter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-webdisplay \
 root-io \
 "
RDEPENDS:root-gui-fitpanel = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-mathcore \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-gui-fitpanelv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-graf-gpadv7 \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-gui-ged = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-gui-html = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-gui \
 root-net \
 "
RDEPENDS:root-gui-qt6webdisplay = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 root-core \
 root-gui-webdisplay \
 root-net-http \
 "
RDEPENDS:root-gui-recorder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-gui \
 root-io \
 root-tree \
 "
RDEPENDS:root-gui-treemap = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 "
RDEPENDS:root-gui-webdisplay = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 root-net \
 root-net-http \
 "
RDEPENDS:root-gui-webgui6 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-net-http \
 "
RDEPENDS:root-hbook = " \
 glibc \
 libgcc \
 libgfortran \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-tree \
 "
RDEPENDS:root-hist = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist-painter \
 root-io \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-hist-factory = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-io-xmlparser \
 root-roofit \
 root-roofit-core \
 root-roostats \
 "
RDEPENDS:root-hist-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-histv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-histv7util = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 "
RDEPENDS:root-icons = " \
 root-core \
 "
RDEPENDS:root-io = " \
 glibc \
 libgcc \
 libstdc++ \
 liburing \
 liburing-devel \
 root-core \
 "
RDEPENDS:root-io-dcache = " \
 dcap-libs \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-io-sql = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-io-xml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-io-xmlparser = " \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 root-core \
 "
RDEPENDS:root-mathcore = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathmore \
 root-minuit2 \
 "
RDEPENDS:root-mathmore = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 "
RDEPENDS:root-matrix = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 "
RDEPENDS:root-minuit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-minuit2 = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-mlp = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 root-matrix \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-montecarlo-eg = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-mathcore \
 "
RDEPENDS:root-montecarlo-pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 root-core \
 root-montecarlo-eg \
 "
RDEPENDS:root-multiproc = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-net = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 root-core \
 root-io \
 "
RDEPENDS:root-net-auth = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 root-core \
 root-net \
 "
RDEPENDS:root-net-curl = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:root-net-davix = " \
 davix-libs \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-net-http = " \
 bash \
 fcgi \
 glibc \
 js-jsroot \
 libgcc \
 libstdc++ \
 openssl-libs \
 root-core \
 root-io \
 "
RDEPENDS:root-net-httpsniff = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-io-xml \
 root-net-http \
 root-tree \
 "
RDEPENDS:root-net-rpdutils = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 root-core \
 root-net \
 "
RDEPENDS:root-netx:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
"
RDEPENDS:root-netx:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 xrootd-client-libs \
 xrootd-libs \
"
RDEPENDS:root-physics = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-quadp = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-matrix \
 "
RDEPENDS:root-r = " \
 R-RInside \
 R-Rcpp \
 R-core \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 readline \
 root-core \
 root-matrix \
 "
RDEPENDS:root-r-tools = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-matrix \
 root-r \
 "
RDEPENDS:root-roofit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-roofit-batchcompute \
 root-roofit-core \
 root-tree \
 "
RDEPENDS:root-roofit-batchcompute = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-roofit-codegen = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist-factory \
 root-roofit \
 root-roofit-core \
 "
RDEPENDS:root-roofit-core = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-foam \
 root-graf \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-minuit2 \
 root-roofit-batchcompute \
 root-roofit-multiprocess \
 root-roofit-zmq \
 root-tree \
 zeromq \
 "
RDEPENDS:root-roofit-hs3 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-hist-factory \
 root-matrix \
 root-roofit \
 root-roofit-core \
 root-roofit-jsoninterface \
 "
RDEPENDS:root-roofit-jsoninterface = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-roofit-more = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-mathmore \
 root-roofit-core \
 "
RDEPENDS:root-roofit-multiprocess = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-roofit-zmq \
 zeromq \
 "
RDEPENDS:root-roofit-zmq = " \
 glibc \
 libgcc \
 libstdc++ \
 zeromq \
 "
RDEPENDS:root-roostats = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-minuit \
 root-roofit \
 root-roofit-core \
 root-tree \
 "
RDEPENDS:root-smatrix = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-spectrum = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 "
RDEPENDS:root-spectrum-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
 "
RDEPENDS:root-splot = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-matrix \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-sql-sqlite = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-net \
 sqlite-libs \
 "
RDEPENDS:root-testsupport = " \
 root-core \
 "
RDEPENDS:root-tmva = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-io-xml \
 root-mathcore \
 root-matrix \
 root-minuit \
 root-mlp \
 root-multiproc \
 root-net \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-tmva-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-io \
 root-io-xml \
 root-matrix \
 root-tmva \
 root-tree \
 root-tree-viewer \
 "
RDEPENDS:root-tmva-python = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-numpy \
 root-core \
 root-tmva \
 root-tree \
 "
RDEPENDS:root-tmva-r = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-matrix \
 root-r \
 root-tmva \
 "
RDEPENDS:root-tmva-sofie = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-tmva-sofie-parser = " \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 root-core \
 root-tmva-sofie \
 "
RDEPENDS:root-tmva-sofie-parser-python = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-numpy \
 root-core \
 root-tmva-sofie \
 "
RDEPENDS:root-tmva-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-tpython = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-root \
 root-core \
 "
RDEPENDS:root-tree = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-tree-dataframe = " \
 glibc \
 libarrow \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 root-tree-ntuple \
 root-tree-player \
 root-vecops \
 sqlite-libs \
 "
RDEPENDS:root-tree-ml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-vecops \
 "
RDEPENDS:root-tree-ntuple = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 root-core \
 root-io \
 xxhash-libs \
 "
RDEPENDS:root-tree-ntuple-browse = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui-treemap \
 root-hist \
 root-io \
 root-tree-ntuple \
 root-tree-ntuple-utils \
 "
RDEPENDS:root-tree-ntuple-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-tree \
 root-tree-ntuple \
 "
RDEPENDS:root-tree-player = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 root-io \
 root-mathcore \
 root-multiproc \
 root-net \
 root-tree \
 "
RDEPENDS:root-tree-viewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-tree-webviewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-tree \
 "
RDEPENDS:root-tutorial = " \
 root \
 "
RDEPENDS:root-unfold = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io-xmlparser \
 root-matrix \
 "
RDEPENDS:root-unuran = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 unuran \
 "
RDEPENDS:root-vecops = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-xroofit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-gui-fitpanel \
 root-gui-ged \
 root-hist \
 root-hist-factory \
 root-io \
 root-mathcore \
 root-matrix \
 root-roofit \
 root-roofit-core \
 root-roofit-hs3 \
 root-roostats \
 root-tree \
 "
