# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "protobuf"
PV = "3.19.6"
PR = "11.el10"
PACKAGES = " \
 protobuf \
 protobuf-compiler \
 protobuf-devel \
 protobuf-lite \
 protobuf-lite-devel \
 python3-protobuf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/protobuf-3.19.6-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86b20dbb682114d738b179cd3c555069f3b165dfbe4801199c15eff682ddd393"

URI_x86_64_v2_protobuf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/protobuf-3.19.6-11.el10.x86_64_v2.rpm;name=x86_64_v2_protobuf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_protobuf}"
SRC_URI[x86_64_v2_protobuf.sha256sum] = "323d83fde01349d1e64b454974c7a38d8c19fc4aa7cd083ba56fcd7e4f2877c8"

URI_x86_64_v2_protobuf-compiler = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/protobuf-compiler-3.19.6-11.el10.x86_64_v2.rpm;name=x86_64_v2_protobuf-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_protobuf-compiler}"
SRC_URI[x86_64_v2_protobuf-compiler.sha256sum] = "2c51966384dcfa552b6ae3a54d88e6487921ff06814a49047cefef5f09ac426e"

URI_x86_64_v2_protobuf-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/protobuf-devel-3.19.6-11.el10.x86_64_v2.rpm;name=x86_64_v2_protobuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_protobuf-devel}"
SRC_URI[x86_64_v2_protobuf-devel.sha256sum] = "ab3a418ef58188b76afb7c6aa55a0f52a07f7623fd482ef3ffa710523814b0c9"

URI_x86_64_v2_protobuf-lite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/protobuf-lite-3.19.6-11.el10.x86_64_v2.rpm;name=x86_64_v2_protobuf-lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_protobuf-lite}"
SRC_URI[x86_64_v2_protobuf-lite.sha256sum] = "02b3d6540dfcbbbdff4c16f5ea5803ebb7df726c58abdcf45943ab53e84cc96b"

URI_x86_64_v2_protobuf-lite-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/protobuf-lite-devel-3.19.6-11.el10.x86_64_v2.rpm;name=x86_64_v2_protobuf-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_protobuf-lite-devel}"
SRC_URI[x86_64_v2_protobuf-lite-devel.sha256sum] = "795a0be8c0044c8c19236552073120233c94da9b1dff1cb2fc429c056cc42a8e"

URI_x86_64_v2_python3-protobuf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-protobuf-3.19.6-11.el10.x86_64_v2.rpm;name=x86_64_v2_python3-protobuf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-protobuf}"
SRC_URI[x86_64_v2_python3-protobuf.sha256sum] = "686546868fbd3957b575e2068d742c705f53744a89231ab0c06aaafff9a09282"

URI_aarch64_protobuf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/protobuf-3.19.6-11.el10.aarch64.rpm;name=aarch64_protobuf;unpack=0"
SRC_URI:append = " ${URI_aarch64_protobuf}"
SRC_URI[aarch64_protobuf.sha256sum] = "2144da1ae39ebf92ab27868872e7e68d4c217bc445abf1c7cf74cdd63f074b59"

URI_aarch64_protobuf-compiler = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/protobuf-compiler-3.19.6-11.el10.aarch64.rpm;name=aarch64_protobuf-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_protobuf-compiler}"
SRC_URI[aarch64_protobuf-compiler.sha256sum] = "a5da200cc7d2e9b7e36723f0945908230cc41189091658cdf5cabce3e3796627"

URI_aarch64_protobuf-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/protobuf-devel-3.19.6-11.el10.aarch64.rpm;name=aarch64_protobuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_protobuf-devel}"
SRC_URI[aarch64_protobuf-devel.sha256sum] = "99612a3ad07c4b67093b90f463756723437e49f882777264605abbcf36fcf687"

URI_aarch64_protobuf-lite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/protobuf-lite-3.19.6-11.el10.aarch64.rpm;name=aarch64_protobuf-lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_protobuf-lite}"
SRC_URI[aarch64_protobuf-lite.sha256sum] = "42207c345244fa0ca1e0fbea41f22524d2fdb9ef4ba079b6375458594372aa57"

URI_aarch64_protobuf-lite-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/protobuf-lite-devel-3.19.6-11.el10.aarch64.rpm;name=aarch64_protobuf-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_protobuf-lite-devel}"
SRC_URI[aarch64_protobuf-lite-devel.sha256sum] = "0ba18b586be483de6149f4dcdcccff7adf5a816a2c865d0c405291902e2c0051"

URI_aarch64_python3-protobuf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-protobuf-3.19.6-11.el10.aarch64.rpm;name=aarch64_python3-protobuf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-protobuf}"
SRC_URI[aarch64_python3-protobuf.sha256sum] = "916add4fa0acfa8a5760857acd798b42286459a174e19e4ea37febebcf080b6d"

RDEPENDS:protobuf = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:protobuf-compiler = " \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 zlib-ng-compat \
 "
RDEPENDS:protobuf-devel = " \
 pkgconf-pkg-config \
 protobuf \
 protobuf-compiler \
 zlib-ng-compat-devel \
 "
RDEPENDS:protobuf-lite = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:protobuf-lite-devel = " \
 pkgconf-pkg-config \
 protobuf-devel \
 protobuf-lite \
 "
RDEPENDS:python3-protobuf = " \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 python3 \
 "
