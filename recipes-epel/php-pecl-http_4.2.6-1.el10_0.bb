# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-http"
PV = "4.2.6"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-http \
 php-pecl-http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-http-4.2.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "683628ccc123c028f9ec2c88bcc8c362a6fce8af18b7113d1022a490ff421790"

URI_x86_64_v2_php-pecl-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-http-4.2.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-http}"
SRC_URI[x86_64_v2_php-pecl-http.sha256sum] = "a9776e67f4898e33628a73604d90a1b0a67be2a0b7f30ab0c1055a238c0866b6"

URI_x86_64_v2_php-pecl-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-http-devel-4.2.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-http-devel}"
SRC_URI[x86_64_v2_php-pecl-http-devel.sha256sum] = "19ef468dbd8d9a88bc124f1aa2d739851f78b29fc4810e9b5730108c112e23b7"

URI_aarch64_php-pecl-http = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-http-4.2.6-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-http}"
SRC_URI[aarch64_php-pecl-http.sha256sum] = "b0198dcc7e4ccfd8e98a9f8c14b3ff36cbca8c8d3ef9d505c7d5b4430a06a74a"

URI_aarch64_php-pecl-http-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-http-devel-4.2.6-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-http-devel}"
SRC_URI[aarch64_php-pecl-http-devel.sha256sum] = "0139943ce6695c959a3422ba703f7a7e2d45475fdb2aaf99fbd1bc79b6f70f54"

RDEPENDS:php-pecl-http = " \
 glibc \
 libbrotli \
 libevent \
 libicu \
 openssl-libs \
 php-common \
 php-pecl-raphf \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:php-pecl-http-devel = " \
 php-devel \
 php-pecl-http \
 "
