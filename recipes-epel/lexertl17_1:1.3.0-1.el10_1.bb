# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lexertl17"
PE = "1"
PV = "1.3.0"
PR = "1.el10_1"
PACKAGES = " \
 lexertl17-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lexertl17-1.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73b2955025f090f4bfb5c7abdda02a90d0bbfd9d6df3fa0e0589f5c677f9754f"

URI_x86_64_v2_lexertl17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lexertl17-devel-1.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lexertl17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lexertl17-devel}"
SRC_URI[x86_64_v2_lexertl17-devel.sha256sum] = "32ed59866da5ab1ed5d2576930b6f0c8a1395d09100ef4b044eee8135a82b49a"

URI_aarch64_lexertl17-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lexertl17-devel-1.3.0-1.el10_1.aarch64.rpm;name=aarch64_lexertl17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lexertl17-devel}"
SRC_URI[aarch64_lexertl17-devel.sha256sum] = "eb4e38b58ebf52460f2bf7eb2980210d1b7d9b86c1d694d125c049187b6ca643"

RDEPENDS:lexertl17-devel = " \
 cmake-filesystem \
 "
