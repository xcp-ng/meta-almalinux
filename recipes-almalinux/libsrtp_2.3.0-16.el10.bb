# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsrtp"
PV = "2.3.0"
PR = "16.el10"
PACKAGES = " \
 libsrtp \
 libsrtp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsrtp-2.3.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f13aa71884e1889e9b370b00810448ee6d259a42633c926e8e39a29583bd5b57"

URI_x86_64_v2_libsrtp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsrtp-2.3.0-16.el10.x86_64_v2.rpm;name=x86_64_v2_libsrtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsrtp}"
SRC_URI[x86_64_v2_libsrtp.sha256sum] = "aa1546a1753578f63a2b38b4c90919a972bc2ba7f48689504518af0b3f519e3c"

URI_x86_64_v2_libsrtp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsrtp-devel-2.3.0-16.el10.x86_64_v2.rpm;name=x86_64_v2_libsrtp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsrtp-devel}"
SRC_URI[x86_64_v2_libsrtp-devel.sha256sum] = "dae3d9c9dcf5b7d1053dc28aac1261ed3bdba5cb00b126cce2783976bc0ead33"

URI_aarch64_libsrtp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsrtp-2.3.0-16.el10.aarch64.rpm;name=aarch64_libsrtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsrtp}"
SRC_URI[aarch64_libsrtp.sha256sum] = "fbc5b5ff3cb8f9ca11d7979bc837fa3df2451db290640cad156bbb2953a8b85c"

URI_aarch64_libsrtp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsrtp-devel-2.3.0-16.el10.aarch64.rpm;name=aarch64_libsrtp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsrtp-devel}"
SRC_URI[aarch64_libsrtp-devel.sha256sum] = "e6d402297a8a0226c167cf63c6120d85ae0d06fda7776cd27b62f09f702d9129"

RDEPENDS:libsrtp = " \
 glibc \
 nspr \
 nss \
 "
RDEPENDS:libsrtp-devel = " \
 libsrtp \
 pkgconf-pkg-config \
 "
