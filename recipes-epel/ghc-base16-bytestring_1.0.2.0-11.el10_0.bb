# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-base16-bytestring"
PV = "1.0.2.0"
PR = "11.el10_0"
PACKAGES = " \
 ghc-base16-bytestring \
 ghc-base16-bytestring-devel \
 ghc-base16-bytestring-doc \
 ghc-base16-bytestring-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-base16-bytestring-1.0.2.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e229bb4567511593da70dfcea5c0eccdcc3852a2e81944d3a68f3180dc86655"

URI_x86_64_v2_ghc-base16-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base16-bytestring-1.0.2.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base16-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base16-bytestring}"
SRC_URI[x86_64_v2_ghc-base16-bytestring.sha256sum] = "d5e65fa4e514f2398ff923ef058d9a21376e114660b81d363c27268720c0c480"

URI_x86_64_v2_ghc-base16-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base16-bytestring-devel-1.0.2.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base16-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base16-bytestring-devel}"
SRC_URI[x86_64_v2_ghc-base16-bytestring-devel.sha256sum] = "1b68a04193c72004303503e2a74446b4c2ff826653e4ba5808f7fac77ec6a41e"

URI_x86_64_v2_ghc-base16-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base16-bytestring-doc-1.0.2.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-base16-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base16-bytestring-doc}"
SRC_URI[x86_64_v2_ghc-base16-bytestring-doc.sha256sum] = "7770ea350543666ea2daf7b6619415bad92ff3c56d92e9926bbeb0c701f22ce5"

URI_x86_64_v2_ghc-base16-bytestring-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-base16-bytestring-prof-1.0.2.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-base16-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-base16-bytestring-prof}"
SRC_URI[x86_64_v2_ghc-base16-bytestring-prof.sha256sum] = "3b6502839200510f94c5fbc2bc21f036f7c0405b643606bd32c3518976598b60"

URI_aarch64_ghc-base16-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base16-bytestring-1.0.2.0-11.el10_0.aarch64.rpm;name=aarch64_ghc-base16-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base16-bytestring}"
SRC_URI[aarch64_ghc-base16-bytestring.sha256sum] = "2280f59b90488761ff66724d5f8a73e3a6b05cb9d04692da97196fe0cc48fd5c"

URI_aarch64_ghc-base16-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base16-bytestring-devel-1.0.2.0-11.el10_0.aarch64.rpm;name=aarch64_ghc-base16-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base16-bytestring-devel}"
SRC_URI[aarch64_ghc-base16-bytestring-devel.sha256sum] = "897e014154d95e71fbf1a07af22c04c6c34636c10811f3085f1f83d169b91b7b"

URI_aarch64_ghc-base16-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base16-bytestring-doc-1.0.2.0-11.el10_0.noarch.rpm;name=aarch64_ghc-base16-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base16-bytestring-doc}"
SRC_URI[aarch64_ghc-base16-bytestring-doc.sha256sum] = "ede8245a56eda1661de9986f00d8c41143d647167d5d3cbf8ebffe7eb3ec5d44"

URI_aarch64_ghc-base16-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-base16-bytestring-prof-1.0.2.0-11.el10_0.aarch64.rpm;name=aarch64_ghc-base16-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-base16-bytestring-prof}"
SRC_URI[aarch64_ghc-base16-bytestring-prof.sha256sum] = "2b7ded94cd8e0171c42d9c014f3031fe77d9723e83c3da20e2cdf68fe90f2312"

RDEPENDS:ghc-base16-bytestring = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-base16-bytestring-devel = " \
 ghc-base-devel \
 ghc-base16-bytestring \
 ghc-bytestring-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-base16-bytestring-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-base16-bytestring-prof = " \
 ghc-base-prof \
 ghc-base16-bytestring-devel \
 ghc-bytestring-prof \
 "
