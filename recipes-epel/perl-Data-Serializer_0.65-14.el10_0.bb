# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Serializer"
PV = "0.65"
PR = "14.el10_0"
PACKAGES = " \
 perl-Data-Serializer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Serializer-0.65-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbec9323546e203316883fd9fd959107cad752a1393746154e6417f51b7e23dd"

URI_x86_64_v2_perl-Data-Serializer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Serializer-0.65-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Serializer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Serializer}"
SRC_URI[x86_64_v2_perl-Data-Serializer.sha256sum] = "b5328ebaa0b80bfad05c82154e2d72c1539b8f54503515baee3198cc599d5d6f"

URI_aarch64_perl-Data-Serializer = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Serializer-0.65-14.el10_0.noarch.rpm;name=aarch64_perl-Data-Serializer;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Serializer}"
SRC_URI[aarch64_perl-Data-Serializer.sha256sum] = "01ff2fa3d32a8cb4dc1c9a8e7f7e96c428a66665c5b4e47325c05891a2c32a9c"

RDEPENDS:perl-Data-Serializer = " \
 perl-Bencode \
 perl-Carp \
 perl-Config-General \
 perl-Convert-Bencode \
 perl-Convert-Bencode_XS \
 perl-Crypt-Blowfish \
 perl-Crypt-CBC \
 perl-Data-Denter \
 perl-Data-Dumper \
 perl-Data-Taxi \
 perl-Digest \
 perl-Digest-SHA \
 perl-FreezeThaw \
 perl-IO \
 perl-IO-Compress \
 perl-JSON \
 perl-PHP-Serialization \
 perl-Storable \
 perl-XML-Dumper \
 perl-XML-Simple \
 perl-YAML \
 perl-YAML-Syck \
 perl-libs \
 perl-vars \
 "
