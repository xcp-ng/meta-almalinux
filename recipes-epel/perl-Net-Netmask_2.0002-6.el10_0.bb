# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-Netmask"
PV = "2.0002"
PR = "6.el10_0"
PACKAGES = " \
 perl-Net-Netmask \
 perl-Net-Netmask-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-Netmask-2.0002-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49ce68884ffe545bdf5cba400f86dedd1f0626b803b5b5f7d1d8f69575cb2fc2"

URI_x86_64_v2_perl-Net-Netmask = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-Netmask-2.0002-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-Netmask;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Netmask}"
SRC_URI[x86_64_v2_perl-Net-Netmask.sha256sum] = "99de3c6d9587e3038c61d335144e006d6498b709c8a45bae1196d21df930edc8"

URI_x86_64_v2_perl-Net-Netmask-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-Netmask-tests-2.0002-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-Netmask-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Netmask-tests}"
SRC_URI[x86_64_v2_perl-Net-Netmask-tests.sha256sum] = "514d84630a25f470cbd6b48545cbd341ce735bc0d71a42f193cea5aa0b453d20"

URI_aarch64_perl-Net-Netmask = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-Netmask-2.0002-6.el10_0.noarch.rpm;name=aarch64_perl-Net-Netmask;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Netmask}"
SRC_URI[aarch64_perl-Net-Netmask.sha256sum] = "487e1758086a06e6284b4aa4312ee55b1fd8473be8510990a1097001524321d0"

URI_aarch64_perl-Net-Netmask-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-Netmask-tests-2.0002-6.el10_0.noarch.rpm;name=aarch64_perl-Net-Netmask-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Netmask-tests}"
SRC_URI[aarch64_perl-Net-Netmask-tests.sha256sum] = "cb246b0339e66f3efba313c606684590b87b60caa9905a86f2af4b0c756f5813"

RDEPENDS:perl-Net-Netmask = " \
 perl-Carp \
 perl-Exporter \
 perl-Math-BigInt \
 perl-POSIX \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:perl-Net-Netmask-tests = " \
 bash \
 perl-Benchmark \
 perl-Carp \
 perl-Net-Netmask \
 perl-Test-Harness \
 perl-Test-UseAllModules \
 perl-Test2-Suite \
 perl-interpreter \
 perl-libs \
 "
