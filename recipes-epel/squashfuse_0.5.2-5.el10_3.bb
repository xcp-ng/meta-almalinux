# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "squashfuse"
PV = "0.5.2"
PR = "5.el10_3"
PACKAGES = " \
 squashfuse \
 squashfuse-devel \
 squashfuse-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/squashfuse-0.5.2-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "901bf0ab3faef0bb747642685fbd4205df59a9a39816a9368c9397168c4f64ff"

URI_x86_64_v2_squashfuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squashfuse-0.5.2-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squashfuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squashfuse}"
SRC_URI[x86_64_v2_squashfuse.sha256sum] = "36488c5d662e794d0f69114e55c9372db4a49ef66508ad8769dec31d9ece8237"
RPROVIDES:squashfuse:x86_64_v2 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_x86_64_v2_squashfuse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squashfuse-devel-0.5.2-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squashfuse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squashfuse-devel}"
SRC_URI[x86_64_v2_squashfuse-devel.sha256sum] = "1fa4ac5cd81901da504d8fbdafcd43b1a7bf8b9ff0c81817e5968460fe571793"

URI_x86_64_v2_squashfuse-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squashfuse-libs-0.5.2-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squashfuse-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squashfuse-libs}"
SRC_URI[x86_64_v2_squashfuse-libs.sha256sum] = "606a19a085501642de066d4dee6baff6b5235ec31e10bd69d487cd919af5e60e"

URI_aarch64_squashfuse = "${EPEL_MIRROR}/aarch64/Packages/s/squashfuse-0.5.2-5.el10_3.aarch64.rpm;name=aarch64_squashfuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_squashfuse}"
SRC_URI[aarch64_squashfuse.sha256sum] = "356747e807fdff71e5a3a5028120c6ca31a7622db5be5bee6a622d434cc4e819"
RPROVIDES:squashfuse:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_squashfuse-devel = "${EPEL_MIRROR}/aarch64/Packages/s/squashfuse-devel-0.5.2-5.el10_3.aarch64.rpm;name=aarch64_squashfuse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_squashfuse-devel}"
SRC_URI[aarch64_squashfuse-devel.sha256sum] = "763e6f8a0872e9b4c6a86bdb9bf483d7838d327f11d308902a1ce9102295ba95"

URI_aarch64_squashfuse-libs = "${EPEL_MIRROR}/aarch64/Packages/s/squashfuse-libs-0.5.2-5.el10_3.aarch64.rpm;name=aarch64_squashfuse-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_squashfuse-libs}"
SRC_URI[aarch64_squashfuse-libs.sha256sum] = "d8555d6e7b3fa79316834ee8dd3ded1a55ccee6f5b94eac1b413bab6d91ea304"

RDEPENDS:squashfuse = " \
 fuse3-libs \
 glibc \
 libzstd \
 lz4-libs \
 squashfuse-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:squashfuse-devel = " \
 pkgconf-pkg-config \
 squashfuse-libs \
 "
RDEPENDS:squashfuse-libs = " \
 fuse3-libs \
 glibc \
 libzstd \
 lz4-libs \
 xz-libs \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

PROVIDES:append:aarch64 = " rpm/virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"
