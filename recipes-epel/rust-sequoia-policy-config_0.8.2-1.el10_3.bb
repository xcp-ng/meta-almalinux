# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-policy-config"
PV = "0.8.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-sequoia-policy-config+crypto-nettle-devel \
 rust-sequoia-policy-config+crypto-openssl-devel \
 rust-sequoia-policy-config+default-devel \
 rust-sequoia-policy-config-devel \
 sequoia-policy-config \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-policy-config-0.8.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7dfde0fdc24385b5eef6e2fdbfbc9e8f71fff049b1424aed448d432a8584c841"

URI_x86_64_v2_rust-sequoia-policy-config+crypto-nettle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-policy-config+crypto-nettle-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-policy-config+crypto-nettle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-policy-config+crypto-nettle-devel}"
SRC_URI[x86_64_v2_rust-sequoia-policy-config+crypto-nettle-devel.sha256sum] = "e4809c624fa433e03e65cd58a103bfda5ba56b4c1eb3f64a976fd6c4513245b3"

URI_x86_64_v2_rust-sequoia-policy-config+crypto-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-policy-config+crypto-openssl-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-policy-config+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-policy-config+crypto-openssl-devel}"
SRC_URI[x86_64_v2_rust-sequoia-policy-config+crypto-openssl-devel.sha256sum] = "081a6989a3a0cc8f5eb4e61c07b8583f63117e0b46c4ff61927fb43cc7a1b7dd"

URI_x86_64_v2_rust-sequoia-policy-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-policy-config+default-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-policy-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-policy-config+default-devel}"
SRC_URI[x86_64_v2_rust-sequoia-policy-config+default-devel.sha256sum] = "562c43057c1b55761d82d057c47467bbc86e42578629df12d251f95c6d664fb9"

URI_x86_64_v2_rust-sequoia-policy-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-policy-config-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-policy-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-policy-config-devel}"
SRC_URI[x86_64_v2_rust-sequoia-policy-config-devel.sha256sum] = "dd5fdf8e8eb8ac52efde6241fa0219217fb4a876724c09abe9d9bb30a506c24d"

URI_x86_64_v2_sequoia-policy-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sequoia-policy-config-0.8.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sequoia-policy-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sequoia-policy-config}"
SRC_URI[x86_64_v2_sequoia-policy-config.sha256sum] = "cde37e2e4af97533b426bf21bae19f8d7dc44ed78df8a45b9cd478e2d4183a44"

URI_aarch64_rust-sequoia-policy-config+crypto-nettle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-policy-config+crypto-nettle-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-policy-config+crypto-nettle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-policy-config+crypto-nettle-devel}"
SRC_URI[aarch64_rust-sequoia-policy-config+crypto-nettle-devel.sha256sum] = "2d3ae7471a90a27de7438744da72f69c72f847c871d3ee20df6eaceb7f7494bc"

URI_aarch64_rust-sequoia-policy-config+crypto-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-policy-config+crypto-openssl-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-policy-config+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-policy-config+crypto-openssl-devel}"
SRC_URI[aarch64_rust-sequoia-policy-config+crypto-openssl-devel.sha256sum] = "db27293fd66c5fd2b7ac5e5a2a40a89ac82e5b0f067e7beb76b72f1cbce5728b"

URI_aarch64_rust-sequoia-policy-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-policy-config+default-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-policy-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-policy-config+default-devel}"
SRC_URI[aarch64_rust-sequoia-policy-config+default-devel.sha256sum] = "dfc73dd1746fcf511c02418c0229b0f2a9be7d3148a44b8f656245f9c555e5c1"

URI_aarch64_rust-sequoia-policy-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-policy-config-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-sequoia-policy-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-policy-config-devel}"
SRC_URI[aarch64_rust-sequoia-policy-config-devel.sha256sum] = "c7678059969399dba2d96312190860195dabf6d02b37b5df9a5963fb881311b0"

URI_aarch64_sequoia-policy-config = "${EPEL_MIRROR}/aarch64/Packages/s/sequoia-policy-config-0.8.2-1.el10_3.aarch64.rpm;name=aarch64_sequoia-policy-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_sequoia-policy-config}"
SRC_URI[aarch64_sequoia-policy-config.sha256sum] = "d7de9530f13c734334474808aaa390a3b9a2fa5fcf69cb930cfbcf507e1b4719"

RDEPENDS:rust-sequoia-policy-config+crypto-nettle-devel = " \
 cargo \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-policy-config-devel \
 "
RDEPENDS:rust-sequoia-policy-config+crypto-openssl-devel = " \
 cargo \
 rust-sequoia-openpgp+crypto-openssl-devel \
 rust-sequoia-policy-config-devel \
 "
RDEPENDS:rust-sequoia-policy-config+default-devel = " \
 cargo \
 rust-sequoia-policy-config-devel \
 "
RDEPENDS:rust-sequoia-policy-config-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-chrono+default-devel \
 rust-sequoia-openpgp-devel \
 rust-serde+default-devel \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~ \
 "
RDEPENDS:sequoia-policy-config = " \
 glibc \
 libgcc \
 openssl-libs \
 "
