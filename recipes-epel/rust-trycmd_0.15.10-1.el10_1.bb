# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trycmd"
PV = "0.15.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-trycmd+color-auto-devel \
 rust-trycmd+color-devel \
 rust-trycmd+debug-devel \
 rust-trycmd+default-devel \
 rust-trycmd+diff-devel \
 rust-trycmd+escargot-devel \
 rust-trycmd+examples-devel \
 rust-trycmd+filesystem-devel \
 rust-trycmd+schema-devel \
 rust-trycmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-trycmd-0.15.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "165f9dc122dbf8c033905bee0e26457e0997303fd3aa12ae154ed173a8bd90a5"

URI_x86_64_v2_rust-trycmd+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+color-auto-devel-0.15.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+color-auto-devel}"
SRC_URI[x86_64_v2_rust-trycmd+color-auto-devel.sha256sum] = "66ebfd88b3e8123b09e647216b1a674c0a937059e3d357a255cc111f72be496e"

URI_x86_64_v2_rust-trycmd+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+color-devel-0.15.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+color-devel}"
SRC_URI[x86_64_v2_rust-trycmd+color-devel.sha256sum] = "c71d116348dbea59cb9d2fa0c9f545d6428be179758eb0d196c0eb033a6acc7b"

URI_x86_64_v2_rust-trycmd+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+debug-devel-0.15.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+debug-devel}"
SRC_URI[x86_64_v2_rust-trycmd+debug-devel.sha256sum] = "c625b958fa413e991e379ef51c0f531d35048b1d2d5ca2655ae0e3ee0ddde399"

URI_x86_64_v2_rust-trycmd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+default-devel-0.15.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+default-devel}"
SRC_URI[x86_64_v2_rust-trycmd+default-devel.sha256sum] = "40a57bb0ae2e6ccd2932510953c93dcebe1ea3a0ea3ce1f365eee62e35440dc8"

URI_x86_64_v2_rust-trycmd+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+diff-devel-0.15.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+diff-devel}"
SRC_URI[x86_64_v2_rust-trycmd+diff-devel.sha256sum] = "2c903cacdafe77f9dd05896b0327b1312002079508c376a6da138b335bf88ee2"

URI_x86_64_v2_rust-trycmd+escargot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+escargot-devel-0.15.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+escargot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+escargot-devel}"
SRC_URI[x86_64_v2_rust-trycmd+escargot-devel.sha256sum] = "9e34bde79c49e1df211a1437f973cdcc5c08b4b1b1cce8986143a9d5854f42a4"

URI_x86_64_v2_rust-trycmd+examples-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+examples-devel-0.15.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+examples-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+examples-devel}"
SRC_URI[x86_64_v2_rust-trycmd+examples-devel.sha256sum] = "c785f214ee2ac94a9cc42ae6dd5884f666ea2112e971f0a849a2c7edd37677f7"

URI_x86_64_v2_rust-trycmd+filesystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+filesystem-devel-0.15.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+filesystem-devel}"
SRC_URI[x86_64_v2_rust-trycmd+filesystem-devel.sha256sum] = "c7ebf9ea64dca54e5ae05120ca97c01923049fe448dd7aac6b2d066f6703ac54"

URI_x86_64_v2_rust-trycmd+schema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd+schema-devel-0.15.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd+schema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd+schema-devel}"
SRC_URI[x86_64_v2_rust-trycmd+schema-devel.sha256sum] = "d0923bb13fb5ebe03687922cea897f0307697543d0e2dec1ec044932c4cbec16"

URI_x86_64_v2_rust-trycmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trycmd-devel-0.15.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trycmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trycmd-devel}"
SRC_URI[x86_64_v2_rust-trycmd-devel.sha256sum] = "37d933ea9fa36a4942a81ea71ca897b289422a4adea6de17c29959d5edfa5328"

URI_aarch64_rust-trycmd+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+color-auto-devel-0.15.10-1.el10_1.noarch.rpm;name=aarch64_rust-trycmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+color-auto-devel}"
SRC_URI[aarch64_rust-trycmd+color-auto-devel.sha256sum] = "8df2e9535d885212498bab4c2650a0e747163e5f1f700e73a1f7e47658083161"

URI_aarch64_rust-trycmd+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+color-devel-0.15.10-1.el10_1.noarch.rpm;name=aarch64_rust-trycmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+color-devel}"
SRC_URI[aarch64_rust-trycmd+color-devel.sha256sum] = "c68b6f3bddad27cdc57f8d1d0a864a13889ec05606e67c243585bab04f12c215"

URI_aarch64_rust-trycmd+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+debug-devel-0.15.10-1.el10_1.noarch.rpm;name=aarch64_rust-trycmd+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+debug-devel}"
SRC_URI[aarch64_rust-trycmd+debug-devel.sha256sum] = "23d2aefdad7b411492c8abd7a4c4e331edf28bceb4d0454866eedb9df5975caf"

URI_aarch64_rust-trycmd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+default-devel-0.15.10-1.el10_1.noarch.rpm;name=aarch64_rust-trycmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+default-devel}"
SRC_URI[aarch64_rust-trycmd+default-devel.sha256sum] = "7c6e770d5fb2c3de88d15cb918819ca31052f5155e90afd17137ac82e6fe0af4"

URI_aarch64_rust-trycmd+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+diff-devel-0.15.10-1.el10_1.noarch.rpm;name=aarch64_rust-trycmd+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+diff-devel}"
SRC_URI[aarch64_rust-trycmd+diff-devel.sha256sum] = "bdca9951b5b22bc992996b3bf69d5bda18fb8312553eecc07b664b22b57563af"

URI_aarch64_rust-trycmd+escargot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+escargot-devel-0.15.10-1.el10_1.noarch.rpm;name=aarch64_rust-trycmd+escargot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+escargot-devel}"
SRC_URI[aarch64_rust-trycmd+escargot-devel.sha256sum] = "9014ce2634dd18bb6d1d181c06cd236d10f3c999aca9d8613593197f399cac63"

URI_aarch64_rust-trycmd+examples-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+examples-devel-0.15.10-1.el10_1.noarch.rpm;name=aarch64_rust-trycmd+examples-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+examples-devel}"
SRC_URI[aarch64_rust-trycmd+examples-devel.sha256sum] = "58713a362ce0588ff9601d3c4b121cedeec81846cbcf68a5399deac0208bb211"

URI_aarch64_rust-trycmd+filesystem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+filesystem-devel-0.15.10-1.el10_1.noarch.rpm;name=aarch64_rust-trycmd+filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+filesystem-devel}"
SRC_URI[aarch64_rust-trycmd+filesystem-devel.sha256sum] = "773f47694750ad8cf649577f52aba7b3bdf8e71a97eda1f1982127905b05b091"

URI_aarch64_rust-trycmd+schema-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd+schema-devel-0.15.10-1.el10_1.noarch.rpm;name=aarch64_rust-trycmd+schema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd+schema-devel}"
SRC_URI[aarch64_rust-trycmd+schema-devel.sha256sum] = "975a31254786bf7a8f235daaf1bd7c3dafea3e7922d0987f67abd2a51d66d2eb"

URI_aarch64_rust-trycmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trycmd-devel-0.15.10-1.el10_1.noarch.rpm;name=aarch64_rust-trycmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trycmd-devel}"
SRC_URI[aarch64_rust-trycmd-devel.sha256sum] = "e5e2330f433ae8e3dc6aace6abd6a78a97c7176a500223a464e3ceeba7b2d666"

RDEPENDS:rust-trycmd+color-auto-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-trycmd+color-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox+color-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+debug-devel = " \
 cargo \
 rust-snapbox+debug-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+default-devel = " \
 cargo \
 rust-trycmd+color-auto-devel \
 rust-trycmd+diff-devel \
 rust-trycmd+filesystem-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+diff-devel = " \
 cargo \
 rust-snapbox+diff-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+escargot-devel = " \
 cargo \
 rust-escargot+default-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+examples-devel = " \
 cargo \
 rust-snapbox+examples-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+filesystem-devel = " \
 cargo \
 rust-snapbox+dir-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd+schema-devel = " \
 cargo \
 rust-schemars0.8+default-devel \
 rust-schemars0.8+preserve_order-devel \
 rust-serde_json+default-devel \
 rust-trycmd-devel \
 "
RDEPENDS:rust-trycmd-devel = " \
 cargo \
 rust \
 rust-automod+default-devel \
 rust-glob+default-devel \
 rust-humantime+default-devel \
 rust-humantime-serde+default-devel \
 rust-rayon+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-shlex+default-devel \
 rust-snapbox+cmd-devel \
 rust-snapbox-devel \
 rust-toml_edit+default-devel \
 rust-toml_edit+serde-devel \
 "
