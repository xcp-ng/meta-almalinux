# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matchit"
PV = "0.8.6"
PR = "2.el10_0"
PACKAGES = " \
 rust-matchit+default-devel \
 rust-matchit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matchit-0.8.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd7e76b7154df35475f94791389ae3f9cf7a8033708fc6d0f2ff5e1cc6b72a3f"

URI_x86_64_v2_rust-matchit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit+default-devel-0.8.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit+default-devel}"
SRC_URI[x86_64_v2_rust-matchit+default-devel.sha256sum] = "5804410302a1548b7c95687cfb14a6624f3cf4648fab540ccb5f13db0c135e91"

URI_x86_64_v2_rust-matchit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit-devel-0.8.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit-devel}"
SRC_URI[x86_64_v2_rust-matchit-devel.sha256sum] = "1d86c21c14c77a3ccc88fb601304214955f95858353e7bca8a214191a0525bbe"

URI_aarch64_rust-matchit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit+default-devel-0.8.6-2.el10_0.noarch.rpm;name=aarch64_rust-matchit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit+default-devel}"
SRC_URI[aarch64_rust-matchit+default-devel.sha256sum] = "a033a2447c6b01a56c0a2a452e68d0350e77b71dcff9101bfa2bd9c57c50b534"

URI_aarch64_rust-matchit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit-devel-0.8.6-2.el10_0.noarch.rpm;name=aarch64_rust-matchit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit-devel}"
SRC_URI[aarch64_rust-matchit-devel.sha256sum] = "3e4283bb144f007fe6463de0120c28102161549787f84993afb2f17630680d05"

RDEPENDS:rust-matchit+default-devel = " \
 cargo \
 rust-matchit-devel \
 "
RDEPENDS:rust-matchit-devel = " \
 cargo \
 "
