# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-httpcore"
PV = "1.0.7"
PR = "8.el10_0"
PACKAGES = " \
 python3-httpcore \
 python3-httpcore+http2 \
 python3-httpcore+socks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-httpcore-1.0.7-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c87fa5bfa1f0a3d26f0d33bad50eb023cdc767944d3d36b32ea71773283ef2f"

URI_x86_64_v2_python3-httpcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpcore-1.0.7-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpcore}"
SRC_URI[x86_64_v2_python3-httpcore.sha256sum] = "472e6cf182f5f5db6c503cd2e4b48b7be4c7ba6d5cfc802be72a15775d525c98"

URI_x86_64_v2_python3-httpcore+http2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpcore+http2-1.0.7-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpcore+http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpcore+http2}"
SRC_URI[x86_64_v2_python3-httpcore+http2.sha256sum] = "2f9edca6ebe1c797045d42dad40ee773747c502e1453da72fbfa5c9ca872813a"

URI_x86_64_v2_python3-httpcore+socks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpcore+socks-1.0.7-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpcore+socks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpcore+socks}"
SRC_URI[x86_64_v2_python3-httpcore+socks.sha256sum] = "e9a06ee90fc4f536a16b28d4d9f2442d905110c85b2440105403cb97f164ff78"

URI_aarch64_python3-httpcore = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpcore-1.0.7-8.el10_0.noarch.rpm;name=aarch64_python3-httpcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpcore}"
SRC_URI[aarch64_python3-httpcore.sha256sum] = "060d4da7e76eb64917df7e73c45b6fc9e3cf5d4b0f9de695bc3e756938e751ea"

URI_aarch64_python3-httpcore+http2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpcore+http2-1.0.7-8.el10_0.noarch.rpm;name=aarch64_python3-httpcore+http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpcore+http2}"
SRC_URI[aarch64_python3-httpcore+http2.sha256sum] = "26bd2fae4b6568fee323f65fd51d2c88aebbdf963b7c4f60f5bf0f25e76ebc23"

URI_aarch64_python3-httpcore+socks = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpcore+socks-1.0.7-8.el10_0.noarch.rpm;name=aarch64_python3-httpcore+socks;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpcore+socks}"
SRC_URI[aarch64_python3-httpcore+socks.sha256sum] = "489dbe2e8166e58519f0069fd415ad8d4c29a6f2bd3105a9d8fedc6eda4c0241"

RDEPENDS:python3-httpcore = " \
 python3 \
 python3-certifi \
 python3-h11 \
 "
RDEPENDS:python3-httpcore+http2 = " \
 python3 \
 python3-h2 \
 python3-httpcore \
 "
RDEPENDS:python3-httpcore+socks = " \
 python3 \
 python3-httpcore \
 python3-socksio \
 "
