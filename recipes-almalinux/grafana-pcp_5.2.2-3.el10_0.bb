# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana-pcp"
PV = "5.2.2"
PR = "3.el10_0"
PACKAGES = " \
 grafana-pcp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-pcp-5.2.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ad8fd29d47b99043fe662cceba95c080a0340285f6c3fb6998f08779e36176b"

URI_x86_64_v2_grafana-pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-pcp-5.2.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_grafana-pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grafana-pcp}"
SRC_URI[x86_64_v2_grafana-pcp.sha256sum] = "fa4c1ed7ba2906c223fc707be9a09776510b094cf09dad0aeb0ab5bd0cc078df"

URI_aarch64_grafana-pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-pcp-5.2.2-3.el10_0.aarch64.rpm;name=aarch64_grafana-pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_grafana-pcp}"
SRC_URI[aarch64_grafana-pcp.sha256sum] = "f7957da8ce83235c08ec451854967106b1f97eb0fe8a042b83a8fd1b470c9bae"

RDEPENDS:grafana-pcp = " \
 bash \
 glibc \
 grafana \
 systemd \
 "
