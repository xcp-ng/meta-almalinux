# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librabbitmq"
PV = "0.14.0"
PR = "3.el10"
PACKAGES = " \
 librabbitmq \
 librabbitmq-devel \
 librabbitmq-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/librabbitmq-0.14.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66f22509d513d3651f77e07bf00a3471cd13b808941c8da8abd1fb52964e0d37"

URI_x86_64_v2_librabbitmq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/librabbitmq-0.14.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_librabbitmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librabbitmq}"
SRC_URI[x86_64_v2_librabbitmq.sha256sum] = "3e7f9e55c40fc91778b475921f02c07b586f170bcb34caab08276fc6264145f7"

URI_x86_64_v2_librabbitmq-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/librabbitmq-devel-0.14.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_librabbitmq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librabbitmq-devel}"
SRC_URI[x86_64_v2_librabbitmq-devel.sha256sum] = "f12cc43e261f3e983a7504c78d533f55de28b2c00f8e281f66412d9830e209d3"

URI_x86_64_v2_librabbitmq-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/librabbitmq-tools-0.14.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_librabbitmq-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librabbitmq-tools}"
SRC_URI[x86_64_v2_librabbitmq-tools.sha256sum] = "ac4ab378315781b03b0203dc23d4b18e3f1d7513289dad8c0b9ef4e5f83c4891"

URI_aarch64_librabbitmq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/librabbitmq-0.14.0-3.el10.aarch64.rpm;name=aarch64_librabbitmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_librabbitmq}"
SRC_URI[aarch64_librabbitmq.sha256sum] = "fc3acccff5332f92b59dc407aca58d8b1ee494424d6480ba8f22fe685ff2b1e6"

URI_aarch64_librabbitmq-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/librabbitmq-devel-0.14.0-3.el10.aarch64.rpm;name=aarch64_librabbitmq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librabbitmq-devel}"
SRC_URI[aarch64_librabbitmq-devel.sha256sum] = "d3f59775b6c29ff2eccffd54bb538e23392412656caf66a622abfcac2a8ae852"

URI_aarch64_librabbitmq-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/librabbitmq-tools-0.14.0-3.el10.aarch64.rpm;name=aarch64_librabbitmq-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_librabbitmq-tools}"
SRC_URI[aarch64_librabbitmq-tools.sha256sum] = "79feed0cd95f8b5db89da3cc8581b58d4329437deace744158c43b4202e3f5ce"

RDEPENDS:librabbitmq = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:librabbitmq-devel = " \
 cmake-filesystem \
 librabbitmq \
 pkgconf-pkg-config \
 "
RDEPENDS:librabbitmq-tools = " \
 glibc \
 librabbitmq \
 popt \
 "
