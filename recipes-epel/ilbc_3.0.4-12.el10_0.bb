# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ilbc"
PV = "3.0.4"
PR = "12.el10_0"
PACKAGES = " \
 ilbc \
 ilbc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ilbc-3.0.4-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c0ffd95470a663d15764ed5a74f26bc9d534166eb93b2629a6a0850f26da1c4"

URI_x86_64_v2_ilbc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ilbc-3.0.4-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ilbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ilbc}"
SRC_URI[x86_64_v2_ilbc.sha256sum] = "7a1518aa181160b1bff1c88609c9a4412a3c4fd35e47b19132b5485882228e40"

URI_x86_64_v2_ilbc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ilbc-devel-3.0.4-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ilbc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ilbc-devel}"
SRC_URI[x86_64_v2_ilbc-devel.sha256sum] = "d4700a403638896d09ec5e215e7c1a8a0bf149704cfa4156bfbb28a561973a89"

URI_aarch64_ilbc = "${EPEL_MIRROR}/aarch64/Packages/i/ilbc-3.0.4-12.el10_0.aarch64.rpm;name=aarch64_ilbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ilbc}"
SRC_URI[aarch64_ilbc.sha256sum] = "f296ef74310723ac0d42c00351393467a7bc55fc6ac3843c1e55a6eaacff0f93"

URI_aarch64_ilbc-devel = "${EPEL_MIRROR}/aarch64/Packages/i/ilbc-devel-3.0.4-12.el10_0.aarch64.rpm;name=aarch64_ilbc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ilbc-devel}"
SRC_URI[aarch64_ilbc-devel.sha256sum] = "b44286fd69b977df0df1b67b99aa7285f6d441b13171abd610feafa9e1f31cb3"

RDEPENDS:ilbc = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:ilbc-devel = " \
 glibc \
 ilbc \
 pkgconf-pkg-config \
 "
