# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-beautifulsoup4"
PV = "4.13.3"
PR = "3.el10_0"
PACKAGES = " \
 python3-beautifulsoup4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-beautifulsoup4-4.13.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f28b8c507c8f5128d665949ef66482b7005a6ea8888692c7013a6ed27efb1a9c"

URI_x86_64_v2_python3-beautifulsoup4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-beautifulsoup4-4.13.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-beautifulsoup4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-beautifulsoup4}"
SRC_URI[x86_64_v2_python3-beautifulsoup4.sha256sum] = "d71ac41ec948fcb233d6f2e945524b5025ae42ccb69ac4c6916d33dfa8b80531"

URI_aarch64_python3-beautifulsoup4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-beautifulsoup4-4.13.3-3.el10_0.noarch.rpm;name=aarch64_python3-beautifulsoup4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-beautifulsoup4}"
SRC_URI[aarch64_python3-beautifulsoup4.sha256sum] = "d7b1190618befd226cbe192553ae9c4257aeb9d83f6648da8e04a76a0dd5a016"

RDEPENDS:python3-beautifulsoup4 = " \
 python3 \
 python3-lxml \
 python3-soupsieve \
 python3-typing-extensions \
 "
