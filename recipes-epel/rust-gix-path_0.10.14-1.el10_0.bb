# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-path"
PV = "0.10.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-path+default-devel \
 rust-gix-path-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-path-0.10.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27da1632265358742c807e38980d0840ebb27ca30a44a22f8af1911826dcb674"

URI_x86_64_v2_rust-gix-path+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-path+default-devel-0.10.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-path+default-devel}"
SRC_URI[x86_64_v2_rust-gix-path+default-devel.sha256sum] = "d1cff29a1c8f368882551b9861342afc0dfaa9e0480d80dbfa3508b9522ef999"

URI_x86_64_v2_rust-gix-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-path-devel-0.10.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-path-devel}"
SRC_URI[x86_64_v2_rust-gix-path-devel.sha256sum] = "8c929bdb861faddcae5f442a9398c5ecda266b808af587d09632deed7db1455f"

URI_aarch64_rust-gix-path+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-path+default-devel-0.10.14-1.el10_0.noarch.rpm;name=aarch64_rust-gix-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-path+default-devel}"
SRC_URI[aarch64_rust-gix-path+default-devel.sha256sum] = "4b16295aa57b48d6d57b12ed6e15b7defadf8f78d33a3b7d250183dfde4deaa5"

URI_aarch64_rust-gix-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-path-devel-0.10.14-1.el10_0.noarch.rpm;name=aarch64_rust-gix-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-path-devel}"
SRC_URI[aarch64_rust-gix-path-devel.sha256sum] = "078ccb058af34edb3b5bcf63109a5bdde36fb431a463b4550a29eb167d162849"

RDEPENDS:rust-gix-path+default-devel = " \
 cargo \
 rust-gix-path-devel \
 "
RDEPENDS:rust-gix-path-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-trace+default-devel \
 rust-home+default-devel \
 rust-once_cell+default-devel \
 rust-thiserror+default-devel \
 "
