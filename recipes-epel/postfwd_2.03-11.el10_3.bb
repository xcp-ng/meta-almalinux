# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postfwd"
PV = "2.03"
PR = "11.el10_3"
PACKAGES = " \
 postfwd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/postfwd-2.03-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "538e206c444130fd942908b95552b340adc71a164255847e77b60c13b46756e8"

URI_x86_64_v2_postfwd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/postfwd-2.03-11.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_postfwd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postfwd}"
SRC_URI[x86_64_v2_postfwd.sha256sum] = "49c0370c9efe4d10a3e825ab53abc71892deb148ab36532c2bf5c5c81ce15adc"

URI_aarch64_postfwd = "${EPEL_MIRROR}/aarch64/Packages/p/postfwd-2.03-11.el10_3.noarch.rpm;name=aarch64_postfwd;unpack=0"
SRC_URI:append = " ${URI_aarch64_postfwd}"
SRC_URI[aarch64_postfwd.sha256sum] = "37d3b1be59fab17e76fdb3336bfd5f1bbb2ba0fff08cd606cc731c723c55a252"

RDEPENDS:postfwd = " \
 bash \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Exporter \
 perl-Getopt-Long \
 perl-IO \
 perl-Net-CIDR-Lite \
 perl-Net-DNS \
 perl-Net-Server \
 perl-NetAddr-IP \
 perl-POSIX \
 perl-Pod-Usage \
 perl-Storable \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-podlators \
 perl-vars \
 shadow-utils \
 systemd \
 util-linux-core \
 "
