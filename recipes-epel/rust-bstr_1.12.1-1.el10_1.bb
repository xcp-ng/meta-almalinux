# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bstr"
PV = "1.12.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-bstr+alloc-devel \
 rust-bstr+default-devel \
 rust-bstr+serde-devel \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bstr-1.12.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "566388b361332ed1ce9cd6112f3e9b5b16a3b2c4c8e114758fd0ffa600c0a6c8"

URI_x86_64_v2_rust-bstr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+alloc-devel-1.12.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+alloc-devel}"
SRC_URI[x86_64_v2_rust-bstr+alloc-devel.sha256sum] = "7a31230e142270b496e0a5d0a0060039791a3c0dc0f3c39c7dc9f146e273d3f6"

URI_x86_64_v2_rust-bstr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+default-devel-1.12.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+default-devel}"
SRC_URI[x86_64_v2_rust-bstr+default-devel.sha256sum] = "0c923d536ad21137fb28d46c7f6cc191832095d1e6716ef3c9df434f1068fdf0"

URI_x86_64_v2_rust-bstr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+serde-devel-1.12.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+serde-devel}"
SRC_URI[x86_64_v2_rust-bstr+serde-devel.sha256sum] = "fb88dc4e94fd7036ad90dfcb31b31513e4e987198c3072882f1b6c237f33c3ed"

URI_x86_64_v2_rust-bstr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+std-devel-1.12.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+std-devel}"
SRC_URI[x86_64_v2_rust-bstr+std-devel.sha256sum] = "5fca2cac0f2ec078b1f9a8202b692224a8ce01134d50d13095780b08a49e8880"

URI_x86_64_v2_rust-bstr+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+unicode-devel-1.12.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+unicode-devel}"
SRC_URI[x86_64_v2_rust-bstr+unicode-devel.sha256sum] = "e00e1d6d002b1eaacc1a751052107cf9e36ea1ec6fd4e5d1f72d66b2d4bb326f"

URI_x86_64_v2_rust-bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr-devel-1.12.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr-devel}"
SRC_URI[x86_64_v2_rust-bstr-devel.sha256sum] = "83b2000197cd8404720e2eb0fcb67fc08d4257b6d3b0693d76584dabc7317f28"

URI_aarch64_rust-bstr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+alloc-devel-1.12.1-1.el10_1.noarch.rpm;name=aarch64_rust-bstr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+alloc-devel}"
SRC_URI[aarch64_rust-bstr+alloc-devel.sha256sum] = "669f71be73f576ac3006f8a59fafd991b05637ab81d8a0d2a16789cbca182cce"

URI_aarch64_rust-bstr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+default-devel-1.12.1-1.el10_1.noarch.rpm;name=aarch64_rust-bstr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+default-devel}"
SRC_URI[aarch64_rust-bstr+default-devel.sha256sum] = "ae4e9e8ca638e9b6fbacb53c5f447e90e1c56b114267c19d742311862139104a"

URI_aarch64_rust-bstr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+serde-devel-1.12.1-1.el10_1.noarch.rpm;name=aarch64_rust-bstr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+serde-devel}"
SRC_URI[aarch64_rust-bstr+serde-devel.sha256sum] = "409460cce9fc507db0884eb509959107f2d0e809b8e396540087e208f665c99b"

URI_aarch64_rust-bstr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+std-devel-1.12.1-1.el10_1.noarch.rpm;name=aarch64_rust-bstr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+std-devel}"
SRC_URI[aarch64_rust-bstr+std-devel.sha256sum] = "a2f7c27d33064a7f0f1389eccea1275cb1a4df9b234f1544740beac5ba0e6283"

URI_aarch64_rust-bstr+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+unicode-devel-1.12.1-1.el10_1.noarch.rpm;name=aarch64_rust-bstr+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+unicode-devel}"
SRC_URI[aarch64_rust-bstr+unicode-devel.sha256sum] = "74dd21b459fa8156e78834a060ebf2c99f5ab5319407a8a6cb0d104bcc29dfe7"

URI_aarch64_rust-bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr-devel-1.12.1-1.el10_1.noarch.rpm;name=aarch64_rust-bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr-devel}"
SRC_URI[aarch64_rust-bstr-devel.sha256sum] = "ea743deadd6dee03bcc5646207f345bc77a2272d7023662e611ac39d703e5459"

RDEPENDS:rust-bstr+alloc-devel = " \
 cargo \
 rust-bstr-devel \
 rust-memchr+alloc-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bstr+default-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "
RDEPENDS:rust-bstr+serde-devel = " \
 cargo \
 rust-bstr-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bstr+std-devel = " \
 cargo \
 rust-bstr+alloc-devel \
 rust-bstr-devel \
 rust-memchr+std-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bstr+unicode-devel = " \
 cargo \
 rust-bstr-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-bstr-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
