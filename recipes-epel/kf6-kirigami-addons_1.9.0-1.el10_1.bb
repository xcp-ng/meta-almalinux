# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kirigami-addons"
PV = "1.9.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kirigami-addons \
 kf6-kirigami-addons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kirigami-addons-1.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0ee8c7ffedf03fbf3e5abad59f2f11eadced904007a00d9eb3bf0de2fed9674"

URI_x86_64_v2_kf6-kirigami-addons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-addons-1.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-addons}"
SRC_URI[x86_64_v2_kf6-kirigami-addons.sha256sum] = "adac1885a8349e77342dbaef48b7c476792003939e0b66cebffa55569340946d"

URI_x86_64_v2_kf6-kirigami-addons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-addons-devel-1.9.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-addons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-addons-devel}"
SRC_URI[x86_64_v2_kf6-kirigami-addons-devel.sha256sum] = "20d7cacebfcaf2641705ad6d6dbc3d738333f3125ffcc82a27860c97de1c4647"

URI_aarch64_kf6-kirigami-addons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-addons-1.9.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kirigami-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-addons}"
SRC_URI[aarch64_kf6-kirigami-addons.sha256sum] = "ff93cf9870c6737cdc9bff16cca60682d3fb36882dd10aa9c901bf7d60c5f831"

URI_aarch64_kf6-kirigami-addons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-addons-devel-1.9.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kirigami-addons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-addons-devel}"
SRC_URI[aarch64_kf6-kirigami-addons-devel.sha256sum] = "12001fa9592cb9f597a4c3c0573d43f5f76007d0b7cb0f49273d62ed7cf300b7"

RDEPENDS:kf6-kirigami-addons = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kirigami-addons-devel = " \
 cmake-filesystem \
 kf6-kirigami-addons \
 "
