# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-utf8_iter"
PV = "1.0.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-utf8_iter+default-devel \
 rust-utf8_iter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-utf8_iter-1.0.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc5dc32622e8e5f48bbcb74df52d649145b4964568567d7c8d93942413df42de"

URI_x86_64_v2_rust-utf8_iter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8_iter+default-devel-1.0.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8_iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8_iter+default-devel}"
SRC_URI[x86_64_v2_rust-utf8_iter+default-devel.sha256sum] = "11f89944ccce9df18b8a8f9947fd1747e3d9b2d42454f98b54424ec60f768a27"

URI_x86_64_v2_rust-utf8_iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf8_iter-devel-1.0.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf8_iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf8_iter-devel}"
SRC_URI[x86_64_v2_rust-utf8_iter-devel.sha256sum] = "ed266b7ae2da4b3e349e37bf52fd400780192d90c25ed636281720fe5acccf50"

URI_aarch64_rust-utf8_iter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8_iter+default-devel-1.0.4-1.el10_0.noarch.rpm;name=aarch64_rust-utf8_iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8_iter+default-devel}"
SRC_URI[aarch64_rust-utf8_iter+default-devel.sha256sum] = "1fa24762974fe7618716fccb5816803000505873582fb4bc5b51ab0f8a236158"

URI_aarch64_rust-utf8_iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf8_iter-devel-1.0.4-1.el10_0.noarch.rpm;name=aarch64_rust-utf8_iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf8_iter-devel}"
SRC_URI[aarch64_rust-utf8_iter-devel.sha256sum] = "d89b21fad660e02a50e3d8b0575e2298e1f4d89fd5d6cf7b5929a6853fcc5fa4"

RDEPENDS:rust-utf8_iter+default-devel = " \
 cargo \
 rust-utf8_iter-devel \
 "
RDEPENDS:rust-utf8_iter-devel = " \
 cargo \
 "
