# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unindent"
PV = "0.2.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-unindent+default-devel \
 rust-unindent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unindent-0.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f2a84f123719da3f52fed730a155abdc2e479b8366048afe3241a2bdc6537f3"

URI_x86_64_v2_rust-unindent+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unindent+default-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unindent+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unindent+default-devel}"
SRC_URI[x86_64_v2_rust-unindent+default-devel.sha256sum] = "fa9e67322b1bb6178e9ecff432ee49d368c8d52e0009a53df4c3dbc28085894c"

URI_x86_64_v2_rust-unindent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unindent-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unindent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unindent-devel}"
SRC_URI[x86_64_v2_rust-unindent-devel.sha256sum] = "bdb623cccec6a1ad96923b4a2c10062847a300edff2d94ad25e1cc1cede26859"

URI_aarch64_rust-unindent+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unindent+default-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-unindent+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unindent+default-devel}"
SRC_URI[aarch64_rust-unindent+default-devel.sha256sum] = "f4534c51e21339c1dc53048a15cda28423e3c1341db2b7feb72a98c1ba2df7cc"

URI_aarch64_rust-unindent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unindent-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-unindent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unindent-devel}"
SRC_URI[aarch64_rust-unindent-devel.sha256sum] = "7dd19e797d6ae42343d76e312a4b51de858d49affc3f9f92ed39d095dcc829db"

RDEPENDS:rust-unindent+default-devel = " \
 cargo \
 rust-unindent-devel \
 "
RDEPENDS:rust-unindent-devel = " \
 cargo \
 "
