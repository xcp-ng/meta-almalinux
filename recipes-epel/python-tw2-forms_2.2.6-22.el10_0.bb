# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tw2-forms"
PV = "2.2.6"
PR = "22.el10_0"
PACKAGES = " \
 python3-tw2-forms \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tw2-forms-2.2.6-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73bd6a33b2b9442194620ff8a9c037938487e76f14220779682bdb16f0eba04d"

URI_x86_64_v2_python3-tw2-forms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tw2-forms-2.2.6-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tw2-forms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tw2-forms}"
SRC_URI[x86_64_v2_python3-tw2-forms.sha256sum] = "ac2647d328c0f3b0fe93cdd28a6c7660f2420143e1f65a24baca32dfd609011b"

URI_aarch64_python3-tw2-forms = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tw2-forms-2.2.6-22.el10_0.noarch.rpm;name=aarch64_python3-tw2-forms;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tw2-forms}"
SRC_URI[aarch64_python3-tw2-forms.sha256sum] = "f3813b8692740221ac78fadb0b10cb2efb169a1fcfee7fb1f2f7cf557253d6d3"

RDEPENDS:python3-tw2-forms = " \
 python3 \
 python3-six \
 python3-tw2-core \
 "
