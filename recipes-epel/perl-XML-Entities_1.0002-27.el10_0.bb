# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-Entities"
PV = "1.0002"
PR = "27.el10_0"
PACKAGES = " \
 perl-XML-Entities \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-Entities-1.0002-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da8fcc9dbe1149657bebd3241e5d9042e8d34a528d657b72c22c48a73ce89ac0"

URI_x86_64_v2_perl-XML-Entities = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-Entities-1.0002-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-Entities;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Entities}"
SRC_URI[x86_64_v2_perl-XML-Entities.sha256sum] = "93cd5e0c0386e5b4dd79cf46bce70cb7f408ce983e8555e1fa0a9e9f06eec28c"

URI_aarch64_perl-XML-Entities = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-Entities-1.0002-27.el10_0.noarch.rpm;name=aarch64_perl-XML-Entities;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Entities}"
SRC_URI[aarch64_perl-XML-Entities.sha256sum] = "d97fc06fbbc996227b7d5e94175abd3b84ee941a3927902eea9f24f06df99c92"

RDEPENDS:perl-XML-Entities = " \
 perl-Carp \
 perl-File-Basename \
 perl-autodie \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
