# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-image"
PV = "0.25.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-image+avif-devel \
 rust-image+avif-native-devel \
 rust-image+bmp-devel \
 rust-image+color_quant-devel \
 rust-image+dds-devel \
 rust-image+default-devel \
 rust-image+default-formats-devel \
 rust-image+exr-devel \
 rust-image+ff-devel \
 rust-image+gif-devel \
 rust-image+hdr-devel \
 rust-image+ico-devel \
 rust-image+jpeg-devel \
 rust-image+nasm-devel \
 rust-image+png-devel \
 rust-image+pnm-devel \
 rust-image+qoi-devel \
 rust-image+rayon-devel \
 rust-image+serde-devel \
 rust-image+tga-devel \
 rust-image+tiff-devel \
 rust-image+webp-devel \
 rust-image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-image-0.25.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4331e4e1828e18b61db3330efa599eb5e41c905c28d96f3522271093f98ebcb"

URI_x86_64_v2_rust-image+avif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+avif-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+avif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+avif-devel}"
SRC_URI[x86_64_v2_rust-image+avif-devel.sha256sum] = "080184fbbd92626cf6e043f2eda40e405c7955cda2ebf004c91572e919120cb1"

URI_x86_64_v2_rust-image+avif-native-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+avif-native-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+avif-native-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+avif-native-devel}"
SRC_URI[x86_64_v2_rust-image+avif-native-devel.sha256sum] = "4e7bfddb0e62ae80a8d711c1c276432aa74351bf016e776a8c16652933c4f1bf"

URI_x86_64_v2_rust-image+bmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+bmp-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+bmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+bmp-devel}"
SRC_URI[x86_64_v2_rust-image+bmp-devel.sha256sum] = "d493c4ce1407cd1d4f828566e154b8a35b028799d578d827813c91d0e9691806"

URI_x86_64_v2_rust-image+color_quant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+color_quant-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+color_quant-devel}"
SRC_URI[x86_64_v2_rust-image+color_quant-devel.sha256sum] = "8396e81f38b09a84042ae3b3846628c3f44c770ad528df34ae8480f482856776"

URI_x86_64_v2_rust-image+dds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+dds-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+dds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+dds-devel}"
SRC_URI[x86_64_v2_rust-image+dds-devel.sha256sum] = "5d488fc838424e9af18ccab0f4da7f30e8b01e77123737528de478bc608ac95a"

URI_x86_64_v2_rust-image+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+default-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+default-devel}"
SRC_URI[x86_64_v2_rust-image+default-devel.sha256sum] = "1758b101a183c42958be81cf8f6f6d24318f36717671ba514a2e5bb61a8f1b60"

URI_x86_64_v2_rust-image+default-formats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+default-formats-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+default-formats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+default-formats-devel}"
SRC_URI[x86_64_v2_rust-image+default-formats-devel.sha256sum] = "ecc35de3d7769a91440e7e3e894fa80e226085b61445c019f47426e353c1eeb4"

URI_x86_64_v2_rust-image+exr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+exr-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+exr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+exr-devel}"
SRC_URI[x86_64_v2_rust-image+exr-devel.sha256sum] = "09685687067be7369f71cca5c203f490dfae83a92fcf414c152e6f3442f21590"

URI_x86_64_v2_rust-image+ff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+ff-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+ff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+ff-devel}"
SRC_URI[x86_64_v2_rust-image+ff-devel.sha256sum] = "a0bf97c32d640509aa9807483b239341b9fc1b8c2351cc3f61c2220dc36ab60a"

URI_x86_64_v2_rust-image+gif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+gif-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+gif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+gif-devel}"
SRC_URI[x86_64_v2_rust-image+gif-devel.sha256sum] = "3e2ca896951b3eda1c033e4c146698a362eb14f4cc27a77839ad2b3711c49769"

URI_x86_64_v2_rust-image+hdr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+hdr-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+hdr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+hdr-devel}"
SRC_URI[x86_64_v2_rust-image+hdr-devel.sha256sum] = "fc6627d520e7ab09240e6bbbb57e4bef032fc3bd09648ab1315e3623e6552671"

URI_x86_64_v2_rust-image+ico-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+ico-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+ico-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+ico-devel}"
SRC_URI[x86_64_v2_rust-image+ico-devel.sha256sum] = "59cfa4051f26842b641a36eba2c92774893b7104f4f6b434af817f526520ed39"

URI_x86_64_v2_rust-image+jpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+jpeg-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+jpeg-devel}"
SRC_URI[x86_64_v2_rust-image+jpeg-devel.sha256sum] = "40c4c50386e7ff84f9849ef835074525ea148ba2546086ad959a26a005b8b57a"

URI_x86_64_v2_rust-image+nasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+nasm-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+nasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+nasm-devel}"
SRC_URI[x86_64_v2_rust-image+nasm-devel.sha256sum] = "a78f37fa657650313d81cdfeb6edaebac834aa6622d3e30b2f65ba7a31df7638"

URI_x86_64_v2_rust-image+png-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+png-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+png-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+png-devel}"
SRC_URI[x86_64_v2_rust-image+png-devel.sha256sum] = "08c90d48b259b856020259c33cb10cfec82ed5e3b4193d717316d94e8c2d57b1"

URI_x86_64_v2_rust-image+pnm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+pnm-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+pnm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+pnm-devel}"
SRC_URI[x86_64_v2_rust-image+pnm-devel.sha256sum] = "f1773d0e36e7b3579c5427a1e262ce2422af049194fe7f651a7a841495167612"

URI_x86_64_v2_rust-image+qoi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+qoi-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+qoi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+qoi-devel}"
SRC_URI[x86_64_v2_rust-image+qoi-devel.sha256sum] = "84e81e2d69896ae7e308829af0310baa6ef73f916bb9d4770c09a9cc68516f86"

URI_x86_64_v2_rust-image+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+rayon-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+rayon-devel}"
SRC_URI[x86_64_v2_rust-image+rayon-devel.sha256sum] = "9ad7f9688994567b8abc8c3f3806933d263ae14999423bb6d492e76546734b2b"

URI_x86_64_v2_rust-image+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+serde-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+serde-devel}"
SRC_URI[x86_64_v2_rust-image+serde-devel.sha256sum] = "bc29a74523df92b77a382287db5b025ff1e15a6d4f0429ad59c908446cf4c012"

URI_x86_64_v2_rust-image+tga-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+tga-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+tga-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+tga-devel}"
SRC_URI[x86_64_v2_rust-image+tga-devel.sha256sum] = "3fbe79faaf14ab940632941b7c921b721bdf599ae87d1d8879797e79a808b8f6"

URI_x86_64_v2_rust-image+tiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+tiff-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+tiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+tiff-devel}"
SRC_URI[x86_64_v2_rust-image+tiff-devel.sha256sum] = "d67cf2499815bac77073ea4efcee81aa5b20f0ac902e0fdea57f4ef3abcfebe1"

URI_x86_64_v2_rust-image+webp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+webp-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+webp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+webp-devel}"
SRC_URI[x86_64_v2_rust-image+webp-devel.sha256sum] = "2276dfb6498963c11984bafd133e3646012d576d768b8250abdfa46fb78008e5"

URI_x86_64_v2_rust-image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image-devel-0.25.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image-devel}"
SRC_URI[x86_64_v2_rust-image-devel.sha256sum] = "31eccc3add110de4b4ce3c5f354150fa6f704178b45ca838981309ad5fb6d308"

URI_aarch64_rust-image+avif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+avif-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+avif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+avif-devel}"
SRC_URI[aarch64_rust-image+avif-devel.sha256sum] = "3529237d46b130fc720d9c363d573f0cfa10958dfd49c7cb6ad019b32c40c927"

URI_aarch64_rust-image+avif-native-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+avif-native-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+avif-native-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+avif-native-devel}"
SRC_URI[aarch64_rust-image+avif-native-devel.sha256sum] = "6a1f2d77a416d5f973711112119ceb5793283c82f6dc9647a85d2d67d6a69cbc"

URI_aarch64_rust-image+bmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+bmp-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+bmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+bmp-devel}"
SRC_URI[aarch64_rust-image+bmp-devel.sha256sum] = "ae4991c91a56e8b72dc4fce26e92daf7a239f894ca1ecb336fc1acc44b8120ca"

URI_aarch64_rust-image+color_quant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+color_quant-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+color_quant-devel}"
SRC_URI[aarch64_rust-image+color_quant-devel.sha256sum] = "a47267360be34493c01ccad8dc478998cb6835c7b1e07db8049422a7acfcfc14"

URI_aarch64_rust-image+dds-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+dds-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+dds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+dds-devel}"
SRC_URI[aarch64_rust-image+dds-devel.sha256sum] = "b6cf29d4dabe1335303ce8993a8d84f9a674ea99b408c21abb2953664e811497"

URI_aarch64_rust-image+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+default-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+default-devel}"
SRC_URI[aarch64_rust-image+default-devel.sha256sum] = "4b256747882265066e1037cead16756ea587711afcb31d5f3bf952a289500b56"

URI_aarch64_rust-image+default-formats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+default-formats-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+default-formats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+default-formats-devel}"
SRC_URI[aarch64_rust-image+default-formats-devel.sha256sum] = "f4c4404ddfd74302b133f652f8f7983b77cf4c7465107c506aee606d6d246d2b"

URI_aarch64_rust-image+exr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+exr-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+exr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+exr-devel}"
SRC_URI[aarch64_rust-image+exr-devel.sha256sum] = "bf9bdaf73530ba3202cd130c670edcfac88e7e99cb9f4924f864702a9f6a8873"

URI_aarch64_rust-image+ff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+ff-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+ff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+ff-devel}"
SRC_URI[aarch64_rust-image+ff-devel.sha256sum] = "23a7a8df0a7f4042a43f2248fdbd81b5c8f1fa4e963840aa135b9d57732cd3d0"

URI_aarch64_rust-image+gif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+gif-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+gif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+gif-devel}"
SRC_URI[aarch64_rust-image+gif-devel.sha256sum] = "24b85c4132ebbbf6b41398db6db81d95e57f16aeac597a0fab823a0a02fb3407"

URI_aarch64_rust-image+hdr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+hdr-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+hdr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+hdr-devel}"
SRC_URI[aarch64_rust-image+hdr-devel.sha256sum] = "3fed832c3c2193685d31ed3aa3a9774e14f41340dd3336da51c34d95e0379697"

URI_aarch64_rust-image+ico-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+ico-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+ico-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+ico-devel}"
SRC_URI[aarch64_rust-image+ico-devel.sha256sum] = "730e3c681b5c8264fc2c9cc56cfadbe0a1b91ac295483df3a3d55327de0cda73"

URI_aarch64_rust-image+jpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+jpeg-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+jpeg-devel}"
SRC_URI[aarch64_rust-image+jpeg-devel.sha256sum] = "1f3abc75ae68459dbae38c7f322ffce5065c497184418c4db824d7cb73b6d9b5"

URI_aarch64_rust-image+nasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+nasm-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+nasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+nasm-devel}"
SRC_URI[aarch64_rust-image+nasm-devel.sha256sum] = "acb74e340b18be3a6fd1164cbb86e5ec46eed6d6fe4ac2cfa97ec5379f2bc651"

URI_aarch64_rust-image+png-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+png-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+png-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+png-devel}"
SRC_URI[aarch64_rust-image+png-devel.sha256sum] = "682c20b178632277795b7b7abaab11aae5c72faeb713f8ab26aa008c4d772794"

URI_aarch64_rust-image+pnm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+pnm-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+pnm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+pnm-devel}"
SRC_URI[aarch64_rust-image+pnm-devel.sha256sum] = "947db9ac1d79fc2cc06fd4657929c8f8bc2706ca818fa567c59199311e213824"

URI_aarch64_rust-image+qoi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+qoi-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+qoi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+qoi-devel}"
SRC_URI[aarch64_rust-image+qoi-devel.sha256sum] = "87557c379ecff3063235cf9c896bdceff96bd69866e1f8543ed1e57824586a75"

URI_aarch64_rust-image+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+rayon-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+rayon-devel}"
SRC_URI[aarch64_rust-image+rayon-devel.sha256sum] = "8e00588eaa13e9a6e883ad4362f9397ab9322360abdd15b44bf6eadc8421f7d8"

URI_aarch64_rust-image+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+serde-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+serde-devel}"
SRC_URI[aarch64_rust-image+serde-devel.sha256sum] = "d1cf7a9246666f54890ad66bce51181ec5f3081e36284c9b7c72532994c15e1b"

URI_aarch64_rust-image+tga-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+tga-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+tga-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+tga-devel}"
SRC_URI[aarch64_rust-image+tga-devel.sha256sum] = "963532cbb490964e70e63cc86ecd851a96e449393bf054a12e094bcd7ccda4ad"

URI_aarch64_rust-image+tiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+tiff-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+tiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+tiff-devel}"
SRC_URI[aarch64_rust-image+tiff-devel.sha256sum] = "3dfd6d05b5784ce6c873e1145520cd4f5284c70a2f8904d81eef11029eec0cd8"

URI_aarch64_rust-image+webp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+webp-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image+webp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+webp-devel}"
SRC_URI[aarch64_rust-image+webp-devel.sha256sum] = "5e570d21c37da8d89eba57af4976801e4b26eb754c304dd6dfd9e51dd128fd70"

URI_aarch64_rust-image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image-devel-0.25.6-1.el10_0.noarch.rpm;name=aarch64_rust-image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image-devel}"
SRC_URI[aarch64_rust-image-devel.sha256sum] = "6499de05f04f6c3f4e6ec9436abf553008fba52d22bc8b19220f72a6599c8af2"

RDEPENDS:rust-image+avif-devel = " \
 cargo \
 rust-image-devel \
 rust-ravif-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-image+avif-native-devel = " \
 cargo \
 rust-dav1d+default-devel \
 rust-image-devel \
 rust-mp4parse+default-devel \
 "
RDEPENDS:rust-image+bmp-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+color_quant-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+dds-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+default-devel = " \
 cargo \
 rust-image+default-formats-devel \
 rust-image+rayon-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+default-formats-devel = " \
 cargo \
 rust-image+avif-devel \
 rust-image+bmp-devel \
 rust-image+dds-devel \
 rust-image+exr-devel \
 rust-image+ff-devel \
 rust-image+gif-devel \
 rust-image+hdr-devel \
 rust-image+ico-devel \
 rust-image+jpeg-devel \
 rust-image+png-devel \
 rust-image+pnm-devel \
 rust-image+qoi-devel \
 rust-image+tga-devel \
 rust-image+tiff-devel \
 rust-image+webp-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+exr-devel = " \
 cargo \
 rust-exr+default-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+ff-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+gif-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-gif+default-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+hdr-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+ico-devel = " \
 cargo \
 rust-image+bmp-devel \
 rust-image+png-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+jpeg-devel = " \
 cargo \
 rust-image-devel \
 rust-zune-core-devel \
 rust-zune-jpeg+default-devel \
 "
RDEPENDS:rust-image+nasm-devel = " \
 cargo \
 rust-image-devel \
 rust-ravif+asm-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-image+png-devel = " \
 cargo \
 rust-image-devel \
 rust-png+default-devel \
 "
RDEPENDS:rust-image+pnm-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+qoi-devel = " \
 cargo \
 rust-image-devel \
 rust-qoi+default-devel \
 "
RDEPENDS:rust-image+rayon-devel = " \
 cargo \
 rust-image-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-image+serde-devel = " \
 cargo \
 rust-image-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-image+tga-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+tiff-devel = " \
 cargo \
 rust-image-devel \
 rust-tiff+default-devel \
 "
RDEPENDS:rust-image+webp-devel = " \
 cargo \
 rust-image-devel \
 rust-image-webp+default-devel \
 "
RDEPENDS:rust-image-devel = " \
 cargo \
 rust \
 rust-bytemuck+default-devel \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-byteorder-lite+default-devel \
 rust-num-traits+default-devel \
 "
