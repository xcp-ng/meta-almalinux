# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libseccomp"
PV = "2.5.6"
PR = "1.el10"
PACKAGES = " \
 libseccomp \
 libseccomp-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libseccomp-2.5.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e808ed5c576bcb892a10c0457447dfb742bacc82caa48010bacc5d81c8f14d25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libseccomp-2.5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_libseccomp;unpack=0"
SRC_URI[x86_64_v2_libseccomp.sha256sum] = "a44f580ddcdb5dd5c54d12fb34069b2fc93bc03e8e05573b27d314e55560ac98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libseccomp-devel-2.5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_libseccomp-devel;unpack=0"
SRC_URI[x86_64_v2_libseccomp-devel.sha256sum] = "80c90ec0edebf026925d594a741584f169b770c30ba55142f3388c0fde8f9550"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libseccomp-2.5.6-1.el10.aarch64.rpm;name=aarch64_libseccomp;unpack=0"
SRC_URI[aarch64_libseccomp.sha256sum] = "587345a8caf0e0a81e6f93adf5f556ac01b0178f2a3f3ca9ad0833e6439e9d80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libseccomp-devel-2.5.6-1.el10.aarch64.rpm;name=aarch64_libseccomp-devel;unpack=0"
SRC_URI[aarch64_libseccomp-devel.sha256sum] = "86e55021e14019e5538271cae605aaaa25c6df67368c0f58f09f05c1c97f2f00"

RDEPENDS:libseccomp = " \
 glibc \
 "
RDEPENDS:libseccomp-devel = " \
 glibc \
 libseccomp \
 pkgconf-pkg-config \
 "
