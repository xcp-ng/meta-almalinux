# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jcmturner-goidentity"
PV = "6.0.1"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-jcmturner-goidentity-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jcmturner-goidentity-6.0.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b7a07079486e3af9a15aa121cddb4dce94ef57fed3b994ed221c86f44474b50"

URI_x86_64_v2_golang-github-jcmturner-goidentity-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jcmturner-goidentity-devel-6.0.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jcmturner-goidentity-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jcmturner-goidentity-devel}"
SRC_URI[x86_64_v2_golang-github-jcmturner-goidentity-devel.sha256sum] = "4f164e38757e8e2bbbf8a8e2a03b5a31108606aa2890001ea3f324a60761250c"

URI_aarch64_golang-github-jcmturner-goidentity-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jcmturner-goidentity-devel-6.0.1-13.el10_0.noarch.rpm;name=aarch64_golang-github-jcmturner-goidentity-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jcmturner-goidentity-devel}"
SRC_URI[aarch64_golang-github-jcmturner-goidentity-devel.sha256sum] = "e95157f2229240375e1c50495ae4e1c316baa9c2efd95d64c14df0a82bc36d1f"

RDEPENDS:golang-github-jcmturner-goidentity-devel = " \
 go-filesystem \
 golang-github-hashicorp-uuid-devel \
 "
