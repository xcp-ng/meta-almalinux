# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "acl"
PV = "2.3.2"
PR = "4.el10"
PACKAGES = " \
 acl \
 libacl \
 libacl-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/acl-2.3.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c509daedaece4fd86e18d60ba06567057db32f0a01414ef441af91d4c669ab0"

URI_x86_64_v2_acl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/acl-2.3.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_acl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_acl}"
SRC_URI[x86_64_v2_acl.sha256sum] = "5099687b7f22987f762d21e1b07eeba2078535d8933ff97ee1eb3a2e112878f0"

URI_x86_64_v2_libacl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libacl-2.3.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_libacl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libacl}"
SRC_URI[x86_64_v2_libacl.sha256sum] = "a0b2714264b25a1382a5cb65c1e700debc17e2c3df1d59d9fe85efdee02ce9ed"

URI_x86_64_v2_libacl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libacl-devel-2.3.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_libacl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libacl-devel}"
SRC_URI[x86_64_v2_libacl-devel.sha256sum] = "58493805d1f1d658b24b07ea834e7082ac4b7ca6211e5b3a787e854ce0d16b1a"

URI_aarch64_acl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/acl-2.3.2-4.el10.aarch64.rpm;name=aarch64_acl;unpack=0"
SRC_URI:append = " ${URI_aarch64_acl}"
SRC_URI[aarch64_acl.sha256sum] = "dc441127b37af9f836d9f7dfbab9be15e1fedfb06af93f78f2d8d3d4ee8da26e"

URI_aarch64_libacl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libacl-2.3.2-4.el10.aarch64.rpm;name=aarch64_libacl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libacl}"
SRC_URI[aarch64_libacl.sha256sum] = "d71a1543de4f02705f27eb8a331458ae2c6b660c0bca5176882c7247f3b38b55"

URI_aarch64_libacl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libacl-devel-2.3.2-4.el10.aarch64.rpm;name=aarch64_libacl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libacl-devel}"
SRC_URI[aarch64_libacl-devel.sha256sum] = "d3a7e56036976d23daae22063b9ed87b512ed1b8fc75ab97f030ece5f5c4434b"

RDEPENDS:acl = " \
 glibc \
 libacl \
 "
RDEPENDS:libacl = " \
 glibc \
 libattr \
 "
RDEPENDS:libacl-devel = " \
 libacl \
 libattr-devel \
 pkgconf-pkg-config \
 "
