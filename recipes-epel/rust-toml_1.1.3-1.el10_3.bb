# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml"
PV = "1.1.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-toml+debug-devel \
 rust-toml+default-devel \
 rust-toml+display-devel \
 rust-toml+fast_hash-devel \
 rust-toml+parse-devel \
 rust-toml+preserve_order-devel \
 rust-toml+serde-devel \
 rust-toml+std-devel \
 rust-toml+unbounded-devel \
 rust-toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml-1.1.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cb22ce48eafe7482435c510f1c702436c5bc7eaf35b9ac7f1694392a0a3bf22"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-toml+debug-devel: (crate(toml_parser) >= 1.1.2 with crate(toml_parser) < 2.0.0~)
# - rust-toml+debug-devel: (crate(toml_parser/alloc) >= 1.1.2 with crate(toml_parser/alloc) < 2.0.0~)
# - rust-toml+debug-devel: (crate(toml_parser/debug) >= 1.1.2 with crate(toml_parser/debug) < 2.0.0~)
# - rust-toml+parse-devel: (crate(toml_parser) >= 1.1.2 with crate(toml_parser) < 2.0.0~)
# - rust-toml+parse-devel: (crate(toml_parser/alloc) >= 1.1.2 with crate(toml_parser/alloc) < 2.0.0~)
# - rust-toml+std-devel: (crate(toml_parser) >= 1.1.2 with crate(toml_parser) < 2.0.0~)
# - rust-toml+std-devel: (crate(toml_parser/alloc) >= 1.1.2 with crate(toml_parser/alloc) < 2.0.0~)
# - rust-toml+std-devel: (crate(toml_parser/std) >= 1.1.2 with crate(toml_parser/std) < 2.0.0~)

URI_x86_64_v2_rust-toml+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+debug-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+debug-devel}"
SRC_URI[x86_64_v2_rust-toml+debug-devel.sha256sum] = "d278d52b8bcb6e90498a89fc4cb0628b78bd369063a502237327cab024d02a1a"

URI_x86_64_v2_rust-toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+default-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+default-devel}"
SRC_URI[x86_64_v2_rust-toml+default-devel.sha256sum] = "e92c99985a26593324773c9f1e629e6bebdc7030f872283bcc65d5f252c439eb"
RPROVIDES:rust-toml+default-devel:x86_64_v2 = "virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~"

URI_x86_64_v2_rust-toml+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+display-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+display-devel}"
SRC_URI[x86_64_v2_rust-toml+display-devel.sha256sum] = "73ab499bb793bfcfeeb96b3ef41b9651ee2a83d1bb481f16867bb3682fc5f935"

URI_x86_64_v2_rust-toml+fast_hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+fast_hash-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+fast_hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+fast_hash-devel}"
SRC_URI[x86_64_v2_rust-toml+fast_hash-devel.sha256sum] = "7a94d6f803533b0d191d4a54a636dd00f8668240d4d41e227d9c6ba9f1a71570"

URI_x86_64_v2_rust-toml+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+parse-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+parse-devel}"
SRC_URI[x86_64_v2_rust-toml+parse-devel.sha256sum] = "3ad25001eebab854170b99b8a253e09fdafeff72bcdbbbec82884fdd1efcfc4d"

URI_x86_64_v2_rust-toml+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+preserve_order-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-toml+preserve_order-devel.sha256sum] = "8d9c15e1186b475522272d6162daed786c65bf69b05645ffb6357f46e08bb51e"

URI_x86_64_v2_rust-toml+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+serde-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+serde-devel}"
SRC_URI[x86_64_v2_rust-toml+serde-devel.sha256sum] = "82f59143ab90dd2912c1a31a63eab852b372a188b392935d0a838b8009c7a71c"

URI_x86_64_v2_rust-toml+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+std-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+std-devel}"
SRC_URI[x86_64_v2_rust-toml+std-devel.sha256sum] = "3768b79cd8698c014e3d119bb7e09c52319fc35eb996493306d94179df349a0c"

URI_x86_64_v2_rust-toml+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+unbounded-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml+unbounded-devel.sha256sum] = "a953bc750b427bdc168e92b82b34096682f2777d989008f11f437d808dc88ce0"

URI_x86_64_v2_rust-toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml-devel-1.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml-devel}"
SRC_URI[x86_64_v2_rust-toml-devel.sha256sum] = "079976a1fe2a063ceef8082300ee5ccdc0ab3ba3734ec9b64ba5fad699f0d6d0"

URI_aarch64_rust-toml+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+debug-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+debug-devel}"
SRC_URI[aarch64_rust-toml+debug-devel.sha256sum] = "8d666be80a00ada89a3e66b1ae0d53d89e4fbfa623a5497ded9ae36d34e884a3"

URI_aarch64_rust-toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+default-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+default-devel}"
SRC_URI[aarch64_rust-toml+default-devel.sha256sum] = "dd2ac2745e6e6058b6269155936e5a4388050793763fd7704fc7ad15345f16a7"
RPROVIDES:rust-toml+default-devel:aarch64 = "virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~"

URI_aarch64_rust-toml+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+display-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+display-devel}"
SRC_URI[aarch64_rust-toml+display-devel.sha256sum] = "93ba987cc00137523d08bfb5edf84551336cf3aee6d729deb2e010c8d05fd09d"

URI_aarch64_rust-toml+fast_hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+fast_hash-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml+fast_hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+fast_hash-devel}"
SRC_URI[aarch64_rust-toml+fast_hash-devel.sha256sum] = "439c7ceb20aefe5681a01b271490a5bdfbefacfb15b032165adc77b47f4b2064"

URI_aarch64_rust-toml+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+parse-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+parse-devel}"
SRC_URI[aarch64_rust-toml+parse-devel.sha256sum] = "7de69796cb89bdaeea3748874b67acc407470633ab99b32ccceb6584d8ff914e"

URI_aarch64_rust-toml+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+preserve_order-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+preserve_order-devel}"
SRC_URI[aarch64_rust-toml+preserve_order-devel.sha256sum] = "b15b8cb6f8f0ac33debafaba6e57de7edd9b660842dd8cbaa947f919c49d88ec"

URI_aarch64_rust-toml+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+serde-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+serde-devel}"
SRC_URI[aarch64_rust-toml+serde-devel.sha256sum] = "a941e845e2cfa67d0770a0ef42cbb37a05c33c5b93a42eaaea88063aa754ea25"

URI_aarch64_rust-toml+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+std-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+std-devel}"
SRC_URI[aarch64_rust-toml+std-devel.sha256sum] = "eba4af2ccd0a222a0e42c8a73b664a448936a65894bed76e9df8f46ae509997d"

URI_aarch64_rust-toml+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+unbounded-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+unbounded-devel}"
SRC_URI[aarch64_rust-toml+unbounded-devel.sha256sum] = "81678c1363ea7c433617dc1b3699ef554168c8bc550aecf4781f474049cf51b3"

URI_aarch64_rust-toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml-devel-1.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml-devel}"
SRC_URI[aarch64_rust-toml-devel.sha256sum] = "347b8e5e5bb8ecd2a0ed1ce948fe557d7f17b2fc53e60c7a570a5f3b67499005"

RDEPENDS:rust-toml+debug-devel:x86_64_v2 = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-toml+std-devel \
 rust-toml-devel \
"
RDEPENDS:rust-toml+debug-devel:aarch64 = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser-devel \
"
RDEPENDS:rust-toml+default-devel = " \
 cargo \
 rust-toml+display-devel \
 rust-toml+parse-devel \
 rust-toml+serde-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+display-devel = " \
 cargo \
 rust-toml-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml+fast_hash-devel = " \
 cargo \
 rust-foldhash-devel \
 rust-toml+preserve_order-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+parse-devel:x86_64_v2 = " \
 cargo \
 rust-toml-devel \
 rust-winnow-devel \
"
RDEPENDS:rust-toml+parse-devel:aarch64 = " \
 cargo \
 rust-toml-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser-devel \
 rust-winnow-devel \
"
RDEPENDS:rust-toml+preserve_order-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+serde-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-serde_spanned+serde-devel \
 rust-toml-devel \
 rust-toml_datetime+serde-devel \
 "
RDEPENDS:rust-toml+std-devel:x86_64_v2 = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_spanned+std-devel \
 rust-toml-devel \
 rust-toml_datetime+std-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
"
RDEPENDS:rust-toml+std-devel:aarch64 = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_spanned+std-devel \
 rust-toml-devel \
 rust-toml_datetime+std-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
"
RDEPENDS:rust-toml+unbounded-devel = " \
 cargo \
 rust-toml-devel \
 "
RDEPENDS:rust-toml-devel = " \
 cargo \
 rust \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned-devel \
 rust-toml_datetime+alloc-devel \
 rust-toml_datetime-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_toml/default__ge_0.6.0_with_crate_toml/default__lt_2.0.0~"
