# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zanshin"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 zanshin \
 zanshin-common \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/z/zanshin-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0763887fab8629e508ce2b3bf8aaf8cd48c48769bc80ee40ddb8e6643c825376"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zanshin-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zanshin;unpack=0"
SRC_URI[x86_64_v2_zanshin.sha256sum] = "9cd6ad0554268320ab1fb37b3f5245580cc0d0155d63775309e1662751d2e090"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zanshin-common-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zanshin-common;unpack=0"
SRC_URI[x86_64_v2_zanshin-common.sha256sum] = "7b7a0a07b0f0e3fa50a6dd7e3134d0f3648f6b3a8f75dfe877a24ebbe05f5654"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zanshin-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_zanshin;unpack=0"
SRC_URI[aarch64_zanshin.sha256sum] = "fa81d1bf0f51443e8b8bfd8bc8ff947c64884dc975d109f5650b3aec180e0256"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zanshin-common-26.08.1-1.el10_3.noarch.rpm;name=aarch64_zanshin-common;unpack=0"
SRC_URI[aarch64_zanshin-common.sha256sum] = "2a4ee12218f866a2399106032c47a6558c180a9a9c388d3839d4f3d31967b292"

RDEPENDS:zanshin = " \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kparts \
 kf6-krunner \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kontactinterface \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 zanshin-common \
 "
RDEPENDS:zanshin-common = " \
 zanshin \
 "
