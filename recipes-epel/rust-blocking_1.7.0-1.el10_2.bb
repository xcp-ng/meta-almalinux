# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blocking"
PV = "1.7.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-blocking+default-devel \
 rust-blocking+tracing-devel \
 rust-blocking-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-blocking-1.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "83e21eb3b34e107c8d7995d885928448cf3f6efbbca4a5a33f3af925c933e2e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking+default-devel-1.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blocking+default-devel.sha256sum] = "19a75a30a3260782f4ad00e382c30df6928e23f2903d1e0b6bef64dfc20f616a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking+tracing-devel-1.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blocking+tracing-devel.sha256sum] = "21db3cb01b7a3baa00e412fb6477c525980846d4f7c054acff3e684737e0bded"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blocking-devel-1.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blocking-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blocking-devel.sha256sum] = "8120c464057aa427a5971035d49c57fc2867fe4804466c7dc804b0623159a29d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking+default-devel-1.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-blocking+default-devel;unpack=0"
SRC_URI[aarch64_rust-blocking+default-devel.sha256sum] = "77fa6b30383c84f78f3958af7e7da22f952d488e4b02e1ee033f9f38eb593f1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking+tracing-devel-1.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-blocking+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-blocking+tracing-devel.sha256sum] = "21795809d85e03ea77accce8ec988afc7b862028229d1639da42cff2870abbbb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blocking-devel-1.7.0-1.el10_2.noarch.rpm;name=aarch64_rust-blocking-devel;unpack=0"
SRC_URI[aarch64_rust-blocking-devel.sha256sum] = "67d27539938bbddfcdcbed747f2824a7354de96ab702c7d408c797072f39fbee"

RDEPENDS:rust-blocking+default-devel = " \
 cargo \
 rust-blocking-devel \
 "
RDEPENDS:rust-blocking+tracing-devel = " \
 cargo \
 rust-blocking-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-blocking-devel = " \
 cargo \
 rust \
 rust-async-channel+default-devel \
 rust-async-task+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-lite-devel \
 rust-piper+default-devel \
 "
