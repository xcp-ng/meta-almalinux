# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-sq"
PV = "1.3.1.1"
PR = "1.el10"
PACKAGES = " \
 sequoia-sq \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-sequoia-sq-1.3.1.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adaf09ac15faa7615e62b777068898771ad66439f2d00ea9f95e3619f17d192e"

URI_x86_64_v2_sequoia-sq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sequoia-sq-1.3.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_sequoia-sq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sequoia-sq}"
SRC_URI[x86_64_v2_sequoia-sq.sha256sum] = "fedf8a6f1bb444ff345fe11acafd26c29a11e600b8a4aff329d892b46e375823"

URI_aarch64_sequoia-sq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sequoia-sq-1.3.1.1-1.el10.aarch64.rpm;name=aarch64_sequoia-sq;unpack=0"
SRC_URI:append = " ${URI_aarch64_sequoia-sq}"
SRC_URI[aarch64_sequoia-sq.sha256sum] = "720fd562cc6f9f424901c3447f0ed1b7b795fc1ff5f4d490b9a04ff018dfc312"

RDEPENDS:sequoia-sq = " \
 glibc \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
