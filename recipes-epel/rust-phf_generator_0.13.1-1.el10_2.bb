# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_generator"
PV = "0.13.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-phf_generator+default-devel \
 rust-phf_generator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_generator-0.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26a3bf4c45c377b02e9c14e7c159e1736b70354f584a04dbbac889719a1b9e5d"

URI_x86_64_v2_rust-phf_generator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_generator+default-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_generator+default-devel}"
SRC_URI[x86_64_v2_rust-phf_generator+default-devel.sha256sum] = "344d7145a364645abfc64b658711c93344a2d75fbdba56b2f443b18a309a9c16"

URI_x86_64_v2_rust-phf_generator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_generator-devel-0.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_generator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_generator-devel}"
SRC_URI[x86_64_v2_rust-phf_generator-devel.sha256sum] = "3b67133d50b286147b1e202f4eca25b2bace7eb48a5ff6aba5fd08bc3a8861ad"

URI_aarch64_rust-phf_generator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_generator+default-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_generator+default-devel}"
SRC_URI[aarch64_rust-phf_generator+default-devel.sha256sum] = "2a98fc7a610d7b0ff01fead220fe8050845fca5e280503c1fcbc0edef8938be9"

URI_aarch64_rust-phf_generator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_generator-devel-0.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-phf_generator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_generator-devel}"
SRC_URI[aarch64_rust-phf_generator-devel.sha256sum] = "dde02504eff892bcb0faaf4134b84f0c02fd7593a5c2dfee16eb0c7bdcf38ea4"

RDEPENDS:rust-phf_generator+default-devel = " \
 cargo \
 rust-phf_generator-devel \
 "
RDEPENDS:rust-phf_generator-devel = " \
 cargo \
 rust \
 rust-fastrand-devel \
 rust-phf_shared-devel \
 "
