# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "selinux-policy"
PV = "42.1.25"
PR = "1.el10"
PACKAGES = " \
 selinux-policy \
 selinux-policy-devel \
 selinux-policy-doc \
 selinux-policy-extra \
 selinux-policy-mls \
 selinux-policy-mls-extra \
 selinux-policy-sandbox \
 selinux-policy-targeted \
 selinux-policy-targeted-extra \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/selinux-policy-42.1.25-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "361ec1ecd1668a5afe984fde231d8c96979f5ae12be0e862f31a0d02b728459d"

URI_x86_64_v2_selinux-policy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-42.1.25-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy}"
SRC_URI[x86_64_v2_selinux-policy.sha256sum] = "5748af6d6eac45a5a93e6f06b997345409442ba8accb30c8124bc7708cd6ff29"

URI_x86_64_v2_selinux-policy-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/selinux-policy-devel-42.1.25-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-devel}"
SRC_URI[x86_64_v2_selinux-policy-devel.sha256sum] = "2304602e4cf6afa681e8010e2b6c80599522d0ff49cb5730085743e32f5a1b35"

URI_x86_64_v2_selinux-policy-doc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-doc-42.1.25-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-doc}"
SRC_URI[x86_64_v2_selinux-policy-doc.sha256sum] = "6ae9018c8369c02c04ae93202fc1ddce1069b6ec61761efdbe10a44c735c9a54"

URI_x86_64_v2_selinux-policy-extra = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-extra-42.1.25-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-extra}"
SRC_URI[x86_64_v2_selinux-policy-extra.sha256sum] = "d42f1ef1e7cb096cf752fe52238d81783d96744a3dbb8a2cb11021189d5ecacb"

URI_x86_64_v2_selinux-policy-mls = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-mls-42.1.25-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-mls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-mls}"
SRC_URI[x86_64_v2_selinux-policy-mls.sha256sum] = "22e811c0716e20cc0b39c81eae5245b0ce46454f496e362a1b8db168ceea8118"
RPROVIDES:selinux-policy-mls:x86_64_v2 = "virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.25-1.el10 virtual/selinux-policy-any_ge_42.1.13 virtual/selinux-policy-any_ge_42.1.15 virtual/selinux-policy-any_ge_42.1.25"

URI_x86_64_v2_selinux-policy-mls-extra = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-mls-extra-42.1.25-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-mls-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-mls-extra}"
SRC_URI[x86_64_v2_selinux-policy-mls-extra.sha256sum] = "2e90509a5675b34716ad5b927ba155005e56f918217c7a2de30e9a98d0cf7f21"

URI_x86_64_v2_selinux-policy-sandbox = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-sandbox-42.1.25-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-sandbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-sandbox}"
SRC_URI[x86_64_v2_selinux-policy-sandbox.sha256sum] = "c458ca6d73de9efe2178a08a814b3e48d55f99ecaf18a25aaf8ca62e3e6f58f6"

URI_x86_64_v2_selinux-policy-targeted = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-targeted-42.1.25-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-targeted;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-targeted}"
SRC_URI[x86_64_v2_selinux-policy-targeted.sha256sum] = "4cb66fe0300aca39d76dbed4d2f16f2658ff438f3b28eb7793e0ff5efd3e6c7c"
RPROVIDES:selinux-policy-targeted:x86_64_v2 = "virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.25-1.el10 virtual/selinux-policy-any_ge_42.1.13 virtual/selinux-policy-any_ge_42.1.15 virtual/selinux-policy-any_ge_42.1.25"

URI_x86_64_v2_selinux-policy-targeted-extra = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-targeted-extra-42.1.25-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-targeted-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-targeted-extra}"
SRC_URI[x86_64_v2_selinux-policy-targeted-extra.sha256sum] = "8ac6944ee6749f8a96ee1bf30fdac97eec11b0bfd8b59b201dcb1b5edc48f073"

URI_aarch64_selinux-policy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-42.1.25-1.el10.noarch.rpm;name=aarch64_selinux-policy;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy}"
SRC_URI[aarch64_selinux-policy.sha256sum] = "5748af6d6eac45a5a93e6f06b997345409442ba8accb30c8124bc7708cd6ff29"

URI_aarch64_selinux-policy-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/selinux-policy-devel-42.1.25-1.el10.noarch.rpm;name=aarch64_selinux-policy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-devel}"
SRC_URI[aarch64_selinux-policy-devel.sha256sum] = "2304602e4cf6afa681e8010e2b6c80599522d0ff49cb5730085743e32f5a1b35"

URI_aarch64_selinux-policy-doc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-doc-42.1.25-1.el10.noarch.rpm;name=aarch64_selinux-policy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-doc}"
SRC_URI[aarch64_selinux-policy-doc.sha256sum] = "6ae9018c8369c02c04ae93202fc1ddce1069b6ec61761efdbe10a44c735c9a54"

URI_aarch64_selinux-policy-extra = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-extra-42.1.25-1.el10.noarch.rpm;name=aarch64_selinux-policy-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-extra}"
SRC_URI[aarch64_selinux-policy-extra.sha256sum] = "d42f1ef1e7cb096cf752fe52238d81783d96744a3dbb8a2cb11021189d5ecacb"

URI_aarch64_selinux-policy-mls = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-mls-42.1.25-1.el10.noarch.rpm;name=aarch64_selinux-policy-mls;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-mls}"
SRC_URI[aarch64_selinux-policy-mls.sha256sum] = "22e811c0716e20cc0b39c81eae5245b0ce46454f496e362a1b8db168ceea8118"
RPROVIDES:selinux-policy-mls:aarch64 = "virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.25-1.el10 virtual/selinux-policy-any_ge_42.1.12 virtual/selinux-policy-any_ge_42.1.15 virtual/selinux-policy-any_ge_42.1.25"

URI_aarch64_selinux-policy-mls-extra = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-mls-extra-42.1.25-1.el10.noarch.rpm;name=aarch64_selinux-policy-mls-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-mls-extra}"
SRC_URI[aarch64_selinux-policy-mls-extra.sha256sum] = "2e90509a5675b34716ad5b927ba155005e56f918217c7a2de30e9a98d0cf7f21"

URI_aarch64_selinux-policy-sandbox = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-sandbox-42.1.25-1.el10.noarch.rpm;name=aarch64_selinux-policy-sandbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-sandbox}"
SRC_URI[aarch64_selinux-policy-sandbox.sha256sum] = "c458ca6d73de9efe2178a08a814b3e48d55f99ecaf18a25aaf8ca62e3e6f58f6"

URI_aarch64_selinux-policy-targeted = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-targeted-42.1.25-1.el10.noarch.rpm;name=aarch64_selinux-policy-targeted;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-targeted}"
SRC_URI[aarch64_selinux-policy-targeted.sha256sum] = "4cb66fe0300aca39d76dbed4d2f16f2658ff438f3b28eb7793e0ff5efd3e6c7c"
RPROVIDES:selinux-policy-targeted:aarch64 = "virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.25-1.el10 virtual/selinux-policy-any_ge_42.1.12 virtual/selinux-policy-any_ge_42.1.15 virtual/selinux-policy-any_ge_42.1.25"

URI_aarch64_selinux-policy-targeted-extra = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-targeted-extra-42.1.25-1.el10.noarch.rpm;name=aarch64_selinux-policy-targeted-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-targeted-extra}"
SRC_URI[aarch64_selinux-policy-targeted-extra.sha256sum] = "8ac6944ee6749f8a96ee1bf30fdac97eec11b0bfd8b59b201dcb1b5edc48f073"

RDEPENDS:selinux-policy = " \
 bash \
 gawk \
 policycoreutils \
 rpm-plugin-selinux \
 virtual//usr/bin/sha512sum \
 virtual/selinux-policy-any_eq_42.1.25-1.el10 \
 "
RDEPENDS:selinux-policy-devel = " \
 bash \
 checkpolicy \
 m4 \
 make \
 policycoreutils-devel \
 selinux-policy \
 "
RDEPENDS:selinux-policy-doc = " \
 selinux-policy \
 "
RDEPENDS:selinux-policy-extra = " \
 selinux-policy-mls-extra \
 selinux-policy-targeted-extra \
 "
RDEPENDS:selinux-policy-mls = " \
 bash \
 mcstrans \
 policycoreutils \
 policycoreutils-newrole \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-mls-extra = " \
 bash \
 selinux-policy-mls \
 "
RDEPENDS:selinux-policy-sandbox = " \
 bash \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:selinux-policy-targeted = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-targeted-extra = " \
 bash \
 selinux-policy-targeted \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/selinux-policy-any rpm/virtual/selinux-policy-any_eq_42.1.25-1.el10 rpm/virtual/selinux-policy-any_ge_42.1.13 rpm/virtual/selinux-policy-any_ge_42.1.15 rpm/virtual/selinux-policy-any_ge_42.1.25"

PROVIDES:append:aarch64 = " rpm/virtual/selinux-policy-any rpm/virtual/selinux-policy-any_eq_42.1.25-1.el10 rpm/virtual/selinux-policy-any_ge_42.1.12 rpm/virtual/selinux-policy-any_ge_42.1.15 rpm/virtual/selinux-policy-any_ge_42.1.25"
