# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls"
PV = "0.23.36"
PR = "1.el10_1"
PACKAGES = " \
 rust-rustls+brotli-devel \
 rust-rustls+custom-provider-devel \
 rust-rustls+default-devel \
 rust-rustls+hashbrown-devel \
 rust-rustls+log-devel \
 rust-rustls+logging-devel \
 rust-rustls+read_buf-devel \
 rust-rustls+ring-devel \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls+zlib-devel \
 rust-rustls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-0.23.36-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f2ce61d8c9623fe3cb47d437b0775bac5a0debf8fe43875c54eddd35f1b41ec"

URI_x86_64_v2_rust-rustls+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+brotli-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+brotli-devel}"
SRC_URI[x86_64_v2_rust-rustls+brotli-devel.sha256sum] = "e14a72f132d39faa6440988ad4a50a94564468273fd3777bd336c65e3628cc30"

URI_x86_64_v2_rust-rustls+custom-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+custom-provider-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+custom-provider-devel}"
SRC_URI[x86_64_v2_rust-rustls+custom-provider-devel.sha256sum] = "91c66af5641ed3a66e0ce05f279158b2258239a9648d4df118150e56a96c578e"

URI_x86_64_v2_rust-rustls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+default-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+default-devel}"
SRC_URI[x86_64_v2_rust-rustls+default-devel.sha256sum] = "5cccc9592bf6f9f7daea2ea321e4f4fb03aee31a67ecb5623fa135bdf184e6c1"

URI_x86_64_v2_rust-rustls+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+hashbrown-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-rustls+hashbrown-devel.sha256sum] = "6fb0874361790511c4588bae8486746efae344dffeda6a5c6abbcbb9d8d5f820"

URI_x86_64_v2_rust-rustls+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+log-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+log-devel}"
SRC_URI[x86_64_v2_rust-rustls+log-devel.sha256sum] = "ac51a0b9fd827954f9b158ea13ac2ed372022435de6e9f788dafd74470958a4a"

URI_x86_64_v2_rust-rustls+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+logging-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+logging-devel}"
SRC_URI[x86_64_v2_rust-rustls+logging-devel.sha256sum] = "0931dcebef9cdc4bb23ed10dcc3bb413f319a5a098d6c13da154d29e41f5a9a5"

URI_x86_64_v2_rust-rustls+read_buf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+read_buf-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+read_buf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+read_buf-devel}"
SRC_URI[x86_64_v2_rust-rustls+read_buf-devel.sha256sum] = "9e0d85d20aec8a0cceb0139285b3d31cf7007ff6868a9f1796a3a7a1d2bb2efb"

URI_x86_64_v2_rust-rustls+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+ring-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+ring-devel}"
SRC_URI[x86_64_v2_rust-rustls+ring-devel.sha256sum] = "4fc6e0cad7fde0bd25b1ec386ca75fc66497a16e4826326830521dad12fb012d"

URI_x86_64_v2_rust-rustls+rustversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+rustversion-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+rustversion-devel}"
SRC_URI[x86_64_v2_rust-rustls+rustversion-devel.sha256sum] = "901ba3f13e46a761fa9f34afe64dc8bae734e77f711bfedcdf04fc2cdb0e2c25"

URI_x86_64_v2_rust-rustls+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+std-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+std-devel}"
SRC_URI[x86_64_v2_rust-rustls+std-devel.sha256sum] = "0ddb2ab99dcc7cc2e8551aafeb22e7f97178a95056221ba1879c44d3f6095d96"

URI_x86_64_v2_rust-rustls+tls12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+tls12-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+tls12-devel}"
SRC_URI[x86_64_v2_rust-rustls+tls12-devel.sha256sum] = "ddee66ee48075ee6d039c148765437917619d6be4f839d72b6a70a72b7d9ac01"

URI_x86_64_v2_rust-rustls+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls+zlib-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls+zlib-devel}"
SRC_URI[x86_64_v2_rust-rustls+zlib-devel.sha256sum] = "ddd7e789165766258237300f07b8724f8ea110f3b8522b2453745691bae9dfd8"

URI_x86_64_v2_rust-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-devel-0.23.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-devel}"
SRC_URI[x86_64_v2_rust-rustls-devel.sha256sum] = "71ba5e6426a9cf47db1ec06ff109cb8592e3b82e07a94ba1bdae1e1791d0a87c"

URI_aarch64_rust-rustls+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+brotli-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+brotli-devel}"
SRC_URI[aarch64_rust-rustls+brotli-devel.sha256sum] = "588eedfada73bd1a477b26b63935b0ff7230f98fd0e10b1bd6804cb8953f7cdf"

URI_aarch64_rust-rustls+custom-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+custom-provider-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+custom-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+custom-provider-devel}"
SRC_URI[aarch64_rust-rustls+custom-provider-devel.sha256sum] = "efb8ad46c0b4810a9f117e42dbbafd3096724e7ea2a69a2c77350392204fb169"

URI_aarch64_rust-rustls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+default-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+default-devel}"
SRC_URI[aarch64_rust-rustls+default-devel.sha256sum] = "9a6a9a7f3e39f6a8dcb207fcd2f13cf0c0bd3ab05c015330979b4f4f061d27b6"

URI_aarch64_rust-rustls+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+hashbrown-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+hashbrown-devel}"
SRC_URI[aarch64_rust-rustls+hashbrown-devel.sha256sum] = "522e689d460f4f620bbab00cd961d39f649bdbad93b68051fb44cde3f290d9e8"

URI_aarch64_rust-rustls+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+log-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+log-devel}"
SRC_URI[aarch64_rust-rustls+log-devel.sha256sum] = "95a04ec6c8063a2518d70e80fced3f2ad9bcb3eee3f5da99c5feacb80fcc6fa3"

URI_aarch64_rust-rustls+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+logging-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+logging-devel}"
SRC_URI[aarch64_rust-rustls+logging-devel.sha256sum] = "0a7de92b66ce85ac23399d7aded2e85c9ba33600054e12a398ea3181671478ba"

URI_aarch64_rust-rustls+read_buf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+read_buf-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+read_buf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+read_buf-devel}"
SRC_URI[aarch64_rust-rustls+read_buf-devel.sha256sum] = "73211dce500e8075ec862582fca46b7ea956cfa2de9d2892fb2f232b84c37510"

URI_aarch64_rust-rustls+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+ring-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+ring-devel}"
SRC_URI[aarch64_rust-rustls+ring-devel.sha256sum] = "cfee8acbd0f795b79209798f0a0f27a4feee2055b8253a2ac8f8e301acd19b5b"

URI_aarch64_rust-rustls+rustversion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+rustversion-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+rustversion-devel}"
SRC_URI[aarch64_rust-rustls+rustversion-devel.sha256sum] = "c42d4af313234faa78ffdddda7a3d7e724a00c7b8f912af7adeb1d1016bc3ae2"

URI_aarch64_rust-rustls+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+std-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+std-devel}"
SRC_URI[aarch64_rust-rustls+std-devel.sha256sum] = "686f77c52241206b866a9cff922cbdf03dd337b728e9d0697a4989810b7beb4d"

URI_aarch64_rust-rustls+tls12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+tls12-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+tls12-devel}"
SRC_URI[aarch64_rust-rustls+tls12-devel.sha256sum] = "fadd0114f97844db1fc64d8e644d5855fa2fa3e84c72e9e9505959acc50f899c"

URI_aarch64_rust-rustls+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls+zlib-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls+zlib-devel}"
SRC_URI[aarch64_rust-rustls+zlib-devel.sha256sum] = "554b2788a339c186866dabb82766268513839d68e321f894b6067b2e0f4cc801"

URI_aarch64_rust-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-devel-0.23.36-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-devel}"
SRC_URI[aarch64_rust-rustls-devel.sha256sum] = "af7860433ec17a00e079daea5249232b78850e3bc453c7f71366ed592818fd82"

RDEPENDS:rust-rustls+brotli-devel = " \
 cargo \
 rust-brotli+std-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+custom-provider-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+default-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+hashbrown-devel = " \
 cargo \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+logging-devel = " \
 cargo \
 rust-rustls+log-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+read_buf-devel = " \
 cargo \
 rust-rustls+rustversion-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-rustls-devel \
 rust-rustls-webpki+ring-devel \
 "
RDEPENDS:rust-rustls+rustversion-devel = " \
 cargo \
 rust-rustls-devel \
 rust-rustversion+default-devel \
 "
RDEPENDS:rust-rustls+std-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-rustls-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+std-devel \
 "
RDEPENDS:rust-rustls+tls12-devel = " \
 cargo \
 rust-rustls-devel \
 "
RDEPENDS:rust-rustls+zlib-devel = " \
 cargo \
 rust-rustls-devel \
 rust-zlib-rs+default-devel \
 "
RDEPENDS:rust-rustls-devel = " \
 cargo \
 rust \
 rust-once_cell+alloc-devel \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 rust-subtle-devel \
 rust-zeroize+default-devel \
 "
