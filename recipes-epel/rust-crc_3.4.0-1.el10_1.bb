# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crc"
PV = "3.4.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-crc+default-devel \
 rust-crc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crc-3.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "877800574034ea8c4d0bea870bbb54a739562b4bad8444b4c766579ed30b8a88"

URI_x86_64_v2_rust-crc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc+default-devel-3.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc+default-devel}"
SRC_URI[x86_64_v2_rust-crc+default-devel.sha256sum] = "ff1e34e2eaf3e85926ca6787fdf8e07cbc042b783a73580fe7e8bd5b767d5620"

URI_x86_64_v2_rust-crc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc-devel-3.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crc-devel}"
SRC_URI[x86_64_v2_rust-crc-devel.sha256sum] = "6568aa5105079a21e05c49cf03d83ca312af66afcdfe1aecec23fe21fff8e0bd"

URI_aarch64_rust-crc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc+default-devel-3.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-crc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc+default-devel}"
SRC_URI[aarch64_rust-crc+default-devel.sha256sum] = "9a1b5c856bf31aef6533cb68a294d7ff28ff3a2f1b139a4a0e0568491def3d80"

URI_aarch64_rust-crc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crc-devel-3.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-crc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crc-devel}"
SRC_URI[aarch64_rust-crc-devel.sha256sum] = "717e04cfcc6dc95526dc0a63a2c4fca7d876c7056127f0eed5f722f7e3e9efb4"

RDEPENDS:rust-crc+default-devel = " \
 cargo \
 rust-crc-devel \
 "
RDEPENDS:rust-crc-devel = " \
 cargo \
 rust \
 rust-crc-catalog+default-devel \
 "
