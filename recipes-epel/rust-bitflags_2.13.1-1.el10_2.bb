# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitflags"
PV = "2.13.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-bitflags+arbitrary-devel \
 rust-bitflags+bytemuck-devel \
 rust-bitflags+default-devel \
 rust-bitflags+example_generated-devel \
 rust-bitflags+serde-devel \
 rust-bitflags+serde_core-devel \
 rust-bitflags+std-devel \
 rust-bitflags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitflags-2.13.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e95b0b184cd97ca017f8bf25c7c7496ca034c7ff3f1c921fe77338440c4147d5"

URI_x86_64_v2_rust-bitflags+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+arbitrary-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-bitflags+arbitrary-devel.sha256sum] = "3a7ed1e3fe3b0bd5303ccadfa8e71bd64f78025e155a05f1cad682bac7d2dc8b"

URI_x86_64_v2_rust-bitflags+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+bytemuck-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-bitflags+bytemuck-devel.sha256sum] = "42380f1fa49e03e141b3adaa26d3efeead8e2516e6c53452799b82ed9198bbc5"

URI_x86_64_v2_rust-bitflags+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+default-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+default-devel}"
SRC_URI[x86_64_v2_rust-bitflags+default-devel.sha256sum] = "95b71be1261954c394ff7cd9393a0aa8efc2eea29f0528069991235fbb961e14"

URI_x86_64_v2_rust-bitflags+example_generated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+example_generated-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+example_generated-devel}"
SRC_URI[x86_64_v2_rust-bitflags+example_generated-devel.sha256sum] = "4c597d8fda1e100a57ab34eeff6850909c67a2f9e753ac89b1da3109bc9d6525"

URI_x86_64_v2_rust-bitflags+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+serde-devel}"
SRC_URI[x86_64_v2_rust-bitflags+serde-devel.sha256sum] = "23546adc083faf0fea6d61e4de3d10a3ec9ca652779873c60319b480bf4dbfa6"

URI_x86_64_v2_rust-bitflags+serde_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+serde_core-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+serde_core-devel}"
SRC_URI[x86_64_v2_rust-bitflags+serde_core-devel.sha256sum] = "e4a7d2f967c025e84ce239f4bebb0a1cd7597c5db1fcb3c611b566ea916b7c94"

URI_x86_64_v2_rust-bitflags+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags+std-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags+std-devel}"
SRC_URI[x86_64_v2_rust-bitflags+std-devel.sha256sum] = "d02816bfc168fb6c374d97b21c1c800655793f60051bb5007150533045210dfe"

URI_x86_64_v2_rust-bitflags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags-devel-2.13.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags-devel}"
SRC_URI[x86_64_v2_rust-bitflags-devel.sha256sum] = "a7b20848ab7a796bf1c3027b18b01156190af6095ab578638208cad0a14e6a86"

URI_aarch64_rust-bitflags+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+arbitrary-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+arbitrary-devel}"
SRC_URI[aarch64_rust-bitflags+arbitrary-devel.sha256sum] = "cc2992e879eacb84d011d39a21d45246ac3cd513603f484533c8decd8814c48a"

URI_aarch64_rust-bitflags+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+bytemuck-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+bytemuck-devel}"
SRC_URI[aarch64_rust-bitflags+bytemuck-devel.sha256sum] = "fcca1df45ab385f16d89febb811ea30323d0d027a298c187054c7f49b2d5fd48"

URI_aarch64_rust-bitflags+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+default-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+default-devel}"
SRC_URI[aarch64_rust-bitflags+default-devel.sha256sum] = "1e77fc4856b50a1a96cc1d93ea7c92d0765e07e589f70663529f619d4a5a1d0f"

URI_aarch64_rust-bitflags+example_generated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+example_generated-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+example_generated-devel}"
SRC_URI[aarch64_rust-bitflags+example_generated-devel.sha256sum] = "e3f3efb7875d1eb4ad8c33772084ac91b7e346da7b4540f08c6bf0c5ae1cf3f3"

URI_aarch64_rust-bitflags+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+serde-devel}"
SRC_URI[aarch64_rust-bitflags+serde-devel.sha256sum] = "999035f04c68515d63dd737ccb85338b0be16530f686c3eea95a6382d18faa40"

URI_aarch64_rust-bitflags+serde_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+serde_core-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+serde_core-devel}"
SRC_URI[aarch64_rust-bitflags+serde_core-devel.sha256sum] = "a84e35ad365726372e53bb009473ccaf0962dd102589cb3330d27542c852e92b"

URI_aarch64_rust-bitflags+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags+std-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags+std-devel}"
SRC_URI[aarch64_rust-bitflags+std-devel.sha256sum] = "acf9c09066e70484b23b35b452b957a42f664422c7dd4065224dda4b2c486577"

URI_aarch64_rust-bitflags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags-devel-2.13.1-1.el10_2.noarch.rpm;name=aarch64_rust-bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags-devel}"
SRC_URI[aarch64_rust-bitflags-devel.sha256sum] = "73df3adbdb4d9f34e8a288b7b4c837b389774a0f26a524cf3f2582235dc7a4ac"

RDEPENDS:rust-bitflags+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+bytemuck-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-bytemuck+default-devel \
 "
RDEPENDS:rust-bitflags+default-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+example_generated-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde-devel = " \
 cargo \
 rust-bitflags+serde_core-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags+serde_core-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bitflags+std-devel = " \
 cargo \
 rust-bitflags-devel \
 "
RDEPENDS:rust-bitflags-devel = " \
 cargo \
 rust \
 "
