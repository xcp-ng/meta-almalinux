# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ogr"
PV = "0.63.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-ogr \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-ogr-0.63.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c378ea8840e29eefa7ff58e436bd6fc9e451214fb58b984211741f7b3570f1c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ogr-0.63.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ogr;unpack=0"
SRC_URI[x86_64_v2_python3-ogr.sha256sum] = "4b383815c89593685c49f1423ed77960a9a224df12c5ff69af996077711d1ca8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-ogr-0.63.0-1.el10_2.noarch.rpm;name=aarch64_python3-ogr;unpack=0"
SRC_URI[aarch64_python3-ogr.sha256sum] = "9ae971c269044d0b7c7e0116984364c33f2d9f2a3bbdba02ba902899989f21fe"

RDEPENDS:python3-ogr = " \
 python3 \
 python3-GitPython \
 python3-cryptography \
 python3-deprecated \
 python3-gitlab \
 python3-httpx \
 python3-pyforgejo \
 python3-pygithub \
 python3-pyyaml \
 python3-requests \
 python3-urllib3 \
 "
