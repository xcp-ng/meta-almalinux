# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-peg-runtime"
PV = "0.8.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-peg-runtime+default-devel \
 rust-peg-runtime+std-devel \
 rust-peg-runtime+unstable-devel \
 rust-peg-runtime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-peg-runtime-0.8.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "764ce1594c97bcada6c2a93b2c399fe2b911de2875dba864008649ad68d44212"

URI_x86_64_v2_rust-peg-runtime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-runtime+default-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-runtime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-runtime+default-devel}"
SRC_URI[x86_64_v2_rust-peg-runtime+default-devel.sha256sum] = "0a308d28f37d0820db51ba05bc17bd6a3abee703c61722c9ca4b83695a00b5cc"

URI_x86_64_v2_rust-peg-runtime+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-runtime+std-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-runtime+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-runtime+std-devel}"
SRC_URI[x86_64_v2_rust-peg-runtime+std-devel.sha256sum] = "942107f8eeef25e2c336a18eb43b4f59b0c90b5da209a36fb59cbb943ccec392"

URI_x86_64_v2_rust-peg-runtime+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-runtime+unstable-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-runtime+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-runtime+unstable-devel}"
SRC_URI[x86_64_v2_rust-peg-runtime+unstable-devel.sha256sum] = "23c8dd8e1cc2202b0403c8528b072add4ac097a41f0ec33204d377d7c47b68f6"

URI_x86_64_v2_rust-peg-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-runtime-devel-0.8.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-runtime-devel}"
SRC_URI[x86_64_v2_rust-peg-runtime-devel.sha256sum] = "3ae2b18aa1c2af6e79f3ac3a136a9142fd7fbcbb3e739b78f19c817ed9a0eff3"

URI_aarch64_rust-peg-runtime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-runtime+default-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg-runtime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-runtime+default-devel}"
SRC_URI[aarch64_rust-peg-runtime+default-devel.sha256sum] = "59907d66a5a95919658fcd7afcd435394c5f1cd822e9bb6c2793684138023a48"

URI_aarch64_rust-peg-runtime+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-runtime+std-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg-runtime+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-runtime+std-devel}"
SRC_URI[aarch64_rust-peg-runtime+std-devel.sha256sum] = "e72bedfa53e3ccbe87ce024054e66f1e82b4b66503b2e9a64552053162aed73f"

URI_aarch64_rust-peg-runtime+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-runtime+unstable-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg-runtime+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-runtime+unstable-devel}"
SRC_URI[aarch64_rust-peg-runtime+unstable-devel.sha256sum] = "1977249c311587a7651699a9b0c467c240f8db1cf0ded9b40282fe4b23c2a6d4"

URI_aarch64_rust-peg-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-runtime-devel-0.8.5-1.el10_1.noarch.rpm;name=aarch64_rust-peg-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-runtime-devel}"
SRC_URI[aarch64_rust-peg-runtime-devel.sha256sum] = "4cee56b07eda4678a0d3ff0b958ee5aa4dbd9116578ba294d1a6654afcf92d98"

RDEPENDS:rust-peg-runtime+default-devel = " \
 cargo \
 rust-peg-runtime-devel \
 "
RDEPENDS:rust-peg-runtime+std-devel = " \
 cargo \
 rust-peg-runtime-devel \
 "
RDEPENDS:rust-peg-runtime+unstable-devel = " \
 cargo \
 rust-peg-runtime-devel \
 "
RDEPENDS:rust-peg-runtime-devel = " \
 cargo \
 "
