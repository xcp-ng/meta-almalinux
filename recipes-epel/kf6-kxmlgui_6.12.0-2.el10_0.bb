# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kxmlgui"
PV = "6.12.0"
PR = "2.el10_0"
PACKAGES = " \
 kf6-kxmlgui \
 kf6-kxmlgui-devel \
 kf6-kxmlgui-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kxmlgui-6.12.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "941553d12dfa47b90dea29da94afc8ecdfd0e29f034cae2ca336086165a4fc89"

URI_x86_64_v2_kf6-kxmlgui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-6.12.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui}"
SRC_URI[x86_64_v2_kf6-kxmlgui.sha256sum] = "684b423221de550bf0acd5b5cd57e38eb09a05ea257e54679c642f38ffeca110"

URI_x86_64_v2_kf6-kxmlgui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-devel-6.12.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kxmlgui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-devel}"
SRC_URI[x86_64_v2_kf6-kxmlgui-devel.sha256sum] = "639fccaa7dab66a3e0214035de9f75209e14f4cf9b2d01d3d5a1bae10280dbd3"

URI_x86_64_v2_kf6-kxmlgui-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-doc-6.12.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kxmlgui-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-doc}"
SRC_URI[x86_64_v2_kf6-kxmlgui-doc.sha256sum] = "bff5de03041647ddd4f5d45eee043127d83df8ef01be8268fe5acd54f4d2f66d"

URI_aarch64_kf6-kxmlgui = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-6.12.0-2.el10_0.aarch64.rpm;name=aarch64_kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui}"
SRC_URI[aarch64_kf6-kxmlgui.sha256sum] = "531016478d959f20abf45b9d5c8933dd0fac3ab53507ff556d368c75932ed62b"

URI_aarch64_kf6-kxmlgui-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-devel-6.12.0-2.el10_0.aarch64.rpm;name=aarch64_kf6-kxmlgui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-devel}"
SRC_URI[aarch64_kf6-kxmlgui-devel.sha256sum] = "263ee9c595d22e017524c576c729f00a8fec9bbb3f0718c0ba2c95628650d5af"

URI_aarch64_kf6-kxmlgui-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-doc-6.12.0-2.el10_0.noarch.rpm;name=aarch64_kf6-kxmlgui-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-doc}"
SRC_URI[aarch64_kf6-kxmlgui-doc.sha256sum] = "4faad6b1d7dc5c36af8606e6fd27494821c1242f07007de959df289630b309a0"

RDEPENDS:kf6-kxmlgui = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kxmlgui-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-kguiaddons-devel \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kxmlgui-doc = " \
 "
