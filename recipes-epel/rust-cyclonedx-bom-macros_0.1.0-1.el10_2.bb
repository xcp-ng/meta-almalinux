# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cyclonedx-bom-macros"
PV = "0.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-cyclonedx-bom-macros+default-devel \
 rust-cyclonedx-bom-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cyclonedx-bom-macros-0.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "222817dec2d28add86ad3cb20246775c27ebf2c5dd8ac881f7d8ccebc12a6a20"

URI_x86_64_v2_rust-cyclonedx-bom-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cyclonedx-bom-macros+default-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cyclonedx-bom-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cyclonedx-bom-macros+default-devel}"
SRC_URI[x86_64_v2_rust-cyclonedx-bom-macros+default-devel.sha256sum] = "9c9994f8b5711945d92cb5d308d4fc12be48a6f5c905f6ebf4599670b09e2808"

URI_x86_64_v2_rust-cyclonedx-bom-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cyclonedx-bom-macros-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cyclonedx-bom-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cyclonedx-bom-macros-devel}"
SRC_URI[x86_64_v2_rust-cyclonedx-bom-macros-devel.sha256sum] = "bacf99711c107e99d4beaab13da33330ddb6230a91c69f3eab84e9255350c2fd"

URI_aarch64_rust-cyclonedx-bom-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cyclonedx-bom-macros+default-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-cyclonedx-bom-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cyclonedx-bom-macros+default-devel}"
SRC_URI[aarch64_rust-cyclonedx-bom-macros+default-devel.sha256sum] = "f69218715887c6150367bcc131e6c182d052345c63760a42839344096bf92eb1"

URI_aarch64_rust-cyclonedx-bom-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cyclonedx-bom-macros-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-cyclonedx-bom-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cyclonedx-bom-macros-devel}"
SRC_URI[aarch64_rust-cyclonedx-bom-macros-devel.sha256sum] = "1b4885dad7d0f13b06bba4e139e3a55ce1dd62f7208ad2436453d9059bfd20ea"

RDEPENDS:rust-cyclonedx-bom-macros+default-devel = " \
 cargo \
 rust-cyclonedx-bom-macros-devel \
 "
RDEPENDS:rust-cyclonedx-bom-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 "
