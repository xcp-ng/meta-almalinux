# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "assertj-core"
PV = "3.24.2"
PR = "10.el10"
PACKAGES = " \
 assertj-core \
 assertj-core-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/assertj-core-3.24.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "976d1cc57f625fc95093e085570ebb6762d48addc4e61ed2f637e813f6cff169"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/assertj-core-3.24.2-10.el10.noarch.rpm;name=x86_64_v2_assertj-core;unpack=0"
SRC_URI[x86_64_v2_assertj-core.sha256sum] = "be6f9e52713bb862f50ba4cb52cfb4d2748d5ba488f272ad150b169236baa480"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/assertj-core-javadoc-3.24.2-10.el10.noarch.rpm;name=x86_64_v2_assertj-core-javadoc;unpack=0"
SRC_URI[x86_64_v2_assertj-core-javadoc.sha256sum] = "f904e85a40c24ac8ebd9e567930c0acfff860d8ede878e82b3c216554ec41286"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/assertj-core-3.24.2-10.el10.noarch.rpm;name=aarch64_assertj-core;unpack=0"
SRC_URI[aarch64_assertj-core.sha256sum] = "be6f9e52713bb862f50ba4cb52cfb4d2748d5ba488f272ad150b169236baa480"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/assertj-core-javadoc-3.24.2-10.el10.noarch.rpm;name=aarch64_assertj-core-javadoc;unpack=0"
SRC_URI[aarch64_assertj-core-javadoc.sha256sum] = "f904e85a40c24ac8ebd9e567930c0acfff860d8ede878e82b3c216554ec41286"

RDEPENDS:assertj-core = " \
 byte-buddy \
 javapackages-filesystem \
 "
RDEPENDS:assertj-core-javadoc = " \
 javapackages-filesystem \
 "
