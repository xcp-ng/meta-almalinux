# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "asio"
PV = "1.30.2"
PR = "9.el10_0"
PACKAGES = " \
 asio-devel \
 asio-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/asio-1.30.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "192a163bb1368b3edb8c4292dc3888ae413c637bbabeece6c4a2764de466e869"

URI_x86_64_v2_asio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asio-devel-1.30.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asio-devel}"
SRC_URI[x86_64_v2_asio-devel.sha256sum] = "8a8b5b244f7dbc56f5742ec5a4d656091ca45cfd9c69c8c7efafee9089aa11f8"

URI_x86_64_v2_asio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asio-doc-1.30.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_asio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asio-doc}"
SRC_URI[x86_64_v2_asio-doc.sha256sum] = "74ef85c10305b2f3351d7eb914af355a6597f848d93af3dbe1e8677b2a900e59"

URI_aarch64_asio-devel = "${EPEL_MIRROR}/aarch64/Packages/a/asio-devel-1.30.2-9.el10_0.aarch64.rpm;name=aarch64_asio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_asio-devel}"
SRC_URI[aarch64_asio-devel.sha256sum] = "6f8dab16fe1e2fa9873dee70d57a6e4e1e9bef0f5045b7b22f26066b8e618ad0"

URI_aarch64_asio-doc = "${EPEL_MIRROR}/aarch64/Packages/a/asio-doc-1.30.2-9.el10_0.noarch.rpm;name=aarch64_asio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_asio-doc}"
SRC_URI[aarch64_asio-doc.sha256sum] = "e464d90b568d5be858716cb799102a2c8a8136adb77411de9a8a6d38a575d261"

RDEPENDS:asio-devel = " \
 boost-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:asio-doc = " \
 "
