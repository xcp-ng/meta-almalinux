# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radare2"
PV = "5.9.8"
PR = "7.el10_1"
PACKAGES = " \
 radare2 \
 radare2-common \
 radare2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/radare2-5.9.8-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b030f450184d834596309ffd8db965c593153ee9649ed5269bead4c8a7ab6636"

URI_x86_64_v2_radare2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radare2-5.9.8-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radare2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radare2}"
SRC_URI[x86_64_v2_radare2.sha256sum] = "8baaa6826e3556f12557f5e3e449f7c5963b7277c1a748a8d4428c09b3405682"

URI_x86_64_v2_radare2-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radare2-common-5.9.8-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_radare2-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radare2-common}"
SRC_URI[x86_64_v2_radare2-common.sha256sum] = "59581c9be9c41d7538e854b5ca34a4ae09e3e01806b6c6e2cc7e39b12f894520"

URI_x86_64_v2_radare2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radare2-devel-5.9.8-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radare2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radare2-devel}"
SRC_URI[x86_64_v2_radare2-devel.sha256sum] = "4490790502a4a1956dbc708c1b2c9fd018321784b6e309ce2ece875a5d1895c7"

URI_aarch64_radare2 = "${EPEL_MIRROR}/aarch64/Packages/r/radare2-5.9.8-7.el10_1.aarch64.rpm;name=aarch64_radare2;unpack=0"
SRC_URI:append = " ${URI_aarch64_radare2}"
SRC_URI[aarch64_radare2.sha256sum] = "8504dca5786e7c528d59c34d5ed9accd17683084ad16d37436698cd3b4bc284b"

URI_aarch64_radare2-common = "${EPEL_MIRROR}/aarch64/Packages/r/radare2-common-5.9.8-7.el10_1.noarch.rpm;name=aarch64_radare2-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_radare2-common}"
SRC_URI[aarch64_radare2-common.sha256sum] = "9286bf39c0e860ec28501f5cf2b2260d685b9b7ef1b66eca739b83157029925c"

URI_aarch64_radare2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/radare2-devel-5.9.8-7.el10_1.aarch64.rpm;name=aarch64_radare2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_radare2-devel}"
SRC_URI[aarch64_radare2-devel.sha256sum] = "b90058745401450343d0a535a37e0d2e9927f1d4ae42731d2d56ce4f533d23b1"

RDEPENDS:radare2 = " \
 capstone \
 file-libs \
 glibc \
 libgcc \
 libuv \
 libzip \
 lz4-libs \
 radare2-common \
 xxhash-libs \
 zlib-ng-compat \
 "
RDEPENDS:radare2-common = " \
 radare2 \
 "
RDEPENDS:radare2-devel = " \
 capstone-devel \
 file-devel \
 libuv-devel \
 libzip-devel \
 lz4-devel \
 openssl-devel \
 pkgconf-pkg-config \
 radare2 \
 radare2-devel \
 xxhash-devel \
 zlib-ng-compat-devel \
 "
