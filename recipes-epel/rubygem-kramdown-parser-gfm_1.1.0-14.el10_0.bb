# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-kramdown-parser-gfm"
PV = "1.1.0"
PR = "14.el10_0"
PACKAGES = " \
 rubygem-kramdown-parser-gfm \
 rubygem-kramdown-parser-gfm-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-kramdown-parser-gfm-1.1.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3ec13bbf8e044b86fa017c8298ccbe824ed286e4224d4f65c9a814a7e72096f"

URI_x86_64_v2_rubygem-kramdown-parser-gfm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-kramdown-parser-gfm-1.1.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-kramdown-parser-gfm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-kramdown-parser-gfm}"
SRC_URI[x86_64_v2_rubygem-kramdown-parser-gfm.sha256sum] = "cdebc5f5d67d348c7b86508e53937ee88df6de40e063a24497207f2b76a995b0"

URI_x86_64_v2_rubygem-kramdown-parser-gfm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-kramdown-parser-gfm-doc-1.1.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-kramdown-parser-gfm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-kramdown-parser-gfm-doc}"
SRC_URI[x86_64_v2_rubygem-kramdown-parser-gfm-doc.sha256sum] = "4ab682fed578a065c1e32eda4c7b1da85b0154e4d3277f9604b3220fd0feacf3"

URI_aarch64_rubygem-kramdown-parser-gfm = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-kramdown-parser-gfm-1.1.0-14.el10_0.noarch.rpm;name=aarch64_rubygem-kramdown-parser-gfm;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-kramdown-parser-gfm}"
SRC_URI[aarch64_rubygem-kramdown-parser-gfm.sha256sum] = "3276c75a0338bfc837bb68b2e2ca7163425410ff67447cc764d85fa48022db58"

URI_aarch64_rubygem-kramdown-parser-gfm-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-kramdown-parser-gfm-doc-1.1.0-14.el10_0.noarch.rpm;name=aarch64_rubygem-kramdown-parser-gfm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-kramdown-parser-gfm-doc}"
SRC_URI[aarch64_rubygem-kramdown-parser-gfm-doc.sha256sum] = "0d68c9e5c3dca5fee1deedfefab1163963d3a25b1197ef8cb7256797eab67e2c"

RDEPENDS:rubygem-kramdown-parser-gfm = " \
 rubygem-kramdown \
 rubygems \
 "
RDEPENDS:rubygem-kramdown-parser-gfm-doc = " \
 rubygem-kramdown-parser-gfm \
 "
