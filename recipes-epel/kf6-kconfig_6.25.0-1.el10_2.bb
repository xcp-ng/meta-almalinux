# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kconfig"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kconfig \
 kf6-kconfig-devel \
 kf6-kconfig-doc \
 kf6-kconfig-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kconfig-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2460a025ac61cf71e14e234fef03282162276895899a8cf99d1769ccb2078de2"

URI_x86_64_v2_kf6-kconfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig}"
SRC_URI[x86_64_v2_kf6-kconfig.sha256sum] = "7e755a12261aee15a8337f95081d9f5dfcf7801e773bd2cde659ccf93077935b"

URI_x86_64_v2_kf6-kconfig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-devel}"
SRC_URI[x86_64_v2_kf6-kconfig-devel.sha256sum] = "e519cf77886624a89a7656702e0dfe118408b073fc90bec8fda796e039c24ffe"

URI_x86_64_v2_kf6-kconfig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-doc}"
SRC_URI[x86_64_v2_kf6-kconfig-doc.sha256sum] = "8a63cad64a0a0670ed6558e49934ea56bb5773970d07061c51b175a10ecd071e"

URI_x86_64_v2_kf6-kconfig-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfig-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-html}"
SRC_URI[x86_64_v2_kf6-kconfig-html.sha256sum] = "74d83b190ccd586f9b8cf8a2053dac94aa22a5ab86fde54d0ece7f5fd2877b02"

URI_aarch64_kf6-kconfig = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig}"
SRC_URI[aarch64_kf6-kconfig.sha256sum] = "2779c9707480edd2eee42891169ebf4710a0c94be63e91299dc8a9b2f580d604"

URI_aarch64_kf6-kconfig-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-devel}"
SRC_URI[aarch64_kf6-kconfig-devel.sha256sum] = "67734feeb2adc509b000de406e1b1d83f9c4a551bd04fe531bb14810f2ceb603"

URI_aarch64_kf6-kconfig-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kconfig-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-doc}"
SRC_URI[aarch64_kf6-kconfig-doc.sha256sum] = "8210170e3c9df1571f696621df34cc531ff5e502b8066ba3aa96cd32be1de800"

URI_aarch64_kf6-kconfig-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kconfig-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-html}"
SRC_URI[aarch64_kf6-kconfig-html.sha256sum] = "d8f67f5583db0b2a24ba344b34f2b4a9173fe3e30a67fb6da3f150ece355b702"

RDEPENDS:kf6-kconfig = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kconfig-devel = " \
 cmake-filesystem \
 kf6-kconfig \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kconfig-doc = " \
 "
RDEPENDS:kf6-kconfig-html = " \
 "
