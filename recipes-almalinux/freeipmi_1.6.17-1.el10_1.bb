# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeipmi"
PV = "1.6.17"
PR = "1.el10_1"
PACKAGES = " \
 freeipmi \
 freeipmi-bmc-watchdog \
 freeipmi-devel \
 freeipmi-ipmidetectd \
 freeipmi-ipmiseld \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freeipmi-1.6.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d72c3f51d5a74879eb8fd6b58899e8193972befb9a45ef4ad14f42e89fe4f707"

URI_x86_64_v2_freeipmi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-1.6.17-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_freeipmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi}"
SRC_URI[x86_64_v2_freeipmi.sha256sum] = "657f381ccbd11548f03484d0114e96169d413ab19f4f01be6e92ddbad8a6bb92"

URI_x86_64_v2_freeipmi-bmc-watchdog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-bmc-watchdog-1.6.17-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_freeipmi-bmc-watchdog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-bmc-watchdog}"
SRC_URI[x86_64_v2_freeipmi-bmc-watchdog.sha256sum] = "7d1924d4667ac0f378c5af254bc9b12fd94db0354b6794af5de719f248a7028f"

URI_x86_64_v2_freeipmi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeipmi-devel-1.6.17-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_freeipmi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-devel}"
SRC_URI[x86_64_v2_freeipmi-devel.sha256sum] = "1890b8df63aa38834925b21764c980374949703968c025987baee6aefc560f52"

URI_x86_64_v2_freeipmi-ipmidetectd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-ipmidetectd-1.6.17-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_freeipmi-ipmidetectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-ipmidetectd}"
SRC_URI[x86_64_v2_freeipmi-ipmidetectd.sha256sum] = "706525b3e9fe9d2943b6d818da46ec7d4d6dcfc6357229fad43397e455a4f3b7"

URI_x86_64_v2_freeipmi-ipmiseld = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-ipmiseld-1.6.17-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_freeipmi-ipmiseld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-ipmiseld}"
SRC_URI[x86_64_v2_freeipmi-ipmiseld.sha256sum] = "7bfaa4b1b4f9a7da87cca3f8810b7bd5e728fed9491dd52445e21538e65b384c"

URI_aarch64_freeipmi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-1.6.17-1.el10_1.aarch64.rpm;name=aarch64_freeipmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi}"
SRC_URI[aarch64_freeipmi.sha256sum] = "5afb6743cc1bc2a36c9de10e0830f971c108f87d1a30a3ffe750c4a29c2dd9a5"

URI_aarch64_freeipmi-bmc-watchdog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-bmc-watchdog-1.6.17-1.el10_1.aarch64.rpm;name=aarch64_freeipmi-bmc-watchdog;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-bmc-watchdog}"
SRC_URI[aarch64_freeipmi-bmc-watchdog.sha256sum] = "449db352a64832b8ecb4df2a79f5fa6b4e8f8f125ac6d3c36ad24b53225325d2"

URI_aarch64_freeipmi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeipmi-devel-1.6.17-1.el10_1.aarch64.rpm;name=aarch64_freeipmi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-devel}"
SRC_URI[aarch64_freeipmi-devel.sha256sum] = "db13438c1c90da8623d54c716a33c27f89164053937c6f2642123d74c4527163"

URI_aarch64_freeipmi-ipmidetectd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-ipmidetectd-1.6.17-1.el10_1.aarch64.rpm;name=aarch64_freeipmi-ipmidetectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-ipmidetectd}"
SRC_URI[aarch64_freeipmi-ipmidetectd.sha256sum] = "6240800df792d43df12415cc69396db77718fc3279abaf8111b65ee12f2c2760"

URI_aarch64_freeipmi-ipmiseld = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-ipmiseld-1.6.17-1.el10_1.aarch64.rpm;name=aarch64_freeipmi-ipmiseld;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-ipmiseld}"
SRC_URI[aarch64_freeipmi-ipmiseld.sha256sum] = "c457f0bfd80fc507702b0b26c4ff39ad5f564039c141a7fb8662ca8be5f88deb"

RDEPENDS:freeipmi = " \
 bash \
 glibc \
 libgcrypt \
 systemd \
 "
RDEPENDS:freeipmi-bmc-watchdog = " \
 bash \
 freeipmi \
 glibc \
 "
RDEPENDS:freeipmi-devel = " \
 freeipmi \
 pkgconf-pkg-config \
 "
RDEPENDS:freeipmi-ipmidetectd = " \
 bash \
 freeipmi \
 glibc \
 "
RDEPENDS:freeipmi-ipmiseld = " \
 bash \
 freeipmi \
 glibc \
 "
