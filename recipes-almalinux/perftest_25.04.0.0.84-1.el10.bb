# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perftest"
PV = "25.04.0.0.84"
PR = "1.el10"
PACKAGES = " \
 perftest \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/perftest-25.04.0.0.84-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dd776dc5e19cf0a9e2a821e3aed307c6d81f5fd6f211fd08d02951f3a3610ae1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/perftest-25.04.0.0.84-1.el10.x86_64_v2.rpm;name=x86_64_v2_perftest;unpack=0"
SRC_URI[x86_64_v2_perftest.sha256sum] = "c7d3f4a23c9794bb310d6c129f20c3254b636dae8cfc9990a32fe01892ab2e4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/perftest-25.04.0.0.84-1.el10.aarch64.rpm;name=aarch64_perftest;unpack=0"
SRC_URI[aarch64_perftest.sha256sum] = "122d832a01dc12dae703417996cebd5eaf3e579177cf49fdbd650273c94dfe4f"

RDEPENDS:perftest = " \
 glibc \
 libibumad \
 libibverbs \
 librdmacm \
 pciutils-libs \
 "
