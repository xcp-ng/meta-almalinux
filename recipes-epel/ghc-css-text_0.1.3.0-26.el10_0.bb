# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-css-text"
PV = "0.1.3.0"
PR = "26.el10_0"
PACKAGES = " \
 ghc-css-text \
 ghc-css-text-devel \
 ghc-css-text-doc \
 ghc-css-text-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-css-text-0.1.3.0-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e1b62e8c786a9ed4eb232d5d1940c5156a304a12e9c12c72f3dee43e560e97e"

URI_x86_64_v2_ghc-css-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-css-text-0.1.3.0-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-css-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-css-text}"
SRC_URI[x86_64_v2_ghc-css-text.sha256sum] = "ebd3ae80dc9215a3418634c9c4c1f5c385f27aa91ebcf4ea59e281270edeecac"

URI_x86_64_v2_ghc-css-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-css-text-devel-0.1.3.0-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-css-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-css-text-devel}"
SRC_URI[x86_64_v2_ghc-css-text-devel.sha256sum] = "1806a0f54172c3bc9be73bfcc8ede8cdd4a8e5fd89e2ae65212791486aa80703"

URI_x86_64_v2_ghc-css-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-css-text-doc-0.1.3.0-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-css-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-css-text-doc}"
SRC_URI[x86_64_v2_ghc-css-text-doc.sha256sum] = "d7da92141abb0131d2204e66139d4a1be3937299aa507834e6d752dc095aa6f1"

URI_x86_64_v2_ghc-css-text-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-css-text-prof-0.1.3.0-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-css-text-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-css-text-prof}"
SRC_URI[x86_64_v2_ghc-css-text-prof.sha256sum] = "aaf0b9b9f32ff7500a3a4db0f5ad3eeb74e1d9bb14415f1aac75fe5abff338c6"

URI_aarch64_ghc-css-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-css-text-0.1.3.0-26.el10_0.aarch64.rpm;name=aarch64_ghc-css-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-css-text}"
SRC_URI[aarch64_ghc-css-text.sha256sum] = "8a07b1b1528b19ac09166e8da0c475f938499f6fb6c2dcc17c82ee39a7486c7f"

URI_aarch64_ghc-css-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-css-text-devel-0.1.3.0-26.el10_0.aarch64.rpm;name=aarch64_ghc-css-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-css-text-devel}"
SRC_URI[aarch64_ghc-css-text-devel.sha256sum] = "ca05ade2da8401e91478bce6b931fa02579c95ca3c3ad425bde28abcde0185b0"

URI_aarch64_ghc-css-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-css-text-doc-0.1.3.0-26.el10_0.noarch.rpm;name=aarch64_ghc-css-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-css-text-doc}"
SRC_URI[aarch64_ghc-css-text-doc.sha256sum] = "85479ad81742e808970879dde334ca95c22678ea13b442149414c970392415ec"

URI_aarch64_ghc-css-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-css-text-prof-0.1.3.0-26.el10_0.aarch64.rpm;name=aarch64_ghc-css-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-css-text-prof}"
SRC_URI[aarch64_ghc-css-text-prof.sha256sum] = "cdf72d868d2cf6d42069876978f5d8467e9ced10d7a4bbf6920fbc6c4c41a92e"

RDEPENDS:ghc-css-text = " \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-css-text-devel = " \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-css-text \
 ghc-text-devel \
 "
RDEPENDS:ghc-css-text-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-css-text-prof = " \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-css-text-devel \
 ghc-text-prof \
 "
