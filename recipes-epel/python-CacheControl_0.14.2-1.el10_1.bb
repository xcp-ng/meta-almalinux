# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-CacheControl"
PV = "0.14.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-CacheControl \
 python3-CacheControl+filecache \
 python3-CacheControl+redis \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-CacheControl-0.14.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3677967d18a0573fd8aeb0309e38967347e088041adb4215f6c4d89f137efd4"

URI_x86_64_v2_python3-CacheControl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-CacheControl-0.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-CacheControl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-CacheControl}"
SRC_URI[x86_64_v2_python3-CacheControl.sha256sum] = "827604b0827648bad56c283812d128b848b318fc2b254d8af1e56b7fdd76532a"

URI_x86_64_v2_python3-CacheControl+filecache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-CacheControl+filecache-0.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-CacheControl+filecache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-CacheControl+filecache}"
SRC_URI[x86_64_v2_python3-CacheControl+filecache.sha256sum] = "c333570fc062e471c565b8f746a07a07974bdfa0735dabe1c3c0740686063bd1"

URI_x86_64_v2_python3-CacheControl+redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-CacheControl+redis-0.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-CacheControl+redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-CacheControl+redis}"
SRC_URI[x86_64_v2_python3-CacheControl+redis.sha256sum] = "97a47843db5c9c43ac93f3a3352d858f003745314aaa5650249a0eff35047b66"

URI_aarch64_python3-CacheControl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-CacheControl-0.14.2-1.el10_1.noarch.rpm;name=aarch64_python3-CacheControl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-CacheControl}"
SRC_URI[aarch64_python3-CacheControl.sha256sum] = "fc9c10b08b0acd3f312e70adf00b6f9afdea9ad1cb4da3ebdc4cb339bb66129d"

URI_aarch64_python3-CacheControl+filecache = "${EPEL_MIRROR}/aarch64/Packages/p/python3-CacheControl+filecache-0.14.2-1.el10_1.noarch.rpm;name=aarch64_python3-CacheControl+filecache;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-CacheControl+filecache}"
SRC_URI[aarch64_python3-CacheControl+filecache.sha256sum] = "525ed454ccfebde460eceb22766ac3f3a864fbf0ad9b979874d30ffbfd87fef0"

URI_aarch64_python3-CacheControl+redis = "${EPEL_MIRROR}/aarch64/Packages/p/python3-CacheControl+redis-0.14.2-1.el10_1.noarch.rpm;name=aarch64_python3-CacheControl+redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-CacheControl+redis}"
SRC_URI[aarch64_python3-CacheControl+redis.sha256sum] = "aa0baa86c812ace9e4fa54fb1eac186af59fce7a1b744606e5bda17b001a4496"

RDEPENDS:python3-CacheControl = " \
 python3 \
 python3-msgpack \
 python3-requests \
 "
RDEPENDS:python3-CacheControl+filecache = " \
 python3 \
 python3-CacheControl \
 python3-filelock \
 "
RDEPENDS:python3-CacheControl+redis = " \
 python3 \
 python3-CacheControl \
 python3-redis \
 "
