# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pycdio"
PV = "2.1.0"
PR = "16.el10"
PACKAGES = " \
 python3-pycdio \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pycdio-2.1.0-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20cee336d2640a118e4bf40ba6a13ab12652c6d345c0d1baf8a344599d894db8"

URI_x86_64_v2_python3-pycdio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pycdio-2.1.0-16.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pycdio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pycdio}"
SRC_URI[x86_64_v2_python3-pycdio.sha256sum] = "d9a146b53f5bcb9709d82049a60740d6f9548e48b14d3f111a8b8b1b88b24ee3"

URI_aarch64_python3-pycdio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pycdio-2.1.0-16.el10.aarch64.rpm;name=aarch64_python3-pycdio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pycdio}"
SRC_URI[aarch64_python3-pycdio.sha256sum] = "347659401b377557d117d8129c5bdb5feb1b4c1d3ae74a657feb0733b11c76ee"

RDEPENDS:python3-pycdio = " \
 glibc \
 libcdio \
 python3 \
 "
