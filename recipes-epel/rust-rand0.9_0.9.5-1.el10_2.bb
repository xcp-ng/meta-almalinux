# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand0.9"
PV = "0.9.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand0.9+alloc-devel \
 rust-rand0.9+default-devel \
 rust-rand0.9+log-devel \
 rust-rand0.9+os_rng-devel \
 rust-rand0.9+serde-devel \
 rust-rand0.9+small_rng-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9+thread_rng-devel \
 rust-rand0.9+unbiased-devel \
 rust-rand0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand0.9-0.9.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69c45cef6ed5590f7ca712026ba56e2d142389ff5339d0fb816c5e59852c3934"

URI_x86_64_v2_rust-rand0.9+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+alloc-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+alloc-devel.sha256sum] = "278b99a36e133f0b7e7b659a4f3b74bbc2c3246e0bd8b20d02f7dfa97a42de33"

URI_x86_64_v2_rust-rand0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+default-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+default-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+default-devel.sha256sum] = "335ce2fe5f7b0b65a08e757c7a4ea601eede0bd537296ad61c791e5c7478206f"

URI_x86_64_v2_rust-rand0.9+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+log-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+log-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+log-devel.sha256sum] = "dc4b0570e1cb1c43b713969a3f7be9174f3e53c38a79fefe0b2045a99bb5f811"

URI_x86_64_v2_rust-rand0.9+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+os_rng-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+os_rng-devel.sha256sum] = "7146ecce9b264656db547bd8fcc8774977e4f06c76fdf0951cc208e26759406e"

URI_x86_64_v2_rust-rand0.9+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+serde-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+serde-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+serde-devel.sha256sum] = "fb702799756efdc5906340e39c1597816f13e383b03d48236c5d79a3577d1aac"

URI_x86_64_v2_rust-rand0.9+small_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+small_rng-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+small_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+small_rng-devel.sha256sum] = "4d2ec2fb15a90a49e65eae01de167f9dfef66dfa4f952b8211d7f8af04c19742"

URI_x86_64_v2_rust-rand0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+std-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+std-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+std-devel.sha256sum] = "279068fc7e95967445c64884b0b46d7cbb3c183c2c4ab9f5e6521503f63c9b6d"

URI_x86_64_v2_rust-rand0.9+std_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+std_rng-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+std_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+std_rng-devel.sha256sum] = "ff7eb92e14b7b9763e9bbdcf73cbcbb80234685caf669f6a4251cc4f4896e814"

URI_x86_64_v2_rust-rand0.9+thread_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+thread_rng-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+thread_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+thread_rng-devel.sha256sum] = "c24176a57c4936fc4b43bf466ebe0fa0a8e6f231e19ed1d4f159564bee2d2c75"
RPROVIDES:rust-rand0.9+thread_rng-devel:x86_64_v2 = "virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

URI_x86_64_v2_rust-rand0.9+unbiased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9+unbiased-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9+unbiased-devel}"
SRC_URI[x86_64_v2_rust-rand0.9+unbiased-devel.sha256sum] = "4b47e7e29a0558ffe255675e2cbab7c38ddc76338b5405da8a7894343575f8d0"

URI_x86_64_v2_rust-rand0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.9-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.9-devel}"
SRC_URI[x86_64_v2_rust-rand0.9-devel.sha256sum] = "3d1c8ff383cd0fe06cc7965e7a2e480e7ea1c8da53bdbdbaa01ad439a078be2d"
RPROVIDES:rust-rand0.9-devel:x86_64_v2 = "virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

URI_aarch64_rust-rand0.9+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+alloc-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+alloc-devel}"
SRC_URI[aarch64_rust-rand0.9+alloc-devel.sha256sum] = "6ec063f8fd24a24bf9d3e74b9944bb10d7debdbc15acb0227682e7cb9c8845c1"

URI_aarch64_rust-rand0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+default-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+default-devel}"
SRC_URI[aarch64_rust-rand0.9+default-devel.sha256sum] = "64db7f538492ef5ac099b8936cead21898550fae08a2e916b70f3c64d5decdd3"

URI_aarch64_rust-rand0.9+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+log-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+log-devel}"
SRC_URI[aarch64_rust-rand0.9+log-devel.sha256sum] = "e0c27d58668a016a9e17e71e28eaab65136f7f35ff24e3d292999bd475a947f6"

URI_aarch64_rust-rand0.9+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+os_rng-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+os_rng-devel}"
SRC_URI[aarch64_rust-rand0.9+os_rng-devel.sha256sum] = "8022075b47cddac2fc52736766fdbc21aff4566bc95a1e0bd89dc47cb40ad723"

URI_aarch64_rust-rand0.9+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+serde-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+serde-devel}"
SRC_URI[aarch64_rust-rand0.9+serde-devel.sha256sum] = "9d5b2168c35499cdcd894f66b67f941a62a92e908e3050e315157470770592ce"

URI_aarch64_rust-rand0.9+small_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+small_rng-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+small_rng-devel}"
SRC_URI[aarch64_rust-rand0.9+small_rng-devel.sha256sum] = "6ef26a0189dfae14784aae524e9d9ca7948e54921fa918480915f934f26d0cdf"

URI_aarch64_rust-rand0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+std-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+std-devel}"
SRC_URI[aarch64_rust-rand0.9+std-devel.sha256sum] = "6ab1bc9935dc1cf1fa0c50b689a163914d9020e1a11958833590c6af9b08f7a8"

URI_aarch64_rust-rand0.9+std_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+std_rng-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+std_rng-devel}"
SRC_URI[aarch64_rust-rand0.9+std_rng-devel.sha256sum] = "9ac75cadbc39edccc141b34a507e6d59ceb7e10352d3f232ae737742c7d0e8ed"

URI_aarch64_rust-rand0.9+thread_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+thread_rng-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+thread_rng-devel}"
SRC_URI[aarch64_rust-rand0.9+thread_rng-devel.sha256sum] = "8c88d0dc8937f477156af451b00fc646bab5a2bd7f9e87a0777858a4c92fecba"
RPROVIDES:rust-rand0.9+thread_rng-devel:aarch64 = "virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

URI_aarch64_rust-rand0.9+unbiased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9+unbiased-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9+unbiased-devel}"
SRC_URI[aarch64_rust-rand0.9+unbiased-devel.sha256sum] = "3459b794d2c95ea1462945b0986b96ac3e012ae1326902a40a3795b07c6a59ee"

URI_aarch64_rust-rand0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.9-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.9-devel}"
SRC_URI[aarch64_rust-rand0.9-devel.sha256sum] = "8e87fcc40a0dccf52b377c1604c9ce7e57a7113dd3b2fc863b3d03dd21e3f61d"
RPROVIDES:rust-rand0.9-devel:aarch64 = "virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

RDEPENDS:rust-rand0.9+alloc-devel = " \
 cargo \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9+default-devel = " \
 cargo \
 rust-rand0.9+os_rng-devel \
 rust-rand0.9+small_rng-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9+thread_rng-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9+log-devel = " \
 cargo \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9+os_rng-devel = " \
 cargo \
 rust-rand0.9-devel \
 rust-rand_core0.9+os_rng-devel \
 "
RDEPENDS:rust-rand0.9+serde-devel = " \
 cargo \
 rust-rand0.9-devel \
 rust-rand_core0.9+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand0.9+small_rng-devel = " \
 cargo \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9+std-devel = " \
 cargo \
 rust-rand0.9+alloc-devel \
 rust-rand0.9-devel \
 rust-rand_chacha0.9+std-devel \
 rust-rand_chacha0.9-devel \
 rust-rand_core0.9+std-devel \
 "
RDEPENDS:rust-rand0.9+std_rng-devel = " \
 cargo \
 rust-rand0.9-devel \
 rust-rand_chacha0.9-devel \
 "
RDEPENDS:rust-rand0.9+thread_rng-devel = " \
 cargo \
 rust-rand0.9+os_rng-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9+unbiased-devel = " \
 cargo \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-rand0.9-devel = " \
 cargo \
 rust \
 rust-rand_core0.9-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 rpm/virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

PROVIDES:append:aarch64 = " rpm/virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 rpm/virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"
