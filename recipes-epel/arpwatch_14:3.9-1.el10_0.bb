# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arpwatch"
PE = "14"
PV = "3.9"
PR = "1.el10_0"
PACKAGES = " \
 arpwatch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/arpwatch-3.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7863ad8b7917838a016a6c412cd0a00c7647e2f0384b31d6a5c844211f478de"

URI_x86_64_v2_arpwatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arpwatch-3.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arpwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arpwatch}"
SRC_URI[x86_64_v2_arpwatch.sha256sum] = "fc9807adfda57161cac6f307220fcfb2dcd841c03dba00349e82634fd216907f"

URI_aarch64_arpwatch = "${EPEL_MIRROR}/aarch64/Packages/a/arpwatch-3.9-1.el10_0.aarch64.rpm;name=aarch64_arpwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_arpwatch}"
SRC_URI[aarch64_arpwatch.sha256sum] = "d5766bae9b36e1e3e3bf471298febdf25151f90fcace94c346f73d774f71910b"

RDEPENDS:arpwatch = " \
 bash \
 glibc \
 libpcap \
 python3 \
 shadow-utils \
 virtual//usr/sbin/sendmail \
 "
