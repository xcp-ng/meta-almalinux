# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg-expr"
PV = "0.17.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-cfg-expr+default-devel \
 rust-cfg-expr+target-lexicon-devel \
 rust-cfg-expr+targets-devel \
 rust-cfg-expr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg-expr-0.17.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "643ed9def5ab36fb7bc1ffa3c7e11f2a3e020047120e1016f3054248f69bb45e"

URI_x86_64_v2_rust-cfg-expr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+default-devel-0.17.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr+default-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr+default-devel.sha256sum] = "3e5eb4130421a53ef8819e40e32761c004e94fa3f3070a005bf8ba4c9046a2d9"

URI_x86_64_v2_rust-cfg-expr+target-lexicon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+target-lexicon-devel-0.17.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr+target-lexicon-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr+target-lexicon-devel.sha256sum] = "cfdbec8de2b0c09a401297b91136cd55ea044fef2fc52479c1ee9436f52d66a0"

URI_x86_64_v2_rust-cfg-expr+targets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+targets-devel-0.17.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+targets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr+targets-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr+targets-devel.sha256sum] = "623bba473f54ab4d12945ec8f46c79cae1de234d3b733818da55ecbe31514a5b"

URI_x86_64_v2_rust-cfg-expr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr-devel-0.17.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr-devel.sha256sum] = "04140a536d037022b4bcf70d177d8d4981116291dcf3ea433a595fd614b000b4"

URI_aarch64_rust-cfg-expr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+default-devel-0.17.2-2.el10_0.noarch.rpm;name=aarch64_rust-cfg-expr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr+default-devel}"
SRC_URI[aarch64_rust-cfg-expr+default-devel.sha256sum] = "b73fab9d47617546cb684a4ff6bb94aea3dd26704e54765254b2da1ec34bdce6"

URI_aarch64_rust-cfg-expr+target-lexicon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+target-lexicon-devel-0.17.2-2.el10_0.noarch.rpm;name=aarch64_rust-cfg-expr+target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr+target-lexicon-devel}"
SRC_URI[aarch64_rust-cfg-expr+target-lexicon-devel.sha256sum] = "aa856476f42db473af8696e2a2abdb6cbf300aee9df64de43c4e48c3b1394ce0"

URI_aarch64_rust-cfg-expr+targets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+targets-devel-0.17.2-2.el10_0.noarch.rpm;name=aarch64_rust-cfg-expr+targets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr+targets-devel}"
SRC_URI[aarch64_rust-cfg-expr+targets-devel.sha256sum] = "9ecc46e90239b3fddbd4682b9f4ab08a38226f04f6b554c858524020a14e51c4"

URI_aarch64_rust-cfg-expr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr-devel-0.17.2-2.el10_0.noarch.rpm;name=aarch64_rust-cfg-expr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr-devel}"
SRC_URI[aarch64_rust-cfg-expr-devel.sha256sum] = "45c1f515a123460417ff56feb885c2dc80cf8d5e7107646bc9f50109336a05f1"

RDEPENDS:rust-cfg-expr+default-devel = " \
 cargo \
 rust-cfg-expr-devel \
 "
RDEPENDS:rust-cfg-expr+target-lexicon-devel = " \
 cargo \
 rust-cfg-expr-devel \
 rust-target-lexicon0.12+default-devel \
 "
RDEPENDS:rust-cfg-expr+targets-devel = " \
 cargo \
 rust-cfg-expr+target-lexicon-devel \
 rust-cfg-expr-devel \
 "
RDEPENDS:rust-cfg-expr-devel = " \
 cargo \
 rust \
 rust-smallvec+default-devel \
 "
