# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-clock"
PV = "0.8.4"
PR = "4.el10_0"
PACKAGES = " \
 ghc-clock \
 ghc-clock-devel \
 ghc-clock-doc \
 ghc-clock-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-clock-0.8.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b512d42afd533cf54dcbf06b5178dec6017396ece3b79377e69d690a5cadbeb"

URI_x86_64_v2_ghc-clock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-clock-0.8.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-clock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-clock}"
SRC_URI[x86_64_v2_ghc-clock.sha256sum] = "7ccf12ee0409c418b85e94801a69a902448e9007cc33116311eb5a5652badccf"

URI_x86_64_v2_ghc-clock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-clock-devel-0.8.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-clock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-clock-devel}"
SRC_URI[x86_64_v2_ghc-clock-devel.sha256sum] = "c124a69ff4cea412cbfd4edd296b40f16968ea3882529f29a2d73968fec20e41"

URI_x86_64_v2_ghc-clock-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-clock-doc-0.8.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-clock-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-clock-doc}"
SRC_URI[x86_64_v2_ghc-clock-doc.sha256sum] = "9b580b3cfc60fb927b42ffd9e9089657d577e5a48e3bbfbe8126c99bd4cb96ec"

URI_x86_64_v2_ghc-clock-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-clock-prof-0.8.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-clock-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-clock-prof}"
SRC_URI[x86_64_v2_ghc-clock-prof.sha256sum] = "4dce90312799952ed9cdbe39839563e7644fb6b9ffdf6ce9519e9a9102e45e2f"

URI_aarch64_ghc-clock = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-clock-0.8.4-4.el10_0.aarch64.rpm;name=aarch64_ghc-clock;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-clock}"
SRC_URI[aarch64_ghc-clock.sha256sum] = "5d73d7a5e67d411f3769934eb0004b9b8528371e3cbb15d2ad93796cc0d9eeae"

URI_aarch64_ghc-clock-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-clock-devel-0.8.4-4.el10_0.aarch64.rpm;name=aarch64_ghc-clock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-clock-devel}"
SRC_URI[aarch64_ghc-clock-devel.sha256sum] = "6b596827b2157e2539764129f4a683fd5d5e5a90ca7ca2d9a12ba5fc23690b94"

URI_aarch64_ghc-clock-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-clock-doc-0.8.4-4.el10_0.noarch.rpm;name=aarch64_ghc-clock-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-clock-doc}"
SRC_URI[aarch64_ghc-clock-doc.sha256sum] = "8b32acd35855a2cec54d45c761d841ec1d7fba035355a4888f8ef8095dce1c0e"

URI_aarch64_ghc-clock-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-clock-prof-0.8.4-4.el10_0.aarch64.rpm;name=aarch64_ghc-clock-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-clock-prof}"
SRC_URI[aarch64_ghc-clock-prof.sha256sum] = "289394d691bf42f59eb198f9f3227de5b053b60748883af0b9a268f44dbfed5e"

RDEPENDS:ghc-clock = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-clock-devel = " \
 ghc-base-devel \
 ghc-clock \
 ghc-compiler \
 "
RDEPENDS:ghc-clock-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-clock-prof = " \
 ghc-base-prof \
 ghc-clock-devel \
 "
