# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knotifyconfig"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-knotifyconfig \
 kf6-knotifyconfig-devel \
 kf6-knotifyconfig-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knotifyconfig-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f70cd8cda719b06f8a19d82e183b71d662920fe732d7a2bc9500bcdd55de185"

URI_x86_64_v2_kf6-knotifyconfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifyconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig}"
SRC_URI[x86_64_v2_kf6-knotifyconfig.sha256sum] = "e8b6b5206de16f06c1fe5dc1a2e87b11bacdf13de76bd9ad29e04ba54ba026e0"

URI_x86_64_v2_kf6-knotifyconfig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifyconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-devel}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-devel.sha256sum] = "2cc645174c5e4951d4b08c643fc703dad14c2e09039790512a5456082e6b8ba9"

URI_x86_64_v2_kf6-knotifyconfig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifyconfig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-doc}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-doc.sha256sum] = "806c9caf811eac8606be31f2d7a5109badbaf168633d16536ee28b5fde0e6b0c"

URI_aarch64_kf6-knotifyconfig = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-knotifyconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig}"
SRC_URI[aarch64_kf6-knotifyconfig.sha256sum] = "676a4f0f24a10c0850abebf8ef9c0590e45ed26e5a7adc76dc6da74f9f91d102"

URI_aarch64_kf6-knotifyconfig-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-knotifyconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-devel}"
SRC_URI[aarch64_kf6-knotifyconfig-devel.sha256sum] = "db3bddad71f927c1b899d079ade54aa64bf2a5ccb741e05e8e3279797b09ef3f"

URI_aarch64_kf6-knotifyconfig-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-knotifyconfig-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-doc}"
SRC_URI[aarch64_kf6-knotifyconfig-doc.sha256sum] = "e8410efe4a9a08336a474a57a45ad0a2dfa13286dd92c4cea86292b61230f40f"

RDEPENDS:kf6-knotifyconfig = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 libcanberra \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-knotifyconfig-devel = " \
 cmake-filesystem \
 kf6-knotifyconfig \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-knotifyconfig-doc = " \
 "
