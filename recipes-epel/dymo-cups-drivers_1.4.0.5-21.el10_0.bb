# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dymo-cups-drivers"
PV = "1.4.0.5"
PR = "21.el10_0"
PACKAGES = " \
 dymo-cups-drivers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dymo-cups-drivers-1.4.0.5-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62b9566f8920e8928fb7f4be1bcc5954a414386022d7b2dda22ad67c19e839b7"

URI_x86_64_v2_dymo-cups-drivers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dymo-cups-drivers-1.4.0.5-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dymo-cups-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dymo-cups-drivers}"
SRC_URI[x86_64_v2_dymo-cups-drivers.sha256sum] = "e5c3d3a066a6b4218eb29f398adb84d9de5d6d13c7d28789b07d03a666732861"

URI_aarch64_dymo-cups-drivers = "${EPEL_MIRROR}/aarch64/Packages/d/dymo-cups-drivers-1.4.0.5-21.el10_0.aarch64.rpm;name=aarch64_dymo-cups-drivers;unpack=0"
SRC_URI:append = " ${URI_aarch64_dymo-cups-drivers}"
SRC_URI[aarch64_dymo-cups-drivers.sha256sum] = "73a8ab149e083043597544149a5fa41d19df191f7d44f46737c655e02b3250e7"

RDEPENDS:dymo-cups-drivers = " \
 cups \
 cups-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
