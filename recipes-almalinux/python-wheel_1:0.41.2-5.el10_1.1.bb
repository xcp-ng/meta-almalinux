# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wheel"
PE = "1"
PV = "0.41.2"
PR = "5.el10_1.1"
PACKAGES = " \
 python3-wheel \
 python3-wheel-wheel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-wheel-0.41.2-5.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f3bd5dcda529ef293bd449d4443d544d69fcc5372d9514d903ee775f1034f18"

URI_x86_64_v2_python3-wheel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-wheel-0.41.2-5.el10_1.1.noarch.rpm;name=x86_64_v2_python3-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wheel}"
SRC_URI[x86_64_v2_python3-wheel.sha256sum] = "526834e9f1485bd54d081d53739d5af8b9041cb043cbac4c4a48f5dc15693afd"

URI_x86_64_v2_python3-wheel-wheel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-wheel-wheel-0.41.2-5.el10_1.1.noarch.rpm;name=x86_64_v2_python3-wheel-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wheel-wheel}"
SRC_URI[x86_64_v2_python3-wheel-wheel.sha256sum] = "d4a990e9084a15b4ecd6fe1cc0ad10bf653891914d36b6941dd44c2950e729ba"

URI_aarch64_python3-wheel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-wheel-0.41.2-5.el10_1.1.noarch.rpm;name=aarch64_python3-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wheel}"
SRC_URI[aarch64_python3-wheel.sha256sum] = "526834e9f1485bd54d081d53739d5af8b9041cb043cbac4c4a48f5dc15693afd"

URI_aarch64_python3-wheel-wheel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-wheel-wheel-0.41.2-5.el10_1.1.noarch.rpm;name=aarch64_python3-wheel-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wheel-wheel}"
SRC_URI[aarch64_python3-wheel-wheel.sha256sum] = "d4a990e9084a15b4ecd6fe1cc0ad10bf653891914d36b6941dd44c2950e729ba"

RDEPENDS:python3-wheel = " \
 python3 \
 "
RDEPENDS:python3-wheel-wheel = " \
 "
