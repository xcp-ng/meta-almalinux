# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "catch"
PV = "3.8.1"
PR = "1.el10_1"
PACKAGES = " \
 catch \
 catch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/catch-3.8.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "191b8fdf7ff993721f7bc0262563dc40c02c06fdc5fca1cb6169dc3d12827df0"

URI_x86_64_v2_catch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/catch-3.8.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_catch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_catch}"
SRC_URI[x86_64_v2_catch.sha256sum] = "fd29c2dfb71a2ca7e073f966d2b29f2f347573ebb2ec9ce11b556f0ab7a0055f"

URI_x86_64_v2_catch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/catch-devel-3.8.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_catch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_catch-devel}"
SRC_URI[x86_64_v2_catch-devel.sha256sum] = "409e4b3f5ed6afd85cb5ec798d5d16ec12bb0eb34383b8676c872c5ca074071a"

URI_aarch64_catch = "${EPEL_MIRROR}/aarch64/Packages/c/catch-3.8.1-1.el10_1.aarch64.rpm;name=aarch64_catch;unpack=0"
SRC_URI:append = " ${URI_aarch64_catch}"
SRC_URI[aarch64_catch.sha256sum] = "54db84e3d7c942fcec760d143166578d859f798fdac7bae3a691794c71ecf962"

URI_aarch64_catch-devel = "${EPEL_MIRROR}/aarch64/Packages/c/catch-devel-3.8.1-1.el10_1.aarch64.rpm;name=aarch64_catch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_catch-devel}"
SRC_URI[aarch64_catch-devel.sha256sum] = "466628f0a2d22d7f198a9920d2436a722959ef8359b249b94304367cad603fce"

RDEPENDS:catch = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:catch-devel = " \
 catch \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
