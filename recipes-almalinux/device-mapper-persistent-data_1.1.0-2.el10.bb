# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "device-mapper-persistent-data"
PV = "1.1.0"
PR = "2.el10"
PACKAGES = " \
 device-mapper-persistent-data \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/device-mapper-persistent-data-1.1.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45ca7781874793f18e51560905c73e7e020b6e90d648af8d5b531c0bc92f7a92"

URI_x86_64_v2_device-mapper-persistent-data = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-persistent-data-1.1.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-persistent-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-persistent-data}"
SRC_URI[x86_64_v2_device-mapper-persistent-data.sha256sum] = "805e01c4021097990a6f5151636c138b2833c973832e85276adf2d71bab00403"

URI_aarch64_device-mapper-persistent-data = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-persistent-data-1.1.0-2.el10.aarch64.rpm;name=aarch64_device-mapper-persistent-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-persistent-data}"
SRC_URI[aarch64_device-mapper-persistent-data.sha256sum] = "cd059cf8f052a1f50d4745b0c52be19cafd1ced9e09296978052f7bb48762f79"

RDEPENDS:device-mapper-persistent-data = " \
 glibc \
 libgcc \
 systemd-libs \
 "
