# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jcmturner-aescts"
PV = "2.0.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-jcmturner-aescts-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jcmturner-aescts-2.0.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f28a167d197999ecd3611f33f58e82c60fe59c654a024245e4fff54bca23ac6f"

URI_x86_64_v2_golang-github-jcmturner-aescts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jcmturner-aescts-devel-2.0.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jcmturner-aescts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jcmturner-aescts-devel}"
SRC_URI[x86_64_v2_golang-github-jcmturner-aescts-devel.sha256sum] = "6941e903ea4a167a90aef00d40f27f32f1ec0167cb90d621d04910bbe2e77a57"

URI_aarch64_golang-github-jcmturner-aescts-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jcmturner-aescts-devel-2.0.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-jcmturner-aescts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jcmturner-aescts-devel}"
SRC_URI[aarch64_golang-github-jcmturner-aescts-devel.sha256sum] = "e8f52df45272c1fec073c80b9ee001212b98f00a74889ee4e2283368a89607ba"

RDEPENDS:golang-github-jcmturner-aescts-devel = " \
 go-filesystem \
 "
