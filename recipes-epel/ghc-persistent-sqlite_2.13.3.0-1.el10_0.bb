# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-persistent-sqlite"
PV = "2.13.3.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-persistent-sqlite \
 ghc-persistent-sqlite-devel \
 ghc-persistent-sqlite-doc \
 ghc-persistent-sqlite-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-persistent-sqlite-2.13.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12b6b32ae6756b405820e6cdd989510e535abf9bc9c73d8146ecfd44b39c815c"

URI_x86_64_v2_ghc-persistent-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-persistent-sqlite-2.13.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-persistent-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-persistent-sqlite}"
SRC_URI[x86_64_v2_ghc-persistent-sqlite.sha256sum] = "93058d175ebeaf1ab9c81389704a700afb9af37b51b49a32b9a89be30f6ba083"

URI_x86_64_v2_ghc-persistent-sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-persistent-sqlite-devel-2.13.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-persistent-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-persistent-sqlite-devel}"
SRC_URI[x86_64_v2_ghc-persistent-sqlite-devel.sha256sum] = "dfa82b5fbb2992449fca530bd31b9acbbd25401b3b9c8f68bbbb0e8e4f11d74e"

URI_x86_64_v2_ghc-persistent-sqlite-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-persistent-sqlite-doc-2.13.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-persistent-sqlite-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-persistent-sqlite-doc}"
SRC_URI[x86_64_v2_ghc-persistent-sqlite-doc.sha256sum] = "031067e49bf7a4fa7dcb4e8879ebeda50f0848afbe6804017a2e0a5b5a350957"

URI_x86_64_v2_ghc-persistent-sqlite-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-persistent-sqlite-prof-2.13.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-persistent-sqlite-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-persistent-sqlite-prof}"
SRC_URI[x86_64_v2_ghc-persistent-sqlite-prof.sha256sum] = "0e08a67edd7c72d71691d5d04a740cd718ba0a66f60aeeab52bc18c69774d4e7"

URI_aarch64_ghc-persistent-sqlite = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-persistent-sqlite-2.13.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-persistent-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-persistent-sqlite}"
SRC_URI[aarch64_ghc-persistent-sqlite.sha256sum] = "514c847b201a373d281e5bf97c23b9637393fe26511aceaf0cde752341165f28"

URI_aarch64_ghc-persistent-sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-persistent-sqlite-devel-2.13.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-persistent-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-persistent-sqlite-devel}"
SRC_URI[aarch64_ghc-persistent-sqlite-devel.sha256sum] = "ded73682538c1e0cd3c9942abec88c992789b7312339ff5b98a16d04bd767665"

URI_aarch64_ghc-persistent-sqlite-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-persistent-sqlite-doc-2.13.3.0-1.el10_0.noarch.rpm;name=aarch64_ghc-persistent-sqlite-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-persistent-sqlite-doc}"
SRC_URI[aarch64_ghc-persistent-sqlite-doc.sha256sum] = "06ca699b3dfa23ab74c79fa1f797a4257d1525853804acac00bef1d6076c0756"

URI_aarch64_ghc-persistent-sqlite-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-persistent-sqlite-prof-2.13.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-persistent-sqlite-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-persistent-sqlite-prof}"
SRC_URI[aarch64_ghc-persistent-sqlite-prof.sha256sum] = "82c024edfeac92f4066150fcea6f159ff10595dfa01702673be72781ffda9dfe"

RDEPENDS:ghc-persistent-sqlite = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-attoparsec-iso8601 \
 ghc-auto-update \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-easy-file \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-api-data \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-conversion \
 ghc-integer-logarithms \
 ghc-lift-type \
 ghc-lifted-base \
 ghc-microlens \
 ghc-microlens-th \
 ghc-monad-control \
 ghc-monad-logger \
 ghc-monad-loops \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-path-pieces \
 ghc-persistent \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resource-pool \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-silently \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-stm-chans \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-persistent-sqlite-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-containers-devel \
 ghc-microlens-th-devel \
 ghc-monad-logger-devel \
 ghc-mtl-devel \
 ghc-persistent-devel \
 ghc-persistent-sqlite \
 ghc-resource-pool-devel \
 ghc-resourcet-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unliftio-core-devel \
 ghc-unordered-containers-devel \
 sqlite-devel \
 "
RDEPENDS:ghc-persistent-sqlite-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-persistent-sqlite-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-conduit-prof \
 ghc-containers-prof \
 ghc-microlens-th-prof \
 ghc-monad-logger-prof \
 ghc-mtl-prof \
 ghc-persistent-prof \
 ghc-persistent-sqlite-devel \
 ghc-resource-pool-prof \
 ghc-resourcet-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unliftio-core-prof \
 ghc-unordered-containers-prof \
 "
