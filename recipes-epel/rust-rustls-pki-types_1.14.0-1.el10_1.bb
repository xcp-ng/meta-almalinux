# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-pki-types"
PV = "1.14.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-pki-types+web-devel \
 rust-rustls-pki-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-pki-types-1.14.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c15883c06553372f68cf579539aeac4c75edd5e49f901d0f19bfe15ad81824c2"

URI_x86_64_v2_rust-rustls-pki-types+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+alloc-devel-1.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+alloc-devel.sha256sum] = "961fbead22e631bf78e3edcd19fa7ebe7e1d6eb58cb426214fb2c3da284be1c0"

URI_x86_64_v2_rust-rustls-pki-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+default-devel-1.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+default-devel.sha256sum] = "8c9b089d9dd08454005ba199fcaa7160433d5f8d803609c7dce696b1d73d4006"

URI_x86_64_v2_rust-rustls-pki-types+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+std-devel-1.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+std-devel.sha256sum] = "ea9ce3b3f58cdeb3218af996c705671696464fad4f21d30b615a675c33a67f74"

URI_x86_64_v2_rust-rustls-pki-types+web-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+web-devel-1.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+web-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+web-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+web-devel.sha256sum] = "c62370af32f9a419e967ba3c84f21698caf779b04e6798eb228cb6731fbaa6e3"

URI_x86_64_v2_rust-rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types-devel-1.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types-devel.sha256sum] = "2d98262940f7a6a7a9c52650b2c944672acfc6a82ebc85d2e4b133eefdbabf11"

URI_aarch64_rust-rustls-pki-types+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+alloc-devel-1.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-pki-types+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+alloc-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+alloc-devel.sha256sum] = "2626432056e478699b030598d8d14bc7c976542bf04a26032b5c8a4aadea99a8"

URI_aarch64_rust-rustls-pki-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+default-devel-1.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-pki-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+default-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+default-devel.sha256sum] = "7ed19644ef69f9a5de8e3b3893b2aeef44c4edb92474fe44a13c225f614e8d47"

URI_aarch64_rust-rustls-pki-types+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+std-devel-1.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-pki-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+std-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+std-devel.sha256sum] = "fc732a6ec1a33505a5692b5ea4403910406aadd5580f605ce2d6cc3e175cc438"

URI_aarch64_rust-rustls-pki-types+web-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+web-devel-1.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-pki-types+web-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+web-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+web-devel.sha256sum] = "34ba34377be349a3d817011708acc279719c4311c85f9e2bc7c61c90bc5e30fb"

URI_aarch64_rust-rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types-devel-1.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types-devel}"
SRC_URI[aarch64_rust-rustls-pki-types-devel.sha256sum] = "cd8c50de3ac4929ec750e4b29c59de42d3ae833d3e978df69c3db07e770d1f0e"

RDEPENDS:rust-rustls-pki-types+alloc-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-rustls-pki-types+default-devel = " \
 cargo \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types+std-devel = " \
 cargo \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types+web-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types-devel = " \
 cargo \
 rust \
 "
