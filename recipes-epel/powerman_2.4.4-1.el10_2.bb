# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerman"
PV = "2.4.4"
PR = "1.el10_2"
PACKAGES = " \
 powerman \
 powerman-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/powerman-2.4.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c17c33193d350990fa102f62715c7c15ef80dab9cef9482af622a003cd78844"

URI_x86_64_v2_powerman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerman-2.4.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powerman}"
SRC_URI[x86_64_v2_powerman.sha256sum] = "0f2434dd67cdbdfbf256fa6f46798e093ac67bc223e1620b7a61adb1358ce4d0"

URI_x86_64_v2_powerman-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerman-devel-2.4.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powerman-devel}"
SRC_URI[x86_64_v2_powerman-devel.sha256sum] = "183078b88494c1489df2251fe0633b751a223fecc8e00eb8c306fb3ef2e28f82"

URI_aarch64_powerman = "${EPEL_MIRROR}/aarch64/Packages/p/powerman-2.4.4-1.el10_2.aarch64.rpm;name=aarch64_powerman;unpack=0"
SRC_URI:append = " ${URI_aarch64_powerman}"
SRC_URI[aarch64_powerman.sha256sum] = "58222550dc90d29f47a8d43f225395f17b0475826b5a1ff56e730e5ebabd780d"

URI_aarch64_powerman-devel = "${EPEL_MIRROR}/aarch64/Packages/p/powerman-devel-2.4.4-1.el10_2.aarch64.rpm;name=aarch64_powerman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_powerman-devel}"
SRC_URI[aarch64_powerman-devel.sha256sum] = "46f609f1d0911c24119495948221392e97d28449ca9f231301035852f5cac9de"

RDEPENDS:powerman = " \
 bash \
 glibc \
 jansson \
 libgenders \
 net-snmp-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:powerman-devel = " \
 pkgconf-pkg-config \
 powerman \
 "
