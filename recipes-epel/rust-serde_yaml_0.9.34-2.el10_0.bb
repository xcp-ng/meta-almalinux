# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_yaml"
PV = "0.9.34"
PR = "2.el10_0"
PACKAGES = " \
 rust-serde_yaml+default-devel \
 rust-serde_yaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_yaml-0.9.34-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0f69797122b3b9300f81e86723d17f732219c6a268dd3e9d5c68615bbfc754d"

URI_x86_64_v2_rust-serde_yaml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_yaml+default-devel-0.9.34-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_yaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_yaml+default-devel}"
SRC_URI[x86_64_v2_rust-serde_yaml+default-devel.sha256sum] = "31f294873151082270c5a04b7b066b0d3cafdfd3bd3977ab7832d33407884a94"

URI_x86_64_v2_rust-serde_yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_yaml-devel-0.9.34-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_yaml-devel}"
SRC_URI[x86_64_v2_rust-serde_yaml-devel.sha256sum] = "7efa01bec559d42cf2a54f0ba5efb3353eb5bb21fe721333187ff4a61f8ade8e"

URI_aarch64_rust-serde_yaml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_yaml+default-devel-0.9.34-2.el10_0.noarch.rpm;name=aarch64_rust-serde_yaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_yaml+default-devel}"
SRC_URI[aarch64_rust-serde_yaml+default-devel.sha256sum] = "07e88c8823e575bbbd1c3ea7ce2de626318259164c0eeb43d803e09d144f86f9"

URI_aarch64_rust-serde_yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_yaml-devel-0.9.34-2.el10_0.noarch.rpm;name=aarch64_rust-serde_yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_yaml-devel}"
SRC_URI[aarch64_rust-serde_yaml-devel.sha256sum] = "160f7cb8d4b60d4bf659f63b2c928d47809a5fd1a279ff309e49c8fd6a55a2bc"

RDEPENDS:rust-serde_yaml+default-devel = " \
 cargo \
 rust-serde_yaml-devel \
 "
RDEPENDS:rust-serde_yaml-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-itoa+default-devel \
 rust-ryu+default-devel \
 rust-serde+default-devel \
 rust-unsafe-libyaml+default-devel \
 "
