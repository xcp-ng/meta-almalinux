# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-user-dirs"
PV = "0.18"
PR = "6.el10_0.1"
PACKAGES = " \
 xdg-user-dirs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdg-user-dirs-0.18-6.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b77f3bdcd5ff0851d5eff80c8df3bce73f0853f62c6262d86844f0b01203609e"

URI_x86_64_v2_xdg-user-dirs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdg-user-dirs-0.18-6.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_xdg-user-dirs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-user-dirs}"
SRC_URI[x86_64_v2_xdg-user-dirs.sha256sum] = "30c931599c7b12c4465d125d41d2c5884be9d4c1363430ea2e0f21d80471f394"

URI_aarch64_xdg-user-dirs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdg-user-dirs-0.18-6.el10_0.1.aarch64.rpm;name=aarch64_xdg-user-dirs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-user-dirs}"
SRC_URI[aarch64_xdg-user-dirs.sha256sum] = "b8035fe7dcbfa7fb174a298b6b21a5fb49b3fb79954af4814e1612eb32c72cce"

RDEPENDS:xdg-user-dirs = " \
 bash \
 filesystem \
 glibc \
 "
