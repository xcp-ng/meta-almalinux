# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fragile"
PV = "2.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-fragile+default-devel \
 rust-fragile+future-devel \
 rust-fragile+futures-core-devel \
 rust-fragile+slab-devel \
 rust-fragile+stream-devel \
 rust-fragile-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-fragile-2.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b57d299fdc427521d0cb5c00f1d3664899c7a89c0db8506e05e4e5c62a372188"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+default-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile+default-devel.sha256sum] = "e89d3bc804251869210f1e45b36e89e3386de57a8f6dd969f61df1efc1d17c41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+future-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+future-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile+future-devel.sha256sum] = "e50129a23f926d2275e0e21b8c3cfda6fc489096b1823e48da589e7b52a9b89a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+futures-core-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+futures-core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile+futures-core-devel.sha256sum] = "cfd955c68acbe4ec1d6305467cba1920121c577e77131d8d18428d351d8233ac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+slab-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+slab-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile+slab-devel.sha256sum] = "13d9ffde39675febd9b51a8caabfcf44b887de1e3d2888f91253e1f6e18cb21c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+stream-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+stream-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile+stream-devel.sha256sum] = "3ee163b127316acab978c219b34194755e4fff087228a1410420656e3a651403"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fragile-devel.sha256sum] = "d152409c3728e0ee03b121491d389f07853d12d53b9ff4aa731395bc540170ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+default-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-fragile+default-devel;unpack=0"
SRC_URI[aarch64_rust-fragile+default-devel.sha256sum] = "fde2a2a3f9d1c93e19ed615e18cee0173baf7e4d4cda7167b3d7946eaa78503a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+future-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-fragile+future-devel;unpack=0"
SRC_URI[aarch64_rust-fragile+future-devel.sha256sum] = "b12557b437d1fce4f15ebf02563c20564c9af3fe33cb8daaf0e1e69b39a04854"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+futures-core-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-fragile+futures-core-devel;unpack=0"
SRC_URI[aarch64_rust-fragile+futures-core-devel.sha256sum] = "ad25c539fa3dfe4597c950b901289c5d306edd4b38f993c98ff19d2aa5599e59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+slab-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-fragile+slab-devel;unpack=0"
SRC_URI[aarch64_rust-fragile+slab-devel.sha256sum] = "1623bb64b4332982d0372af23579d0bebcc75d53b23756fa104c72360b00b563"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+stream-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-fragile+stream-devel;unpack=0"
SRC_URI[aarch64_rust-fragile+stream-devel.sha256sum] = "9c063402f22354ba7a9002ac809428c3ec9448d33569b37a1d9754c939eee77d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-fragile-devel;unpack=0"
SRC_URI[aarch64_rust-fragile-devel.sha256sum] = "fb618db13d1c0ea2e2734a787ca08bbe5d2b80e28d6a28208215ccb41a383c60"

RDEPENDS:rust-fragile+default-devel = " \
 cargo \
 rust-fragile+stream-devel \
 rust-fragile-devel \
 "
RDEPENDS:rust-fragile+future-devel = " \
 cargo \
 rust-fragile-devel \
 "
RDEPENDS:rust-fragile+futures-core-devel = " \
 cargo \
 rust-fragile-devel \
 rust-futures-core+default-devel \
 "
RDEPENDS:rust-fragile+slab-devel = " \
 cargo \
 rust-fragile-devel \
 rust-slab+default-devel \
 "
RDEPENDS:rust-fragile+stream-devel = " \
 cargo \
 rust-fragile+future-devel \
 rust-fragile+futures-core-devel \
 rust-fragile-devel \
 "
RDEPENDS:rust-fragile-devel = " \
 cargo \
 rust \
 "
