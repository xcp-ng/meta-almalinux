# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-form3tech-oss-jwt"
PV = "3.2.2"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-form3tech-oss-jwt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-form3tech-oss-jwt-3.2.2-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ee5d9e6c6296c820c46fff8b648c3ab961b56c95e25a2637b46dde22badc44c"

URI_x86_64_v2_golang-github-form3tech-oss-jwt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-form3tech-oss-jwt-devel-3.2.2-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-form3tech-oss-jwt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-form3tech-oss-jwt-devel}"
SRC_URI[x86_64_v2_golang-github-form3tech-oss-jwt-devel.sha256sum] = "4668462906491876bd8aeab0231bf06c8e88325a5fe93d2dd733c12b975ed886"

URI_aarch64_golang-github-form3tech-oss-jwt-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-form3tech-oss-jwt-devel-3.2.2-12.el10_0.noarch.rpm;name=aarch64_golang-github-form3tech-oss-jwt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-form3tech-oss-jwt-devel}"
SRC_URI[aarch64_golang-github-form3tech-oss-jwt-devel.sha256sum] = "ef6d5c2e71779d7fc2a47423706d0878688ce6851edd8e62e6891d2be969bb78"

RDEPENDS:golang-github-form3tech-oss-jwt-devel = " \
 go-filesystem \
 "
