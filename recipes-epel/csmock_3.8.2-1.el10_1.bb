# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "csmock"
PV = "3.8.2"
PR = "1.el10_1"
PACKAGES = " \
 csbuild \
 csmock \
 csmock-common \
 csmock-plugin-bandit \
 csmock-plugin-cbmc \
 csmock-plugin-clang \
 csmock-plugin-clippy \
 csmock-plugin-cppcheck \
 csmock-plugin-divine \
 csmock-plugin-gitleaks \
 csmock-plugin-infer \
 csmock-plugin-pylint \
 csmock-plugin-semgrep \
 csmock-plugin-shellcheck \
 csmock-plugin-shellcheck-core \
 csmock-plugin-smatch \
 csmock-plugin-snyk \
 csmock-plugin-strace \
 csmock-plugin-symbiotic \
 csmock-plugin-unicontrol \
 csmock-plugin-valgrind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/csmock-3.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f6e9586821479b115ca4f37fc866428c8ef201b23a6cb5fd15b0887bcf4d66e"

URI_x86_64_v2_csbuild = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csbuild-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csbuild}"
SRC_URI[x86_64_v2_csbuild.sha256sum] = "950d3dc62705758c657760a80f944dac041abbed1ff5b4cf7158d874e0c2d35b"

URI_x86_64_v2_csmock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock}"
SRC_URI[x86_64_v2_csmock.sha256sum] = "0284528bd198c3c525d2dde9f07894cbfcf9e06ac2c4a4dccf9ede79719dddca"

URI_x86_64_v2_csmock-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-common-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-common}"
SRC_URI[x86_64_v2_csmock-common.sha256sum] = "2a37cfe051df624d9eebc01e1e04f6325d7636f56bef7bfb85e5729cb7b3623d"

URI_x86_64_v2_csmock-plugin-bandit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-bandit-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-bandit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-bandit}"
SRC_URI[x86_64_v2_csmock-plugin-bandit.sha256sum] = "9fc9182a36611ae3c87a668b58d09c5e109ce6dd5fbd43f12c82fd23ad67e711"

URI_x86_64_v2_csmock-plugin-cbmc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-cbmc-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-cbmc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-cbmc}"
SRC_URI[x86_64_v2_csmock-plugin-cbmc.sha256sum] = "44a36fff5c1dab9b62eaea0483628130b2a161678f92769fb9c0174774fd02a4"

URI_x86_64_v2_csmock-plugin-clang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-clang-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-clang}"
SRC_URI[x86_64_v2_csmock-plugin-clang.sha256sum] = "f19bba2f1f225809010449e207291c4f79eb3d465d30c15629e4deeeb0455d7a"

URI_x86_64_v2_csmock-plugin-clippy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-clippy-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-clippy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-clippy}"
SRC_URI[x86_64_v2_csmock-plugin-clippy.sha256sum] = "88f547929c77446f07aeb53c6e37dd8468f80433005bd9c6defa1c2e34da7fb7"

URI_x86_64_v2_csmock-plugin-cppcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-cppcheck-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-cppcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-cppcheck}"
SRC_URI[x86_64_v2_csmock-plugin-cppcheck.sha256sum] = "b36971868d760f8989213245c8d90f7c0f23f5d6adcf916053f2b89dfdcff901"

URI_x86_64_v2_csmock-plugin-divine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-divine-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-divine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-divine}"
SRC_URI[x86_64_v2_csmock-plugin-divine.sha256sum] = "622da9fc2e61e6312f45e6302977fbc50b0978b94230ed1b68307971f5616cc9"

URI_x86_64_v2_csmock-plugin-gitleaks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-gitleaks-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-gitleaks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-gitleaks}"
SRC_URI[x86_64_v2_csmock-plugin-gitleaks.sha256sum] = "211c03332ea0288008274249dd61ee7023e846684bef5c58948ee17a3f1905bb"

URI_x86_64_v2_csmock-plugin-infer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-infer-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-infer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-infer}"
SRC_URI[x86_64_v2_csmock-plugin-infer.sha256sum] = "c03ebd0733670265932549e54c7fce5a4aed27fbf4c2df1978e8fef6124033d8"

URI_x86_64_v2_csmock-plugin-pylint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-pylint-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-pylint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-pylint}"
SRC_URI[x86_64_v2_csmock-plugin-pylint.sha256sum] = "fda2444020f1fb502db455e200cd179a6deb4a80376db458bd09d5db790ac210"

URI_x86_64_v2_csmock-plugin-semgrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-semgrep-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-semgrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-semgrep}"
SRC_URI[x86_64_v2_csmock-plugin-semgrep.sha256sum] = "ab00a4014e3bf262efbb4199d39ab62cd7a8145be7eea99f9321f0f565d0649d"

URI_x86_64_v2_csmock-plugin-shellcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-shellcheck-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-shellcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-shellcheck}"
SRC_URI[x86_64_v2_csmock-plugin-shellcheck.sha256sum] = "43e9156f6a504c79f8169f616f085dda1423a8d01f22ae9d5d9c7df4a0c38c6e"

URI_x86_64_v2_csmock-plugin-shellcheck-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-shellcheck-core-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-shellcheck-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-shellcheck-core}"
SRC_URI[x86_64_v2_csmock-plugin-shellcheck-core.sha256sum] = "6bbd07b3895a2b91fef813ea956352e22221288992ea1db32563d6269d4a6667"

URI_x86_64_v2_csmock-plugin-smatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-smatch-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-smatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-smatch}"
SRC_URI[x86_64_v2_csmock-plugin-smatch.sha256sum] = "fb753fd9903c87e9a54ecfa48f4350e4dcf4ba1abd7c3eb06f7f61f158fba53c"

URI_x86_64_v2_csmock-plugin-snyk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-snyk-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-snyk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-snyk}"
SRC_URI[x86_64_v2_csmock-plugin-snyk.sha256sum] = "6555f9e465bb1683c833fe88c25c10b5cc30ec8244981e4920dac074d3616fe6"

URI_x86_64_v2_csmock-plugin-strace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-strace-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-strace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-strace}"
SRC_URI[x86_64_v2_csmock-plugin-strace.sha256sum] = "7f5e565a90587924392b860111332fe937f26555b137d36a82a2a20ccdd13e8d"

URI_x86_64_v2_csmock-plugin-symbiotic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-symbiotic-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-symbiotic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-symbiotic}"
SRC_URI[x86_64_v2_csmock-plugin-symbiotic.sha256sum] = "02b69fbdc1ccef9da09c586b83ac8ac961d99927a132cda711e112fdd86aed9d"

URI_x86_64_v2_csmock-plugin-unicontrol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-unicontrol-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-unicontrol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-unicontrol}"
SRC_URI[x86_64_v2_csmock-plugin-unicontrol.sha256sum] = "5db45a6406584515c73f7e7c80bcf44693851a0c434d760869246779c55d30fe"

URI_x86_64_v2_csmock-plugin-valgrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-valgrind-3.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-valgrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-valgrind}"
SRC_URI[x86_64_v2_csmock-plugin-valgrind.sha256sum] = "9d6e26ddef7918b08b65e7f499694ae7fdc2a733d5735a87a352269f8e531c7c"

URI_aarch64_csbuild = "${EPEL_MIRROR}/aarch64/Packages/c/csbuild-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_csbuild}"
SRC_URI[aarch64_csbuild.sha256sum] = "1cf1cb4309d881f4a30bd85939ee5db9567773d443ca5daf1d8d11d385e16b66"

URI_aarch64_csmock = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock}"
SRC_URI[aarch64_csmock.sha256sum] = "57631db7d7ee028f66b8b8500ca8d7572f57f5819f5a51b55b90638aa2968477"

URI_aarch64_csmock-common = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-common-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-common}"
SRC_URI[aarch64_csmock-common.sha256sum] = "b3ab503dfbf7c3e16848f3a8f161627542797d97f2a23eceddd8f57925c13a0b"

URI_aarch64_csmock-plugin-bandit = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-bandit-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-bandit;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-bandit}"
SRC_URI[aarch64_csmock-plugin-bandit.sha256sum] = "19527da83a42d12a7bbd06adbaddb271b7c0dac3ecde1a6bc7a0b15398ee5ded"

URI_aarch64_csmock-plugin-cbmc = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-cbmc-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-cbmc;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-cbmc}"
SRC_URI[aarch64_csmock-plugin-cbmc.sha256sum] = "30d70f42963da24c445b821e562f7bb44b2a0af82d8302ad554a25290eb1adf1"

URI_aarch64_csmock-plugin-clang = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-clang-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-clang}"
SRC_URI[aarch64_csmock-plugin-clang.sha256sum] = "69ca2ace2bbb24652b17ba60e1dc62f7fa0b6a8ae22819b86d55406a96e41149"

URI_aarch64_csmock-plugin-clippy = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-clippy-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-clippy;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-clippy}"
SRC_URI[aarch64_csmock-plugin-clippy.sha256sum] = "0118a829be96aa52c1d8900dd59030105b8a57161c0eeaa7d4480b2643e0dafd"

URI_aarch64_csmock-plugin-cppcheck = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-cppcheck-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-cppcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-cppcheck}"
SRC_URI[aarch64_csmock-plugin-cppcheck.sha256sum] = "9b70bf9b6775d0530daba37be8eb3cfdc560bbe645f1fe6151ffde67ed067b3f"

URI_aarch64_csmock-plugin-divine = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-divine-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-divine;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-divine}"
SRC_URI[aarch64_csmock-plugin-divine.sha256sum] = "79aab787d9413bf8b2b5ba220e72966881c98d4fa6833088d721fec2ba38a88e"

URI_aarch64_csmock-plugin-gitleaks = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-gitleaks-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-gitleaks;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-gitleaks}"
SRC_URI[aarch64_csmock-plugin-gitleaks.sha256sum] = "869c72bea24da07af4e0053399ed0cd6723e1ba46793bc54e9c98e1b22738442"

URI_aarch64_csmock-plugin-infer = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-infer-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-infer;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-infer}"
SRC_URI[aarch64_csmock-plugin-infer.sha256sum] = "1eaff10a0ae28b3afe00a75a63126c3b55db09be78438b34be93e97971ec008d"

URI_aarch64_csmock-plugin-pylint = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-pylint-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-pylint;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-pylint}"
SRC_URI[aarch64_csmock-plugin-pylint.sha256sum] = "638b3d747cfc3e8aacc82da145b7f226b8498df5219aaba36544d641785845e5"

URI_aarch64_csmock-plugin-semgrep = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-semgrep-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-semgrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-semgrep}"
SRC_URI[aarch64_csmock-plugin-semgrep.sha256sum] = "47de79a9ccde0c64b7ecdb0b8ab087e764485f308fa4c859f45fd11cc4db4405"

URI_aarch64_csmock-plugin-shellcheck = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-shellcheck-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-shellcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-shellcheck}"
SRC_URI[aarch64_csmock-plugin-shellcheck.sha256sum] = "d3f1caa6fbec6f2abbfbcc26f5333bb7246943f51854d8fee16ede38ef34570f"

URI_aarch64_csmock-plugin-shellcheck-core = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-shellcheck-core-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-shellcheck-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-shellcheck-core}"
SRC_URI[aarch64_csmock-plugin-shellcheck-core.sha256sum] = "b58c0a68194e47fbea5ab5f50cdc98c1b7e098e2e4aa2f9e664f85ea0b361a97"

URI_aarch64_csmock-plugin-smatch = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-smatch-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-smatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-smatch}"
SRC_URI[aarch64_csmock-plugin-smatch.sha256sum] = "75d28cfddf5e1b6ebbffe094f5a0a123b0cad412c6e37a52b69418de3059ec1a"

URI_aarch64_csmock-plugin-snyk = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-snyk-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-snyk;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-snyk}"
SRC_URI[aarch64_csmock-plugin-snyk.sha256sum] = "6212b755916b3d9ab342ea638ad9f4bb723b6f7008baf8a0925b186685040511"

URI_aarch64_csmock-plugin-strace = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-strace-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-strace;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-strace}"
SRC_URI[aarch64_csmock-plugin-strace.sha256sum] = "efe8bf7e08c2308ee066aa242340b53bad7240fff579b25b31b22c69c01301cf"

URI_aarch64_csmock-plugin-symbiotic = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-symbiotic-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-symbiotic;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-symbiotic}"
SRC_URI[aarch64_csmock-plugin-symbiotic.sha256sum] = "bed6f4ddcaa1b57daf883c4142da83988616c1aad9745737bb281a4b72fc5a17"

URI_aarch64_csmock-plugin-unicontrol = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-unicontrol-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-unicontrol;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-unicontrol}"
SRC_URI[aarch64_csmock-plugin-unicontrol.sha256sum] = "cb828a9c9365af76a39e6c1847471a38b731a5ee9399727d37896d7c5155401e"

URI_aarch64_csmock-plugin-valgrind = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-valgrind-3.8.2-1.el10_1.noarch.rpm;name=aarch64_csmock-plugin-valgrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-valgrind}"
SRC_URI[aarch64_csmock-plugin-valgrind.sha256sum] = "953f351f828325fa7ae41637dd1a87afbfa5b9ec6a8d60a1ba46c71830f1d303"

RDEPENDS:csbuild = " \
 bash \
 csclng \
 cscppc \
 csdiff \
 csmock-common \
 cswrap \
 python3 \
 python3-GitPython \
 "
RDEPENDS:csmock = " \
 csmock-common \
 csmock-plugin-clang \
 csmock-plugin-cppcheck \
 csmock-plugin-gitleaks \
 csmock-plugin-shellcheck \
 "
RDEPENDS:csmock-common = " \
 bash \
 csdiff \
 csgcca \
 cswrap \
 mock \
 python3 \
 tar \
 xz \
 "
RDEPENDS:csmock-plugin-bandit = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-cbmc = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-clang = " \
 csclng \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-clippy = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-cppcheck = " \
 cscppc \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-divine = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-gitleaks = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-infer = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-pylint = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-semgrep = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-shellcheck = " \
 csmock-common \
 csmock-plugin-shellcheck-core \
 python3 \
 "
RDEPENDS:csmock-plugin-shellcheck-core = " \
 bash \
 "
RDEPENDS:csmock-plugin-smatch = " \
 csmatch \
 csmock-common \
 cswrap \
 python3 \
 "
RDEPENDS:csmock-plugin-snyk = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-strace = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-symbiotic = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-unicontrol = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-valgrind = " \
 csexec \
 csmock-common \
 python3 \
 "
