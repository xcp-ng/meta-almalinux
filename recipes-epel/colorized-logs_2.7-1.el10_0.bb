# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colorized-logs"
PV = "2.7"
PR = "1.el10_0"
PACKAGES = " \
 colorized-logs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/colorized-logs-2.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6461abe0bad8adfbf402a381fb844e5d92e7b27f77c8d1e140c4461f253a3b26"

URI_x86_64_v2_colorized-logs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/colorized-logs-2.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_colorized-logs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colorized-logs}"
SRC_URI[x86_64_v2_colorized-logs.sha256sum] = "0cbdaaa380a0ea8c780403c1c43c7c0d9bf8292e90c9f8f4fdc2242e035b0964"

URI_aarch64_colorized-logs = "${EPEL_MIRROR}/aarch64/Packages/c/colorized-logs-2.7-1.el10_0.aarch64.rpm;name=aarch64_colorized-logs;unpack=0"
SRC_URI:append = " ${URI_aarch64_colorized-logs}"
SRC_URI[aarch64_colorized-logs.sha256sum] = "b18a3af997d86bca7b52fce05c598092b82d365b359f5eabb8524d016a4485c5"

RDEPENDS:colorized-logs = " \
 glibc \
 "
