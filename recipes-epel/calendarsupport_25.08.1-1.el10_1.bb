# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calendarsupport"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 calendarsupport \
 calendarsupport-devel \
 calendarsupport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/calendarsupport-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec028826a43c6d85bc84e39715750baed4036666edf8118efca8fab2ce823f50"

URI_x86_64_v2_calendarsupport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calendarsupport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport}"
SRC_URI[x86_64_v2_calendarsupport.sha256sum] = "7f26faa869ef0191265e1f084a1a3b2256d36bb0c564ee9825f8b0c7dfa50fc7"

URI_x86_64_v2_calendarsupport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calendarsupport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport-devel}"
SRC_URI[x86_64_v2_calendarsupport-devel.sha256sum] = "970bd394710558ded3260b581a7c089cf9df3aeb2a4f10880d6b79757a3e4e4d"

URI_x86_64_v2_calendarsupport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_calendarsupport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport-doc}"
SRC_URI[x86_64_v2_calendarsupport-doc.sha256sum] = "eac1ecd127e56f187662e23887c2079c22b5d325e2006d91dc5b1edba7bd7e19"

URI_aarch64_calendarsupport = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_calendarsupport;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport}"
SRC_URI[aarch64_calendarsupport.sha256sum] = "f8918fe47057130332087f6281fafb19f6555974e2bb15e2ded401da3cc51a90"

URI_aarch64_calendarsupport-devel = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_calendarsupport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport-devel}"
SRC_URI[aarch64_calendarsupport-devel.sha256sum] = "1fe0184627e5e709b637b280dd21883d237a022ceabf08c18e7d1c853668153e"

URI_aarch64_calendarsupport-doc = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_calendarsupport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport-doc}"
SRC_URI[aarch64_calendarsupport-doc.sha256sum] = "f0e7dcbcf3598f61dde8817280b3b001b38c00fff0a2fc66d8a2287e79a7ee2f"

RDEPENDS:calendarsupport = " \
 akonadi-calendar \
 akonadi-server \
 glibc \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:calendarsupport-devel = " \
 akonadi-calendar-devel \
 calendarsupport \
 cmake-filesystem \
 kidentitymanagement-devel \
 kmime-devel \
 "
RDEPENDS:calendarsupport-doc = " \
 "
