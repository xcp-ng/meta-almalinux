# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-pluggy"
PV = "1.6.0"
PR = "3.el10"
PACKAGES = " \
 python3.14-pluggy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-pluggy-1.6.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7e9b1076a9fc7ac400a69dc7efbedaff5161122368dda78b00dc8cafae133df"

URI_x86_64_v2_python3.14-pluggy = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-pluggy-1.6.0-3.el10.noarch.rpm;name=x86_64_v2_python3.14-pluggy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-pluggy}"
SRC_URI[x86_64_v2_python3.14-pluggy.sha256sum] = "835cb124eaa58ca9bfd441f239a3c60cb13c8a2f55b21a7fb34b040e217182a1"

URI_aarch64_python3.14-pluggy = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-pluggy-1.6.0-3.el10.noarch.rpm;name=aarch64_python3.14-pluggy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-pluggy}"
SRC_URI[aarch64_python3.14-pluggy.sha256sum] = "835cb124eaa58ca9bfd441f239a3c60cb13c8a2f55b21a7fb34b040e217182a1"

RDEPENDS:python3.14-pluggy = " \
 python3.14 \
 "
