# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ryu"
PV = "1.0.23"
PR = "1.el10_3"
PACKAGES = " \
 rust-ryu+default-devel \
 rust-ryu+no-panic-devel \
 rust-ryu+small-devel \
 rust-ryu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ryu-1.0.23-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5096aedb2fb8682567ed7bf88ff7340b5cf498df3f56e3e25658c3819151625"

URI_x86_64_v2_rust-ryu+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+default-devel-1.0.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+default-devel}"
SRC_URI[x86_64_v2_rust-ryu+default-devel.sha256sum] = "5c0cf62e71ec94eec58917df8b0aeb232e339819d3f631216bacbeacf4798446"

URI_x86_64_v2_rust-ryu+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+no-panic-devel-1.0.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+no-panic-devel}"
SRC_URI[x86_64_v2_rust-ryu+no-panic-devel.sha256sum] = "23a9f4131abb65ba1b3572b08bf6a765238d1a4d82feb15cbbda8a420c6c4b51"

URI_x86_64_v2_rust-ryu+small-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+small-devel-1.0.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+small-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+small-devel}"
SRC_URI[x86_64_v2_rust-ryu+small-devel.sha256sum] = "dd6add2b42ba29ff38b40fd2b9b9586d9f159e3c732cfac83ecd675adf199769"

URI_x86_64_v2_rust-ryu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu-devel-1.0.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu-devel}"
SRC_URI[x86_64_v2_rust-ryu-devel.sha256sum] = "1b302ebdb02ceaf7fb53bd1ffcc68469ba3075d23f574c241758c57b28a33977"

URI_aarch64_rust-ryu+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+default-devel-1.0.23-1.el10_3.noarch.rpm;name=aarch64_rust-ryu+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+default-devel}"
SRC_URI[aarch64_rust-ryu+default-devel.sha256sum] = "dacfdb05ca98bf102ae3e8e55388dc5a685a292d5bd419dcae638ce7e9e44da2"

URI_aarch64_rust-ryu+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+no-panic-devel-1.0.23-1.el10_3.noarch.rpm;name=aarch64_rust-ryu+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+no-panic-devel}"
SRC_URI[aarch64_rust-ryu+no-panic-devel.sha256sum] = "5c07fbc77fb3100b92ea4e4e1e3ff060ea5fcccf752b2c55b5ac631835e6ddeb"

URI_aarch64_rust-ryu+small-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+small-devel-1.0.23-1.el10_3.noarch.rpm;name=aarch64_rust-ryu+small-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+small-devel}"
SRC_URI[aarch64_rust-ryu+small-devel.sha256sum] = "493d4c90372f2e25b33338e6992aef30c0ba2bc11a1b0a020c3edb430b27d5f3"

URI_aarch64_rust-ryu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu-devel-1.0.23-1.el10_3.noarch.rpm;name=aarch64_rust-ryu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu-devel}"
SRC_URI[aarch64_rust-ryu-devel.sha256sum] = "90859b6264e249996a645be6c49b79b38b5362b7179afb5364d559fa44a31cc4"

RDEPENDS:rust-ryu+default-devel = " \
 cargo \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu+no-panic-devel = " \
 cargo \
 rust-no-panic+default-devel \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu+small-devel = " \
 cargo \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu-devel = " \
 cargo \
 rust \
 "
