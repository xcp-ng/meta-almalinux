# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-typer"
PV = "0.20.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-typer \
 python3-typer-cli \
 python3-typer-slim \
 python3-typer-slim+standard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-typer-0.20.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b627b4f6edacf03765dd55e8b7ba58b09bdf32c6044da4a3d43fab0844a6f69"

URI_x86_64_v2_python3-typer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer}"
SRC_URI[x86_64_v2_python3-typer.sha256sum] = "ee9ad0633f8a38f899b7492ab8100aae1802243c63a84d76b74c6fd2adc54692"

URI_x86_64_v2_python3-typer-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-cli-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer-cli}"
SRC_URI[x86_64_v2_python3-typer-cli.sha256sum] = "ed6a8af05f2e23870b5de7bebdd45fbe6beda1f6de77f5fe467a0a3b2fe2e3ac"

URI_x86_64_v2_python3-typer-slim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-slim-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer-slim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer-slim}"
SRC_URI[x86_64_v2_python3-typer-slim.sha256sum] = "29cfc0e85da87533c8cf42e79e801386fba8c01d17fe33a9611964a8649a1f2a"

URI_x86_64_v2_python3-typer-slim+standard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-typer-slim+standard-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-typer-slim+standard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typer-slim+standard}"
SRC_URI[x86_64_v2_python3-typer-slim+standard.sha256sum] = "6850eefde11f73fb7d67a6fb4572cafd5220cb98df20990824b4f73d2cdf624e"

URI_aarch64_python3-typer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-0.20.0-1.el10_1.noarch.rpm;name=aarch64_python3-typer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer}"
SRC_URI[aarch64_python3-typer.sha256sum] = "b727675f70432f897593a0be46707b3b608cb78fdb66fe26da2f7e6baa15c336"

URI_aarch64_python3-typer-cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-cli-0.20.0-1.el10_1.noarch.rpm;name=aarch64_python3-typer-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer-cli}"
SRC_URI[aarch64_python3-typer-cli.sha256sum] = "abafd3f12c562063945d1cd933397ad59bd07a0e9b676567cb6f3c5d9b96f139"

URI_aarch64_python3-typer-slim = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-slim-0.20.0-1.el10_1.noarch.rpm;name=aarch64_python3-typer-slim;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer-slim}"
SRC_URI[aarch64_python3-typer-slim.sha256sum] = "261df4727248941c33ec71a87a5a6bae79651cb47857cd800e615c9aba99fe7b"

URI_aarch64_python3-typer-slim+standard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-typer-slim+standard-0.20.0-1.el10_1.noarch.rpm;name=aarch64_python3-typer-slim+standard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typer-slim+standard}"
SRC_URI[aarch64_python3-typer-slim+standard.sha256sum] = "0edba4faf3f91665f3b573cbff81612abe18f73a56db4647f2010041eef8d1d6"

RDEPENDS:python3-typer = " \
 python3 \
 python3-click \
 python3-rich \
 python3-shellingham \
 python3-typer-cli \
 python3-typer-slim \
 python3-typing-extensions \
 "
RDEPENDS:python3-typer-cli = " \
 python3 \
 python3-typer \
 python3-typer-slim \
 "
RDEPENDS:python3-typer-slim = " \
 python3 \
 python3-click \
 python3-typing-extensions \
 "
RDEPENDS:python3-typer-slim+standard = " \
 python3 \
 python3-rich \
 python3-shellingham \
 python3-typer-slim \
 "
