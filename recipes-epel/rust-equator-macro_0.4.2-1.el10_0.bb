# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-equator-macro"
PV = "0.4.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-equator-macro+default-devel \
 rust-equator-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-equator-macro-0.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4b9075dee892ae6e3123bc7d8f89d88166681aa42827258b4cb3b608cf298a6"

URI_x86_64_v2_rust-equator-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equator-macro+default-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equator-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equator-macro+default-devel}"
SRC_URI[x86_64_v2_rust-equator-macro+default-devel.sha256sum] = "6fe0ca8f897742772d8d8ea36c58e33bc1c6351a92dc0a980a91fe907355a8aa"

URI_x86_64_v2_rust-equator-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equator-macro-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equator-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equator-macro-devel}"
SRC_URI[x86_64_v2_rust-equator-macro-devel.sha256sum] = "dc38fee84b82d5ae3876f057ab71039d9ed811731b30f42cb3b5e3b397b58dc9"

URI_aarch64_rust-equator-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equator-macro+default-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-equator-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equator-macro+default-devel}"
SRC_URI[aarch64_rust-equator-macro+default-devel.sha256sum] = "769d3f0e8420115e0870835170aed033c6cc52b7046acfa101ac62244c37e636"

URI_aarch64_rust-equator-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equator-macro-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-equator-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equator-macro-devel}"
SRC_URI[aarch64_rust-equator-macro-devel.sha256sum] = "1d6f237128c2093a2890346f8c76abdad91bdbadeb73e55df46ee51bb68730eb"

RDEPENDS:rust-equator-macro+default-devel = " \
 cargo \
 rust-equator-macro-devel \
 "
RDEPENDS:rust-equator-macro-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
