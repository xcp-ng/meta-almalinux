# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grantlee-editor"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 grantlee-editor \
 grantlee-editor-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grantlee-editor-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffb261d5b85cddc046a55dc4428bca0526dbabc956a05b683fea8efa869b7ac7"

URI_x86_64_v2_grantlee-editor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantlee-editor-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantlee-editor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantlee-editor}"
SRC_URI[x86_64_v2_grantlee-editor.sha256sum] = "8e2660431635abb2f1e4ad72d656bdf39585fe8b61341b2811b58ea13e482a18"

URI_x86_64_v2_grantlee-editor-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantlee-editor-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantlee-editor-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantlee-editor-libs}"
SRC_URI[x86_64_v2_grantlee-editor-libs.sha256sum] = "0361eff829039010936c25f920faf6f9c65c7f325262804dad03b1203c7d35ef"

URI_aarch64_grantlee-editor = "${EPEL_MIRROR}/aarch64/Packages/g/grantlee-editor-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_grantlee-editor;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantlee-editor}"
SRC_URI[aarch64_grantlee-editor.sha256sum] = "b1a5042565fdd93670cf9e7298a0bbcc559ccf9dd72a5f9504990c55a9ffa7cd"

URI_aarch64_grantlee-editor-libs = "${EPEL_MIRROR}/aarch64/Packages/g/grantlee-editor-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_grantlee-editor-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantlee-editor-libs}"
SRC_URI[aarch64_grantlee-editor-libs.sha256sum] = "ad98862ee44c51bd8b2e1cadf8a54ab63388dd2a2915a861f2d49d97ec53da2a"

RDEPENDS:grantlee-editor = " \
 akonadi-contacts \
 glibc \
 grantlee-editor-libs \
 grantleetheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:grantlee-editor-libs = " \
 glibc \
 grantlee-editor \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-syntax-highlighting \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
