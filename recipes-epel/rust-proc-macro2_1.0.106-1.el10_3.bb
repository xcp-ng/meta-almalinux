# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro2"
PV = "1.0.106"
PR = "1.el10_3"
PACKAGES = " \
 rust-proc-macro2+default-devel \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro2-1.0.106-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0b88a7a0996aedd073ccead4c442e03b6c512aa7742f614a89ee227fbd55a00"

URI_x86_64_v2_rust-proc-macro2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+default-devel-1.0.106-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+default-devel.sha256sum] = "7e377480acb3082fceb507325911013ba056ca83026bd991af31aedb714ea01b"

URI_x86_64_v2_rust-proc-macro2+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+proc-macro-devel-1.0.106-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+proc-macro-devel.sha256sum] = "0c1305db25fca16e501bfdf4802b40b99536b713c5f149aeaade0d6036e84e52"

URI_x86_64_v2_rust-proc-macro2+span-locations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+span-locations-devel-1.0.106-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+span-locations-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+span-locations-devel.sha256sum] = "0ab8aea3a9e2c9d7e6ef0f459a5c322884abb281990f374f12224194ad458d2d"

URI_x86_64_v2_rust-proc-macro2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2-devel-1.0.106-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2-devel.sha256sum] = "23564ed7da8fe8ef24cfb3a4758fe1c8818e8baccddb105406c777f79f94f51c"

URI_aarch64_rust-proc-macro2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+default-devel-1.0.106-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+default-devel}"
SRC_URI[aarch64_rust-proc-macro2+default-devel.sha256sum] = "587b7b311cd87feb77a514c29134f76b1622a6a5f39ffaf641670cc698cedc20"

URI_aarch64_rust-proc-macro2+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+proc-macro-devel-1.0.106-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+proc-macro-devel}"
SRC_URI[aarch64_rust-proc-macro2+proc-macro-devel.sha256sum] = "9239caeb1c1a0f73f64b2c9605fb7c16168d358818196518a79db85ae86a122e"

URI_aarch64_rust-proc-macro2+span-locations-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+span-locations-devel-1.0.106-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+span-locations-devel}"
SRC_URI[aarch64_rust-proc-macro2+span-locations-devel.sha256sum] = "c6406976d492e71d184646b9eb622120dbf282ff05f1d26e1b391c26e6256210"

URI_aarch64_rust-proc-macro2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2-devel-1.0.106-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2-devel}"
SRC_URI[aarch64_rust-proc-macro2-devel.sha256sum] = "cbae33f2084ff5e6569be6bfe4cd93c2d722e4207b2fdf89cde84d3550733528"

RDEPENDS:rust-proc-macro2+default-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+proc-macro-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+span-locations-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2-devel = " \
 cargo \
 rust \
 rust-unicode-ident+default-devel \
 "
