# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipsparse"
PV = "7.2.0"
PR = "6.el10_3"
PACKAGES:x86_64_v2 = " \
 hipsparse \
 hipsparse-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipsparse-7.2.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52c0ea3bd2d45025dd59df9930cd39be7e27bb479619dcb63a30bca121249bf2"

URI_x86_64_v2_hipsparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsparse-7.2.0-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsparse}"
SRC_URI[x86_64_v2_hipsparse.sha256sum] = "b268881497482d4d9178ed7537c3c2fbf0d2a7c800aa874bb9c6e48e437164c4"

URI_x86_64_v2_hipsparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsparse-devel-7.2.0-6.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsparse-devel}"
SRC_URI[x86_64_v2_hipsparse-devel.sha256sum] = "f7b5fbe7a7a9e0b98953bd266b9684ecc49436416b51087184251365d1f65d09"

RDEPENDS:hipsparse = " \
 glibc \
 libstdc++ \
 rocm-hip \
 rocsparse \
 "
RDEPENDS:hipsparse-devel = " \
 cmake-filesystem \
 hipsparse \
 "
