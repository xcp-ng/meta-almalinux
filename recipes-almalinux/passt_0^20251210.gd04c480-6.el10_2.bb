# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "passt"
PV = "0^20251210.gd04c480"
PR = "6.el10_2"
PACKAGES = " \
 passt \
 passt-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/passt-0^20251210.gd04c480-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dcface59a3cff3553c9c28df300b0c39ad97355c029fd82b8a04337500b9e75"

URI_x86_64_v2_passt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-0^20251210.gd04c480-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_passt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_passt}"
SRC_URI[x86_64_v2_passt.sha256sum] = "f2b39f499541e21a020698a8484f4551b0cdf91f3fa14060acc63992b5bfd18d"

URI_x86_64_v2_passt-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-selinux-0^20251210.gd04c480-6.el10_2.noarch.rpm;name=x86_64_v2_passt-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_passt-selinux}"
SRC_URI[x86_64_v2_passt-selinux.sha256sum] = "a1bd10ac5b797f4b13040c7ce1e282c2a0d0f00f5e99132fbca4241aa4f5ea39"

URI_aarch64_passt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-0^20251210.gd04c480-6.el10_2.aarch64.rpm;name=aarch64_passt;unpack=0"
SRC_URI:append = " ${URI_aarch64_passt}"
SRC_URI[aarch64_passt.sha256sum] = "81c853e0bb956e4ba589c8e57ed7ca15ca150103c20008398889d0bf5b436181"

URI_aarch64_passt-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-selinux-0^20251210.gd04c480-6.el10_2.noarch.rpm;name=aarch64_passt-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_passt-selinux}"
SRC_URI[aarch64_passt-selinux.sha256sum] = "a1bd10ac5b797f4b13040c7ce1e282c2a0d0f00f5e99132fbca4241aa4f5ea39"

RDEPENDS:passt = " \
 glibc \
 passt-selinux \
 "
RDEPENDS:passt-selinux = " \
 bash \
 container-selinux \
 libselinux-utils \
 policycoreutils \
 selinux-policy-targeted \
 "
