# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kldap"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kldap \
 kldap-devel \
 kldap-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kldap-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbfd3ac26c4514b3a0630ab15abcc199274fc63d8f4692ed78a1d83d7b3cb1e8"

URI_x86_64_v2_kldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap}"
SRC_URI[x86_64_v2_kldap.sha256sum] = "c7c7bd6a4bea76c9869064c6dbdd70eaa93a164d50110741a8c61530089a151e"

URI_x86_64_v2_kldap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kldap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap-devel}"
SRC_URI[x86_64_v2_kldap-devel.sha256sum] = "281a3bca5e9fa3a2c8e46ee571ccbfa00f474d2ec06ce0f5d85d6dd766023fe2"

URI_x86_64_v2_kldap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kldap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kldap-doc}"
SRC_URI[x86_64_v2_kldap-doc.sha256sum] = "f258b7ad44bcc7fcd0addd360c1d3be4656de27215bc465e804fc51fadeeeb3e"

URI_aarch64_kldap = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap}"
SRC_URI[aarch64_kldap.sha256sum] = "ae469472f4f52616990ac6032a88cde96b6b594c14658714f1fcdc19b0e40e39"

URI_aarch64_kldap-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kldap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap-devel}"
SRC_URI[aarch64_kldap-devel.sha256sum] = "afe79f0fce9d3df8dd6578891661bfbcd0880f83b344fab032688677aa9a0169"

URI_aarch64_kldap-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kldap-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kldap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kldap-doc}"
SRC_URI[aarch64_kldap-doc.sha256sum] = "a0bd9dd27eeff564c8524b7e7556d204d9f14b106dedf5bc63602bc7e3547441"

RDEPENDS:kldap = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 openldap \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:kldap-devel = " \
 cmake-filesystem \
 cyrus-sasl-devel \
 kldap \
 openldap-devel \
 "
RDEPENDS:kldap-doc = " \
 "
