# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kamera"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kamera \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kamera-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e1624f9513ca2a4aed58ab620f212793e12d5f812e7b72a99a0a643297033d5"

URI_x86_64_v2_kamera = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kamera-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kamera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kamera}"
SRC_URI[x86_64_v2_kamera.sha256sum] = "1e0d51a0d7ba0a1cf225156b67fe78942257865de0f30a9c84d6825718d645a2"

URI_aarch64_kamera = "${EPEL_MIRROR}/aarch64/Packages/k/kamera-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kamera;unpack=0"
SRC_URI:append = " ${URI_aarch64_kamera}"
SRC_URI[aarch64_kamera.sha256sum] = "d1835751e60a010d381ab13110505eabcd261b99943592339c56070a7aee74fa"

RDEPENDS:kamera = " \
 glibc \
 kde-cli-tools \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgphoto2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
