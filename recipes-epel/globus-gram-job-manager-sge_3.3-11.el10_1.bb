# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-sge"
PV = "3.3"
PR = "11.el10_1"
PACKAGES = " \
 globus-gram-job-manager-sge \
 globus-gram-job-manager-sge-setup-poll \
 globus-gram-job-manager-sge-setup-seg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-sge-3.3-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12c88b4ba11deac4d6b941b123531e3c08f41727f7196adb97f75ca369032bc2"

URI_x86_64_v2_globus-gram-job-manager-sge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-sge-3.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-sge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-sge}"
SRC_URI[x86_64_v2_globus-gram-job-manager-sge.sha256sum] = "b4ae8b8fec3e05a6dae6ce27f799c8e12ce54f6c0f22181f49e0f91b6d380e93"

URI_x86_64_v2_globus-gram-job-manager-sge-setup-poll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-sge-setup-poll-3.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-sge-setup-poll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-sge-setup-poll}"
SRC_URI[x86_64_v2_globus-gram-job-manager-sge-setup-poll.sha256sum] = "62d1e1eafe65c12ae32973c37eb3d860accb73550bf89df9f5936c1ad77806ca"
RPROVIDES:globus-gram-job-manager-sge-setup-poll:append:x86_64_v2 = " virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_1.alma_altarch"

URI_x86_64_v2_globus-gram-job-manager-sge-setup-seg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-sge-setup-seg-3.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-sge-setup-seg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-sge-setup-seg}"
SRC_URI[x86_64_v2_globus-gram-job-manager-sge-setup-seg.sha256sum] = "911fc200aa82af5aa951428718306aae3e7629181363a77551fff970bdd78bf1"
RPROVIDES:globus-gram-job-manager-sge-setup-seg:append:x86_64_v2 = " virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_1.alma_altarch"

URI_aarch64_globus-gram-job-manager-sge = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-sge-3.3-11.el10_1.aarch64.rpm;name=aarch64_globus-gram-job-manager-sge;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-sge}"
SRC_URI[aarch64_globus-gram-job-manager-sge.sha256sum] = "124a4ad5c4ea8107c96fd1919c0833cd201249e584259cd3d65b2f1478b10ef0"

URI_aarch64_globus-gram-job-manager-sge-setup-poll = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-sge-setup-poll-3.3-11.el10_1.noarch.rpm;name=aarch64_globus-gram-job-manager-sge-setup-poll;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-sge-setup-poll}"
SRC_URI[aarch64_globus-gram-job-manager-sge-setup-poll.sha256sum] = "5d90db0331a1dfe6dd1fc96e7b30c9dbeeb81cda954817ce22ad5a0000773e45"
RPROVIDES:globus-gram-job-manager-sge-setup-poll:append:aarch64 = " virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_1"

URI_aarch64_globus-gram-job-manager-sge-setup-seg = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-sge-setup-seg-3.3-11.el10_1.aarch64.rpm;name=aarch64_globus-gram-job-manager-sge-setup-seg;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-sge-setup-seg}"
SRC_URI[aarch64_globus-gram-job-manager-sge-setup-seg.sha256sum] = "1b582591ab56e0138c60c9f6090bfad22a99175519ef2b290b2638cba242fac7"
RPROVIDES:globus-gram-job-manager-sge-setup-seg:append:aarch64 = " virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_1"

RDEPENDS:globus-gram-job-manager-sge:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IO \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_1.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-sge:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IO \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_1 \
"
RDEPENDS:globus-gram-job-manager-sge-setup-poll = " \
 bash \
 globus-gram-job-manager-scripts \
 globus-gram-job-manager-sge \
 "
RDEPENDS:globus-gram-job-manager-sge-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-scripts \
 globus-gram-job-manager-sge \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 systemd \
 "
