# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-commonlisp"
PV = "0.4.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-commonlisp+default-devel \
 rust-tree-sitter-commonlisp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-commonlisp-0.4.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "265faac0b1ddd945a9f181e8fa83204d84bcc6caaa6136f890abb2e7959fd14d"

URI_x86_64_v2_rust-tree-sitter-commonlisp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-commonlisp+default-devel-0.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-commonlisp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-commonlisp+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-commonlisp+default-devel.sha256sum] = "0e747c2536f617c3c36fb7e5bcb880a00c1c644129d2cc040095acce44f2d7e9"

URI_x86_64_v2_rust-tree-sitter-commonlisp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-commonlisp-devel-0.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-commonlisp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-commonlisp-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-commonlisp-devel.sha256sum] = "a8b9277bd5838e0348499c33693cf486302db17fd8d6cbde4818bf3e9966d072"

URI_aarch64_rust-tree-sitter-commonlisp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-commonlisp+default-devel-0.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-commonlisp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-commonlisp+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-commonlisp+default-devel.sha256sum] = "d47f61c0a67b9e2ba98ac27e347365cd3b632ea8e4b9761a5b577cc4a774a8b2"

URI_aarch64_rust-tree-sitter-commonlisp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-commonlisp-devel-0.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-commonlisp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-commonlisp-devel}"
SRC_URI[aarch64_rust-tree-sitter-commonlisp-devel.sha256sum] = "0bf52d36b9c1d29ede40796ce357c14a453be90027aceaa2bc1beefef85adf93"

RDEPENDS:rust-tree-sitter-commonlisp+default-devel = " \
 cargo \
 rust-tree-sitter-commonlisp-devel \
 "
RDEPENDS:rust-tree-sitter-commonlisp-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
