# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook-mio"
PV = "0.2.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-signal-hook-mio+default-devel \
 rust-signal-hook-mio+mio-0_8-devel \
 rust-signal-hook-mio+mio-1_0-devel \
 rust-signal-hook-mio+support-v0_8-devel \
 rust-signal-hook-mio+support-v1_0-devel \
 rust-signal-hook-mio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook-mio-0.2.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21afdc62d2cb6fcd9bd69642e37023de6533c1554e9252b6b7045005e0a18a56"

URI_x86_64_v2_rust-signal-hook-mio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+default-devel-0.2.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+default-devel.sha256sum] = "6296a2b120527847bc20c074e4d9a4f1992822baa9aa2182922b267b168466d3"

URI_x86_64_v2_rust-signal-hook-mio+mio-0_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+mio-0_8-devel-0.2.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+mio-0_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+mio-0_8-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+mio-0_8-devel.sha256sum] = "bba8ba0f622af2d80f38cb55cc405dec48731cf48b5b39fe17ff5c87f0981f27"

URI_x86_64_v2_rust-signal-hook-mio+mio-1_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+mio-1_0-devel-0.2.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+mio-1_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+mio-1_0-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+mio-1_0-devel.sha256sum] = "32bc1851a49ba2819567db63795cf5c7f092577718084e60b2b3709f82eb954f"

URI_x86_64_v2_rust-signal-hook-mio+support-v0_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+support-v0_8-devel-0.2.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+support-v0_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+support-v0_8-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+support-v0_8-devel.sha256sum] = "52d85e42fab76d5bfe781ec18b09575d998a0631dffb6500e152480b0588d63f"

URI_x86_64_v2_rust-signal-hook-mio+support-v1_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+support-v1_0-devel-0.2.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+support-v1_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+support-v1_0-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+support-v1_0-devel.sha256sum] = "d272a0d64bcdf8cdc6a4848109bcfbed6d0c1bc2af9a7af479ec14bd266e6e8a"

URI_x86_64_v2_rust-signal-hook-mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio-devel-0.2.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio-devel.sha256sum] = "077df053eda6ef49001af4cc643fc411470061b86b4fb1f60df4f6bc1b7358db"

URI_aarch64_rust-signal-hook-mio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+default-devel-0.2.5-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+default-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+default-devel.sha256sum] = "dea2a4b995160a36edc40664c22a2cc51c80348b8a074f7c75fdf96f8749fa8e"

URI_aarch64_rust-signal-hook-mio+mio-0_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+mio-0_8-devel-0.2.5-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook-mio+mio-0_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+mio-0_8-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+mio-0_8-devel.sha256sum] = "d14ebcf29617ed8d66905420e8f63ccf6ced27b873930bf5d6d6069b5b0cd05b"

URI_aarch64_rust-signal-hook-mio+mio-1_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+mio-1_0-devel-0.2.5-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook-mio+mio-1_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+mio-1_0-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+mio-1_0-devel.sha256sum] = "98d86c88d544882c516fac9b11aa932d5e0201a43d83f91a1bafa89c7f3bf727"

URI_aarch64_rust-signal-hook-mio+support-v0_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+support-v0_8-devel-0.2.5-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook-mio+support-v0_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+support-v0_8-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+support-v0_8-devel.sha256sum] = "5e60cba094075ad0cae8f3a27a7868db562aea4d90713d9819bb069d6b89363b"

URI_aarch64_rust-signal-hook-mio+support-v1_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+support-v1_0-devel-0.2.5-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook-mio+support-v1_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+support-v1_0-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+support-v1_0-devel.sha256sum] = "e8f0b6826500178e8d454b4e6ab5a4b3c06f26315dc75c29aad890af19fa46be"

URI_aarch64_rust-signal-hook-mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio-devel-0.2.5-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook-mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio-devel}"
SRC_URI[aarch64_rust-signal-hook-mio-devel.sha256sum] = "a0c9d0e4a55db3660d66a7bae2e9d018babecc296f9ff8e38cc81e0f93b1b463"

RDEPENDS:rust-signal-hook-mio+default-devel = " \
 cargo \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+mio-0_8-devel = " \
 cargo \
 rust-mio0.8+default-devel \
 rust-mio0.8+net-devel \
 rust-mio0.8+os-ext-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+mio-1_0-devel = " \
 cargo \
 rust-mio+default-devel \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+support-v0_8-devel = " \
 cargo \
 rust-signal-hook-mio+mio-0_8-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+support-v1_0-devel = " \
 cargo \
 rust-signal-hook-mio+mio-1_0-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-signal-hook+default-devel \
 "
