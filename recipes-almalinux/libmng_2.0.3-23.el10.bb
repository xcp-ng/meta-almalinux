# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmng"
PV = "2.0.3"
PR = "23.el10"
PACKAGES = " \
 libmng \
 libmng-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libmng-2.0.3-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1165ca10258fb4e944156ddc2c8f001acc3d393ad0babd5f529fc9b4b17c298"

URI_x86_64_v2_libmng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmng-2.0.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_libmng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmng}"
SRC_URI[x86_64_v2_libmng.sha256sum] = "5f7dacb59d11b3222e3420b97c38b8a12ce723f1ce8e81c79c391e480e2506f1"

URI_x86_64_v2_libmng-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmng-devel-2.0.3-23.el10.x86_64_v2.rpm;name=x86_64_v2_libmng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmng-devel}"
SRC_URI[x86_64_v2_libmng-devel.sha256sum] = "13fb568ffb40032dfb51dce65dc62622b0d48a87b6c64c08287907763b43ae1c"

URI_aarch64_libmng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmng-2.0.3-23.el10.aarch64.rpm;name=aarch64_libmng;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmng}"
SRC_URI[aarch64_libmng.sha256sum] = "e3124f15a0326c9859a5d254e0eb70cf2c5f54388cb458b2ccf394afb622f2c7"

URI_aarch64_libmng-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmng-devel-2.0.3-23.el10.aarch64.rpm;name=aarch64_libmng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmng-devel}"
SRC_URI[aarch64_libmng-devel.sha256sum] = "5ff1f6fa276a0d47130004c84c91a2e0797a6499f2bd7745c35ff2457fb7a763"

RDEPENDS:libmng = " \
 glibc \
 lcms2 \
 libjpeg-turbo \
 zlib-ng-compat \
 "
RDEPENDS:libmng-devel = " \
 libjpeg-turbo-devel \
 libmng \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
