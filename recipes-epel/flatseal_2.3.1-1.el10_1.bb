# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatseal"
PV = "2.3.1"
PR = "1.el10_1"
PACKAGES = " \
 flatseal \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/flatseal-2.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f530a66865ffae0d7b0125965c2afd1acaaa68709ce1e0c0df5988a7a07ad026"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatseal-2.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_flatseal;unpack=0"
SRC_URI[x86_64_v2_flatseal.sha256sum] = "e5d69f5f19cb45f6afd753e17cddf18c5afc6efc33fb68788c5ddee27570c3e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/flatseal-2.3.1-1.el10_1.noarch.rpm;name=aarch64_flatseal;unpack=0"
SRC_URI[aarch64_flatseal.sha256sum] = "51df3c485997967d8f63c053f8ad71b799eab908e8a0221226a6dfc463632228"

RDEPENDS:flatseal = " \
 appstream \
 gjs \
 gtk4 \
 libadwaita \
 webkitgtk6.0 \
 "
