# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-xdist"
PV = "3.6.1"
PR = "4.el10_0"
PACKAGES = " \
 python3-pytest-xdist \
 python3-pytest-xdist+psutil \
 python3-pytest-xdist+setproctitle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-xdist-3.6.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b22b84277f4f035fdd63b15fcded6dab8fd3765fd90759e96290e7cb4a48a5a0"

URI_x86_64_v2_python3-pytest-xdist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-xdist-3.6.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-xdist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-xdist}"
SRC_URI[x86_64_v2_python3-pytest-xdist.sha256sum] = "e64809872ca39e6e710b484ed6012b254cde51a0f27634ef8d5be66a6bb1da8d"

URI_x86_64_v2_python3-pytest-xdist+psutil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-xdist+psutil-3.6.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-xdist+psutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-xdist+psutil}"
SRC_URI[x86_64_v2_python3-pytest-xdist+psutil.sha256sum] = "72a091db3a04bbe2e974032a9d617606044a360de1f1a868954f94feb530ab78"

URI_x86_64_v2_python3-pytest-xdist+setproctitle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-xdist+setproctitle-3.6.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-xdist+setproctitle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-xdist+setproctitle}"
SRC_URI[x86_64_v2_python3-pytest-xdist+setproctitle.sha256sum] = "e80fffc4db4961da864d815b9650a7b8028b99de6cde9c3012231499e675e85e"

URI_aarch64_python3-pytest-xdist = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-xdist-3.6.1-4.el10_0.noarch.rpm;name=aarch64_python3-pytest-xdist;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-xdist}"
SRC_URI[aarch64_python3-pytest-xdist.sha256sum] = "62d35e06c08f248ba4f25cc2397eee6d771a14f48ca8b8e578fabe3f181c0cda"

URI_aarch64_python3-pytest-xdist+psutil = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-xdist+psutil-3.6.1-4.el10_0.noarch.rpm;name=aarch64_python3-pytest-xdist+psutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-xdist+psutil}"
SRC_URI[aarch64_python3-pytest-xdist+psutil.sha256sum] = "c2db2c826c7bd740edda9bc2410cbe12c92421568bf4c9e0873ca7ddd28cb584"

URI_aarch64_python3-pytest-xdist+setproctitle = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-xdist+setproctitle-3.6.1-4.el10_0.noarch.rpm;name=aarch64_python3-pytest-xdist+setproctitle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-xdist+setproctitle}"
SRC_URI[aarch64_python3-pytest-xdist+setproctitle.sha256sum] = "7f49ed303ce8ac17d0efac41af3569577dd717b9546ec2b3c8fbf0620745293e"

RDEPENDS:python3-pytest-xdist = " \
 python3 \
 python3-execnet \
 python3-pytest \
 "
RDEPENDS:python3-pytest-xdist+psutil = " \
 python3 \
 python3-psutil \
 python3-pytest-xdist \
 "
RDEPENDS:python3-pytest-xdist+setproctitle = " \
 python3 \
 python3-pytest-xdist \
 python3-setproctitle \
 "
