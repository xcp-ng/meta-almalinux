# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colord-kde"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 colord-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/colord-kde-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4128b97a56a4215398813397df801f09a4e7478003454f8ca34a7de95c79dc0b"

URI_x86_64_v2_colord-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/colord-kde-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_colord-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord-kde}"
SRC_URI[x86_64_v2_colord-kde.sha256sum] = "41cdb8ac369d628f9b1ed5b847e308ee24638e5cfdf58a9cac93037f13822983"

URI_aarch64_colord-kde = "${EPEL_MIRROR}/aarch64/Packages/c/colord-kde-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_colord-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord-kde}"
SRC_URI[aarch64_colord-kde.sha256sum] = "9b4f1768498e1f4c42adab7525b763457aef38947b85e615fee64a1b2656e817"

RDEPENDS:colord-kde = " \
 colord \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami-addons \
 kf6-kwidgetsaddons \
 lcms2 \
 libX11 \
 libXrandr \
 libstdc++ \
 plasma-systemsettings \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
