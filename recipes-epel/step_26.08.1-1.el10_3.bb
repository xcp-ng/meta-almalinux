# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "step"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 step \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/step-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b0fccdc0cbbf78ada02fcf8d97b6c030d5a9eb69d456d719782069b1df5fb1b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/step-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_step;unpack=0"
SRC_URI[x86_64_v2_step.sha256sum] = "498f747147ab5f5dcb97e24de519d3a35b1ad5b4d6d69e9abf0411da07ee5941"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/step-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_step;unpack=0"
SRC_URI[aarch64_step.sha256sum] = "aa364c41379c09ecd3608b700ec0da237be46bd1122d32126f09f731a5116b69"

RDEPENDS:step = " \
 glibc \
 gsl \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-kplotting \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libqalculate \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
