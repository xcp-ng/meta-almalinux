# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktorrent"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ktorrent \
 ktorrent-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ktorrent-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8cb669fbc01639e8435aa52a593e7b27ca6d0940eddda051c95d35119e3a0878"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktorrent-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktorrent;unpack=0"
SRC_URI[x86_64_v2_ktorrent.sha256sum] = "e9eca71ff58be74636fc791df2236f659831d4c851e4315ed1c4a9fb200d8f52"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktorrent-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktorrent-libs;unpack=0"
SRC_URI[x86_64_v2_ktorrent-libs.sha256sum] = "afc5756411b48b10e2ee9f54a7de3fdf9bd2dae3d404e37a99e865af76b2f72f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktorrent-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ktorrent;unpack=0"
SRC_URI[aarch64_ktorrent.sha256sum] = "283a3817a02087bea019bc1510ff135a6b4b0db363511879e4838d61ae71c143"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktorrent-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ktorrent-libs;unpack=0"
SRC_URI[aarch64_ktorrent-libs.sha256sum] = "6fa2a71f6bcbecaafcac11d5e33d97db8999b8c5be2522042ff3dbbb5db87d77"

RDEPENDS:ktorrent = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kplotting \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syndication \
 ktorrent-libs \
 libgcc \
 libktorrent \
 libmaxminddb \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:ktorrent-libs = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktorrent \
 libgcc \
 libktorrent \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
