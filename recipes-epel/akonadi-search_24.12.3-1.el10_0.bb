# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-search"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 akonadi-search \
 akonadi-search-devel \
 akonadi-search-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-search-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b105bfd7cf5684be7da461234c220450e69b7e8557cce09d78f6f2236f49eb3"

URI_x86_64_v2_akonadi-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search}"
SRC_URI[x86_64_v2_akonadi-search.sha256sum] = "f6a51a655d638d5cbbcaf06fc4f965e59de84cda9e83684302d3435252610b39"

URI_x86_64_v2_akonadi-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search-devel}"
SRC_URI[x86_64_v2_akonadi-search-devel.sha256sum] = "3fd7c1a95ac491a5fcf6b755d53f2a6a6c0defe75b869e570bfc2b7bc8ee9e37"

URI_x86_64_v2_akonadi-search-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-search-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search-doc}"
SRC_URI[x86_64_v2_akonadi-search-doc.sha256sum] = "066adeafaeeab190bfb826767ee9ed320c25c6f51d4d3b7ab080590c4544304a"

URI_aarch64_akonadi-search = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search}"
SRC_URI[aarch64_akonadi-search.sha256sum] = "0a14ccd33751d8c56e19e9901f908483be0381d21f734cea92acf7e342a6bb2b"

URI_aarch64_akonadi-search-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search-devel}"
SRC_URI[aarch64_akonadi-search-devel.sha256sum] = "4fc27e848f54a02a106ca25a6d764bb8bf081a79a25407e114c672f1288782f5"

URI_aarch64_akonadi-search-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_akonadi-search-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search-doc}"
SRC_URI[aarch64_akonadi-search-doc.sha256sum] = "3bb8cfb146ab074de37d4a85e54e5b62a487e8a2ffa55367d5bacc0a922da7d3"

RDEPENDS:akonadi-search = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-krunner \
 kf6-kwidgetsaddons \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 xapian-core-libs \
 "
RDEPENDS:akonadi-search-devel = " \
 akonadi-mime-devel \
 akonadi-search \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kcoreaddons-devel \
 kmime-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:akonadi-search-doc = " \
 "
