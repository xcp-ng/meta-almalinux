# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dtor-proc-macro"
PV = "0.0.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-dtor-proc-macro+default-devel \
 rust-dtor-proc-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dtor-proc-macro-0.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd891cdd35d8078dff5200f8e108d0ee9eab887ca91b9aca9b558470564902c3"

URI_x86_64_v2_rust-dtor-proc-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtor-proc-macro+default-devel-0.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtor-proc-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtor-proc-macro+default-devel}"
SRC_URI[x86_64_v2_rust-dtor-proc-macro+default-devel.sha256sum] = "af160147e6c58aee1e9d2e9e955dea224797153787ce08b0f64de12dc2c5ffb6"

URI_x86_64_v2_rust-dtor-proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dtor-proc-macro-devel-0.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dtor-proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dtor-proc-macro-devel}"
SRC_URI[x86_64_v2_rust-dtor-proc-macro-devel.sha256sum] = "c36058c178a9a6ad0396c84973f870faf3692c2dfe5838544f4cb0d8f4db1104"

URI_aarch64_rust-dtor-proc-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtor-proc-macro+default-devel-0.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-dtor-proc-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtor-proc-macro+default-devel}"
SRC_URI[aarch64_rust-dtor-proc-macro+default-devel.sha256sum] = "3fdf9b6c1b40ac176811c32ddda6fd87dda33f9e7346114e89ac6c71feb09323"

URI_aarch64_rust-dtor-proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dtor-proc-macro-devel-0.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-dtor-proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dtor-proc-macro-devel}"
SRC_URI[aarch64_rust-dtor-proc-macro-devel.sha256sum] = "e91025bdebe92f8c69dd5b282772e4945495116fde51c28768a1f587029da283"

RDEPENDS:rust-dtor-proc-macro+default-devel = " \
 cargo \
 rust-dtor-proc-macro-devel \
 "
RDEPENDS:rust-dtor-proc-macro-devel = " \
 cargo \
 "
