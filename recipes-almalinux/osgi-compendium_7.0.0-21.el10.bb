# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osgi-compendium"
PV = "7.0.0"
PR = "21.el10"
PACKAGES = " \
 osgi-compendium \
 osgi-compendium-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/osgi-compendium-7.0.0-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96eaeb18df149556604bf8ef8618fa493717b323a5563079cab4dec503d5eb91"

URI_x86_64_v2_osgi-compendium = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/osgi-compendium-7.0.0-21.el10.noarch.rpm;name=x86_64_v2_osgi-compendium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osgi-compendium}"
SRC_URI[x86_64_v2_osgi-compendium.sha256sum] = "32f31269ef0124954455977518d062d73410f516c310322cc3ea8caf60d6f6d7"

URI_x86_64_v2_osgi-compendium-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/osgi-compendium-javadoc-7.0.0-21.el10.noarch.rpm;name=x86_64_v2_osgi-compendium-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osgi-compendium-javadoc}"
SRC_URI[x86_64_v2_osgi-compendium-javadoc.sha256sum] = "291f017c8d3fa93a868ac9227ba7f6834cdd089046acfa4295b72d6bd637a36e"

URI_aarch64_osgi-compendium = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/osgi-compendium-7.0.0-21.el10.noarch.rpm;name=aarch64_osgi-compendium;unpack=0"
SRC_URI:append = " ${URI_aarch64_osgi-compendium}"
SRC_URI[aarch64_osgi-compendium.sha256sum] = "32f31269ef0124954455977518d062d73410f516c310322cc3ea8caf60d6f6d7"

URI_aarch64_osgi-compendium-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/osgi-compendium-javadoc-7.0.0-21.el10.noarch.rpm;name=aarch64_osgi-compendium-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_osgi-compendium-javadoc}"
SRC_URI[aarch64_osgi-compendium-javadoc.sha256sum] = "291f017c8d3fa93a868ac9227ba7f6834cdd089046acfa4295b72d6bd637a36e"

RDEPENDS:osgi-compendium = " \
 javapackages-filesystem \
 "
RDEPENDS:osgi-compendium-javadoc = " \
 javapackages-filesystem \
 "
