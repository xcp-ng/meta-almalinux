# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdegames"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libkdegames \
 libkdegames-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdegames-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "234c53b1c6f348175110f3f69a017b0b88d258f53135cd795fa26ff34fd6a266"

URI_x86_64_v2_libkdegames = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdegames-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdegames;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdegames}"
SRC_URI[x86_64_v2_libkdegames.sha256sum] = "1185fe626b8215649b260cd78f666d2a98da2d84c5709d7e4aa25c94ff66c803"

URI_x86_64_v2_libkdegames-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdegames-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdegames-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdegames-devel}"
SRC_URI[x86_64_v2_libkdegames-devel.sha256sum] = "a4311cf942b13f93465ba8a171256b4a4e43728c4f97c033fdd51c605c9320cb"

URI_aarch64_libkdegames = "${EPEL_MIRROR}/aarch64/Packages/l/libkdegames-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkdegames;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdegames}"
SRC_URI[aarch64_libkdegames.sha256sum] = "6ca069ee7c799fa7ed40a938ee98e53b11ef924d8e28312aca2864354b790c4d"

URI_aarch64_libkdegames-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdegames-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkdegames-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdegames-devel}"
SRC_URI[aarch64_libkdegames-devel.sha256sum] = "3865165905aa78c5642ad2a22da45c19d60b21a9812c4de078b47f4a0e2d549d"

RDEPENDS:libkdegames = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdnssd \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libsndfile \
 libstdc++ \
 openal-soft \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:libkdegames-devel = " \
 cmake-filesystem \
 kf6-kcompletion-devel \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-ki18n-devel \
 kf6-kwidgetsaddons-devel \
 libkdegames \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
