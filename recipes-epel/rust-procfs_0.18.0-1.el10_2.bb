# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-procfs"
PV = "0.18.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-procfs+backtrace-devel \
 rust-procfs+chrono-devel \
 rust-procfs+default-devel \
 rust-procfs+flate2-devel \
 rust-procfs+serde-devel \
 rust-procfs+serde1-devel \
 rust-procfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-procfs-0.18.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3046b6265ac4182f7cc85e185d0a5acf147b9940496d9fa65ee5312f1cb4736"

URI_x86_64_v2_rust-procfs+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+backtrace-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+backtrace-devel}"
SRC_URI[x86_64_v2_rust-procfs+backtrace-devel.sha256sum] = "5cec7b68a3a6312d406823fbafb9b64af272a67070e2045e55a82353398fdd66"

URI_x86_64_v2_rust-procfs+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+chrono-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+chrono-devel}"
SRC_URI[x86_64_v2_rust-procfs+chrono-devel.sha256sum] = "600ab9960eb1eca29acd45a81eb71d091193d700d5a30f4687e67f1cbe3710d5"

URI_x86_64_v2_rust-procfs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+default-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+default-devel}"
SRC_URI[x86_64_v2_rust-procfs+default-devel.sha256sum] = "c876467a4c845edcfa3d4c00d7c86542253474bf96a5f36a8ccb65acb6564c2a"

URI_x86_64_v2_rust-procfs+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+flate2-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+flate2-devel}"
SRC_URI[x86_64_v2_rust-procfs+flate2-devel.sha256sum] = "4642842450e04120ad87e4d099863240a88e13efb401ee4293c1f94dac3025be"

URI_x86_64_v2_rust-procfs+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+serde-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+serde-devel}"
SRC_URI[x86_64_v2_rust-procfs+serde-devel.sha256sum] = "009ed50ee6f6757b61ae32ba7afdb9eaad7ffbb7d51389281c9e0359655ec232"

URI_x86_64_v2_rust-procfs+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+serde1-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+serde1-devel}"
SRC_URI[x86_64_v2_rust-procfs+serde1-devel.sha256sum] = "419c88443e25af163cd30c27650ba23706cc536f69b9a39684c0840c5d00bfe7"

URI_x86_64_v2_rust-procfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-devel-0.18.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-devel}"
SRC_URI[x86_64_v2_rust-procfs-devel.sha256sum] = "8bbc49b08a4c18f43cd7fbe9cfa2b2b8f6b6e60237d512079714e8e86ed0f014"

URI_aarch64_rust-procfs+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+backtrace-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+backtrace-devel}"
SRC_URI[aarch64_rust-procfs+backtrace-devel.sha256sum] = "db14f2994194b91145d7e23d95bf4b794942b63a52328d08d684186640a9b5ed"

URI_aarch64_rust-procfs+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+chrono-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+chrono-devel}"
SRC_URI[aarch64_rust-procfs+chrono-devel.sha256sum] = "7a8a58308d01f7ff4faf896f596e31cd95c251d9583936c5c0999dcdf5856b11"

URI_aarch64_rust-procfs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+default-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+default-devel}"
SRC_URI[aarch64_rust-procfs+default-devel.sha256sum] = "5757e909557b01b7824783a0797e3c1e847986ff0d2f9be0d0b012cfeda24ebb"

URI_aarch64_rust-procfs+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+flate2-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+flate2-devel}"
SRC_URI[aarch64_rust-procfs+flate2-devel.sha256sum] = "fb262018707d21c1aa4074c713ea24e983b9fad79ebad25caa04e13f457ada26"

URI_aarch64_rust-procfs+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+serde-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+serde-devel}"
SRC_URI[aarch64_rust-procfs+serde-devel.sha256sum] = "f97548099f95c9a1919d4ca70962baad05781bd1e211aa1d973b7423aee10b8d"

URI_aarch64_rust-procfs+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+serde1-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+serde1-devel}"
SRC_URI[aarch64_rust-procfs+serde1-devel.sha256sum] = "a2723e61afd70add7d445cf54c61e6b4c59d2df79b24485e5212c443cb7f5787"

URI_aarch64_rust-procfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-devel-0.18.0-1.el10_2.noarch.rpm;name=aarch64_rust-procfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-devel}"
SRC_URI[aarch64_rust-procfs-devel.sha256sum] = "561665cd06ca793cdd945cd20938a4dfa4f405d33d63cdd7eb0abc48ecbbf054"

RDEPENDS:rust-procfs+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-procfs-core+backtrace-devel \
 rust-procfs-devel \
 "
RDEPENDS:rust-procfs+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-procfs-devel \
 "
RDEPENDS:rust-procfs+default-devel = " \
 cargo \
 rust-procfs+chrono-devel \
 rust-procfs+flate2-devel \
 rust-procfs-core+default-devel \
 rust-procfs-devel \
 "
RDEPENDS:rust-procfs+flate2-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-procfs-devel \
 "
RDEPENDS:rust-procfs+serde-devel = " \
 cargo \
 rust-procfs-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-procfs+serde1-devel = " \
 cargo \
 rust-procfs+serde-devel \
 rust-procfs-core+serde1-devel \
 rust-procfs-devel \
 "
RDEPENDS:rust-procfs-devel = " \
 cargo \
 rust \
 rust-bitflags-devel \
 rust-procfs-core-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+param-devel \
 rust-rustix+process-devel \
 rust-rustix+system-devel \
 rust-rustix+thread-devel \
 "
