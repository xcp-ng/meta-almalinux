# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgeography"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kgeography \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kgeography-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2fc749b489f20018b7f3c452cdbff134d2ebc3e0df592d643d9bab8c533054dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgeography-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgeography;unpack=0"
SRC_URI[x86_64_v2_kgeography.sha256sum] = "30366012ce1c34fbf85ddff41ea87fa846e0f7908c3fc94b4d0b75b5e24da1d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kgeography-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kgeography;unpack=0"
SRC_URI[aarch64_kgeography.sha256sum] = "de342fdc8684050bd5b9e3ed62e50adec9cd1b45988a7386ab9d983fc129a913"

RDEPENDS:kgeography = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
