# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IPC-System-Simple"
PV = "1.30"
PR = "16.el10"
PACKAGES = " \
 perl-IPC-System-Simple \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-IPC-System-Simple-1.30-16.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5e42e313f4e8cb951a6891143c7dbd66d186d3c476949481bcdc2671e0d5da09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IPC-System-Simple-1.30-16.el10.noarch.rpm;name=x86_64_v2_perl-IPC-System-Simple;unpack=0"
SRC_URI[x86_64_v2_perl-IPC-System-Simple.sha256sum] = "70520e27709978cb886d9d07fd16d59ee5b8849317974e0d52986083481e188b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IPC-System-Simple-1.30-16.el10.noarch.rpm;name=aarch64_perl-IPC-System-Simple;unpack=0"
SRC_URI[aarch64_perl-IPC-System-Simple.sha256sum] = "70520e27709978cb886d9d07fd16d59ee5b8849317974e0d52986083481e188b"

RDEPENDS:perl-IPC-System-Simple = " \
 perl-Carp \
 perl-Exporter \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-libs \
 "
