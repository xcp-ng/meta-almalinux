# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firefox"
PV = "140.4.0"
PR = "3.el10_0"
PACKAGES = " \
 firefox \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/firefox-140.4.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "155bd52477961fc080ce7ed45ae75018bd4c3f839083935ced2902d66c17b1c6"

URI_x86_64_v2_firefox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firefox-140.4.0-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_firefox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firefox}"
SRC_URI[x86_64_v2_firefox.sha256sum] = "690815c637d6810d871f70eadf92680a30848b506665906aecc9adf843923d60"

URI_aarch64_firefox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firefox-140.4.0-3.el10_0.aarch64.rpm;name=aarch64_firefox;unpack=0"
SRC_URI:append = " ${URI_aarch64_firefox}"
SRC_URI[aarch64_firefox.sha256sum] = "bf5b4b8022d3d7e008fa8431472f786c3220d3976ce8760da443c75abd34425e"

RDEPENDS:firefox = " \
 almalinux-indexhtml \
 alsa-lib \
 atk \
 bash \
 cairo \
 cairo-gobject \
 dbus-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libffi \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libxcb \
 mozilla-filesystem \
 nspr \
 nss \
 nss-util \
 p11-kit-trust \
 pango \
 pciutils-libs \
 zlib-ng-compat \
 "
