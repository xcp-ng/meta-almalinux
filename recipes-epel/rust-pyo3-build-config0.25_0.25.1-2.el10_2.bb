# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config0.25"
PV = "0.25.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-pyo3-build-config0.25+abi3-devel \
 rust-pyo3-build-config0.25+abi3-py310-devel \
 rust-pyo3-build-config0.25+abi3-py311-devel \
 rust-pyo3-build-config0.25+abi3-py312-devel \
 rust-pyo3-build-config0.25+abi3-py313-devel \
 rust-pyo3-build-config0.25+abi3-py314-devel \
 rust-pyo3-build-config0.25+abi3-py37-devel \
 rust-pyo3-build-config0.25+abi3-py38-devel \
 rust-pyo3-build-config0.25+abi3-py39-devel \
 rust-pyo3-build-config0.25+default-devel \
 rust-pyo3-build-config0.25+extension-module-devel \
 rust-pyo3-build-config0.25+resolve-config-devel \
 rust-pyo3-build-config0.25-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config0.25-0.25.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f9054ccdb946db738239cf7af5d669eeb5030a355b99c605d0967e42de336ae5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+abi3-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+abi3-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+abi3-devel.sha256sum] = "20015b9322e1c741bbd38d021835382c346e187840aa03db54bdfca0e042f849"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+abi3-py310-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+abi3-py310-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+abi3-py310-devel.sha256sum] = "770866fdafcc15db92a706fc3a81030ecd1bc3725203f1b349662ebecf05c486"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+abi3-py311-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+abi3-py311-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+abi3-py311-devel.sha256sum] = "83058403c1b98ca527cecdf21036af4d7a424db775cba857dc220070a91e7582"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+abi3-py312-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+abi3-py312-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+abi3-py312-devel.sha256sum] = "968848e5f53016da34a5c3348977f26562c350c6d4aa5f5549917271343a79ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+abi3-py313-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+abi3-py313-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+abi3-py313-devel.sha256sum] = "c9a965b681f95a582bf68f753b1801d9102d208acd4638e21c76859a79e48f0a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+abi3-py314-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+abi3-py314-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+abi3-py314-devel.sha256sum] = "af8db791eca64a90a4053d7cc5f1f3c5d88940052ecbe998d340dd9ff2ba4aae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+abi3-py37-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+abi3-py37-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+abi3-py37-devel.sha256sum] = "87d7ae8cc0f21f077921cc3ad6f97b36fc69865c15403ee7e1d5216894fb3cbb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+abi3-py38-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+abi3-py38-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+abi3-py38-devel.sha256sum] = "1c7deb20c04347940694a0b50f7515d9f393fd4d7691b0395d39bc42e518e8ac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+abi3-py39-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+abi3-py39-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+abi3-py39-devel.sha256sum] = "ab57c6c76effd84994ce52397c5e4e47d6b9d6e42794f24851b2af8a2e717d93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+default-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+default-devel.sha256sum] = "cc5abe625ba806876e73a6678f829f58dd59726f41a174e42b240500e48fc0a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+extension-module-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+extension-module-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+extension-module-devel.sha256sum] = "cdd5f09ca7a71bbf862f3d3c49046f88d2a7fe29782e98f6d1788e8d827921d0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25+resolve-config-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25+resolve-config-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25+resolve-config-devel.sha256sum] = "87afcb2a91badaa225c38e8806b3b815834890fb5285dd42f74353a6ba66eabe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.25-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.25-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.25-devel.sha256sum] = "d2bb10571ef3cbae0d4e4a615dcc275732a9aeaa57df90bd70fd184b0646d127"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+abi3-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+abi3-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+abi3-devel.sha256sum] = "47bf683e134981b0e8c02df60022aa3584ddc89e0eb3c1d87854863cb85f52f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+abi3-py310-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+abi3-py310-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+abi3-py310-devel.sha256sum] = "de6008e02a7a7cda1160ff96768214560148ec577fb6ae23f985215979f8318b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+abi3-py311-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+abi3-py311-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+abi3-py311-devel.sha256sum] = "02edaa78e45d08f1b7b7d8243f71958938fef2c1c878865e031036f87f1606df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+abi3-py312-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+abi3-py312-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+abi3-py312-devel.sha256sum] = "864bc68db32af396c3db3b72f1454876d4a7dd2c7dcb2dd089db0fe9ae42f575"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+abi3-py313-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+abi3-py313-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+abi3-py313-devel.sha256sum] = "dfb40f78954d32dec33799934c839b5799a67e7eab5ffea09a97edda4cc5742c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+abi3-py314-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+abi3-py314-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+abi3-py314-devel.sha256sum] = "a5d0245e9ff6abf7f6db6b26b1660dcc86ae54110ef1a65f96c163d5866a412d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+abi3-py37-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+abi3-py37-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+abi3-py37-devel.sha256sum] = "e007a3ed6089510ff8c5f31148f8fcf7f5158dce751292ead5b490dc3ebaf701"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+abi3-py38-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+abi3-py38-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+abi3-py38-devel.sha256sum] = "b9269d399c39bcc105760e82cd6df0a25403aa611b909c0f56076ded5129634a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+abi3-py39-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+abi3-py39-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+abi3-py39-devel.sha256sum] = "0f21c0289382c832e6ed079e2924793c6112935107e0be8f61d9bdeb2568c52e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+default-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+default-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+default-devel.sha256sum] = "ad8fcb3759462e8256372f2d8122d92a6bd30249bdc2e551646435b7a28342f3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+extension-module-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+extension-module-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+extension-module-devel.sha256sum] = "322c41c0559485fb2707b6209f2765324a5d22384721458298fda2533248d632"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25+resolve-config-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25+resolve-config-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25+resolve-config-devel.sha256sum] = "6885e65b461c4d6cc3d691ebc2d1a603d3c9bb42bf07a9d01bb57fd22ad5eff8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.25-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-build-config0.25-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3-build-config0.25-devel.sha256sum] = "0d9e71bd4025ea1d2fa59707b5026c37febbf0811dbb9040f2cbec6ba038c2f5"

RDEPENDS:rust-pyo3-build-config0.25+abi3-devel = " \
 cargo \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+abi3-py310-devel = " \
 cargo \
 rust-pyo3-build-config0.25+abi3-py311-devel \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+abi3-py311-devel = " \
 cargo \
 rust-pyo3-build-config0.25+abi3-py312-devel \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+abi3-py312-devel = " \
 cargo \
 rust-pyo3-build-config0.25+abi3-py313-devel \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+abi3-py313-devel = " \
 cargo \
 rust-pyo3-build-config0.25+abi3-py314-devel \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+abi3-py314-devel = " \
 cargo \
 rust-pyo3-build-config0.25+abi3-devel \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+abi3-py37-devel = " \
 cargo \
 rust-pyo3-build-config0.25+abi3-py38-devel \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+abi3-py38-devel = " \
 cargo \
 rust-pyo3-build-config0.25+abi3-py39-devel \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+abi3-py39-devel = " \
 cargo \
 rust-pyo3-build-config0.25+abi3-py310-devel \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+default-devel = " \
 cargo \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config0.25-devel \
 "
RDEPENDS:rust-pyo3-build-config0.25-devel = " \
 cargo \
 python3 \
 rust \
 rust-once_cell+default-devel \
 rust-target-lexicon+default-devel \
 "
