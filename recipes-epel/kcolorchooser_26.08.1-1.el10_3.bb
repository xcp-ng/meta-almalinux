# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcolorchooser"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kcolorchooser \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kcolorchooser-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c776e134b1b1555bde2b8a940345c9a1f6bede7a0d3311eb7fa46f1718eef8e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcolorchooser-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcolorchooser;unpack=0"
SRC_URI[x86_64_v2_kcolorchooser.sha256sum] = "86dc5b0e4a2f09464e9fb658c6f39304676c8284e1e1107c1e817b170ff68200"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcolorchooser-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kcolorchooser;unpack=0"
SRC_URI[aarch64_kcolorchooser.sha256sum] = "ded04c323269994e5e33b28abb43c5ba374392c0eed509ff90696dfb237f0040"

RDEPENDS:kcolorchooser = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
