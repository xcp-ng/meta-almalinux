# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num_cpus"
PV = "1.17.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-num_cpus+default-devel \
 rust-num_cpus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num_cpus-1.17.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81a9bcc493fe4a8805601cb3d486aed7328ca6af3922323d18a6561a0852ec6d"

URI_x86_64_v2_rust-num_cpus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_cpus+default-devel-1.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_cpus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_cpus+default-devel}"
SRC_URI[x86_64_v2_rust-num_cpus+default-devel.sha256sum] = "06fb3187868790b796a318ba83e9936bcd8991a37c017fe919d3ee5a57ecbabd"

URI_x86_64_v2_rust-num_cpus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num_cpus-devel-1.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num_cpus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num_cpus-devel}"
SRC_URI[x86_64_v2_rust-num_cpus-devel.sha256sum] = "1770b207c34b55c4ed03d7a508abccd2be3afb9f62719fcafdeb72b64bd0ce62"

URI_aarch64_rust-num_cpus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_cpus+default-devel-1.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-num_cpus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_cpus+default-devel}"
SRC_URI[aarch64_rust-num_cpus+default-devel.sha256sum] = "bcb83a02b9c1f2b11b049d42daeb5d394ebf4602f50832f76506e865f84213d4"

URI_aarch64_rust-num_cpus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num_cpus-devel-1.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-num_cpus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num_cpus-devel}"
SRC_URI[aarch64_rust-num_cpus-devel.sha256sum] = "01cb621e0022d2ca6423d5782f614d19c8e44ccbaf084897fc9e63746923f6bb"

RDEPENDS:rust-num_cpus+default-devel = " \
 cargo \
 rust-num_cpus-devel \
 "
RDEPENDS:rust-num_cpus-devel = " \
 cargo \
 rust-libc+default-devel \
 "
