# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openldap-epel"
PV = "2.6.8"
PR = "3.el10_0"
PACKAGES = " \
 openldap-servers \
 openldap-slapi \
 openldap-slapi-compat \
 openldap-slapi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openldap-epel-2.6.8-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a7e9c94f0e032758094bb62312ec8d7c65035e0f6e125692b7b1de2ebfc2f1b"

URI_x86_64_v2_openldap-servers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-servers-2.6.8-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-servers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-servers}"
SRC_URI[x86_64_v2_openldap-servers.sha256sum] = "740babe7180ab2bfa669fa75a692b1adcf56e870177afa8aadf84cfc64528f00"

URI_x86_64_v2_openldap-slapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-2.6.8-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-slapi}"
SRC_URI[x86_64_v2_openldap-slapi.sha256sum] = "5b7db3e8336f96210bac68232f8b9ae04a981bf6c353408bea5eed1fdd626402"

URI_x86_64_v2_openldap-slapi-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-compat-2.6.8-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-slapi-compat}"
SRC_URI[x86_64_v2_openldap-slapi-compat.sha256sum] = "e2e54fe4bbf867cae1b50ce3f514e2084e0152c13627f486b427c3a48faa2af5"

URI_x86_64_v2_openldap-slapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openldap-slapi-devel-2.6.8-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openldap-slapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-slapi-devel}"
SRC_URI[x86_64_v2_openldap-slapi-devel.sha256sum] = "a49eaabf9c95a3bdcf2b2a8ceafb191fdc062281c1413a654d37362e4236149d"

URI_aarch64_openldap-servers = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-servers-2.6.8-3.el10_0.aarch64.rpm;name=aarch64_openldap-servers;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-servers}"
SRC_URI[aarch64_openldap-servers.sha256sum] = "acc66660c58d5a2975886ec2fb425a7c1ed0f6b78329b680ddcc15c353c8443f"

URI_aarch64_openldap-slapi = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-2.6.8-3.el10_0.aarch64.rpm;name=aarch64_openldap-slapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-slapi}"
SRC_URI[aarch64_openldap-slapi.sha256sum] = "a7938ddbd0321e13525c07a42a8402b95e8c7984d82ca6f1370592026c0295f4"

URI_aarch64_openldap-slapi-compat = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-compat-2.6.8-3.el10_0.aarch64.rpm;name=aarch64_openldap-slapi-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-slapi-compat}"
SRC_URI[aarch64_openldap-slapi-compat.sha256sum] = "33126bdee7cef2de03260c4b10aeca747c4086ad68ec4ed978ec176d91994f2e"

URI_aarch64_openldap-slapi-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openldap-slapi-devel-2.6.8-3.el10_0.aarch64.rpm;name=aarch64_openldap-slapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-slapi-devel}"
SRC_URI[aarch64_openldap-slapi-devel.sha256sum] = "1ff4c87dad4ba931f2ae7afb1951214f3d288173f1c258ca239f438cc48e1492"

RDEPENDS:openldap-servers = " \
 bash \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 libevent \
 libgcc \
 libtool-ltdl \
 libxcrypt \
 openldap \
 openldap-slapi \
 openssl-libs \
 perl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:openldap-slapi = " \
 glibc \
 libtool-ltdl \
 "
RDEPENDS:openldap-slapi-compat = " \
 glibc \
 openldap-slapi \
 "
RDEPENDS:openldap-slapi-devel = " \
 openldap-devel \
 openldap-slapi \
 "
