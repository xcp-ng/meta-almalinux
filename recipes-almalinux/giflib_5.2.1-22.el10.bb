# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "giflib"
PV = "5.2.1"
PR = "22.el10"
PACKAGES = " \
 giflib \
 giflib-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/giflib-5.2.1-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c545f3caf5b4f0bb4f6d80c4260d8f8b4f1db1ce115e026e77e8e53a9480c1f5"

URI_x86_64_v2_giflib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/giflib-5.2.1-22.el10.x86_64_v2.rpm;name=x86_64_v2_giflib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_giflib}"
SRC_URI[x86_64_v2_giflib.sha256sum] = "93f0769bf5dd0a8cac0f288000db80325fad17af8646885eff26f5d36dbc9faf"

URI_x86_64_v2_giflib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/giflib-devel-5.2.1-22.el10.x86_64_v2.rpm;name=x86_64_v2_giflib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_giflib-devel}"
SRC_URI[x86_64_v2_giflib-devel.sha256sum] = "ee6a17c7a9a0827409d5ed8c86974139f0d64a64916381ae6e46eb482a082ece"

URI_aarch64_giflib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/giflib-5.2.1-22.el10.aarch64.rpm;name=aarch64_giflib;unpack=0"
SRC_URI:append = " ${URI_aarch64_giflib}"
SRC_URI[aarch64_giflib.sha256sum] = "76dfb9d551345c353236943a580a79af1e41e325a1b9be6453fa4ab17364717f"

URI_aarch64_giflib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/giflib-devel-5.2.1-22.el10.aarch64.rpm;name=aarch64_giflib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_giflib-devel}"
SRC_URI[aarch64_giflib-devel.sha256sum] = "cc481daa18050e7995320c55b24a3f385c714fd8c1b4372f5f3739ea787f10c8"

RDEPENDS:giflib = " \
 glibc \
 "
RDEPENDS:giflib-devel = " \
 giflib \
 "
