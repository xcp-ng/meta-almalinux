# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-svg0.1"
PV = "0.1.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-anstyle-svg0.1+default-devel \
 rust-anstyle-svg0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-svg0.1-0.1.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fd3c75ee6278933c5e89cba8f6016bf1b05db239b71bb43a1d33ae0ca7c09f0"

URI_x86_64_v2_rust-anstyle-svg0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-svg0.1+default-devel-0.1.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-svg0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-svg0.1+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-svg0.1+default-devel.sha256sum] = "7cf81014bec11c7024168c8d92dd1b7591e59c9011069e59c27cf37ef94d0566"

URI_x86_64_v2_rust-anstyle-svg0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-svg0.1-devel-0.1.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-svg0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-svg0.1-devel}"
SRC_URI[x86_64_v2_rust-anstyle-svg0.1-devel.sha256sum] = "1866f484d8a2028fe84cf605d54e9afbf749f2950cc86058f67951fbd6c2c9b4"

URI_aarch64_rust-anstyle-svg0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-svg0.1+default-devel-0.1.12-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-svg0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-svg0.1+default-devel}"
SRC_URI[aarch64_rust-anstyle-svg0.1+default-devel.sha256sum] = "602255f244cf4f1de130c4da065fd1b4992cb6becb250e9d325cb61fc2104de0"

URI_aarch64_rust-anstyle-svg0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-svg0.1-devel-0.1.12-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-svg0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-svg0.1-devel}"
SRC_URI[aarch64_rust-anstyle-svg0.1-devel.sha256sum] = "3b04159d4401884a8f91b93c1da478cc94142df30b47eaaaa0dcf2309eb2b087"

RDEPENDS:rust-anstyle-svg0.1+default-devel = " \
 cargo \
 rust-anstyle-svg0.1-devel \
 "
RDEPENDS:rust-anstyle-svg0.1-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-anstyle-lossy+default-devel \
 rust-anstyle-parse0.2+default-devel \
 rust-html-escape+default-devel \
 rust-unicode-width+default-devel \
 "
