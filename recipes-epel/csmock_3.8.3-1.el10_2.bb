# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "csmock"
PV = "3.8.3"
PR = "1.el10_2"
PACKAGES = " \
 csbuild \
 csmock \
 csmock-common \
 csmock-plugin-bandit \
 csmock-plugin-cbmc \
 csmock-plugin-clang \
 csmock-plugin-clippy \
 csmock-plugin-cppcheck \
 csmock-plugin-divine \
 csmock-plugin-gitleaks \
 csmock-plugin-infer \
 csmock-plugin-pylint \
 csmock-plugin-semgrep \
 csmock-plugin-shellcheck \
 csmock-plugin-shellcheck-core \
 csmock-plugin-smatch \
 csmock-plugin-snyk \
 csmock-plugin-strace \
 csmock-plugin-symbiotic \
 csmock-plugin-unicontrol \
 csmock-plugin-valgrind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/csmock-3.8.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "999ee028d8650c9255250e093ac9f295dcfe4772a5e53d8f9f969dbe09e2891b"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - csbuild: python3-GitPython

URI_x86_64_v2_csbuild = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csbuild-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csbuild}"
SRC_URI[x86_64_v2_csbuild.sha256sum] = "3ebf872116fed95a085ac8828de4c09dfb8cfc5f306785ec6f25c6d57dd98d4f"

URI_x86_64_v2_csmock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock}"
SRC_URI[x86_64_v2_csmock.sha256sum] = "1a8dd087b1711b08a7aa6e0fce65490d5ddba2a2ef35e58c161301cf8bc38a79"

URI_x86_64_v2_csmock-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-common-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-common}"
SRC_URI[x86_64_v2_csmock-common.sha256sum] = "176ab0a0e7565818986b3fd4e8ce692b2e290ae3b8b5874ad8c41fafecb2ec77"

URI_x86_64_v2_csmock-plugin-bandit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-bandit-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-bandit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-bandit}"
SRC_URI[x86_64_v2_csmock-plugin-bandit.sha256sum] = "764d5e8241b27bb8a7c3eb40e87286a4da28f813503692c2fc20fa59b4d23735"

URI_x86_64_v2_csmock-plugin-cbmc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-cbmc-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-cbmc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-cbmc}"
SRC_URI[x86_64_v2_csmock-plugin-cbmc.sha256sum] = "5d0491e801502e350d22dc9d718f2bf6b85a495b2b6907005abb5d6109c3302c"

URI_x86_64_v2_csmock-plugin-clang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-clang-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-clang}"
SRC_URI[x86_64_v2_csmock-plugin-clang.sha256sum] = "f20e3ef13f3d9ea9ccbbd9bdbd2b2f1c4fc6e4d2dc7a96efe9a6af7ffaa0e442"

URI_x86_64_v2_csmock-plugin-clippy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-clippy-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-clippy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-clippy}"
SRC_URI[x86_64_v2_csmock-plugin-clippy.sha256sum] = "cfc0ed13cbb281c94088aa0c681b9592b8f3f95e117afb24a53ab25e61e88e69"

URI_x86_64_v2_csmock-plugin-cppcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-cppcheck-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-cppcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-cppcheck}"
SRC_URI[x86_64_v2_csmock-plugin-cppcheck.sha256sum] = "54ed7e4204a3d0081bf8d8e76e27b526b8dfd570135f399e13ee01b13bb60b5b"

URI_x86_64_v2_csmock-plugin-divine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-divine-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-divine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-divine}"
SRC_URI[x86_64_v2_csmock-plugin-divine.sha256sum] = "30d11959a9075c173242576cee86fdae9c6f9c2837bff9d75aefeea1d998a9d7"

URI_x86_64_v2_csmock-plugin-gitleaks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-gitleaks-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-gitleaks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-gitleaks}"
SRC_URI[x86_64_v2_csmock-plugin-gitleaks.sha256sum] = "394cc969169fde9c5983f94ae12e11e57e2d87e6ff04e28eeef42d7163baf9a7"

URI_x86_64_v2_csmock-plugin-infer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-infer-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-infer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-infer}"
SRC_URI[x86_64_v2_csmock-plugin-infer.sha256sum] = "9015bd41a6b5c80fdc552920c5170d2c5ca46104148e4b38e2c56b63856f8409"

URI_x86_64_v2_csmock-plugin-pylint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-pylint-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-pylint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-pylint}"
SRC_URI[x86_64_v2_csmock-plugin-pylint.sha256sum] = "4ceca09590cf48c3c25decea9eaa9beca2a738465ee584c50d0cfd7c2fb2f302"

URI_x86_64_v2_csmock-plugin-semgrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-semgrep-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-semgrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-semgrep}"
SRC_URI[x86_64_v2_csmock-plugin-semgrep.sha256sum] = "c67d6ed61797344b04153ea90c1e7e8f753cb7b79a7be34292c08e95757d79e4"

URI_x86_64_v2_csmock-plugin-shellcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-shellcheck-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-shellcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-shellcheck}"
SRC_URI[x86_64_v2_csmock-plugin-shellcheck.sha256sum] = "b1a1ffed6d2b2333531c9425c7aac6bd125e5d3e4817f38108d28b6f7eb80a99"

URI_x86_64_v2_csmock-plugin-shellcheck-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-shellcheck-core-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-shellcheck-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-shellcheck-core}"
SRC_URI[x86_64_v2_csmock-plugin-shellcheck-core.sha256sum] = "f0660216cfcb468f3719ce0a08ab0a0da4030986f8dc45b52543bbed1e2ec1ba"

URI_x86_64_v2_csmock-plugin-smatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-smatch-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-smatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-smatch}"
SRC_URI[x86_64_v2_csmock-plugin-smatch.sha256sum] = "98a0b7ebfaa86b81030e6d738dc7ab24810e858591d70a88159b976ec7575d1b"

URI_x86_64_v2_csmock-plugin-snyk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-snyk-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-snyk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-snyk}"
SRC_URI[x86_64_v2_csmock-plugin-snyk.sha256sum] = "38e3f41f01f6c25f1f6dc57322f150e389361d27ab9de5f1671e77c1766b6ca1"

URI_x86_64_v2_csmock-plugin-strace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-strace-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-strace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-strace}"
SRC_URI[x86_64_v2_csmock-plugin-strace.sha256sum] = "b17a55ff68f0cb7fb2f9fb8118454eed0a57cb878bd0714cb189615870383e46"

URI_x86_64_v2_csmock-plugin-symbiotic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-symbiotic-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-symbiotic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-symbiotic}"
SRC_URI[x86_64_v2_csmock-plugin-symbiotic.sha256sum] = "d900e61d18477d5dde4a8862c6648acae9adcdcc676559e0b25c212f2b64d7a4"

URI_x86_64_v2_csmock-plugin-unicontrol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-unicontrol-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-unicontrol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-unicontrol}"
SRC_URI[x86_64_v2_csmock-plugin-unicontrol.sha256sum] = "70089c407090c664e566acfba7fde3dace546b423e47ce711aff5a76f7449d6b"

URI_x86_64_v2_csmock-plugin-valgrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmock-plugin-valgrind-3.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_csmock-plugin-valgrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmock-plugin-valgrind}"
SRC_URI[x86_64_v2_csmock-plugin-valgrind.sha256sum] = "e44f7082b2962256125de6d69d0669a1bf31f096e81de3e47b5ce5ed16c27f82"

URI_aarch64_csbuild = "${EPEL_MIRROR}/aarch64/Packages/c/csbuild-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_csbuild}"
SRC_URI[aarch64_csbuild.sha256sum] = "85d6f65419a09e3932171b32e517ed20600831d481e259796fade2423658a0d3"

URI_aarch64_csmock = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock}"
SRC_URI[aarch64_csmock.sha256sum] = "e426630189d5ca9bdd95588f20190a4e0971df64511ba678e9efcf5d2701966d"

URI_aarch64_csmock-common = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-common-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-common}"
SRC_URI[aarch64_csmock-common.sha256sum] = "259c7eb3c27e6ae4c624d379a51053ac8303868a75ed7a65d79ff8ba1fafe0b0"

URI_aarch64_csmock-plugin-bandit = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-bandit-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-bandit;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-bandit}"
SRC_URI[aarch64_csmock-plugin-bandit.sha256sum] = "d00acba63a22eb9acd2a03a96503ba262eecac70f80d000e8913b1d332e7ab74"

URI_aarch64_csmock-plugin-cbmc = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-cbmc-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-cbmc;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-cbmc}"
SRC_URI[aarch64_csmock-plugin-cbmc.sha256sum] = "e1f5305a43fc69b003e5de71a55f3a4df1c99d3abdcddf07da175ea810258d6c"

URI_aarch64_csmock-plugin-clang = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-clang-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-clang}"
SRC_URI[aarch64_csmock-plugin-clang.sha256sum] = "a462aeb52dedcaacc4ad7c768fad39bfe91ec95c2cf1c5667c0bb5c652453754"

URI_aarch64_csmock-plugin-clippy = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-clippy-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-clippy;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-clippy}"
SRC_URI[aarch64_csmock-plugin-clippy.sha256sum] = "73112fc4d3d8fff2e88b68a74d0d1bce63aa2c4ee7fecabe06222466efce3f82"

URI_aarch64_csmock-plugin-cppcheck = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-cppcheck-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-cppcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-cppcheck}"
SRC_URI[aarch64_csmock-plugin-cppcheck.sha256sum] = "5b51bcbd157f306ebc566f78beacf1e8eab053be044294025a846bedd88701fb"

URI_aarch64_csmock-plugin-divine = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-divine-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-divine;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-divine}"
SRC_URI[aarch64_csmock-plugin-divine.sha256sum] = "b49259bda806a7967dbf3c3b1b5ea008bea5cc649f0b223cf6cfbdfce0fac9ab"

URI_aarch64_csmock-plugin-gitleaks = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-gitleaks-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-gitleaks;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-gitleaks}"
SRC_URI[aarch64_csmock-plugin-gitleaks.sha256sum] = "e27ce3df804c1943b542bffbb95f2d1c366d7b8f5197347e83567b3802f04e24"

URI_aarch64_csmock-plugin-infer = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-infer-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-infer;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-infer}"
SRC_URI[aarch64_csmock-plugin-infer.sha256sum] = "dc44bb7900af4af40d162ee918080afdf0ede35528c6d63b3485c380f579840e"

URI_aarch64_csmock-plugin-pylint = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-pylint-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-pylint;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-pylint}"
SRC_URI[aarch64_csmock-plugin-pylint.sha256sum] = "3f16a5a3ac2017a14c873b8fc6be7739e0b8cc18eaaa73edc582bc55b50b1fc6"

URI_aarch64_csmock-plugin-semgrep = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-semgrep-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-semgrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-semgrep}"
SRC_URI[aarch64_csmock-plugin-semgrep.sha256sum] = "0fe969518f439e6a1cd60f17a5acff99f58e02d9046baaab7a55e36931a850bd"

URI_aarch64_csmock-plugin-shellcheck = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-shellcheck-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-shellcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-shellcheck}"
SRC_URI[aarch64_csmock-plugin-shellcheck.sha256sum] = "15f66533bd05db69a00921add2530cb76822c0399edd5c98bc93f630398cdd8c"

URI_aarch64_csmock-plugin-shellcheck-core = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-shellcheck-core-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-shellcheck-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-shellcheck-core}"
SRC_URI[aarch64_csmock-plugin-shellcheck-core.sha256sum] = "c057d3c61a2ae15a05b389977971588ef599d23409dab062cd4b6b0e14995427"

URI_aarch64_csmock-plugin-smatch = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-smatch-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-smatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-smatch}"
SRC_URI[aarch64_csmock-plugin-smatch.sha256sum] = "d1fb13b740d1af17de60f3d7c8bac74894dcaefb78952e4125b0fc65295a7a1b"

URI_aarch64_csmock-plugin-snyk = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-snyk-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-snyk;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-snyk}"
SRC_URI[aarch64_csmock-plugin-snyk.sha256sum] = "d99388bc0d1ddc43c684e1756df5ff3c249984ec4c891c0403b3bce0657f79f8"

URI_aarch64_csmock-plugin-strace = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-strace-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-strace;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-strace}"
SRC_URI[aarch64_csmock-plugin-strace.sha256sum] = "b6de17bd0282ca392e73f2d430b8f02c40684c7e8a343dd161a78c01099ae02a"

URI_aarch64_csmock-plugin-symbiotic = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-symbiotic-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-symbiotic;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-symbiotic}"
SRC_URI[aarch64_csmock-plugin-symbiotic.sha256sum] = "b82c817b997bd992668b2123959aba3afb6d800480a4dcc87bd63f5706f20199"

URI_aarch64_csmock-plugin-unicontrol = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-unicontrol-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-unicontrol;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-unicontrol}"
SRC_URI[aarch64_csmock-plugin-unicontrol.sha256sum] = "0f08b50e3d54e549b4410d205b3c07b13af0731b3fcca7e4fcb389c22fa093de"

URI_aarch64_csmock-plugin-valgrind = "${EPEL_MIRROR}/aarch64/Packages/c/csmock-plugin-valgrind-3.8.3-1.el10_2.noarch.rpm;name=aarch64_csmock-plugin-valgrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmock-plugin-valgrind}"
SRC_URI[aarch64_csmock-plugin-valgrind.sha256sum] = "9910245658a10a4719f4d7cd967d0f8b0bbaf71b53e50bebaeabc88423a3caaf"

RDEPENDS:csbuild:x86_64_v2 = " \
 bash \
 csclng \
 cscppc \
 csdiff \
 csmock-common \
 cswrap \
 python3 \
"
RDEPENDS:csbuild:aarch64 = " \
 bash \
 csclng \
 cscppc \
 csdiff \
 csmock-common \
 cswrap \
 python3 \
 python3-GitPython \
"
RDEPENDS:csmock = " \
 csmock-common \
 csmock-plugin-clang \
 csmock-plugin-cppcheck \
 csmock-plugin-gitleaks \
 csmock-plugin-shellcheck \
 "
RDEPENDS:csmock-common = " \
 bash \
 csdiff \
 csgcca \
 cswrap \
 mock \
 python3 \
 tar \
 xz \
 "
RDEPENDS:csmock-plugin-bandit = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-cbmc = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-clang = " \
 csclng \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-clippy = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-cppcheck = " \
 cscppc \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-divine = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-gitleaks = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-infer = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-pylint = " \
 bash \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-semgrep = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-shellcheck = " \
 csmock-common \
 csmock-plugin-shellcheck-core \
 python3 \
 "
RDEPENDS:csmock-plugin-shellcheck-core = " \
 bash \
 "
RDEPENDS:csmock-plugin-smatch = " \
 csmatch \
 csmock-common \
 cswrap \
 python3 \
 "
RDEPENDS:csmock-plugin-snyk = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-strace = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-symbiotic = " \
 csexec \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-unicontrol = " \
 csmock-common \
 python3 \
 "
RDEPENDS:csmock-plugin-valgrind = " \
 csexec \
 csmock-common \
 python3 \
 "
