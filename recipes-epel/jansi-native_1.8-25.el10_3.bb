# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jansi-native"
PV = "1.8"
PR = "25.el10_3"
PACKAGES = " \
 jansi-native \
 jansi-native-javadoc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/jansi-native-1.8-25.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "88829d56717edfcfa64f048a4a1511a6b7022299eb85a52db8cd9841bc7d700b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jansi-native-1.8-25.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jansi-native;unpack=0"
SRC_URI[x86_64_v2_jansi-native.sha256sum] = "15d39d0d0fdb3b1e33410f6d0ecd4f724b4b80ac26ef1fb1239739fb701af983"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jansi-native-javadoc-1.8-25.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_jansi-native-javadoc;unpack=0"
SRC_URI[x86_64_v2_jansi-native-javadoc.sha256sum] = "28538780b5120a654b39f508f2b9d7dd6a468708f5951c4819e67741a1b1c7eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jansi-native-1.8-25.el10_3.aarch64.rpm;name=aarch64_jansi-native;unpack=0"
SRC_URI[aarch64_jansi-native.sha256sum] = "fe73d8aff6ca3e5fcb70f9682eefa5c2481c974eeeebf0437a076e7b411ddbdb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jansi-native-javadoc-1.8-25.el10_3.noarch.rpm;name=aarch64_jansi-native-javadoc;unpack=0"
SRC_URI[aarch64_jansi-native-javadoc.sha256sum] = "4d24e088697a39aa72a61d5550173e935bbb9e60033a0e98f8e8d6117d25aa47"

RDEPENDS:jansi-native = " \
 hawtjni-runtime \
 javapackages-filesystem \
 "
RDEPENDS:jansi-native-javadoc = " \
 javapackages-filesystem \
 "
