# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtquickcontrols2"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtquickcontrols2 \
 qt5-qtquickcontrols2-devel \
 qt5-qtquickcontrols2-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtquickcontrols2-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cab265f56103ec13603f0216fa2c24d72d6caf2a5de339586d9539cb84dd891"

URI_x86_64_v2_qt5-qtquickcontrols2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2.sha256sum] = "6a60b2d92129eb2d8859bbca5958f5f3a9cdb53eb8f6e6dd3d4f9693b14267ce"

URI_x86_64_v2_qt5-qtquickcontrols2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2-devel}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2-devel.sha256sum] = "4e9c8df8078063e0d6f28825a0fd9e2aee945142b8e110d2cea2d49800838216"

URI_x86_64_v2_qt5-qtquickcontrols2-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols2-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2-examples}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2-examples.sha256sum] = "70a7ec29c99b51bc16bc67564b1e56c088562c1fe3a66f07861100460f03c814"

URI_aarch64_qt5-qtquickcontrols2 = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtquickcontrols2;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2}"
SRC_URI[aarch64_qt5-qtquickcontrols2.sha256sum] = "f0489560ed7d441c87d706fa031ba20073af9ffe8d6f63125c9c01f916d4cbac"

URI_aarch64_qt5-qtquickcontrols2-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtquickcontrols2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2-devel}"
SRC_URI[aarch64_qt5-qtquickcontrols2-devel.sha256sum] = "1ba7d6f000c923555c3303c31de29154d8d927a62152c0e2b967ec9351448935"

URI_aarch64_qt5-qtquickcontrols2-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtquickcontrols2-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2-examples}"
SRC_URI[aarch64_qt5-qtquickcontrols2-examples.sha256sum] = "ea6f362636221aed9583defb793b652b40d00a8baf1f1da1b21de3a6ff9206eb"

RDEPENDS:qt5-qtquickcontrols2 = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtgraphicaleffects \
 "
RDEPENDS:qt5-qtquickcontrols2-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtquickcontrols2 \
 "
RDEPENDS:qt5-qtquickcontrols2-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtquickcontrols2 \
 "
