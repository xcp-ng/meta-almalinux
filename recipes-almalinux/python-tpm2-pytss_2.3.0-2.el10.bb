# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tpm2-pytss"
PV = "2.3.0"
PR = "2.el10"
PACKAGES = " \
 python3-tpm2-pytss \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-tpm2-pytss-2.3.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "079927ed46a85d4736fdec11fab9516d82e8d188cfb6265eb04ff46357ec89b2"

URI_x86_64_v2_python3-tpm2-pytss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tpm2-pytss-2.3.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tpm2-pytss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tpm2-pytss}"
SRC_URI[x86_64_v2_python3-tpm2-pytss.sha256sum] = "8ce17eaa7d4e9fa3631d6b7e136bfa18646a6171632574011550f9659ac3668e"

URI_aarch64_python3-tpm2-pytss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tpm2-pytss-2.3.0-2.el10.aarch64.rpm;name=aarch64_python3-tpm2-pytss;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tpm2-pytss}"
SRC_URI[aarch64_python3-tpm2-pytss.sha256sum] = "c530f64fd3c70515e7e70484623185a1ffb31fc2612f2ed427e70af0d6ea9dcb"

RDEPENDS:python3-tpm2-pytss = " \
 glibc \
 python3 \
 python3-asn1crypto \
 python3-cffi \
 python3-cryptography \
 python3-packaging \
 python3-pyyaml \
 tpm2-tss \
 tpm2-tss-fapi \
 "
