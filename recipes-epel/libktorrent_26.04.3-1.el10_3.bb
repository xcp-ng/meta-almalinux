# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libktorrent"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libktorrent \
 libktorrent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libktorrent-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a87fdf8b658eadc4aecd5642b0776f6561bc4a277732b3fd96acd6eb5b6f095"

URI_x86_64_v2_libktorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libktorrent-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libktorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libktorrent}"
SRC_URI[x86_64_v2_libktorrent.sha256sum] = "b5167748706b47661abfdb3a6532bc85da847ad143a4cb04e4aeeae9c8324651"

URI_x86_64_v2_libktorrent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libktorrent-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libktorrent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libktorrent-devel}"
SRC_URI[x86_64_v2_libktorrent-devel.sha256sum] = "6cff544455c5d480de368e7adaa6fbf6c1550b01a397f250b5f736c0543a8fca"

URI_aarch64_libktorrent = "${EPEL_MIRROR}/aarch64/Packages/l/libktorrent-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libktorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_libktorrent}"
SRC_URI[aarch64_libktorrent.sha256sum] = "53ae35c205774a6d14ab55e7781ed414816d41d478c8aa5652749fb36c25b371"

URI_aarch64_libktorrent-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libktorrent-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libktorrent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libktorrent-devel}"
SRC_URI[aarch64_libktorrent-devel.sha256sum] = "291a7bbe905dfe6c4d5c3d8c8d69e4b8a69ff354e01bc902d2f725ac9c35142c"

RDEPENDS:libktorrent = " \
 glibc \
 gmp \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libgcc \
 libgcrypt \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libktorrent-devel = " \
 boost-devel \
 cmake-filesystem \
 gmp-devel \
 kf6-karchive-devel \
 kf6-kconfig-devel \
 kf6-kio-devel \
 libgcrypt-devel \
 libktorrent \
 qt6-qtbase-devel \
 "
