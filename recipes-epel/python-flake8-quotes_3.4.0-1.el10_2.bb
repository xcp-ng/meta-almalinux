# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8-quotes"
PV = "3.4.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-flake8-quotes \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-flake8-quotes-3.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2f9466fd00474e4e6629e535e84d967856cdcbbebf39c66c276b7c5b86143abc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-quotes-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8-quotes;unpack=0"
SRC_URI[x86_64_v2_python3-flake8-quotes.sha256sum] = "70e06b59318bdbb9005b91b890c3a27bd394ff524252c4600dcd7cc85d5a9dac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-quotes-3.4.0-1.el10_2.noarch.rpm;name=aarch64_python3-flake8-quotes;unpack=0"
SRC_URI[aarch64_python3-flake8-quotes.sha256sum] = "6b001eac20fbb7bd115915e3b447f2bbc6d8ce2d86d8c7456c797eb993142eeb"

RDEPENDS:python3-flake8-quotes = " \
 python3 \
 python3-flake8 \
 python3-setuptools \
 "
