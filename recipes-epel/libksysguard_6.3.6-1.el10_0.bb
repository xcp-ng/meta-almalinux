# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksysguard"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 libksysguard \
 libksysguard-common \
 libksysguard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksysguard-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a70cca332dc0b1966659b858bfd28fa2102abd6e4d4af1f10a1e48a91239730"

URI_x86_64_v2_libksysguard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard}"
SRC_URI[x86_64_v2_libksysguard.sha256sum] = "23f9e163692107ec2d52c2c5a13b61c1d07f669cb38b4ae4339115cbcbe5916e"

URI_x86_64_v2_libksysguard-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-common-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard-common}"
SRC_URI[x86_64_v2_libksysguard-common.sha256sum] = "7af170613be0e40e74b931679f76a5c23da9130f0c3f82bdf54262854ba852a3"

URI_x86_64_v2_libksysguard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard-devel}"
SRC_URI[x86_64_v2_libksysguard-devel.sha256sum] = "878659a47e44c1747b7f5f0194377dadae8f4132b6a2b479c641737a9afa707a"

URI_aarch64_libksysguard = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_libksysguard;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard}"
SRC_URI[aarch64_libksysguard.sha256sum] = "6f1707ee7cc40ae0ce39a9690dde843edd33bbeda0407e2ba5edab52f2a84422"

URI_aarch64_libksysguard-common = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-common-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_libksysguard-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard-common}"
SRC_URI[aarch64_libksysguard-common.sha256sum] = "6167f2c10cd05da7ad1eb0b6f17247a4dcccfd15773586c6b01b243b79db6f42"

URI_aarch64_libksysguard-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_libksysguard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard-devel}"
SRC_URI[aarch64_libksysguard-devel.sha256sum] = "54c516413ddf419f99c63985fd82630b1dba24e974c687348d1ee09cacb70860"

RDEPENDS:libksysguard = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kservice \
 kf6-solid \
 libgcc \
 libksysguard-common \
 libnl3 \
 libpcap \
 libstdc++ \
 lm_sensors-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:libksysguard-common = " \
 glibc \
 kf6-kauth \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libksysguard-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-ki18n-devel \
 kf6-kiconthemes-devel \
 libksysguard \
 qt6-qtbase-devel \
 "
