# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-validator"
PV = "0.20.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-validator+default-devel \
 rust-validator+derive-devel \
 rust-validator+indexmap-devel \
 rust-validator+unic-devel \
 rust-validator+unic-ucd-common-devel \
 rust-validator+validator_derive-devel \
 rust-validator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-validator-0.20.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afe48c9b83cec263081e909f3554d803bdb8c3260db173d58b374642ffb5f119"

URI_x86_64_v2_rust-validator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator+default-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator+default-devel}"
SRC_URI[x86_64_v2_rust-validator+default-devel.sha256sum] = "e6532adeea0af343bbab8c5e8cc21b6e03926c8fa9bde07d1c1fc3902ac253ba"

URI_x86_64_v2_rust-validator+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator+derive-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator+derive-devel}"
SRC_URI[x86_64_v2_rust-validator+derive-devel.sha256sum] = "0c79de3d5d6b86315f6ed33b24835e7b3feffeea5b68af19ebebe5056b7a2e5a"

URI_x86_64_v2_rust-validator+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator+indexmap-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator+indexmap-devel}"
SRC_URI[x86_64_v2_rust-validator+indexmap-devel.sha256sum] = "080632db3601d4ab8d16c16a3ef9fef09275ea956cb0397b8b46f83a01b25053"

URI_x86_64_v2_rust-validator+unic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator+unic-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator+unic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator+unic-devel}"
SRC_URI[x86_64_v2_rust-validator+unic-devel.sha256sum] = "1996a805c9012a2c3f12cb80c42bc1c474a5efbdc7f00af882683a2521b9a41d"

URI_x86_64_v2_rust-validator+unic-ucd-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator+unic-ucd-common-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator+unic-ucd-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator+unic-ucd-common-devel}"
SRC_URI[x86_64_v2_rust-validator+unic-ucd-common-devel.sha256sum] = "9fbd9308595596f49d576099b64f3932e6db6f0b04d9b14a5cdd4ce99aa16b00"

URI_x86_64_v2_rust-validator+validator_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator+validator_derive-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator+validator_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator+validator_derive-devel}"
SRC_URI[x86_64_v2_rust-validator+validator_derive-devel.sha256sum] = "8dae2a7c0cf346acbaa130286016c629040ea8808955294f0d066204f21a709f"

URI_x86_64_v2_rust-validator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator-devel-0.20.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator-devel}"
SRC_URI[x86_64_v2_rust-validator-devel.sha256sum] = "fbedeba77c7fcd9c3dc90c5c1db93e94a2a137186bd563a27c927edf431ba184"

URI_aarch64_rust-validator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator+default-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-validator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator+default-devel}"
SRC_URI[aarch64_rust-validator+default-devel.sha256sum] = "4743c0ff9d5af90dcc0fb0917121209ea27aa9423953e259c72db916701dec8d"

URI_aarch64_rust-validator+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator+derive-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-validator+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator+derive-devel}"
SRC_URI[aarch64_rust-validator+derive-devel.sha256sum] = "cc8064c29d18ea26213e564f323c63600ee09d2dc6bf69f175e6db2ac1afe14c"

URI_aarch64_rust-validator+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator+indexmap-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-validator+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator+indexmap-devel}"
SRC_URI[aarch64_rust-validator+indexmap-devel.sha256sum] = "76ec69bf35fd02fe5f899819f7901166013e89abac5b4501ea8997d0c9747578"

URI_aarch64_rust-validator+unic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator+unic-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-validator+unic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator+unic-devel}"
SRC_URI[aarch64_rust-validator+unic-devel.sha256sum] = "e05c6431a8b3810c0d246f4552d69a33a0b78e59cc948b1fb8415cd64f5267bc"

URI_aarch64_rust-validator+unic-ucd-common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator+unic-ucd-common-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-validator+unic-ucd-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator+unic-ucd-common-devel}"
SRC_URI[aarch64_rust-validator+unic-ucd-common-devel.sha256sum] = "cc471af12eb29e1475997b18db03823baaf25b4a9001fc7baffddbc5e06c805c"

URI_aarch64_rust-validator+validator_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator+validator_derive-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-validator+validator_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator+validator_derive-devel}"
SRC_URI[aarch64_rust-validator+validator_derive-devel.sha256sum] = "44a723974233d99428946027ec2550d154194808e84f8999038c81ebcfeb5966"

URI_aarch64_rust-validator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator-devel-0.20.0-1.el10_2.noarch.rpm;name=aarch64_rust-validator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator-devel}"
SRC_URI[aarch64_rust-validator-devel.sha256sum] = "5affae2c6c1d50145f6c53d409cb2a032626a9ea9c6edbe8991bb5df265f83b2"

RDEPENDS:rust-validator+default-devel = " \
 cargo \
 rust-validator-devel \
 "
RDEPENDS:rust-validator+derive-devel = " \
 cargo \
 rust-validator+validator_derive-devel \
 rust-validator-devel \
 "
RDEPENDS:rust-validator+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 rust-validator-devel \
 "
RDEPENDS:rust-validator+unic-devel = " \
 cargo \
 rust-validator+unic-ucd-common-devel \
 rust-validator-devel \
 "
RDEPENDS:rust-validator+unic-ucd-common-devel = " \
 cargo \
 rust-unic-ucd-common+default-devel \
 rust-validator-devel \
 "
RDEPENDS:rust-validator+validator_derive-devel = " \
 cargo \
 rust-validator-devel \
 rust-validator_derive+default-devel \
 "
RDEPENDS:rust-validator-devel = " \
 cargo \
 rust \
 rust-idna+default-devel \
 rust-once_cell+default-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-url+default-devel \
 "
