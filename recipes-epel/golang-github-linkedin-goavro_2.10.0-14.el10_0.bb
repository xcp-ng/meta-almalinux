# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-linkedin-goavro"
PV = "2.10.0"
PR = "14.el10_0"
PACKAGES = " \
 compat-golang-github-linkedin-goavro-2-devel \
 golang-github-linkedin-goavro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-linkedin-goavro-2.10.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e5789a1d36229fdd4fa09e663b2cef0d223fad013d665306fd7e18845d231c1"

URI_x86_64_v2_compat-golang-github-linkedin-goavro-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-linkedin-goavro-2-devel-2.10.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-linkedin-goavro-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-linkedin-goavro-2-devel}"
SRC_URI[x86_64_v2_compat-golang-github-linkedin-goavro-2-devel.sha256sum] = "ee8cb2a0f7e40efaae0eaa39bd495882044281b266b9fa4f7cd467beeb9c73ae"

URI_x86_64_v2_golang-github-linkedin-goavro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-linkedin-goavro-devel-2.10.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-linkedin-goavro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-linkedin-goavro-devel}"
SRC_URI[x86_64_v2_golang-github-linkedin-goavro-devel.sha256sum] = "084f251caa806d8fe09e92c76907c76d912f4a1d03231ccefa74cefb892a499a"

URI_aarch64_compat-golang-github-linkedin-goavro-2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-linkedin-goavro-2-devel-2.10.0-14.el10_0.noarch.rpm;name=aarch64_compat-golang-github-linkedin-goavro-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-linkedin-goavro-2-devel}"
SRC_URI[aarch64_compat-golang-github-linkedin-goavro-2-devel.sha256sum] = "9c49d2f0a3ee984f48e1a89326d5f61112acaa6f0eaed9bbe2947efcc26216d0"

URI_aarch64_golang-github-linkedin-goavro-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-linkedin-goavro-devel-2.10.0-14.el10_0.noarch.rpm;name=aarch64_golang-github-linkedin-goavro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-linkedin-goavro-devel}"
SRC_URI[aarch64_golang-github-linkedin-goavro-devel.sha256sum] = "3ac7896f13fe14cb1e58f580a6090c203cf6a0e7c4ae52ee084f08261c5d0c02"

RDEPENDS:compat-golang-github-linkedin-goavro-2-devel = " \
 go-filesystem \
 golang-github-linkedin-goavro-devel \
 "
RDEPENDS:golang-github-linkedin-goavro-devel = " \
 go-filesystem \
 golang-github-snappy-devel \
 "
