# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-wai"
PV = "3.2.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-wai \
 ghc-wai-devel \
 ghc-wai-doc \
 ghc-wai-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-wai-3.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "644c17a4651460f6e53111c37aa7e3f0f67f7abb8b585b4ff79bb72ebb7e22c7"

URI_x86_64_v2_ghc-wai = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-3.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai}"
SRC_URI[x86_64_v2_ghc-wai.sha256sum] = "912cd5dd0f6db07df5ff17ebff2befb1eb05a3ca78bd7441166743d003898cb1"

URI_x86_64_v2_ghc-wai-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-devel-3.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-devel}"
SRC_URI[x86_64_v2_ghc-wai-devel.sha256sum] = "145fb1dbea04632e816e5437eafb815e46442e0d5392f27beaf79d6a4ac08593"

URI_x86_64_v2_ghc-wai-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-doc-3.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-wai-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-doc}"
SRC_URI[x86_64_v2_ghc-wai-doc.sha256sum] = "91b9607cf4340a6840d8318b88b26a47456f107b25c2c1ac468ad2fc1c2e74da"

URI_x86_64_v2_ghc-wai-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wai-prof-3.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wai-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wai-prof}"
SRC_URI[x86_64_v2_ghc-wai-prof.sha256sum] = "aeaf8d6fdf1a3b58931797be6a7c35c024dd3c8490779e59c3e0dd0b675350d6"

URI_aarch64_ghc-wai = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-3.2.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-wai;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai}"
SRC_URI[aarch64_ghc-wai.sha256sum] = "a09be5c6080ebb506c09aadfde0c8076694d2f0f8727818033b0bb9b7a86da5f"

URI_aarch64_ghc-wai-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-devel-3.2.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-wai-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-devel}"
SRC_URI[aarch64_ghc-wai-devel.sha256sum] = "ce2549ab256965ee59e0389ed3338206c894e68eefe2c7a2e056c27c37f8f207"

URI_aarch64_ghc-wai-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-doc-3.2.4-1.el10_0.noarch.rpm;name=aarch64_ghc-wai-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-doc}"
SRC_URI[aarch64_ghc-wai-doc.sha256sum] = "7c018b964df40003cb5e27d8224a26d5b5d9c02f94a13b2ab9dba06c896a605e"

URI_aarch64_ghc-wai-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wai-prof-3.2.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-wai-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wai-prof}"
SRC_URI[aarch64_ghc-wai-prof.sha256sum] = "22990de823d3144ab26eb70c6571ea135923b9af7d9a095b0d8506c7df644a84"

RDEPENDS:ghc-wai = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-types \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-unordered-containers \
 ghc-vault \
 glibc \
 gmp \
 "
RDEPENDS:ghc-wai-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-http-types-devel \
 ghc-network-devel \
 ghc-text-devel \
 ghc-vault-devel \
 ghc-wai \
 "
RDEPENDS:ghc-wai-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-wai-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-http-types-prof \
 ghc-network-prof \
 ghc-text-prof \
 ghc-vault-prof \
 ghc-wai-devel \
 "
