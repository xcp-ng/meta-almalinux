# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitflags1"
PV = "1.3.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-bitflags1+default-devel \
 rust-bitflags1+example_generated-devel \
 rust-bitflags1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitflags1-1.3.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ac7f2c2298bea6aa99e5d762413dc6e290fe979760598217817f20d34214baa"

URI_x86_64_v2_rust-bitflags1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags1+default-devel-1.3.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags1+default-devel}"
SRC_URI[x86_64_v2_rust-bitflags1+default-devel.sha256sum] = "978f68246e84b77411ab8d2fa938b2915675b2f22bcea95df7a473bd8ebc1d25"

URI_x86_64_v2_rust-bitflags1+example_generated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags1+example_generated-devel-1.3.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags1+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags1+example_generated-devel}"
SRC_URI[x86_64_v2_rust-bitflags1+example_generated-devel.sha256sum] = "7071baf301096fb4c3223621495d38309dcc9069932a368ffb05d4542d15b0be"

URI_x86_64_v2_rust-bitflags1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitflags1-devel-1.3.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitflags1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitflags1-devel}"
SRC_URI[x86_64_v2_rust-bitflags1-devel.sha256sum] = "07ec013bea44bd03e602673afb51facb5bfafa71cc5aba6f87453744cd304435"

URI_aarch64_rust-bitflags1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags1+default-devel-1.3.2-4.el10_0.noarch.rpm;name=aarch64_rust-bitflags1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags1+default-devel}"
SRC_URI[aarch64_rust-bitflags1+default-devel.sha256sum] = "2745d9c5b7d1217459d0fed9efd3233c4294cf9c9d417c1253207d2f30bd913d"

URI_aarch64_rust-bitflags1+example_generated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags1+example_generated-devel-1.3.2-4.el10_0.noarch.rpm;name=aarch64_rust-bitflags1+example_generated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags1+example_generated-devel}"
SRC_URI[aarch64_rust-bitflags1+example_generated-devel.sha256sum] = "a2e75002b9385514a239d40c6e36ca09c9ae44a10aeed40d57ecc5231e9f476a"

URI_aarch64_rust-bitflags1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitflags1-devel-1.3.2-4.el10_0.noarch.rpm;name=aarch64_rust-bitflags1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitflags1-devel}"
SRC_URI[aarch64_rust-bitflags1-devel.sha256sum] = "06d81c3ee1aec68200596b0178bdaa9b49c66571ee1e7393fbe5bc8810829526"

RDEPENDS:rust-bitflags1+default-devel = " \
 cargo \
 rust-bitflags1-devel \
 "
RDEPENDS:rust-bitflags1+example_generated-devel = " \
 cargo \
 rust-bitflags1-devel \
 "
RDEPENDS:rust-bitflags1-devel = " \
 cargo \
 "
