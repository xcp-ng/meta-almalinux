# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-21-openjdk"
PE = "1"
PV = "21.0.11.0.10"
PR = "2.el10.alma.1"
PACKAGES = " \
 java-21-openjdk \
 java-21-openjdk-demo \
 java-21-openjdk-demo-fastdebug \
 java-21-openjdk-demo-slowdebug \
 java-21-openjdk-devel \
 java-21-openjdk-devel-fastdebug \
 java-21-openjdk-devel-slowdebug \
 java-21-openjdk-fastdebug \
 java-21-openjdk-headless \
 java-21-openjdk-headless-fastdebug \
 java-21-openjdk-headless-slowdebug \
 java-21-openjdk-javadoc \
 java-21-openjdk-javadoc-zip \
 java-21-openjdk-jmods \
 java-21-openjdk-jmods-fastdebug \
 java-21-openjdk-jmods-slowdebug \
 java-21-openjdk-slowdebug \
 java-21-openjdk-src \
 java-21-openjdk-src-fastdebug \
 java-21-openjdk-src-slowdebug \
 java-21-openjdk-static-libs \
 java-21-openjdk-static-libs-fastdebug \
 java-21-openjdk-static-libs-slowdebug \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/java-21-openjdk-21.0.11.0.10-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60c714edb38b852d41845bda3df1d2c734eb16c771c78218b535c365cc549f60"

URI_x86_64_v2_java-21-openjdk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk}"
SRC_URI[x86_64_v2_java-21-openjdk.sha256sum] = "f76a6ccfc7c11b02bcbe3f1a52fb08fa34ec15598bbfd6edf4e365d1631df381"

URI_x86_64_v2_java-21-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-demo-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-demo}"
SRC_URI[x86_64_v2_java-21-openjdk-demo.sha256sum] = "aeda4028a5396df23bb43f7c19a7d882096d81bf4b11fa3e4ca6768c5fcbe192"

URI_x86_64_v2_java-21-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-fastdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-demo-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-demo-fastdebug.sha256sum] = "22300756b520a952d530bffeb334915beaf4db8d75f29da78e8873f60bbe50d2"

URI_x86_64_v2_java-21-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-slowdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-demo-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-demo-slowdebug.sha256sum] = "ae5bf868e2000bd04cc77a05feab624ad84e07229c6d5c8f64f10964da895fbd"

URI_x86_64_v2_java-21-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-devel-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-devel}"
SRC_URI[x86_64_v2_java-21-openjdk-devel.sha256sum] = "963311e87fe948f89a613815e497eb4a5d9f29c3727a6a5a8b87a3ac06c13a56"

URI_x86_64_v2_java-21-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-fastdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-devel-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-devel-fastdebug.sha256sum] = "bdd3cea768d862622c73924ffbdac759f0b2cd591e2f12ceb25353feb4773cf1"

URI_x86_64_v2_java-21-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-slowdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-devel-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-devel-slowdebug.sha256sum] = "9dad92e415398ccde2e169f36f6a531f98d8b96441ab2324f16705158259f9a0"

URI_x86_64_v2_java-21-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-fastdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-fastdebug.sha256sum] = "d8c3a8f8743fba840f1da673f57829da46f4ef6ecc9d536961899bcaaeee1ed7"

URI_x86_64_v2_java-21-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-headless-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-headless}"
SRC_URI[x86_64_v2_java-21-openjdk-headless.sha256sum] = "b60719d0bb31ac345be50f0d82d41e4578880abe8f6fd6a1e8cb8d3dabce5af2"
RPROVIDES:java-21-openjdk-headless:x86_64_v2 = "virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

URI_x86_64_v2_java-21-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-fastdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-headless-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-headless-fastdebug.sha256sum] = "1cb8bc204e242295c73a502995e0c3f28e3a48db6a9b6b7d28a6b704b86d4655"

URI_x86_64_v2_java-21-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-slowdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-headless-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-headless-slowdebug.sha256sum] = "18369bb32f33cdd22a6642507f9cd90699130cff9083db3e13732db013174a9d"

URI_x86_64_v2_java-21-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-javadoc}"
SRC_URI[x86_64_v2_java-21-openjdk-javadoc.sha256sum] = "80d3ac438ffc9b20ca154e535cd55c45d1a1b659cba08f28e13f0cd033c6ef96"

URI_x86_64_v2_java-21-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-zip-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-javadoc-zip}"
SRC_URI[x86_64_v2_java-21-openjdk-javadoc-zip.sha256sum] = "9f7b7065a60bde48929d8a0991f62901b67816e82b5b00d55a9697177ff5b1ae"

URI_x86_64_v2_java-21-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-jmods-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-jmods}"
SRC_URI[x86_64_v2_java-21-openjdk-jmods.sha256sum] = "ef80b9935ad5f051c44f94ae4e36c94cea3d456df1346a4b658c57d35f1f0673"

URI_x86_64_v2_java-21-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-jmods-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-jmods-fastdebug.sha256sum] = "34afc12bb4088621f58ad788e153dcc2763acccb4def41c79c427c1b063a0b8e"

URI_x86_64_v2_java-21-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-jmods-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-jmods-slowdebug.sha256sum] = "3e27c6b776df916ba0291d316381822afea48298b1b9d5660109265f2fb4b585"

URI_x86_64_v2_java-21-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-slowdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-slowdebug.sha256sum] = "66732eeaefc662c627c602071948cf43350184174c7e95b09903dcef75bf446a"

URI_x86_64_v2_java-21-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-src-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-src}"
SRC_URI[x86_64_v2_java-21-openjdk-src.sha256sum] = "d4bbab2fba0d433bdcf6d1b00ea832b781c9abab970cab68a9baa226d85eeab1"

URI_x86_64_v2_java-21-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-fastdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-src-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-src-fastdebug.sha256sum] = "e681f9d7682be1c33897717cb03acb1a181cb7a4c02c1cbdce86aa3ce0d5b6f7"

URI_x86_64_v2_java-21-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-slowdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-src-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-src-slowdebug.sha256sum] = "36b92243d331ca5a2d8a3910bab894563548bc580bd2161ce11e1af80bd7153c"

URI_x86_64_v2_java-21-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-static-libs-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-static-libs}"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs.sha256sum] = "eebe36df5de9d481a545d894fbfb0e799e10537fb8f6fd721aaf34dc8a243d17"

URI_x86_64_v2_java-21-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs-fastdebug.sha256sum] = "2d1145b2b6c1eaa7fe823351f95e086b77137ab06d9546e3d17a38422f894266"

URI_x86_64_v2_java-21-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.11.0.10-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-21-openjdk-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs-slowdebug.sha256sum] = "20808f9950a2e4c1fcd008b52fc4d4d2bebdd94c0e26239b492c875492f9c64d"

URI_aarch64_java-21-openjdk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk}"
SRC_URI[aarch64_java-21-openjdk.sha256sum] = "08cebbe4975ec2fd0a107be4d435edf8366dc2c4549339706ca0017f343d6650"

URI_aarch64_java-21-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-demo-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-demo}"
SRC_URI[aarch64_java-21-openjdk-demo.sha256sum] = "81ae9300a34919f43efe2c200710ce3e6ce868280f7c3902dd3169260f973679"

URI_aarch64_java-21-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-demo-fastdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-demo-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-demo-fastdebug.sha256sum] = "a76b52dafed5e7252120638ddba27e48bc7e86220037278b96146670cb617bed"

URI_aarch64_java-21-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-demo-slowdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-demo-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-demo-slowdebug.sha256sum] = "1a8ad5092ed9265b795c0b61380efea2c9a28ce7e4030a55d8254deb8ff20320"

URI_aarch64_java-21-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-devel-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-devel}"
SRC_URI[aarch64_java-21-openjdk-devel.sha256sum] = "6fa7c8948ee492dadf06ede0d798b63e297aa7a353ccead8712083a8fe380be9"

URI_aarch64_java-21-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-devel-fastdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-devel-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-devel-fastdebug.sha256sum] = "27039395bbc5cd2be2048d0754b642d0abbf2ee6247b6ad27e4922a14fd2a60f"

URI_aarch64_java-21-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-devel-slowdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-devel-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-devel-slowdebug.sha256sum] = "2560215b061cfad1f8fe5e5e176b9689abebe2ae138cc6206baefac0bf925b0e"

URI_aarch64_java-21-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-fastdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-fastdebug.sha256sum] = "d7b696ef6baa326ca733daec26872129a624ad0b80aafbdbebd1645df299b51b"

URI_aarch64_java-21-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-headless-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-headless}"
SRC_URI[aarch64_java-21-openjdk-headless.sha256sum] = "638aaf79668a85f5876d4cb28544d5c346bec326b18e41fceaf80ab9a7089a00"
RPROVIDES:java-21-openjdk-headless:aarch64 = "virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

URI_aarch64_java-21-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-headless-fastdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-headless-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-headless-fastdebug.sha256sum] = "30ab7dc50494c7f923c6269823d04e3e3cbfc9d75ca7e4d6b3dd199cee5b460e"

URI_aarch64_java-21-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-headless-slowdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-headless-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-headless-slowdebug.sha256sum] = "62c7726ec488e5725fafe96e24aba08faf019b25644e03782e47543300c93f5a"

URI_aarch64_java-21-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-javadoc-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-javadoc}"
SRC_URI[aarch64_java-21-openjdk-javadoc.sha256sum] = "569c4cd8cfe0d3d7401498dde807948f1f3d535a980babfd98c92a1d3292680d"

URI_aarch64_java-21-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-javadoc-zip-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-javadoc-zip}"
SRC_URI[aarch64_java-21-openjdk-javadoc-zip.sha256sum] = "6b8cf4dddd77e1b8568c1eac0c873a2b680dd351f2ed0d1a9418d149b30eea0a"

URI_aarch64_java-21-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-jmods-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-jmods}"
SRC_URI[aarch64_java-21-openjdk-jmods.sha256sum] = "af2a9d3a352be5669e333e25471f8eeabd7144f78d33e4e4b1bb15cc0f1e0b20"

URI_aarch64_java-21-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-jmods-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-jmods-fastdebug.sha256sum] = "25ddbf83f480058d1cd214877efce93d5d5a8f376bf6a81adb5f6141500fd58e"

URI_aarch64_java-21-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-jmods-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-jmods-slowdebug.sha256sum] = "3038b24d6868afde0ada703690056d5743098f23b923e5a132a3ea78d0c143ed"

URI_aarch64_java-21-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-slowdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-slowdebug.sha256sum] = "8cc049f761fef06ccab1895f9a563bbbbf814d452750f51f4f0099b4e33c4f7b"

URI_aarch64_java-21-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-src-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-src}"
SRC_URI[aarch64_java-21-openjdk-src.sha256sum] = "5ea4376752d6e56adf3f301c16b9577b8d0729ffe01ffb9fec66e096098ada63"

URI_aarch64_java-21-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-src-fastdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-src-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-src-fastdebug.sha256sum] = "2486f8f05a596cb2a52759408c8fc837df581144eef7e2df1f6948cf0ae98e64"

URI_aarch64_java-21-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-src-slowdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-src-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-src-slowdebug.sha256sum] = "eff2f2eea1d66ccaa6de72af5944c440361058dd68602c8b5fd72d8fc868ef56"

URI_aarch64_java-21-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-static-libs-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-static-libs}"
SRC_URI[aarch64_java-21-openjdk-static-libs.sha256sum] = "d49d209e28a3a682070ef6a901b994d4ba2b85b2e4da9f5bbc57b3510734a200"

URI_aarch64_java-21-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-static-libs-fastdebug}"
SRC_URI[aarch64_java-21-openjdk-static-libs-fastdebug.sha256sum] = "929fb149543321fb5bd924762027ad0b1d43a040922c1738c497db002e2f7b53"

URI_aarch64_java-21-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.11.0.10-2.el10.alma.1.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-21-openjdk-static-libs-slowdebug}"
SRC_URI[aarch64_java-21-openjdk-static-libs-slowdebug.sha256sum] = "d82a112ec48ef301ed6fd5c22323be05417aefbce657fbdf00bbe78a041af455"

RDEPENDS:java-21-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-21-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-demo = " \
 java-21-openjdk \
 "
RDEPENDS:java-21-openjdk-demo-fastdebug = " \
 java-21-openjdk-fastdebug \
 "
RDEPENDS:java-21-openjdk-demo-slowdebug = " \
 java-21-openjdk-slowdebug \
 "
RDEPENDS:java-21-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-21-openjdk \
 "
RDEPENDS:java-21-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 java-21-openjdk-fastdebug \
 "
RDEPENDS:java-21-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 java-21-openjdk-slowdebug \
 "
RDEPENDS:java-21-openjdk-fastdebug = " \
 bash \
 fontconfig \
 java-21-openjdk-headless-fastdebug \
 libXcomposite \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-headless-fastdebug = " \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-headless-slowdebug = " \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-javadoc = " \
 alternatives \
 bash \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-21-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-21-openjdk-jmods = " \
 java-21-openjdk-devel \
 "
RDEPENDS:java-21-openjdk-jmods-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
 "
RDEPENDS:java-21-openjdk-jmods-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
 "
RDEPENDS:java-21-openjdk-slowdebug = " \
 bash \
 fontconfig \
 java-21-openjdk-headless-slowdebug \
 libXcomposite \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-src = " \
 java-21-openjdk-headless \
 "
RDEPENDS:java-21-openjdk-src-fastdebug = " \
 java-21-openjdk-headless-fastdebug \
 "
RDEPENDS:java-21-openjdk-src-slowdebug = " \
 java-21-openjdk-headless-slowdebug \
 "
RDEPENDS:java-21-openjdk-static-libs = " \
 java-21-openjdk-devel \
 "
RDEPENDS:java-21-openjdk-static-libs-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
 "
RDEPENDS:java-21-openjdk-static-libs-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless rpm/virtual/java-headless_or_java-25-headless"

PROVIDES:append:aarch64 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless rpm/virtual/java-headless_or_java-25-headless"
