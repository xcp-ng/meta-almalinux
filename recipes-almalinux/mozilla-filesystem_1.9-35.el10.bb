# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mozilla-filesystem"
PV = "1.9"
PR = "35.el10"
PACKAGES = " \
 mozilla-filesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mozilla-filesystem-1.9-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4407bb8cd0ed6576bbe2151a556c9ec549ede56ed3c3cdddc9a20e30c504ebf"

URI_x86_64_v2_mozilla-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mozilla-filesystem-1.9-35.el10.x86_64_v2.rpm;name=x86_64_v2_mozilla-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mozilla-filesystem}"
SRC_URI[x86_64_v2_mozilla-filesystem.sha256sum] = "635b6da1a656263beb868153486b43c5cff8d1cc3085deabfd17a922e631d728"

URI_aarch64_mozilla-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mozilla-filesystem-1.9-35.el10.aarch64.rpm;name=aarch64_mozilla-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_mozilla-filesystem}"
SRC_URI[aarch64_mozilla-filesystem.sha256sum] = "6d6f2cc0e9a004af99f94b23f2bd7cb9a757f790436e24771645b7c3115b0ba9"

RDEPENDS:mozilla-filesystem = " \
 "
