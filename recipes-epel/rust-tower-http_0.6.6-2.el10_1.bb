# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower-http"
PV = "0.6.6"
PR = "2.el10_1"
PACKAGES = " \
 rust-tower-http+add-extension-devel \
 rust-tower-http+async-compression-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+base64-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-full-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+compression-zstd-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-full-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+decompression-zstd-devel \
 rust-tower-http+default-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+full-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+httpdate-devel \
 rust-tower-http+iri-string-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+mime-devel \
 rust-tower-http+mime_guess-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+percent-encoding-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http+tower-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http+util-devel \
 rust-tower-http+uuid-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tower-http-0.6.6-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c87ee19aca628df8c86835614a623cc25264b129a4a9a2d9d984dd61b1029632"

URI_x86_64_v2_rust-tower-http+add-extension-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+add-extension-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+add-extension-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+add-extension-devel}"
SRC_URI[x86_64_v2_rust-tower-http+add-extension-devel.sha256sum] = "5261134da8cf185f308a3257800e2dc41dad133273c8d3e7459a4be6c38eb63a"

URI_x86_64_v2_rust-tower-http+async-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+async-compression-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+async-compression-devel}"
SRC_URI[x86_64_v2_rust-tower-http+async-compression-devel.sha256sum] = "88b5d155bb1920d2acd18f58a75025589206706682d43d64da31f52e92f3cb4c"

URI_x86_64_v2_rust-tower-http+auth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+auth-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+auth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+auth-devel}"
SRC_URI[x86_64_v2_rust-tower-http+auth-devel.sha256sum] = "44a057312319f12494db4c72d47134f28a721b439353985b4adc2684009287c8"

URI_x86_64_v2_rust-tower-http+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+base64-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+base64-devel}"
SRC_URI[x86_64_v2_rust-tower-http+base64-devel.sha256sum] = "14e1376fc2d1352b475959607c1bde99e2daddf9e5112b43cde11c73cf27bc2d"

URI_x86_64_v2_rust-tower-http+catch-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+catch-panic-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+catch-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+catch-panic-devel}"
SRC_URI[x86_64_v2_rust-tower-http+catch-panic-devel.sha256sum] = "445cc9da9a6a46823914298ca4c0c67296f9306f23ae59c1511883f0f79e1cba"

URI_x86_64_v2_rust-tower-http+compression-br-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-br-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-br-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-br-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-br-devel.sha256sum] = "3f05f140bfdab30705867d8be20a27beafffb074ef9cbd4a9e142da47738bac9"

URI_x86_64_v2_rust-tower-http+compression-deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-deflate-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-deflate-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-deflate-devel.sha256sum] = "f74e5965f1cbbe2172c14423ff3f3eae34e222c0b6ba28605a9b6d0eee1ef8b4"

URI_x86_64_v2_rust-tower-http+compression-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-full-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-full-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-full-devel.sha256sum] = "eeb41df1999dd68bf593b65cb47564a261f2bf63a8ec95ffc3687477bf00caa0"

URI_x86_64_v2_rust-tower-http+compression-gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-gzip-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-gzip-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-gzip-devel.sha256sum] = "524d5c97262d365b737d914dfa7e4d2484adea723d8cd783e6723206a7385f86"

URI_x86_64_v2_rust-tower-http+compression-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-zstd-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+compression-zstd-devel}"
SRC_URI[x86_64_v2_rust-tower-http+compression-zstd-devel.sha256sum] = "f4c1a4f7f67806fcf9ffc97f9ff62acc285f86fea600052f45d8cd7365c17168"

URI_x86_64_v2_rust-tower-http+cors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+cors-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+cors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+cors-devel}"
SRC_URI[x86_64_v2_rust-tower-http+cors-devel.sha256sum] = "a9891e2b49cad0620e047d7a04c752b7aa9497d9b7353b5cf850fdd22530b53c"

URI_x86_64_v2_rust-tower-http+decompression-br-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-br-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-br-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-br-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-br-devel.sha256sum] = "8bdee6215ae486d112f214c2db43d96391b0fc69628b216f884bea17521386f2"

URI_x86_64_v2_rust-tower-http+decompression-deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-deflate-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-deflate-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-deflate-devel.sha256sum] = "a925415a188a125700b07f18aab5218b6570e0322b7b9e98fe65c3cfcfdaae54"

URI_x86_64_v2_rust-tower-http+decompression-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-full-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-full-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-full-devel.sha256sum] = "7361f7467dafe5e360dc5adbc6ad191bed9a49b2c75fee5fa90a6d141db6d30d"

URI_x86_64_v2_rust-tower-http+decompression-gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-gzip-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-gzip-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-gzip-devel.sha256sum] = "3bedaf47caa54901bb989ecf7f03f4eb8b96fab549b5ea40d4deafdd028e1780"

URI_x86_64_v2_rust-tower-http+decompression-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-zstd-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+decompression-zstd-devel}"
SRC_URI[x86_64_v2_rust-tower-http+decompression-zstd-devel.sha256sum] = "89f2a8f7352e31687eb80159938380b07e20206312e05352993afab12c0711cb"

URI_x86_64_v2_rust-tower-http+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+default-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+default-devel}"
SRC_URI[x86_64_v2_rust-tower-http+default-devel.sha256sum] = "afd34fa2f18701f1665e24c52565134ceb540cf94b3a74b230747060f86d9641"

URI_x86_64_v2_rust-tower-http+follow-redirect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+follow-redirect-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+follow-redirect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+follow-redirect-devel}"
SRC_URI[x86_64_v2_rust-tower-http+follow-redirect-devel.sha256sum] = "ca3780e182726ae7088d8e86f3a24018a5de88058630516b0b3f9be1025d4e85"

URI_x86_64_v2_rust-tower-http+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+fs-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+fs-devel}"
SRC_URI[x86_64_v2_rust-tower-http+fs-devel.sha256sum] = "293f60672c315364a3354e552829f94f0a390d917ee9528ca1dfef7f4b860786"

URI_x86_64_v2_rust-tower-http+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+full-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+full-devel}"
SRC_URI[x86_64_v2_rust-tower-http+full-devel.sha256sum] = "f5fe14ae68c14002cb09098c183beb3746b2527e572a9dd703c0bb20551950cf"

URI_x86_64_v2_rust-tower-http+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+futures-core-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+futures-core-devel}"
SRC_URI[x86_64_v2_rust-tower-http+futures-core-devel.sha256sum] = "7bb0a47bdd44433d7491ee2717f41d4a7efbfd3f8e9e76c8effc301a6ffe695d"

URI_x86_64_v2_rust-tower-http+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+futures-util-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+futures-util-devel}"
SRC_URI[x86_64_v2_rust-tower-http+futures-util-devel.sha256sum] = "c3e26638d96f446c9256485d24cc1f4705e61328203f87e27567e3101f57c5a4"

URI_x86_64_v2_rust-tower-http+httpdate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+httpdate-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+httpdate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+httpdate-devel}"
SRC_URI[x86_64_v2_rust-tower-http+httpdate-devel.sha256sum] = "ec46b73c32b9a120624559936f28af0770b63f21d39765f5f7e88c3fdf3314a0"

URI_x86_64_v2_rust-tower-http+iri-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+iri-string-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+iri-string-devel}"
SRC_URI[x86_64_v2_rust-tower-http+iri-string-devel.sha256sum] = "19593877064b688e91438c58caab627e68f10b1078fa97401f80d582e4696047"

URI_x86_64_v2_rust-tower-http+limit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+limit-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+limit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+limit-devel}"
SRC_URI[x86_64_v2_rust-tower-http+limit-devel.sha256sum] = "5f35e9fabee64f191393c905e4163ca5d0425308dd1ef5ef46af725d57442f10"

URI_x86_64_v2_rust-tower-http+map-request-body-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+map-request-body-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+map-request-body-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+map-request-body-devel}"
SRC_URI[x86_64_v2_rust-tower-http+map-request-body-devel.sha256sum] = "e7faa702dd8366ebde525cb890842fa7a1655eea6388b98d73da2a21fa04fc45"

URI_x86_64_v2_rust-tower-http+map-response-body-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+map-response-body-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+map-response-body-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+map-response-body-devel}"
SRC_URI[x86_64_v2_rust-tower-http+map-response-body-devel.sha256sum] = "9a4a84398b6c592219214b2317e5c2cd3e2614e915cc4067c91d62a4ea751502"

URI_x86_64_v2_rust-tower-http+metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+metrics-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+metrics-devel}"
SRC_URI[x86_64_v2_rust-tower-http+metrics-devel.sha256sum] = "01c092f850e018e8d8fc40777f275b84bd29b9e8e8fba56c572920e7c819424a"

URI_x86_64_v2_rust-tower-http+mime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+mime-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+mime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+mime-devel}"
SRC_URI[x86_64_v2_rust-tower-http+mime-devel.sha256sum] = "316867cff1247e15c96aacac40446f0228e5153183408ece90f3ed5ceb90ddee"

URI_x86_64_v2_rust-tower-http+mime_guess-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+mime_guess-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+mime_guess-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+mime_guess-devel}"
SRC_URI[x86_64_v2_rust-tower-http+mime_guess-devel.sha256sum] = "182f4fbda50ba6d36c77147e1d95c73ee0624a3387d08ac29890d725113af080"

URI_x86_64_v2_rust-tower-http+normalize-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+normalize-path-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+normalize-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+normalize-path-devel}"
SRC_URI[x86_64_v2_rust-tower-http+normalize-path-devel.sha256sum] = "d551050a37adfae2cb063015c4386cef4e1af4da03aa3294bc007154cfaff6c0"

URI_x86_64_v2_rust-tower-http+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+percent-encoding-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-tower-http+percent-encoding-devel.sha256sum] = "8f51e008396f0172fa28ca4525efa935f593fb0b41c93a54aa83397bf4ba1be9"

URI_x86_64_v2_rust-tower-http+propagate-header-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+propagate-header-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+propagate-header-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+propagate-header-devel}"
SRC_URI[x86_64_v2_rust-tower-http+propagate-header-devel.sha256sum] = "7b9ce8f8a9b879910fa98455024d5aa1774b4e1fab15cd16cfcb4426c115faca"

URI_x86_64_v2_rust-tower-http+redirect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+redirect-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+redirect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+redirect-devel}"
SRC_URI[x86_64_v2_rust-tower-http+redirect-devel.sha256sum] = "e73c3db0e7ec9eb20224777fd58664caa0d13db2ea0f2d87bf78920a5f436118"

URI_x86_64_v2_rust-tower-http+request-id-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+request-id-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+request-id-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+request-id-devel}"
SRC_URI[x86_64_v2_rust-tower-http+request-id-devel.sha256sum] = "985481abdde5f11a7adce102dfff04a82869dcd92b2e878be24fa4e3cc2f615d"

URI_x86_64_v2_rust-tower-http+sensitive-headers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+sensitive-headers-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+sensitive-headers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+sensitive-headers-devel}"
SRC_URI[x86_64_v2_rust-tower-http+sensitive-headers-devel.sha256sum] = "40c688df3dbb3bb813e4b7b2ef17ca59b24b31782231132005a69fa82d3f6175"

URI_x86_64_v2_rust-tower-http+set-header-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+set-header-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+set-header-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+set-header-devel}"
SRC_URI[x86_64_v2_rust-tower-http+set-header-devel.sha256sum] = "b629feefe438ba8fc13be9c4751773d392926e3254c0c4bf849328718685953f"

URI_x86_64_v2_rust-tower-http+set-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+set-status-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+set-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+set-status-devel}"
SRC_URI[x86_64_v2_rust-tower-http+set-status-devel.sha256sum] = "51d462dab3702bade0ff46b40e2ab17c45822f3ae0879629fbb7da866323e527"

URI_x86_64_v2_rust-tower-http+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+timeout-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+timeout-devel}"
SRC_URI[x86_64_v2_rust-tower-http+timeout-devel.sha256sum] = "324a4927f27872540d91a77802fa3ee630cfc66556089925e5bb6bf34084806f"

URI_x86_64_v2_rust-tower-http+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tokio-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tokio-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tokio-devel.sha256sum] = "0b325c988fc75b61401d2091304b0c9ea9c373049f09ad014f9f0d1409102b7c"

URI_x86_64_v2_rust-tower-http+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tokio-util-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tokio-util-devel.sha256sum] = "0a4558b1a9906c2a949f4cafacd7e3246b863bc6f0d20b7fc350d3363d24f004"

URI_x86_64_v2_rust-tower-http+tower-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tower-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tower-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tower-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tower-devel.sha256sum] = "2bc1ca5dd944f5c485234cff9cf0e0806e7d2753160578f7a8b66e83dc4fa67d"

URI_x86_64_v2_rust-tower-http+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+trace-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+trace-devel}"
SRC_URI[x86_64_v2_rust-tower-http+trace-devel.sha256sum] = "11b9e23cefc0f7479150df02435824cef78f502ab5f88fc2c297a4523c833188"

URI_x86_64_v2_rust-tower-http+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tracing-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+tracing-devel}"
SRC_URI[x86_64_v2_rust-tower-http+tracing-devel.sha256sum] = "8e4a09a920fc13519d24a270225fd6c28dd08a7f058147756eaccaf11b972526"

URI_x86_64_v2_rust-tower-http+util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+util-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+util-devel}"
SRC_URI[x86_64_v2_rust-tower-http+util-devel.sha256sum] = "1633b8aebac8990b386e028ff80533e0563f21eafab0b2591ca207e06dd5c53f"

URI_x86_64_v2_rust-tower-http+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+uuid-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+uuid-devel}"
SRC_URI[x86_64_v2_rust-tower-http+uuid-devel.sha256sum] = "6d3ac51aef6ee1f3b140b6943a0cbf8cfab16eed6dad9a152ce790a3f6e61629"

URI_x86_64_v2_rust-tower-http+validate-request-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+validate-request-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+validate-request-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http+validate-request-devel}"
SRC_URI[x86_64_v2_rust-tower-http+validate-request-devel.sha256sum] = "834e62f1283b51501ae6cb97dd28308b2d35ec80dc51e0c3a32c2c81b6d179ec"

URI_x86_64_v2_rust-tower-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http-devel-0.6.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tower-http-devel}"
SRC_URI[x86_64_v2_rust-tower-http-devel.sha256sum] = "0d66abaef251bcbca4c710b285d617e5c710e43d87baf661b391a619d224e402"

URI_aarch64_rust-tower-http+add-extension-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+add-extension-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+add-extension-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+add-extension-devel}"
SRC_URI[aarch64_rust-tower-http+add-extension-devel.sha256sum] = "c3ed16fb016d43f5ce8cc6e441fb6e85846fa0f634f88bb2560fa4a9b7f483a7"

URI_aarch64_rust-tower-http+async-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+async-compression-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+async-compression-devel}"
SRC_URI[aarch64_rust-tower-http+async-compression-devel.sha256sum] = "71178f5ad686b75015de259426d03bece699669f3a9da6329bedd5760edb42c8"

URI_aarch64_rust-tower-http+auth-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+auth-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+auth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+auth-devel}"
SRC_URI[aarch64_rust-tower-http+auth-devel.sha256sum] = "5a090daac041ed60ffaee9f21e19ce0aa1c1d78ba225ce8a23c4cee7e1ac2f6b"

URI_aarch64_rust-tower-http+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+base64-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+base64-devel}"
SRC_URI[aarch64_rust-tower-http+base64-devel.sha256sum] = "1629f907d8c0b24e070874ffff34645cc0be17b0661db1707267b1f4470d3ecc"

URI_aarch64_rust-tower-http+catch-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+catch-panic-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+catch-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+catch-panic-devel}"
SRC_URI[aarch64_rust-tower-http+catch-panic-devel.sha256sum] = "33432a5e1d564324dacf7060b3bb11ba671cc142a6d388918de30764d759ace7"

URI_aarch64_rust-tower-http+compression-br-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-br-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+compression-br-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-br-devel}"
SRC_URI[aarch64_rust-tower-http+compression-br-devel.sha256sum] = "1382b58eaef80e1d3d8910a291126a9fb91492c9368ef4213d780cdddefdca15"

URI_aarch64_rust-tower-http+compression-deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-deflate-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-deflate-devel}"
SRC_URI[aarch64_rust-tower-http+compression-deflate-devel.sha256sum] = "9d05c1f35027d69f7ebe82d5afcf485f34eec96a3232b5a4f9598e579d21c3b8"

URI_aarch64_rust-tower-http+compression-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-full-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+compression-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-full-devel}"
SRC_URI[aarch64_rust-tower-http+compression-full-devel.sha256sum] = "fceff61cfd51fa31a70820bfccc52b0dff989a433b6ba7aea5bc1c482e36150e"

URI_aarch64_rust-tower-http+compression-gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-gzip-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+compression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-gzip-devel}"
SRC_URI[aarch64_rust-tower-http+compression-gzip-devel.sha256sum] = "47ba005d9957df7763df84c54b203ce6f7c020ff4030913088ca9bec8d81bba8"

URI_aarch64_rust-tower-http+compression-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-zstd-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+compression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+compression-zstd-devel}"
SRC_URI[aarch64_rust-tower-http+compression-zstd-devel.sha256sum] = "6cfd15fdbdbc28aa9e7502b4be337662c56ef8d72481c0a6ad25f9c04c98f28f"

URI_aarch64_rust-tower-http+cors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+cors-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+cors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+cors-devel}"
SRC_URI[aarch64_rust-tower-http+cors-devel.sha256sum] = "d3ed53eae2e81b1f87900c6a356a2ee3f181527c93ea34ba8bda07d03ca55556"

URI_aarch64_rust-tower-http+decompression-br-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-br-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+decompression-br-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-br-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-br-devel.sha256sum] = "2955f15cf7e4516372fcd450a61b7a5ab57be586a4085a728b87e3bdc5c4d029"

URI_aarch64_rust-tower-http+decompression-deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-deflate-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+decompression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-deflate-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-deflate-devel.sha256sum] = "78f3dbdf53cca362101b54ae615d0aa58ac12204c0cb9a68f04d3fc9a022cd96"

URI_aarch64_rust-tower-http+decompression-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-full-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+decompression-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-full-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-full-devel.sha256sum] = "5f79490815512bfb0edd24a6350a13675d15aa27154c6bae0388156eec811a1a"

URI_aarch64_rust-tower-http+decompression-gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-gzip-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+decompression-gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-gzip-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-gzip-devel.sha256sum] = "984860795ca390e0aa3343125757b9480db7a19535a97561072b0c18fc07cd82"

URI_aarch64_rust-tower-http+decompression-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-zstd-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+decompression-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+decompression-zstd-devel}"
SRC_URI[aarch64_rust-tower-http+decompression-zstd-devel.sha256sum] = "ba71fad9ed28b9a1cc546417d98b4410344ebc0fd3009c50a595b279774323fd"

URI_aarch64_rust-tower-http+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+default-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+default-devel}"
SRC_URI[aarch64_rust-tower-http+default-devel.sha256sum] = "437ee98dc269bd415d63bd13c09d88642413b0a9d837cfe805df7b7b4c07e3ca"

URI_aarch64_rust-tower-http+follow-redirect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+follow-redirect-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+follow-redirect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+follow-redirect-devel}"
SRC_URI[aarch64_rust-tower-http+follow-redirect-devel.sha256sum] = "51303986304a1b46272270fdc1b35e189a9378f17c03452f714f46535a45e039"

URI_aarch64_rust-tower-http+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+fs-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+fs-devel}"
SRC_URI[aarch64_rust-tower-http+fs-devel.sha256sum] = "2222b8a0cfab58375428a21549246d4151eeb2e4b3376f985d5eaa7db7ca5b2b"

URI_aarch64_rust-tower-http+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+full-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+full-devel}"
SRC_URI[aarch64_rust-tower-http+full-devel.sha256sum] = "cc1899b48fdd75904820dba7f785864b70f1fcb1e3cb03359f8876dbe338c874"

URI_aarch64_rust-tower-http+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+futures-core-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+futures-core-devel}"
SRC_URI[aarch64_rust-tower-http+futures-core-devel.sha256sum] = "69a604edac38bf4a2ef60c11b4474d408cb7e34c98b78bc274af2d48c4d31075"

URI_aarch64_rust-tower-http+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+futures-util-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+futures-util-devel}"
SRC_URI[aarch64_rust-tower-http+futures-util-devel.sha256sum] = "11a6d4ba27cc43a28bb724356d48d90d000b46770c6cd0df0a9bcfdd49604320"

URI_aarch64_rust-tower-http+httpdate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+httpdate-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+httpdate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+httpdate-devel}"
SRC_URI[aarch64_rust-tower-http+httpdate-devel.sha256sum] = "748bc1fdea1487d75a640a0ac69b3cad8fe6290fd846b162674a4a1627dd6b24"

URI_aarch64_rust-tower-http+iri-string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+iri-string-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+iri-string-devel}"
SRC_URI[aarch64_rust-tower-http+iri-string-devel.sha256sum] = "2c4f783dcd22f8e7be08e05f65ab3508bec56bac100cdd2f1d49342eda8187ac"

URI_aarch64_rust-tower-http+limit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+limit-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+limit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+limit-devel}"
SRC_URI[aarch64_rust-tower-http+limit-devel.sha256sum] = "b44ca56e9aaa7cfb12eba116721f908a2e5e21665754422cef102e967e100370"

URI_aarch64_rust-tower-http+map-request-body-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+map-request-body-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+map-request-body-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+map-request-body-devel}"
SRC_URI[aarch64_rust-tower-http+map-request-body-devel.sha256sum] = "e0c3d4829330eb4e5cdffc170897b289b84c4a9d9d5b366e99ad2e7f24227f09"

URI_aarch64_rust-tower-http+map-response-body-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+map-response-body-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+map-response-body-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+map-response-body-devel}"
SRC_URI[aarch64_rust-tower-http+map-response-body-devel.sha256sum] = "0be312802da119b7364daea57c980ed5edc4b1e5ebd2801fbd582bd6e56af158"

URI_aarch64_rust-tower-http+metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+metrics-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+metrics-devel}"
SRC_URI[aarch64_rust-tower-http+metrics-devel.sha256sum] = "72c5234676d11be2a4d005ff06996d29801bb75a71a5a374e9b6463cbadffc7c"

URI_aarch64_rust-tower-http+mime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+mime-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+mime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+mime-devel}"
SRC_URI[aarch64_rust-tower-http+mime-devel.sha256sum] = "937fbe27d3d246f6bf6948ec1569f2d10e7c5775ecb513a46d54de313be61ec7"

URI_aarch64_rust-tower-http+mime_guess-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+mime_guess-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+mime_guess-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+mime_guess-devel}"
SRC_URI[aarch64_rust-tower-http+mime_guess-devel.sha256sum] = "a69f7ea699850d83b4a8169d25b1fe903e1d7943422f0d97897d1cd294cf8daf"

URI_aarch64_rust-tower-http+normalize-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+normalize-path-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+normalize-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+normalize-path-devel}"
SRC_URI[aarch64_rust-tower-http+normalize-path-devel.sha256sum] = "16b97a457238f9c6f2734a50141777dbd1c94bc46fbd2504d760811f74bd068e"

URI_aarch64_rust-tower-http+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+percent-encoding-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+percent-encoding-devel}"
SRC_URI[aarch64_rust-tower-http+percent-encoding-devel.sha256sum] = "99347ecc66d25b8e801ebd5b7c16b6bd135a5db9b3a06d49bc8b5cf53a27abf8"

URI_aarch64_rust-tower-http+propagate-header-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+propagate-header-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+propagate-header-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+propagate-header-devel}"
SRC_URI[aarch64_rust-tower-http+propagate-header-devel.sha256sum] = "a150f303402ee9402e208e28890e50b980694f9b4e847eaf34dbe5530304c357"

URI_aarch64_rust-tower-http+redirect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+redirect-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+redirect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+redirect-devel}"
SRC_URI[aarch64_rust-tower-http+redirect-devel.sha256sum] = "93e7ac8b22f1972b43f6ddc22d29b8a11f45222b89af927e782bc4af2d1fa7c4"

URI_aarch64_rust-tower-http+request-id-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+request-id-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+request-id-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+request-id-devel}"
SRC_URI[aarch64_rust-tower-http+request-id-devel.sha256sum] = "1b544f8a142ccd1d5dd57781f50fdc82376ff9182a2a6b3746ba0db2767e3d96"

URI_aarch64_rust-tower-http+sensitive-headers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+sensitive-headers-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+sensitive-headers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+sensitive-headers-devel}"
SRC_URI[aarch64_rust-tower-http+sensitive-headers-devel.sha256sum] = "b3854d479bf67a6916a0b2dfbebf59966b0ad896fcd34a36bf8d8effaf808c83"

URI_aarch64_rust-tower-http+set-header-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+set-header-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+set-header-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+set-header-devel}"
SRC_URI[aarch64_rust-tower-http+set-header-devel.sha256sum] = "f0b81da35522f84e22d444befa4f8acca30d01579f649b90759320313143d6f1"

URI_aarch64_rust-tower-http+set-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+set-status-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+set-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+set-status-devel}"
SRC_URI[aarch64_rust-tower-http+set-status-devel.sha256sum] = "6b80de7891d3fd410779b49ce2c1f275221808bed427acfae39eb24c4100603e"

URI_aarch64_rust-tower-http+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+timeout-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+timeout-devel}"
SRC_URI[aarch64_rust-tower-http+timeout-devel.sha256sum] = "705e9b004949aa1a691b7db7dc22886a8f10d7d8a4d533c1daca93535f1cd1af"

URI_aarch64_rust-tower-http+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tokio-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tokio-devel}"
SRC_URI[aarch64_rust-tower-http+tokio-devel.sha256sum] = "46d4bad944870f6b297452e5b983815d74a717eca38af29420b3a9e02c727b12"

URI_aarch64_rust-tower-http+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tokio-util-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tokio-util-devel}"
SRC_URI[aarch64_rust-tower-http+tokio-util-devel.sha256sum] = "8f4ef538f3058ff2a6916ead06a55a2564644d191dcdf9b30b9e8f95eef51aed"

URI_aarch64_rust-tower-http+tower-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tower-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+tower-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tower-devel}"
SRC_URI[aarch64_rust-tower-http+tower-devel.sha256sum] = "e275b7c48aa8106ee4503156568973d5bbbda826d9fe7b771848f091f1fec49a"

URI_aarch64_rust-tower-http+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+trace-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+trace-devel}"
SRC_URI[aarch64_rust-tower-http+trace-devel.sha256sum] = "822a61ee24250802631adf71b6e6a3e8423874617f270562c1e493cf7e00b82e"

URI_aarch64_rust-tower-http+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tracing-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+tracing-devel}"
SRC_URI[aarch64_rust-tower-http+tracing-devel.sha256sum] = "9885b6cb15b9604daa33fb9f7f90cc8fe03d2c2ba2b35b04d3605f2520f2f359"

URI_aarch64_rust-tower-http+util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+util-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+util-devel}"
SRC_URI[aarch64_rust-tower-http+util-devel.sha256sum] = "967ba4b9295fdbfe76d62a49c5fe4bb7495e5a4dea0e25a05c86f497e4010d72"

URI_aarch64_rust-tower-http+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+uuid-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+uuid-devel}"
SRC_URI[aarch64_rust-tower-http+uuid-devel.sha256sum] = "35afcbe9a95fdbd1031e43160be238e9b4df58e0a64f5d8eadc33ccb5d71226a"

URI_aarch64_rust-tower-http+validate-request-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+validate-request-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http+validate-request-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http+validate-request-devel}"
SRC_URI[aarch64_rust-tower-http+validate-request-devel.sha256sum] = "dfbdcd2c44447eddb13401e282059edee076a85c7d84dbe6f1f54197928064bf"

URI_aarch64_rust-tower-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http-devel-0.6.6-2.el10_1.noarch.rpm;name=aarch64_rust-tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tower-http-devel}"
SRC_URI[aarch64_rust-tower-http-devel.sha256sum] = "eca674822beb9344ec4fae1d4d1682612c695bfd6ad1175ee5248067b4880950"

RDEPENDS:rust-tower-http+add-extension-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+async-compression-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+auth-devel = " \
 cargo \
 rust-tower-http+base64-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+catch-panic-devel = " \
 cargo \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-br-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-deflate-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zlib-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-full-devel = " \
 cargo \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+compression-zstd-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-gzip-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-zstd-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zstd-devel \
 rust-http-body+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+cors-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-br-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-deflate-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zlib-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-full-devel = " \
 cargo \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+decompression-zstd-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-gzip-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-zstd-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zstd-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+default-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+follow-redirect-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tower+default-devel \
 rust-tower+util-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+iri-string-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+fs-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-http-range-header+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+httpdate-devel \
 rust-tower-http+mime-devel \
 rust-tower-http+mime_guess-devel \
 rust-tower-http+percent-encoding-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+full-devel = " \
 cargo \
 rust-tower-http+add-extension-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-full-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-full-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+util-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+futures-core-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+futures-util-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+httpdate-devel = " \
 cargo \
 rust-httpdate+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+iri-string-devel = " \
 cargo \
 rust-iri-string+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+limit-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+map-request-body-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+map-response-body-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+metrics-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+mime-devel = " \
 cargo \
 rust-mime-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+mime_guess-devel = " \
 cargo \
 rust-mime_guess-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+normalize-path-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+percent-encoding-devel = " \
 cargo \
 rust-percent-encoding+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+propagate-header-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+redirect-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+request-id-devel = " \
 cargo \
 rust-tower-http+uuid-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+sensitive-headers-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+set-header-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+set-status-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+timeout-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tokio-devel = " \
 cargo \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tokio-util-devel = " \
 cargo \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tower-devel = " \
 cargo \
 rust-tower+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+trace-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tracing-devel = " \
 cargo \
 rust-tower-http-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tower-http+util-devel = " \
 cargo \
 rust-tower-http+tower-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+uuid-devel = " \
 cargo \
 rust-tower-http-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 "
RDEPENDS:rust-tower-http+validate-request-devel = " \
 cargo \
 rust-tower-http+mime-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
