# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XS-Parse-Sublike"
PV = "0.39"
PR = "1.el10_0"
PACKAGES = " \
 perl-XS-Parse-Sublike \
 perl-XS-Parse-Sublike-Builder \
 perl-XS-Parse-Sublike-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XS-Parse-Sublike-0.39-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "969b1a4f12314d0fea2d0461f632cdf6099d9fd19286080f0ca8d31a11404f96"

URI_x86_64_v2_perl-XS-Parse-Sublike = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Sublike-0.39-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Sublike;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Sublike}"
SRC_URI[x86_64_v2_perl-XS-Parse-Sublike.sha256sum] = "3dde23a2ce72d087411fe2f681727fb7f37cb5e755430a1555a5729786fb600d"

URI_x86_64_v2_perl-XS-Parse-Sublike-Builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Sublike-Builder-0.39-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Sublike-Builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Sublike-Builder}"
SRC_URI[x86_64_v2_perl-XS-Parse-Sublike-Builder.sha256sum] = "d55d1e288e02b2cb0ae784ff4c2db55a0c26c0d9e557c35e13e5925e131fe571"

URI_x86_64_v2_perl-XS-Parse-Sublike-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Sublike-tests-0.39-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Sublike-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Sublike-tests}"
SRC_URI[x86_64_v2_perl-XS-Parse-Sublike-tests.sha256sum] = "f88e493a184fc339ecd2501312564109e80880a5e20e738e841b61be087bde7e"

URI_aarch64_perl-XS-Parse-Sublike = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Sublike-0.39-1.el10_0.aarch64.rpm;name=aarch64_perl-XS-Parse-Sublike;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Sublike}"
SRC_URI[aarch64_perl-XS-Parse-Sublike.sha256sum] = "11372c9770a34d620a6d8ab17e114e5b687f71e85718671257bce85997f0328b"

URI_aarch64_perl-XS-Parse-Sublike-Builder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Sublike-Builder-0.39-1.el10_0.aarch64.rpm;name=aarch64_perl-XS-Parse-Sublike-Builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Sublike-Builder}"
SRC_URI[aarch64_perl-XS-Parse-Sublike-Builder.sha256sum] = "0333bc528acedd0ad1b548e8f341d9f9bb1fb0012002fceeecdc5184505203fe"

URI_aarch64_perl-XS-Parse-Sublike-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Sublike-tests-0.39-1.el10_0.aarch64.rpm;name=aarch64_perl-XS-Parse-Sublike-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Sublike-tests}"
SRC_URI[aarch64_perl-XS-Parse-Sublike-tests.sha256sum] = "ca4884e9af483a81225104db96fd68717a6fde65008393697576e5f669808953"

RDEPENDS:perl-XS-Parse-Sublike = " \
 glibc \
 perl-Carp \
 perl-XS-Parse-Sublike \
 perl-libs \
 "
RDEPENDS:perl-XS-Parse-Sublike-Builder = " \
 perl-File-ShareDir \
 perl-PathTools \
 perl-XS-Parse-Sublike \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-XS-Parse-Sublike-tests = " \
 bash \
 glibc \
 perl-B \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-XS-Parse-Sublike \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
