# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pykickstart"
PV = "3.52.13"
PR = "1.el10.alma.1"
PACKAGES = " \
 pykickstart \
 python3-kickstart \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pykickstart-3.52.13-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "178b4d9c7b6d209b4b901b125e7cf12d1baca27c976f85e920dcd47ad19d3168"

URI_x86_64_v2_pykickstart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pykickstart-3.52.13-1.el10.alma.1.noarch.rpm;name=x86_64_v2_pykickstart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pykickstart}"
SRC_URI[x86_64_v2_pykickstart.sha256sum] = "1653595c7ffaac80e77d02b2a1422798180d4035615f12c43af2b380fb2eb547"

URI_x86_64_v2_python3-kickstart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-kickstart-3.52.13-1.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-kickstart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kickstart}"
SRC_URI[x86_64_v2_python3-kickstart.sha256sum] = "42f5ab1448825df78b604c775bd1e3b31865027a5d5753d2f75e16e5bc2cbbfe"

URI_aarch64_pykickstart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pykickstart-3.52.13-1.el10.alma.1.noarch.rpm;name=aarch64_pykickstart;unpack=0"
SRC_URI:append = " ${URI_aarch64_pykickstart}"
SRC_URI[aarch64_pykickstart.sha256sum] = "1653595c7ffaac80e77d02b2a1422798180d4035615f12c43af2b380fb2eb547"

URI_aarch64_python3-kickstart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-kickstart-3.52.13-1.el10.alma.1.noarch.rpm;name=aarch64_python3-kickstart;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kickstart}"
SRC_URI[aarch64_python3-kickstart.sha256sum] = "42f5ab1448825df78b604c775bd1e3b31865027a5d5753d2f75e16e5bc2cbbfe"

RDEPENDS:pykickstart = " \
 python3 \
 python3-kickstart \
 "
RDEPENDS:python3-kickstart = " \
 python3 \
 python3-requests \
 "
