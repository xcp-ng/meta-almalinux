# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-macros"
PV = "0.1.5"
PR = "2.el10_0"
PACKAGES = " \
 rust-gix-macros+default-devel \
 rust-gix-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-macros-0.1.5-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27b0e413afb202f052d5e969da4a6501ac9e10fe68b40840578ad92fdb260a16"

URI_x86_64_v2_rust-gix-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-macros+default-devel-0.1.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-macros+default-devel}"
SRC_URI[x86_64_v2_rust-gix-macros+default-devel.sha256sum] = "0d91e2c9b6fed78b8aabaa65b95313536e21cbf996d928c75bd64694bf3e9cdc"

URI_x86_64_v2_rust-gix-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-macros-devel-0.1.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-macros-devel}"
SRC_URI[x86_64_v2_rust-gix-macros-devel.sha256sum] = "2cb8c37e459877eeed1ae2c81dffed0af0d68cbdc642d5ab55ac618edf412829"

URI_aarch64_rust-gix-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-macros+default-devel-0.1.5-2.el10_0.noarch.rpm;name=aarch64_rust-gix-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-macros+default-devel}"
SRC_URI[aarch64_rust-gix-macros+default-devel.sha256sum] = "ab5dfdfa837373760787558dec69071d91533d426d4202c450e9b605e5aeb273"

URI_aarch64_rust-gix-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-macros-devel-0.1.5-2.el10_0.noarch.rpm;name=aarch64_rust-gix-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-macros-devel}"
SRC_URI[aarch64_rust-gix-macros-devel.sha256sum] = "6a855c1691eb8571e3fdf1e514c711134f49d3dd828b88b28f93d0f95fd89c40"

RDEPENDS:rust-gix-macros+default-devel = " \
 cargo \
 rust-gix-macros-devel \
 "
RDEPENDS:rust-gix-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 "
