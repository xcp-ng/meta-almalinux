# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-httpretty"
PV = "1.1.4"
PR = "2.el10_0"
PACKAGES = " \
 python3-httpretty \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-httpretty-1.1.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e55370e2bdf456cf7412f2f80c64845d9a0d4e9e6fbcfe2d34fa440574261885"

URI_x86_64_v2_python3-httpretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpretty-1.1.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpretty}"
SRC_URI[x86_64_v2_python3-httpretty.sha256sum] = "63cdd187b23564860521c12965ec8bb42fa67a7a8c70293cfdcbb3f4c92d8c31"

URI_aarch64_python3-httpretty = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpretty-1.1.4-2.el10_0.noarch.rpm;name=aarch64_python3-httpretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpretty}"
SRC_URI[aarch64_python3-httpretty.sha256sum] = "84f20432340cef314700337ab5641a5be86b55b8ef301d7539dffb6a347cbadb"

RDEPENDS:python3-httpretty = " \
 python3 \
 python3-six \
 "
