# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpackage"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kpackage \
 kf6-kpackage-devel \
 kf6-kpackage-doc \
 kf6-kpackage-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpackage-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "315179d9dcca718bf34ae8e2b530177b15586ec5933750a7bf1130a8b2d5ab3d"

URI_x86_64_v2_kf6-kpackage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpackage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage}"
SRC_URI[x86_64_v2_kf6-kpackage.sha256sum] = "e1e8b5840a3c9bf07004da65a9e264ed5dc0335f478c597399c53c0ea1b9ac83"

URI_x86_64_v2_kf6-kpackage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpackage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-devel}"
SRC_URI[x86_64_v2_kf6-kpackage-devel.sha256sum] = "ba637aa2ddc116123d2c3b1d4043e41b537804ea5eeb402dfb79e7e813145dcc"

URI_x86_64_v2_kf6-kpackage-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpackage-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-doc}"
SRC_URI[x86_64_v2_kf6-kpackage-doc.sha256sum] = "c4f9261ef650c87f067c6ed3edbfb713a334e61ed74a445c2b5dfd9bd8267a14"

URI_x86_64_v2_kf6-kpackage-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpackage-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-html}"
SRC_URI[x86_64_v2_kf6-kpackage-html.sha256sum] = "0a9570329f0e54eeae8a3ce7e2de236019421542a1b1ec5b3e73e9b3cdd5abbc"

URI_aarch64_kf6-kpackage = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kpackage;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage}"
SRC_URI[aarch64_kf6-kpackage.sha256sum] = "648068bc6b55f46acb9a8ed76b5cd9f206f3fd2bad614928408fb7550b91a283"

URI_aarch64_kf6-kpackage-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kpackage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-devel}"
SRC_URI[aarch64_kf6-kpackage-devel.sha256sum] = "eaa59071a989321b9d9f032c72fddc2477a6ef45ecda38570a242b6a7327917d"

URI_aarch64_kf6-kpackage-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kpackage-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-doc}"
SRC_URI[aarch64_kf6-kpackage-doc.sha256sum] = "80ec5344f32c85b755351240629a578d8efdc18e92d61e22b6369887af667944"

URI_aarch64_kf6-kpackage-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kpackage-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-html}"
SRC_URI[aarch64_kf6-kpackage-html.sha256sum] = "b9cbdec0dbc82216d0c48b552918ac479fbade5c28b55d2a88936ef2f9fd1d40"

RDEPENDS:kf6-kpackage = " \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kpackage-devel = " \
 cmake-filesystem \
 kf6-kpackage \
 "
RDEPENDS:kf6-kpackage-doc = " \
 "
RDEPENDS:kf6-kpackage-html = " \
 "
