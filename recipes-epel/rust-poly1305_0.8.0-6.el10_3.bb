# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-poly1305"
PV = "0.8.0"
PR = "6.el10_3"
PACKAGES = " \
 rust-poly1305+default-devel \
 rust-poly1305+std-devel \
 rust-poly1305+zeroize-devel \
 rust-poly1305-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-poly1305-0.8.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "205ad670e552849206f8a43035cfb35494a6b16b7628b6814e13fbf148ff2a25"

URI_x86_64_v2_rust-poly1305+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-poly1305+default-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-poly1305+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-poly1305+default-devel}"
SRC_URI[x86_64_v2_rust-poly1305+default-devel.sha256sum] = "4f98d0d6250f9b27cb292a080a41f63ec0d5d7f0afa7be145ac3c3f34b79b604"

URI_x86_64_v2_rust-poly1305+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-poly1305+std-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-poly1305+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-poly1305+std-devel}"
SRC_URI[x86_64_v2_rust-poly1305+std-devel.sha256sum] = "2a7a7debced5dc8afaf17f4b14f7f4f6f013faa0411a0aa1e52517872d31f348"

URI_x86_64_v2_rust-poly1305+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-poly1305+zeroize-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-poly1305+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-poly1305+zeroize-devel}"
SRC_URI[x86_64_v2_rust-poly1305+zeroize-devel.sha256sum] = "232952723c3dc1ade7dd8c6ffa0cd79bbc53b504f6898ca492d84b9a53665eb0"

URI_x86_64_v2_rust-poly1305-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-poly1305-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-poly1305-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-poly1305-devel}"
SRC_URI[x86_64_v2_rust-poly1305-devel.sha256sum] = "52ea014548e9f4b92ba82aafde2511f1de8334b68392114e94cd485364329285"

URI_aarch64_rust-poly1305+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-poly1305+default-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-poly1305+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-poly1305+default-devel}"
SRC_URI[aarch64_rust-poly1305+default-devel.sha256sum] = "e7fedd8f35b1524ca4a5aaa4ace29c408cb26642e15b8efe1a2843b820a0b5fd"

URI_aarch64_rust-poly1305+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-poly1305+std-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-poly1305+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-poly1305+std-devel}"
SRC_URI[aarch64_rust-poly1305+std-devel.sha256sum] = "ea029442724b190b3372034064e3d0d4d991e3f7a40b33a15a1d58ce7efbef74"

URI_aarch64_rust-poly1305+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-poly1305+zeroize-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-poly1305+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-poly1305+zeroize-devel}"
SRC_URI[aarch64_rust-poly1305+zeroize-devel.sha256sum] = "8276b1d750cef23c1916fe0fb370971507997d284dfb653fd580549bf67e3962"

URI_aarch64_rust-poly1305-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-poly1305-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-poly1305-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-poly1305-devel}"
SRC_URI[aarch64_rust-poly1305-devel.sha256sum] = "860c82a92913b3c2bcef011802eebd147deab3dbc50e006ed2fce575d0fbe1cf"

RDEPENDS:rust-poly1305+default-devel = " \
 cargo \
 rust-poly1305-devel \
 "
RDEPENDS:rust-poly1305+std-devel = " \
 cargo \
 rust-poly1305-devel \
 rust-universal-hash0.5+std-devel \
 "
RDEPENDS:rust-poly1305+zeroize-devel = " \
 cargo \
 rust-poly1305-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-poly1305-devel = " \
 cargo \
 rust \
 rust-cpufeatures0.2+default-devel \
 rust-opaque-debug+default-devel \
 rust-universal-hash0.5-devel \
 "
