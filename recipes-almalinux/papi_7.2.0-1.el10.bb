# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "papi"
PV = "7.2.0"
PR = "1.el10"
PACKAGES = " \
 papi \
 papi-devel \
 papi-libs \
 papi-testsuite \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/papi-7.2.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "744abdf799d19b3c0f972edde8cdafd20a078c3fe4fd52f68e65d92f1db91f1a"

URI_x86_64_v2_papi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papi-7.2.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_papi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papi}"
SRC_URI[x86_64_v2_papi.sha256sum] = "b0b75fcdf6c49203d0d8dd6354c23a1fdb1b8a825c7a9a9b0e3db7ab605c5df4"

URI_x86_64_v2_papi-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papi-devel-7.2.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_papi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papi-devel}"
SRC_URI[x86_64_v2_papi-devel.sha256sum] = "4c0e8d54bcdce94af2cb5e6edb19f8ad37bc2741e8a0a08529bbb0a208999c2e"

URI_x86_64_v2_papi-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papi-libs-7.2.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_papi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papi-libs}"
SRC_URI[x86_64_v2_papi-libs.sha256sum] = "2191f183f8e54668866762b591fdbab859b575a599e302e511327c41646ae6a1"

URI_x86_64_v2_papi-testsuite = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/papi-testsuite-7.2.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_papi-testsuite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papi-testsuite}"
SRC_URI[x86_64_v2_papi-testsuite.sha256sum] = "8ea873e98e540b49c89239463f1e4ae447915f656ba9daa4d3ba654cc00922ec"

URI_aarch64_papi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papi-7.2.0-1.el10.aarch64.rpm;name=aarch64_papi;unpack=0"
SRC_URI:append = " ${URI_aarch64_papi}"
SRC_URI[aarch64_papi.sha256sum] = "17925d21daf5ef084c8cf69bb23f8fbed5feef77d143d9daab44fd827e54ed98"

URI_aarch64_papi-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papi-devel-7.2.0-1.el10.aarch64.rpm;name=aarch64_papi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_papi-devel}"
SRC_URI[aarch64_papi-devel.sha256sum] = "ac69556ba43d9c70658fd70c9855e3142e0b37743bbba44c338a484fdebc34f0"

URI_aarch64_papi-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papi-libs-7.2.0-1.el10.aarch64.rpm;name=aarch64_papi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_papi-libs}"
SRC_URI[aarch64_papi-libs.sha256sum] = "81d3016038108fe9fb08792ccf4e7284bcd63b11602fd03a261565381c84c7e6"

URI_aarch64_papi-testsuite = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/papi-testsuite-7.2.0-1.el10.aarch64.rpm;name=aarch64_papi-testsuite;unpack=0"
SRC_URI:append = " ${URI_aarch64_papi-testsuite}"
SRC_URI[aarch64_papi-testsuite.sha256sum] = "d2d07fbba7cfef9a9c612a263427f7f19059fb4a19c96540b235903b07e674d6"

RDEPENDS:papi = " \
 glibc \
 papi-libs \
 python3 \
 "
RDEPENDS:papi-devel = " \
 papi \
 papi-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:papi-libs = " \
 glibc \
 libpfm \
 "
RDEPENDS:papi-testsuite = " \
 bash \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 papi \
 papi-libs \
 "
