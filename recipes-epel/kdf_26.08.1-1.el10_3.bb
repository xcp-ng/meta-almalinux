# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdf"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdf \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdf-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "031818ff777953113452676f1a159dd50d5073716da8de3b5b0f11fb1cb48142"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdf-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdf;unpack=0"
SRC_URI[x86_64_v2_kdf.sha256sum] = "5b3e85acdc27c11641f3950a26c52c30568607793fe08195fdeb947b3be375c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdf-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdf;unpack=0"
SRC_URI[aarch64_kdf.sha256sum] = "dc23df44ea504949bfd1f969d761d0793368f8fa08f1ca691d275dfcb6c49dc7"

RDEPENDS:kdf = " \
 glibc \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
