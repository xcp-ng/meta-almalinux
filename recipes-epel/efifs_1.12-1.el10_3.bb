# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "efifs"
PV = "1.12"
PR = "1.el10_3"
PACKAGES = " \
 efifs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/efifs-1.12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "20fc0334cea6e6c1a051ba90b263db6a8c1ea077df796859849b543fc5b5b8ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/efifs-1.12-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_efifs;unpack=0"
SRC_URI[x86_64_v2_efifs.sha256sum] = "76d8937029feca413000d1df5b079bad6deba434906ecdcb39c75f843cef4c9c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/efifs-1.12-1.el10_3.aarch64.rpm;name=aarch64_efifs;unpack=0"
SRC_URI[aarch64_efifs.sha256sum] = "ab9d3e301c8aa4adfc7e36bbd81c391ff13c5e955b6d1894bd0bcf7866f6ab14"

RDEPENDS:efifs = " \
 efi-filesystem \
 "
