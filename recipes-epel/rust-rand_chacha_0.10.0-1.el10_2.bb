# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_chacha"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_chacha+default-devel \
 rust-rand_chacha+serde-devel \
 rust-rand_chacha+std-devel \
 rust-rand_chacha-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_chacha-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "410998963f1c5a7ccf4ea52f433cdbb00cb15a54326e881c26a6e5d79391bb86"

URI_x86_64_v2_rust-rand_chacha+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha+default-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha+default-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha+default-devel.sha256sum] = "f648669ba7eefc897c85f1ce4736c261f9a6821738a198bee7bf908d7f9dd6b3"

URI_x86_64_v2_rust-rand_chacha+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha+serde-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha+serde-devel.sha256sum] = "6f5fb2b544dba415cde11a6288406ac3bc36d9a7587a063793ab382c74b62e08"

URI_x86_64_v2_rust-rand_chacha+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha+std-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha+std-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha+std-devel.sha256sum] = "b2ae4bdd5eb27e58510a561d93276f4bf7c3ffd95d22a443869acc4ac384c613"

URI_x86_64_v2_rust-rand_chacha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha-devel.sha256sum] = "82f87964280cc9d36173e9308690aef9d0fa6c0e095d6e82b9a762abf7bf03f9"

URI_aarch64_rust-rand_chacha+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha+default-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_chacha+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha+default-devel}"
SRC_URI[aarch64_rust-rand_chacha+default-devel.sha256sum] = "cb775d4074d2fd1c03297f1373213c8a68cc69fc4dc32dd4dfd0633146e95b9e"

URI_aarch64_rust-rand_chacha+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha+serde-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_chacha+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha+serde-devel}"
SRC_URI[aarch64_rust-rand_chacha+serde-devel.sha256sum] = "0e2effe2e0e1428ac6d32c79f3a46c14923ce0acfb525c730722581845d9a870"

URI_aarch64_rust-rand_chacha+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha+std-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_chacha+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha+std-devel}"
SRC_URI[aarch64_rust-rand_chacha+std-devel.sha256sum] = "8beb205ac103227b438856fec90cea117957b9abc5d3e9a3d20df95e5df0f058"

URI_aarch64_rust-rand_chacha-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_chacha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha-devel}"
SRC_URI[aarch64_rust-rand_chacha-devel.sha256sum] = "60918ce305b57632e5d776a465c00336ac138a4e7d01b5c4752ae40c76332643"

RDEPENDS:rust-rand_chacha+default-devel = " \
 cargo \
 rust-rand_chacha+std-devel \
 rust-rand_chacha-devel \
 "
RDEPENDS:rust-rand_chacha+serde-devel = " \
 cargo \
 rust-rand_chacha-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_chacha+std-devel = " \
 cargo \
 rust-ppv-lite86+std-devel \
 rust-rand_chacha-devel \
 "
RDEPENDS:rust-rand_chacha-devel = " \
 cargo \
 rust \
 rust-ppv-lite86+simd-devel \
 rust-ppv-lite86-devel \
 rust-rand_core+default-devel \
 "
