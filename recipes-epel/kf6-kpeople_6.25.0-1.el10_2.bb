# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpeople"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kpeople \
 kf6-kpeople-devel \
 kf6-kpeople-doc \
 kf6-kpeople-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpeople-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e0127699d00ed6ff3420d1cc8f855365996530c8b98ab00effdb9aa414eb179"

URI_x86_64_v2_kf6-kpeople = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpeople;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople}"
SRC_URI[x86_64_v2_kf6-kpeople.sha256sum] = "e61e2d9952d1726846f1e30bdb65fb6d77ab7dcd1b504698a874a01b92772485"

URI_x86_64_v2_kf6-kpeople-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpeople-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-devel}"
SRC_URI[x86_64_v2_kf6-kpeople-devel.sha256sum] = "53c6e6653a74a64270b29d43386f0bf2d496cbda33e3af9144d61164f9a814f6"

URI_x86_64_v2_kf6-kpeople-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpeople-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-doc}"
SRC_URI[x86_64_v2_kf6-kpeople-doc.sha256sum] = "6aa92da32d588bbb89ce09a8bb0a4cc3be0c3a37b42fa78bc314a15f406bce89"

URI_x86_64_v2_kf6-kpeople-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpeople-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpeople-html}"
SRC_URI[x86_64_v2_kf6-kpeople-html.sha256sum] = "99c27fa4b8a8ae1575bf2b0fcae61cf304221dc21023fea5b159ca6b65e79931"

URI_aarch64_kf6-kpeople = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kpeople;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople}"
SRC_URI[aarch64_kf6-kpeople.sha256sum] = "e541b748b4068ca0fbdba8158302a780b85116a7255998c6ebfa4612f8bc9360"

URI_aarch64_kf6-kpeople-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kpeople-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-devel}"
SRC_URI[aarch64_kf6-kpeople-devel.sha256sum] = "dfea13b92af1b02394ac2e101862bfeeee9ec0df091a57a48ca97b011043202b"

URI_aarch64_kf6-kpeople-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kpeople-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-doc}"
SRC_URI[aarch64_kf6-kpeople-doc.sha256sum] = "8a118c8790df43579a4994e4cd76f1826ff18955f07d16aeb7616c760e94b16b"

URI_aarch64_kf6-kpeople-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kpeople-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpeople-html}"
SRC_URI[aarch64_kf6-kpeople-html.sha256sum] = "9c3a75806d5de69f1b10f7a89dcd3d4e38f2dc3e51c75164257a8c93aeefaf8f"

RDEPENDS:kf6-kpeople = " \
 glibc \
 kf6-filesystem \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kpeople-devel = " \
 cmake-filesystem \
 kf6-kpeople \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kpeople-doc = " \
 "
RDEPENDS:kf6-kpeople-html = " \
 "
