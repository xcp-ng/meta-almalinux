# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liborc"
PV = "2.0.5"
PR = "1.el10_1"
PACKAGES = " \
 liborc-devel \
 liborc2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liborc-2.0.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "544852df4b11c500443627d1bb1aba7defdac1d6221fe9f6fb9a52af6a0a602d"

URI_x86_64_v2_liborc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liborc-devel-2.0.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liborc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liborc-devel}"
SRC_URI[x86_64_v2_liborc-devel.sha256sum] = "763a13b09dd5e8ccf6e44566d7eec35c05e37942026425c03fa4cfe02c01409f"

URI_x86_64_v2_liborc2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liborc2-2.0.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liborc2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liborc2}"
SRC_URI[x86_64_v2_liborc2.sha256sum] = "bb853cfbc27c06c21cec29e793f7f8eb994b32f67349e7dc42e9fff256163b30"

URI_aarch64_liborc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liborc-devel-2.0.5-1.el10_1.aarch64.rpm;name=aarch64_liborc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liborc-devel}"
SRC_URI[aarch64_liborc-devel.sha256sum] = "20ed6c22794ce7de8bab90a2dd1add4f0dc698c5c856ab6d34c56d081324fca8"

URI_aarch64_liborc2 = "${EPEL_MIRROR}/aarch64/Packages/l/liborc2-2.0.5-1.el10_1.aarch64.rpm;name=aarch64_liborc2;unpack=0"
SRC_URI:append = " ${URI_aarch64_liborc2}"
SRC_URI[aarch64_liborc2.sha256sum] = "004a83d4a938d1f73766539b1b8212e2bc621f368e1120f12127250cf3fe4e5a"

RDEPENDS:liborc-devel = " \
 liborc2 \
 "
RDEPENDS:liborc2 = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 protobuf \
 snappy \
 zlib-ng-compat \
 "
