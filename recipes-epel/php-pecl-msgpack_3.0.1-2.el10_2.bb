# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-msgpack"
PV = "3.0.1"
PR = "2.el10_2"
PACKAGES = " \
 php-pecl-msgpack \
 php-pecl-msgpack-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-msgpack-3.0.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a6233d88354b248aea13748fa4e99477ccf2a361f0675e3936cc188caed4d58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-msgpack-3.0.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-msgpack;unpack=0"
SRC_URI[x86_64_v2_php-pecl-msgpack.sha256sum] = "16fdf91322cb43aafc88cdd3a94d88330800af3218a479b545568f24cd405e61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-msgpack-devel-3.0.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-msgpack-devel;unpack=0"
SRC_URI[x86_64_v2_php-pecl-msgpack-devel.sha256sum] = "1d6b2c832951baf359812607f9880563d03f9649bbd378836138c4eeacf3379d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-msgpack-3.0.1-2.el10_2.aarch64.rpm;name=aarch64_php-pecl-msgpack;unpack=0"
SRC_URI[aarch64_php-pecl-msgpack.sha256sum] = "c1c14e46ac5dfe9eab919c91afbde8f730e88e016779bef2f5bbf8e8e3c90c70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-msgpack-devel-3.0.1-2.el10_2.aarch64.rpm;name=aarch64_php-pecl-msgpack-devel;unpack=0"
SRC_URI[aarch64_php-pecl-msgpack-devel.sha256sum] = "b14b4d7a98636617c41f29b3dcb964025993ddb3c37f754d7a76db24189421ad"

RDEPENDS:php-pecl-msgpack = " \
 glibc \
 php-common \
 "
RDEPENDS:php-pecl-msgpack-devel:x86_64_v2 = " \
 php-pecl-msgpack \
 virtual/php-devel_x86-64_ \
"
RDEPENDS:php-pecl-msgpack-devel:aarch64 = " \
 php-pecl-msgpack \
 virtual/php-devel_aarch-64_ \
"
