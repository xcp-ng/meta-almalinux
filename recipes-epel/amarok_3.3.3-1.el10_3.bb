# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "amarok"
PV = "3.3.3"
PR = "1.el10_3"
PACKAGES = " \
 amarok \
 amarok-doc \
 amarok-libs \
 amarok-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/amarok-3.3.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fc228b4fef8f7499fd4f1ad6a761114a2806567aa352e37b71c224dc3974798"

URI_x86_64_v2_amarok = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amarok-3.3.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amarok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amarok}"
SRC_URI[x86_64_v2_amarok.sha256sum] = "22c96d6a2c56f12db2c56c1dbcd017188370e940000226dff00bcd10fdc575bd"

URI_x86_64_v2_amarok-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amarok-doc-3.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_amarok-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amarok-doc}"
SRC_URI[x86_64_v2_amarok-doc.sha256sum] = "aec691526d693cfc71a5a8d6787ea73c69405b4787ad846c64ba3654c74b1d7d"

URI_x86_64_v2_amarok-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amarok-libs-3.3.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amarok-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amarok-libs}"
SRC_URI[x86_64_v2_amarok-libs.sha256sum] = "f8adfac9d1a05afa951a2e6e1310cc6dae600ee706d2d9d58f53da4954b2d872"

URI_x86_64_v2_amarok-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amarok-utils-3.3.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amarok-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amarok-utils}"
SRC_URI[x86_64_v2_amarok-utils.sha256sum] = "229649671adf80320f964809d8f57141197fa635cb3e36bc6a5cc1a68004a9be"

URI_aarch64_amarok = "${EPEL_MIRROR}/aarch64/Packages/a/amarok-3.3.3-1.el10_3.aarch64.rpm;name=aarch64_amarok;unpack=0"
SRC_URI:append = " ${URI_aarch64_amarok}"
SRC_URI[aarch64_amarok.sha256sum] = "b55f85bbdf720f4b5f259c6015cce6b7e945444f57b0d9628eedb67335230700"

URI_aarch64_amarok-doc = "${EPEL_MIRROR}/aarch64/Packages/a/amarok-doc-3.3.3-1.el10_3.noarch.rpm;name=aarch64_amarok-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_amarok-doc}"
SRC_URI[aarch64_amarok-doc.sha256sum] = "70bd885118a563eacae53d5f0a3ec97cfc536f0c92e4ed8f438aa0ec61c78052"

URI_aarch64_amarok-libs = "${EPEL_MIRROR}/aarch64/Packages/a/amarok-libs-3.3.3-1.el10_3.aarch64.rpm;name=aarch64_amarok-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_amarok-libs}"
SRC_URI[aarch64_amarok-libs.sha256sum] = "525ca3c227744c396d9ad617d24c37fcff894ff21f0489e2c369d1f61b57cfcc"

URI_aarch64_amarok-utils = "${EPEL_MIRROR}/aarch64/Packages/a/amarok-utils-3.3.3-1.el10_3.aarch64.rpm;name=aarch64_amarok-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_amarok-utils}"
SRC_URI[aarch64_amarok-utils.sha256sum] = "6fcbbc7de80d46265cc61bd20eefb1a814af8bfed1700f6145963b0dafc05751"

RDEPENDS:amarok = " \
 amarok-libs \
 amarok-utils \
 fftw-libs-double \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kwidgetsaddons \
 kf6-solid \
 kf6-threadweaver \
 libstdc++ \
 mariadb-connector-c \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 taglib \
 virtual/libmariadbd.so.19___64bit_ \
 "
RDEPENDS:amarok-doc = " \
 amarok \
 "
RDEPENDS:amarok-libs = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 kf6-karchive \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kstatusnotifieritem \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 kf6-threadweaver \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 qt6-qttools \
 taglib \
 "
RDEPENDS:amarok-utils = " \
 amarok-libs \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
