# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-hash"
PV = "0.20.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-hash+default-devel \
 rust-gix-hash+document-features-devel \
 rust-gix-hash+serde-devel \
 rust-gix-hash+sha1-devel \
 rust-gix-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-hash-0.20.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1af50c8cdc03ddc0822d6092f19a92efa33c52c073bf3678aa589a7af774eb31"

URI_x86_64_v2_rust-gix-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+default-devel-0.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+default-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+default-devel.sha256sum] = "4cc3e7f8665e01f9f8fa024ba5186ca3aecad4e031f5c96ad1e856c558ed46c8"

URI_x86_64_v2_rust-gix-hash+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+document-features-devel-0.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+document-features-devel.sha256sum] = "da92c05367c40eb9df2f8ef71d7d2e56481f11dd11cc3eb1d092a417baf47bf2"

URI_x86_64_v2_rust-gix-hash+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+serde-devel-0.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+serde-devel.sha256sum] = "f3f050ee6b11e74e96be0f6198a45195b355ddf54879cd07f17c71097c32fc31"

URI_x86_64_v2_rust-gix-hash+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+sha1-devel-0.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+sha1-devel.sha256sum] = "8723e3b10790aba53d5214f168c7915b19b6c0c5a43bc59b60bad1ffc4fdcb33"

URI_x86_64_v2_rust-gix-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash-devel-0.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash-devel}"
SRC_URI[x86_64_v2_rust-gix-hash-devel.sha256sum] = "6633177fd69187a59698bfcb3166ae51a912595580ad97a3819ead557741199c"

URI_aarch64_rust-gix-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+default-devel-0.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+default-devel}"
SRC_URI[aarch64_rust-gix-hash+default-devel.sha256sum] = "dced414590dde9c6abf117d6d4d58a00141642d365fdf8bd0c576b8aeef3fe76"

URI_aarch64_rust-gix-hash+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+document-features-devel-0.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-hash+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+document-features-devel}"
SRC_URI[aarch64_rust-gix-hash+document-features-devel.sha256sum] = "0f7b1ce2654b179509c10b821c6dbc29bd2e4f050f880821d83e5b1e22701954"

URI_aarch64_rust-gix-hash+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+serde-devel-0.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-hash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+serde-devel}"
SRC_URI[aarch64_rust-gix-hash+serde-devel.sha256sum] = "9dc9bcbf5eeef9504f772e59fb04c6541e92cffd569db9e004f85c888e7f0bd0"

URI_aarch64_rust-gix-hash+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+sha1-devel-0.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-hash+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+sha1-devel}"
SRC_URI[aarch64_rust-gix-hash+sha1-devel.sha256sum] = "6385dbcfb337a413605000bd02734080975a16f625d5b7d1cb7d0f6facc1c511"

URI_aarch64_rust-gix-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash-devel-0.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash-devel}"
SRC_URI[aarch64_rust-gix-hash-devel.sha256sum] = "7c5418572fa9209333db4bdb0f644ee4a38158e6e3e972b204bc92c6e7a2544d"

RDEPENDS:rust-gix-hash+default-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-hash-devel \
 "
RDEPENDS:rust-gix-hash+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-hash-devel \
 "
RDEPENDS:rust-gix-hash+serde-devel = " \
 cargo \
 rust-faster-hex+serde-devel \
 rust-gix-hash-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-hash+sha1-devel = " \
 cargo \
 rust-gix-hash-devel \
 "
RDEPENDS:rust-gix-hash-devel = " \
 cargo \
 rust \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-sha1-checked-devel \
 rust-thiserror+default-devel \
 "
