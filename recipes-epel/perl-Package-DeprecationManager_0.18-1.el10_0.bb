# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Package-DeprecationManager"
PV = "0.18"
PR = "1.el10_0"
PACKAGES = " \
 perl-Package-DeprecationManager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Package-DeprecationManager-0.18-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "722ea6abb5e70dda5aafef9b26d1cdfbd6600b75fb9895af2d8dbeb1af424d8f"

URI_x86_64_v2_perl-Package-DeprecationManager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Package-DeprecationManager-0.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Package-DeprecationManager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Package-DeprecationManager}"
SRC_URI[x86_64_v2_perl-Package-DeprecationManager.sha256sum] = "22e022abccbe6073f711e778d3adb73698ac2682ad83ebcfed0029fde5d4ae80"

URI_aarch64_perl-Package-DeprecationManager = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Package-DeprecationManager-0.18-1.el10_0.noarch.rpm;name=aarch64_perl-Package-DeprecationManager;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Package-DeprecationManager}"
SRC_URI[aarch64_perl-Package-DeprecationManager.sha256sum] = "90e81f69763271d9b7ce07fb05638f40188bb10d9adbe411083b0b945082d0ed"

RDEPENDS:perl-Package-DeprecationManager = " \
 perl-Carp \
 perl-Package-Stash \
 perl-Params-Util \
 perl-Scalar-List-Utils \
 perl-Sub-Install \
 perl-libs \
 "
