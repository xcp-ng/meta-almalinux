# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-sink"
PV = "0.3.31"
PR = "1.el10_0"
PACKAGES = " \
 rust-futures-sink+alloc-devel \
 rust-futures-sink+default-devel \
 rust-futures-sink+std-devel \
 rust-futures-sink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-sink-0.3.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e53bbed2c82ab6a75702aeb9875a9b801e3334cc8803c8c2f8dec9cae88c9bb"

URI_x86_64_v2_rust-futures-sink+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+alloc-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-sink+alloc-devel.sha256sum] = "4415eae63c700d477a6570393c6679eec65436f5cea0648d99410917ea476b5a"

URI_x86_64_v2_rust-futures-sink+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+default-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink+default-devel}"
SRC_URI[x86_64_v2_rust-futures-sink+default-devel.sha256sum] = "fad2ab3b6ee9c0a2408b313f3a98d5007fcccd12b5096b161e19e26ce974605f"

URI_x86_64_v2_rust-futures-sink+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+std-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink+std-devel}"
SRC_URI[x86_64_v2_rust-futures-sink+std-devel.sha256sum] = "a781da0c7631ef7d9acac2da5be84db36c10e340d7cb73743b3ae2e4464d8350"

URI_x86_64_v2_rust-futures-sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink-devel}"
SRC_URI[x86_64_v2_rust-futures-sink-devel.sha256sum] = "af670fd57c85c1fb1512a3479587a1ff7c1cc054fd6116b89ab485a38a3ef626"

URI_aarch64_rust-futures-sink+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+alloc-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-sink+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink+alloc-devel}"
SRC_URI[aarch64_rust-futures-sink+alloc-devel.sha256sum] = "0f1a8fbfd7bacb23ca2b75506a242f1bb468d03c2f89e9cfd9c188e18bece791"

URI_aarch64_rust-futures-sink+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+default-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-sink+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink+default-devel}"
SRC_URI[aarch64_rust-futures-sink+default-devel.sha256sum] = "d44adf8da5c5d3a17dae33e521fbf99c4b4deca8fcdaaa865fa1ad5e58fd518c"

URI_aarch64_rust-futures-sink+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+std-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-sink+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink+std-devel}"
SRC_URI[aarch64_rust-futures-sink+std-devel.sha256sum] = "60197c36f458c35a15018097b3285430c4a0aebb49634479175d248237029caa"

URI_aarch64_rust-futures-sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink-devel}"
SRC_URI[aarch64_rust-futures-sink-devel.sha256sum] = "a3c95af9790e540f7979693270f5472b40542338aca1e908c77f138faa27ca8b"

RDEPENDS:rust-futures-sink+alloc-devel = " \
 cargo \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink+default-devel = " \
 cargo \
 rust-futures-sink+std-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink+std-devel = " \
 cargo \
 rust-futures-sink+alloc-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink-devel = " \
 cargo \
 rust \
 "
