# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gitolite3"
PE = "1"
PV = "3.6.14"
PR = "2.el10_2"
PACKAGES = " \
 gitolite3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gitolite3-3.6.14-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37eec8be488aff5d6b5da4e10fdf3b94874f92a69f543bcbb1fa50df01c8e05d"

URI_x86_64_v2_gitolite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gitolite3-3.6.14-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gitolite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gitolite3}"
SRC_URI[x86_64_v2_gitolite3.sha256sum] = "2cdada0e6f57d9851727aeb47c1e6aec2d38347a8a93f812420385160c12ff15"

URI_aarch64_gitolite3 = "${EPEL_MIRROR}/aarch64/Packages/g/gitolite3-3.6.14-2.el10_2.noarch.rpm;name=aarch64_gitolite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_gitolite3}"
SRC_URI[aarch64_gitolite3.sha256sum] = "90e38d1167977ea97cd35a23c54c7664f64364f1f87c17de6be89a7e51c37cbe"

RDEPENDS:gitolite3 = " \
 bash \
 git \
 openssh-clients \
 perl-Carp \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Redis \
 perl-Storable \
 perl-Text-ParseWords \
 perl-Text-Tabs+Wrap \
 perl-Time-HiRes \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
