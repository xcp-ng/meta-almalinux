# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kirigami-addons"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kirigami-addons \
 kf6-kirigami-addons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kirigami-addons-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fca03b6a2b2225d69942f333dfe2e8e804e27510a8ae8b75376a982a306708a1"

URI_x86_64_v2_kf6-kirigami-addons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-addons-1.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-addons}"
SRC_URI[x86_64_v2_kf6-kirigami-addons.sha256sum] = "c2a6c4eec101c8f0c9b61ac50d29ba4bdc00392b98cedaa828ad4bfe7ae7c9aa"

URI_x86_64_v2_kf6-kirigami-addons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-addons-devel-1.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-addons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-addons-devel}"
SRC_URI[x86_64_v2_kf6-kirigami-addons-devel.sha256sum] = "5ab87876d0a3ec58a3ae002a430b002ba4811b857d3773bc68b648e232cb63f3"

URI_aarch64_kf6-kirigami-addons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-addons-1.7.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kirigami-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-addons}"
SRC_URI[aarch64_kf6-kirigami-addons.sha256sum] = "7bb63a496854d06cf5dd6a142cde6e5a50c74d515329a9ade08c757e8f3a79bb"

URI_aarch64_kf6-kirigami-addons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-addons-devel-1.7.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kirigami-addons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-addons-devel}"
SRC_URI[aarch64_kf6-kirigami-addons-devel.sha256sum] = "493e8db7a2c487c10d0bc47ca8fb16a69303bb6d126f4a1374dd080c9f739bda"

RDEPENDS:kf6-kirigami-addons = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kirigami-addons-devel = " \
 cmake-filesystem \
 kf6-kirigami-addons \
 "
