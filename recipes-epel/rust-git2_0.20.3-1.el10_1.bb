# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-git2"
PV = "0.20.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-git2+default-devel \
 rust-git2+https-devel \
 rust-git2+openssl-probe-devel \
 rust-git2+openssl-sys-devel \
 rust-git2+ssh-devel \
 rust-git2+unstable-devel \
 rust-git2+vendored-libgit2-devel \
 rust-git2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-git2-0.20.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "365767203dff42a547f37087a5bbfe0cf480172b285ac241e49ddf87ea4c8f1a"

URI_x86_64_v2_rust-git2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+default-devel-0.20.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+default-devel}"
SRC_URI[x86_64_v2_rust-git2+default-devel.sha256sum] = "02e6964eb9268525c0cbbb7e747fcefe8f021372cea005e1a89b6668899df0c2"

URI_x86_64_v2_rust-git2+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+https-devel-0.20.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+https-devel}"
SRC_URI[x86_64_v2_rust-git2+https-devel.sha256sum] = "c833015dee1cb4dfac5a4c532819cb815eb61edf90da295aaed3028576cfebbc"

URI_x86_64_v2_rust-git2+openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+openssl-probe-devel-0.20.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-git2+openssl-probe-devel.sha256sum] = "96fbcd33b39339b88412b44322a88c6861f7376a8e11b84e75b1c3ac0f4a6726"

URI_x86_64_v2_rust-git2+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+openssl-sys-devel-0.20.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-git2+openssl-sys-devel.sha256sum] = "05eab1423f44a9b383e4f2e9a2f06e6b89e72b79e27875d37dbc9b517e6cdc85"

URI_x86_64_v2_rust-git2+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+ssh-devel-0.20.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+ssh-devel}"
SRC_URI[x86_64_v2_rust-git2+ssh-devel.sha256sum] = "6278bcdf8be82d5ef4212e062c5550ca1740ed83b34600cd571fb59632c0d4e6"

URI_x86_64_v2_rust-git2+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+unstable-devel-0.20.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+unstable-devel}"
SRC_URI[x86_64_v2_rust-git2+unstable-devel.sha256sum] = "eb176afbd0080dc59af8a8f818d0c59d0d097cdbaca28de96fb9bae7e5e9439e"

URI_x86_64_v2_rust-git2+vendored-libgit2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+vendored-libgit2-devel-0.20.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+vendored-libgit2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+vendored-libgit2-devel}"
SRC_URI[x86_64_v2_rust-git2+vendored-libgit2-devel.sha256sum] = "3ee7999e3ca694a0b8de3137e4ac61cc719363880a828578dc911d614f150bd6"

URI_x86_64_v2_rust-git2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2-devel-0.20.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2-devel}"
SRC_URI[x86_64_v2_rust-git2-devel.sha256sum] = "40b2709f4689606630862bc044c0b43aadab690e03917286f725a45d7c41dc12"

URI_aarch64_rust-git2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+default-devel-0.20.3-1.el10_1.noarch.rpm;name=aarch64_rust-git2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+default-devel}"
SRC_URI[aarch64_rust-git2+default-devel.sha256sum] = "98d119cd1396b90205012d521cec501fa226eb751d3c2847f45a335d1997f1b0"

URI_aarch64_rust-git2+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+https-devel-0.20.3-1.el10_1.noarch.rpm;name=aarch64_rust-git2+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+https-devel}"
SRC_URI[aarch64_rust-git2+https-devel.sha256sum] = "63aa0a9d25d5ef2d85ad8ac05fd22a3e3b0d59ab31ac5ebce276ed751ca5d8d8"

URI_aarch64_rust-git2+openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+openssl-probe-devel-0.20.3-1.el10_1.noarch.rpm;name=aarch64_rust-git2+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+openssl-probe-devel}"
SRC_URI[aarch64_rust-git2+openssl-probe-devel.sha256sum] = "427a66f9af484ac947a8437df6135a5256714673e47cab7f5236938380023c39"

URI_aarch64_rust-git2+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+openssl-sys-devel-0.20.3-1.el10_1.noarch.rpm;name=aarch64_rust-git2+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+openssl-sys-devel}"
SRC_URI[aarch64_rust-git2+openssl-sys-devel.sha256sum] = "bd8cc8c3776e8df9e9eefc4a74be6bc12163390d0d498249ebba00a6c707a021"

URI_aarch64_rust-git2+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+ssh-devel-0.20.3-1.el10_1.noarch.rpm;name=aarch64_rust-git2+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+ssh-devel}"
SRC_URI[aarch64_rust-git2+ssh-devel.sha256sum] = "d8eb7456b542012479fdaaae97d4ba4c087d2d924d607aa2845758fab455238a"

URI_aarch64_rust-git2+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+unstable-devel-0.20.3-1.el10_1.noarch.rpm;name=aarch64_rust-git2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+unstable-devel}"
SRC_URI[aarch64_rust-git2+unstable-devel.sha256sum] = "d82272a8196e299688a1f13f318c5d3e9be2bf8b9765034c5ce75d919af67775"

URI_aarch64_rust-git2+vendored-libgit2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+vendored-libgit2-devel-0.20.3-1.el10_1.noarch.rpm;name=aarch64_rust-git2+vendored-libgit2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+vendored-libgit2-devel}"
SRC_URI[aarch64_rust-git2+vendored-libgit2-devel.sha256sum] = "f30ca2b48d4afd350882574f88b75164c8b71abf23a0ef412341ce5c3cbc8287"

URI_aarch64_rust-git2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2-devel-0.20.3-1.el10_1.noarch.rpm;name=aarch64_rust-git2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2-devel}"
SRC_URI[aarch64_rust-git2-devel.sha256sum] = "61fe3f306e1c613ef22f418b63b704c93bcf5d8578c1d3f0b59e3d27a93ad41b"

RDEPENDS:rust-git2+default-devel = " \
 cargo \
 rust-git2+https-devel \
 rust-git2+ssh-devel \
 rust-git2-devel \
 "
RDEPENDS:rust-git2+https-devel = " \
 cargo \
 rust-git2+openssl-probe-devel \
 rust-git2+openssl-sys-devel \
 rust-git2-devel \
 rust-libgit2-sys+https-devel \
 "
RDEPENDS:rust-git2+openssl-probe-devel = " \
 cargo \
 rust-git2-devel \
 rust-openssl-probe+default-devel \
 "
RDEPENDS:rust-git2+openssl-sys-devel = " \
 cargo \
 rust-git2-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-git2+ssh-devel = " \
 cargo \
 rust-git2-devel \
 rust-libgit2-sys+ssh-devel \
 "
RDEPENDS:rust-git2+unstable-devel = " \
 cargo \
 rust-git2-devel \
 "
RDEPENDS:rust-git2+vendored-libgit2-devel = " \
 cargo \
 rust-git2-devel \
 rust-libgit2-sys+vendored-devel \
 "
RDEPENDS:rust-git2-devel = " \
 bash \
 cargo \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys+default-devel \
 rust-log+default-devel \
 rust-url+default-devel \
 "
