# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "supernovas"
PV = "1.7.2"
PR = "2.el10_3"
PACKAGES = " \
 supernovas \
 supernovas-c++ \
 supernovas-devel \
 supernovas-doc \
 supernovas-solsys-calceph \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/supernovas-1.7.2-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04b2c9af91c532dafce096ae240306e120f2bf3bd10e02ebf01143bed12ad445"

URI_x86_64_v2_supernovas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-1.7.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas}"
SRC_URI[x86_64_v2_supernovas.sha256sum] = "0616c3f9bddc423f7b7960db94ed23fa53cd88a1d1af05d91205b80e3006e91c"

URI_x86_64_v2_supernovas-c++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-c++-1.7.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-c++}"
SRC_URI[x86_64_v2_supernovas-c++.sha256sum] = "590dc4cfb9fa6a12cb3249a6edfefc6e916e717903927cd5308e66ae06893360"

URI_x86_64_v2_supernovas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-devel-1.7.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-devel}"
SRC_URI[x86_64_v2_supernovas-devel.sha256sum] = "07915e3cc16f149b009c5f26c151e6d1ca36ec9b39d6e9ad655cced43eceaf92"

URI_x86_64_v2_supernovas-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-doc-1.7.2-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_supernovas-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-doc}"
SRC_URI[x86_64_v2_supernovas-doc.sha256sum] = "28f9640cd8bbd329b47089381fc6a2e957240cbd3a73bf9558f6738bd6620382"

URI_x86_64_v2_supernovas-solsys-calceph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/supernovas-solsys-calceph-1.7.2-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_supernovas-solsys-calceph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supernovas-solsys-calceph}"
SRC_URI[x86_64_v2_supernovas-solsys-calceph.sha256sum] = "06f2d590ca3bf6d47ff837af92f59aa0f4d0077c8a38d5aa2e9f2d6632994437"

URI_aarch64_supernovas = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-1.7.2-2.el10_3.aarch64.rpm;name=aarch64_supernovas;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas}"
SRC_URI[aarch64_supernovas.sha256sum] = "edfde1becae7282d13262177d71cb6e8f164a54b33565b73d98190f472479fa4"

URI_aarch64_supernovas-c++ = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-c++-1.7.2-2.el10_3.aarch64.rpm;name=aarch64_supernovas-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-c++}"
SRC_URI[aarch64_supernovas-c++.sha256sum] = "2afa6feb070e2ae5902f0ab573c214ab2073beba1073f899e605718c9269eb62"

URI_aarch64_supernovas-devel = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-devel-1.7.2-2.el10_3.aarch64.rpm;name=aarch64_supernovas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-devel}"
SRC_URI[aarch64_supernovas-devel.sha256sum] = "b6f795d3fade9de69343f9c8cba4eec42928098c22f4e511528014caa3a88902"

URI_aarch64_supernovas-doc = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-doc-1.7.2-2.el10_3.noarch.rpm;name=aarch64_supernovas-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-doc}"
SRC_URI[aarch64_supernovas-doc.sha256sum] = "853b733671ee91c54eae863b59c87e226c7a9387ce3b0d684c9928c3ab94d4c5"

URI_aarch64_supernovas-solsys-calceph = "${EPEL_MIRROR}/aarch64/Packages/s/supernovas-solsys-calceph-1.7.2-2.el10_3.aarch64.rpm;name=aarch64_supernovas-solsys-calceph;unpack=0"
SRC_URI:append = " ${URI_aarch64_supernovas-solsys-calceph}"
SRC_URI[aarch64_supernovas-solsys-calceph.sha256sum] = "4c3ac9bfd0d287f296dedcec0367f3277bc47638685369309e739105bf07b103"

RDEPENDS:supernovas = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:supernovas-c++ = " \
 glibc \
 libgcc \
 libstdc++ \
 supernovas \
 "
RDEPENDS:supernovas-devel = " \
 cmake-filesystem \
 libcurl-devel \
 pkgconf-pkg-config \
 supernovas \
 supernovas-c++ \
 supernovas-solsys-calceph \
 "
RDEPENDS:supernovas-doc = " \
 "
RDEPENDS:supernovas-solsys-calceph = " \
 calceph-libs \
 glibc \
 supernovas \
 "
