# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lsvpd"
PV = "1.7.15"
PR = "7.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lsvpd-1.7.15-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a128b732bac5b77432b41dcbd58f5dae46fabb1dac1606397fb3a6f06c553bd3"

