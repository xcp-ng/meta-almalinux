# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-config"
PV = "0.43.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-config+default-devel \
 rust-gix-config+document-features-devel \
 rust-gix-config+serde-devel \
 rust-gix-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-config-0.43.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78c8d7cc1329373fb519735b1e1f651effa8054543b56fddc03a488ea2109dbc"

URI_x86_64_v2_rust-gix-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+default-devel-0.43.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+default-devel}"
SRC_URI[x86_64_v2_rust-gix-config+default-devel.sha256sum] = "fae51298f21d30f109277b7840d71491019bbd318d4c1c95bc35d0151f28a058"

URI_x86_64_v2_rust-gix-config+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+document-features-devel-0.43.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-config+document-features-devel.sha256sum] = "125084390b79d5fcc60f08c805d61e76a5c930a621a20ff33857d8a25a53ddc8"

URI_x86_64_v2_rust-gix-config+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+serde-devel-0.43.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-config+serde-devel.sha256sum] = "bbdfeb95ff13f7ef389ab620c3840e205934c9c13b8fffd974dd5389096c80ce"

URI_x86_64_v2_rust-gix-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-devel-0.43.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-devel}"
SRC_URI[x86_64_v2_rust-gix-config-devel.sha256sum] = "ccdcd575d17cd17557ddd1f6552234d54b319af9cc1781b0886730e2b18c2012"

URI_aarch64_rust-gix-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+default-devel-0.43.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+default-devel}"
SRC_URI[aarch64_rust-gix-config+default-devel.sha256sum] = "aa4b8303906e7d3ecb4d8865e27b3a838304227839208afa3752944c560cc6a6"

URI_aarch64_rust-gix-config+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+document-features-devel-0.43.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-config+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+document-features-devel}"
SRC_URI[aarch64_rust-gix-config+document-features-devel.sha256sum] = "c222fd98888f676396366dc6c910dbeec190d0c699ac109a6ef767c74d9dbba0"

URI_aarch64_rust-gix-config+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+serde-devel-0.43.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-config+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+serde-devel}"
SRC_URI[aarch64_rust-gix-config+serde-devel.sha256sum] = "4b12bf6fa84d6fead178ce6c70adfc753264f6d11679f365c1f92bfbe3ac5c88"

URI_aarch64_rust-gix-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-devel-0.43.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-devel}"
SRC_URI[aarch64_rust-gix-config-devel.sha256sum] = "700c1d5ac52dfbd21c2317ca1ed7d9f32dc754e987e2fb27207ce833e8775a81"

RDEPENDS:rust-gix-config+default-devel = " \
 cargo \
 rust-gix-config-devel \
 "
RDEPENDS:rust-gix-config+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-config-devel \
 "
RDEPENDS:rust-gix-config+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-config-devel \
 rust-gix-config-value+serde-devel \
 rust-gix-glob+serde-devel \
 rust-gix-ref+serde-devel \
 rust-gix-sec+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-config-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-config-value+default-devel \
 rust-gix-features+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-sec+default-devel \
 rust-memchr+default-devel \
 rust-once_cell+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-bom+default-devel \
 rust-winnow0.6+default-devel \
 rust-winnow0.6+simd-devel \
 "
