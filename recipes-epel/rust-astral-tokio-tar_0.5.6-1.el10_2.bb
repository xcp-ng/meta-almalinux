# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral-tokio-tar"
PV = "0.5.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-astral-tokio-tar+default-devel \
 rust-astral-tokio-tar+xattr-devel \
 rust-astral-tokio-tar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral-tokio-tar-0.5.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "237c41dcbae47f23aec761ab19000d14ed0b32e25c7e9fe5e86be636d53c58d1"

URI_x86_64_v2_rust-astral-tokio-tar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tokio-tar+default-devel-0.5.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tokio-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tokio-tar+default-devel}"
SRC_URI[x86_64_v2_rust-astral-tokio-tar+default-devel.sha256sum] = "e2a2a481b3deff29d56b014f6441c2cf189aa22dae120788b9479fa59e1c83d3"

URI_x86_64_v2_rust-astral-tokio-tar+xattr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tokio-tar+xattr-devel-0.5.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tokio-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tokio-tar+xattr-devel}"
SRC_URI[x86_64_v2_rust-astral-tokio-tar+xattr-devel.sha256sum] = "53108868d032280aeba48b95c46614c89502c08a536fe6bd54fda63e422d8bce"

URI_x86_64_v2_rust-astral-tokio-tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tokio-tar-devel-0.5.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tokio-tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tokio-tar-devel}"
SRC_URI[x86_64_v2_rust-astral-tokio-tar-devel.sha256sum] = "6fdc1564a2aec31f358836b94fb1a6c80e8bc69f70a2c11ea63941ad72708018"

URI_aarch64_rust-astral-tokio-tar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tokio-tar+default-devel-0.5.6-1.el10_2.noarch.rpm;name=aarch64_rust-astral-tokio-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tokio-tar+default-devel}"
SRC_URI[aarch64_rust-astral-tokio-tar+default-devel.sha256sum] = "6895e11d0bd0ad2eb67fbd386842f0fad7575e2d5a37d0e251ce6563c108af1e"

URI_aarch64_rust-astral-tokio-tar+xattr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tokio-tar+xattr-devel-0.5.6-1.el10_2.noarch.rpm;name=aarch64_rust-astral-tokio-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tokio-tar+xattr-devel}"
SRC_URI[aarch64_rust-astral-tokio-tar+xattr-devel.sha256sum] = "b17f94730790a6d773d7b894392e0927c2ed59de9a4586246d07d847dcde0006"

URI_aarch64_rust-astral-tokio-tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tokio-tar-devel-0.5.6-1.el10_2.noarch.rpm;name=aarch64_rust-astral-tokio-tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tokio-tar-devel}"
SRC_URI[aarch64_rust-astral-tokio-tar-devel.sha256sum] = "6d207c7e3fcb4d5581dd19fd66ccb03e069758abc1d05a84530af85688020f84"

RDEPENDS:rust-astral-tokio-tar+default-devel = " \
 cargo \
 rust-astral-tokio-tar+xattr-devel \
 rust-astral-tokio-tar-devel \
 "
RDEPENDS:rust-astral-tokio-tar+xattr-devel = " \
 cargo \
 rust-astral-tokio-tar-devel \
 rust-xattr+default-devel \
 "
RDEPENDS:rust-astral-tokio-tar-devel = " \
 bash \
 cargo \
 rust \
 rust-filetime+default-devel \
 rust-futures-core+default-devel \
 rust-libc+default-devel \
 rust-portable-atomic+default-devel \
 rust-rustc-hash+default-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+rt-devel \
 rust-tokio-stream+default-devel \
 "
