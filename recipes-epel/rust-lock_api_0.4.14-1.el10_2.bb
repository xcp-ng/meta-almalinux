# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lock_api"
PV = "0.4.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-lock_api+arc_lock-devel \
 rust-lock_api+atomic_usize-devel \
 rust-lock_api+default-devel \
 rust-lock_api+nightly-devel \
 rust-lock_api+owning_ref-devel \
 rust-lock_api+serde-devel \
 rust-lock_api-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lock_api-0.4.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ede2fb98351eb9c3f17d9c8f54c31580c04172e050660c1a048acb0f027fb4eb"

URI_x86_64_v2_rust-lock_api+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+arc_lock-devel-0.4.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-lock_api+arc_lock-devel.sha256sum] = "f0b3a4a0f2e0bd80999f5c05318205b2acca5164ba0157ba06a4d17d9202b33c"

URI_x86_64_v2_rust-lock_api+atomic_usize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+atomic_usize-devel-0.4.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+atomic_usize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+atomic_usize-devel}"
SRC_URI[x86_64_v2_rust-lock_api+atomic_usize-devel.sha256sum] = "ec082afd32581f102b9c8738579877ba90ef89660037bda624b41a79c02b13e8"

URI_x86_64_v2_rust-lock_api+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+default-devel-0.4.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+default-devel}"
SRC_URI[x86_64_v2_rust-lock_api+default-devel.sha256sum] = "4e428b83d71d2b48bce298006494ae3036e14e286c039639d79faf04224cb5df"

URI_x86_64_v2_rust-lock_api+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+nightly-devel-0.4.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+nightly-devel}"
SRC_URI[x86_64_v2_rust-lock_api+nightly-devel.sha256sum] = "a329b97582b4342c4ab8bcaaae0a14cf70e5e6ec13c98ada59ec257f284f2028"

URI_x86_64_v2_rust-lock_api+owning_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+owning_ref-devel-0.4.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+owning_ref-devel}"
SRC_URI[x86_64_v2_rust-lock_api+owning_ref-devel.sha256sum] = "77d9d656d43cbef7d3a5d8f978f066dee8b5025ae4b0a93766cf2fd55682fa25"

URI_x86_64_v2_rust-lock_api+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api+serde-devel-0.4.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api+serde-devel}"
SRC_URI[x86_64_v2_rust-lock_api+serde-devel.sha256sum] = "e8267151d65e5fe770a65af931b388899e77a53f7a597adef779b0a73a907a63"

URI_x86_64_v2_rust-lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lock_api-devel-0.4.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lock_api-devel}"
SRC_URI[x86_64_v2_rust-lock_api-devel.sha256sum] = "20713395377d56724097a704abba9294bf1a237eb62bd81d4e512ea22aed0480"

URI_aarch64_rust-lock_api+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+arc_lock-devel-0.4.14-1.el10_2.noarch.rpm;name=aarch64_rust-lock_api+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+arc_lock-devel}"
SRC_URI[aarch64_rust-lock_api+arc_lock-devel.sha256sum] = "8a15b0125a9b33bf88ec407ec15a66262d0918c68edb4b4c9e21ad8cc833939f"

URI_aarch64_rust-lock_api+atomic_usize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+atomic_usize-devel-0.4.14-1.el10_2.noarch.rpm;name=aarch64_rust-lock_api+atomic_usize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+atomic_usize-devel}"
SRC_URI[aarch64_rust-lock_api+atomic_usize-devel.sha256sum] = "a59c7577c9bbcbdf0f52c96bc4a488efa5fcf8819bd189c6ddf5bd182ed900be"

URI_aarch64_rust-lock_api+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+default-devel-0.4.14-1.el10_2.noarch.rpm;name=aarch64_rust-lock_api+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+default-devel}"
SRC_URI[aarch64_rust-lock_api+default-devel.sha256sum] = "6a6fc0a1e862d184ca129e41ecbf283fbdf96ab39021c5837fa6235e7f6e3ca9"

URI_aarch64_rust-lock_api+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+nightly-devel-0.4.14-1.el10_2.noarch.rpm;name=aarch64_rust-lock_api+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+nightly-devel}"
SRC_URI[aarch64_rust-lock_api+nightly-devel.sha256sum] = "a61965ab2638c286ffbb4a514489880088796525aedc6046c63f654cb69d26ce"

URI_aarch64_rust-lock_api+owning_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+owning_ref-devel-0.4.14-1.el10_2.noarch.rpm;name=aarch64_rust-lock_api+owning_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+owning_ref-devel}"
SRC_URI[aarch64_rust-lock_api+owning_ref-devel.sha256sum] = "48d1210e3209bcde6f41883fbd6f5566009f24c2dfa329668379185bfdc74dd5"

URI_aarch64_rust-lock_api+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api+serde-devel-0.4.14-1.el10_2.noarch.rpm;name=aarch64_rust-lock_api+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api+serde-devel}"
SRC_URI[aarch64_rust-lock_api+serde-devel.sha256sum] = "d05528be2fcac88a22ea387726dcf352125741dcad57f9fceaf24141e9890c22"

URI_aarch64_rust-lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lock_api-devel-0.4.14-1.el10_2.noarch.rpm;name=aarch64_rust-lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lock_api-devel}"
SRC_URI[aarch64_rust-lock_api-devel.sha256sum] = "d83c6b32c2903614f06052d82bdd9700712d40c635e886c0d1ef3f911d52eb67"

RDEPENDS:rust-lock_api+arc_lock-devel = " \
 cargo \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+atomic_usize-devel = " \
 cargo \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+default-devel = " \
 cargo \
 rust-lock_api+atomic_usize-devel \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+nightly-devel = " \
 cargo \
 rust-lock_api-devel \
 "
RDEPENDS:rust-lock_api+owning_ref-devel = " \
 cargo \
 rust-lock_api-devel \
 rust-owning_ref+default-devel \
 "
RDEPENDS:rust-lock_api+serde-devel = " \
 cargo \
 rust-lock_api-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-lock_api-devel = " \
 cargo \
 rust \
 rust-scopeguard-devel \
 "
