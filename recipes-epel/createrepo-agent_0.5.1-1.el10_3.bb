# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "createrepo-agent"
PV = "0.5.1"
PR = "1.el10_3"
PACKAGES = " \
 createrepo-agent \
 python3-createrepo-agent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/createrepo-agent-0.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3499fb3ea6b9dc0816cf5e8f849fb0c9d79be1b12d9f4d76793cb3a0ad16090"

URI_x86_64_v2_createrepo-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/createrepo-agent-0.5.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_createrepo-agent}"
SRC_URI[x86_64_v2_createrepo-agent.sha256sum] = "4ee71e64197671001ee1e7598752649585147e63f4726717537fc3a274f56caf"

URI_x86_64_v2_python3-createrepo-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-createrepo-agent-0.5.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-createrepo-agent}"
SRC_URI[x86_64_v2_python3-createrepo-agent.sha256sum] = "d96d1d96cd199ab6ca827c80b1bdbfb212238c4322ebb65d38df270bb0ed5a47"

URI_aarch64_createrepo-agent = "${EPEL_MIRROR}/aarch64/Packages/c/createrepo-agent-0.5.1-1.el10_3.aarch64.rpm;name=aarch64_createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_createrepo-agent}"
SRC_URI[aarch64_createrepo-agent.sha256sum] = "6731ea827fd5b578c5674da2b10a567ebb34a611c3a550235f0b5423fde61a34"

URI_aarch64_python3-createrepo-agent = "${EPEL_MIRROR}/aarch64/Packages/p/python3-createrepo-agent-0.5.1-1.el10_3.aarch64.rpm;name=aarch64_python3-createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-createrepo-agent}"
SRC_URI[aarch64_python3-createrepo-agent.sha256sum] = "e3e9d884f44df70187292f31cd3580bb3a91854d84aec8ea1ecf07edf26d8855"

RDEPENDS:createrepo-agent = " \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme \
 libassuan \
 libgpg-error \
 "
RDEPENDS:python3-createrepo-agent = " \
 createrepo-agent \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme \
 libassuan \
 libgpg-error \
 python3 \
 "
