# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gridftp-server-control"
PV = "9.5"
PR = "1.el10_2"
PACKAGES = " \
 globus-gridftp-server-control \
 globus-gridftp-server-control-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gridftp-server-control-9.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d932a94f4fc3207a0dc943ea2250b2563ceb864e5752810ee2c80c1ca6b957f3"

URI_x86_64_v2_globus-gridftp-server-control = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-control-9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server-control;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridftp-server-control}"
SRC_URI[x86_64_v2_globus-gridftp-server-control.sha256sum] = "adc3e570787537be85165d0aa7d9a6a88ae79627600f001c51e22dc12c9f426a"

URI_x86_64_v2_globus-gridftp-server-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-control-devel-9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridftp-server-control-devel}"
SRC_URI[x86_64_v2_globus-gridftp-server-control-devel.sha256sum] = "a0f0a3fa6f9854adb96fa0cf4839e4d68e81f0fb2cbf47cdb8e7744d6b77ca6d"

URI_aarch64_globus-gridftp-server-control = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-control-9.5-1.el10_2.aarch64.rpm;name=aarch64_globus-gridftp-server-control;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridftp-server-control}"
SRC_URI[aarch64_globus-gridftp-server-control.sha256sum] = "9ed61c3c4cb96d84c96de9b1fde788c807221e143d2f3598c9bfd2aaf29a41e8"

URI_aarch64_globus-gridftp-server-control-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-control-devel-9.5-1.el10_2.aarch64.rpm;name=aarch64_globus-gridftp-server-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridftp-server-control-devel}"
SRC_URI[aarch64_globus-gridftp-server-control-devel.sha256sum] = "55aed6e226e83a56582f5c899355d38c3381c8019469a6ed9361ae50f693568a"

RDEPENDS:globus-gridftp-server-control = " \
 glibc \
 globus-common \
 globus-gsi-openssl-error \
 globus-gss-assist \
 globus-gssapi-error \
 globus-gssapi-gsi \
 globus-xio \
 globus-xio-gsi-driver \
 globus-xio-pipe-driver \
 "
RDEPENDS:globus-gridftp-server-control-devel = " \
 globus-common-devel \
 globus-gridftp-server-control \
 globus-gsi-openssl-error-devel \
 globus-gss-assist-devel \
 globus-gssapi-error-devel \
 globus-gssapi-gsi-devel \
 globus-xio-devel \
 globus-xio-gsi-driver-devel \
 globus-xio-pipe-driver-devel \
 pkgconf-pkg-config \
 "
