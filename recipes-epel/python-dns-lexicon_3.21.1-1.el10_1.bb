# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dns-lexicon"
PV = "3.21.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-dns-lexicon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dns-lexicon-3.21.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3311448705289e4e16d4114b56149e819a43dbec9d6f36319537cbbbb8e8dbd"

URI_x86_64_v2_python3-dns-lexicon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dns-lexicon-3.21.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dns-lexicon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dns-lexicon}"
SRC_URI[x86_64_v2_python3-dns-lexicon.sha256sum] = "3556d1a092305d3a46070ff90dce289fdcae05f64f02c04a9cd8438afa17a515"

URI_aarch64_python3-dns-lexicon = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dns-lexicon-3.21.1-1.el10_1.noarch.rpm;name=aarch64_python3-dns-lexicon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dns-lexicon}"
SRC_URI[aarch64_python3-dns-lexicon.sha256sum] = "3db09c9b36bddd075304ed857b7ef911660346af825894da4a78d7770707e99d"

RDEPENDS:python3-dns-lexicon = " \
 python3 \
 python3-beautifulsoup4 \
 python3-cryptography \
 python3-dns \
 python3-pyotp \
 python3-pyyaml \
 python3-requests \
 python3-tldextract \
 "
