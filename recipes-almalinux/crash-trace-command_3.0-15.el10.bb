# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crash-trace-command"
PV = "3.0"
PR = "15.el10"
PACKAGES = " \
 crash-trace-command \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crash-trace-command-3.0-15.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "955a0706a6c1e584ca877c8d4df999b557b69800b4842f421b9967a89ef26f12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crash-trace-command-3.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_crash-trace-command;unpack=0"
SRC_URI[x86_64_v2_crash-trace-command.sha256sum] = "f659d0e8ae50116f83a25ef1bda471cd6741e119e9eda77c6310d2bfd1e82ec9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crash-trace-command-3.0-15.el10.aarch64.rpm;name=aarch64_crash-trace-command;unpack=0"
SRC_URI[aarch64_crash-trace-command.sha256sum] = "1c968b95bc96e095d1d3c81eb13d8802a908750e232dc77b93d7893d6dbed0ee"

RDEPENDS:crash-trace-command = " \
 crash \
 glibc \
 trace-cmd \
 "
