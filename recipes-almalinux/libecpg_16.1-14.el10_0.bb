# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libecpg"
PV = "16.1"
PR = "14.el10_0"
PACKAGES = " \
 libecpg \
 libecpg-devel \
 libpgtypes \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libecpg-16.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5360f9ee85e182b17865958a74e712fc17860ddf58b216d64c96fe3e0cd144a"

URI_x86_64_v2_libecpg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libecpg-16.1-14.el10_0.x86_64_v2.rpm;name=x86_64_v2_libecpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libecpg}"
SRC_URI[x86_64_v2_libecpg.sha256sum] = "89fec9585275e5e74e188f60b117418376478bb98acda1d4f3c054fc06095671"

URI_x86_64_v2_libecpg-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libecpg-devel-16.1-14.el10_0.x86_64_v2.rpm;name=x86_64_v2_libecpg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libecpg-devel}"
SRC_URI[x86_64_v2_libecpg-devel.sha256sum] = "ef1f86222de72f57980c3c6427339bc90434783512c9978f1ad9a42b63fcbea2"

URI_x86_64_v2_libpgtypes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpgtypes-16.1-14.el10_0.x86_64_v2.rpm;name=x86_64_v2_libpgtypes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpgtypes}"
SRC_URI[x86_64_v2_libpgtypes.sha256sum] = "77271110eaa19526855b49f4bbb0791f275aecb999d86ed316acba6caa5de8af"

URI_aarch64_libecpg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libecpg-16.1-14.el10_0.aarch64.rpm;name=aarch64_libecpg;unpack=0"
SRC_URI:append = " ${URI_aarch64_libecpg}"
SRC_URI[aarch64_libecpg.sha256sum] = "cad6dd1594f5557051fe329b39d47c40a8c0e49f1a8857f39665d7e10620869f"

URI_aarch64_libecpg-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libecpg-devel-16.1-14.el10_0.aarch64.rpm;name=aarch64_libecpg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libecpg-devel}"
SRC_URI[aarch64_libecpg-devel.sha256sum] = "901ed3204b10d796fcfde5e7c6d76e155e9fac031015c8a2bcd4b805f83a1530"

URI_aarch64_libpgtypes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpgtypes-16.1-14.el10_0.aarch64.rpm;name=aarch64_libpgtypes;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpgtypes}"
SRC_URI[aarch64_libpgtypes.sha256sum] = "ddbe85e00912b80efbac1265cee5cf6c7640772564a0717d06cb6eccd057a6bc"

RDEPENDS:libecpg = " \
 glibc \
 libpgtypes \
 libpq \
 "
RDEPENDS:libecpg-devel = " \
 glibc \
 libecpg \
 libecpg-devel \
 libpgtypes \
 libpq-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libpgtypes = " \
 glibc \
 "
