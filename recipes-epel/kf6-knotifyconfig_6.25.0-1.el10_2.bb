# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knotifyconfig"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-knotifyconfig \
 kf6-knotifyconfig-devel \
 kf6-knotifyconfig-doc \
 kf6-knotifyconfig-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knotifyconfig-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3282d97f575c62e2ec92637f3df9fde3ac49455df0a80dd9ea0eb69152b4b02"

URI_x86_64_v2_kf6-knotifyconfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifyconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig}"
SRC_URI[x86_64_v2_kf6-knotifyconfig.sha256sum] = "406d60e5da30a870a058a282640573662f752393095f4062d0133a51dd388d36"

URI_x86_64_v2_kf6-knotifyconfig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifyconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-devel}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-devel.sha256sum] = "ce7f37b53e25af8d48059834ed09ce82a53ca1da685543f05b5996c6c1407ed6"

URI_x86_64_v2_kf6-knotifyconfig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifyconfig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-doc}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-doc.sha256sum] = "6f482594c0a907d23057340c00061f8b319265f9a640a1d93c677c7c822f2290"

URI_x86_64_v2_kf6-knotifyconfig-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifyconfig-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-html}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-html.sha256sum] = "9815ef813df65c6e79410c73d981dcfc9640b2d38c30e8413facaf5d9f3bef1d"

URI_aarch64_kf6-knotifyconfig = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-knotifyconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig}"
SRC_URI[aarch64_kf6-knotifyconfig.sha256sum] = "73382600826d912e5829e963a34e787f83b2c12f9e455630df77ecb52f1d1893"

URI_aarch64_kf6-knotifyconfig-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-knotifyconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-devel}"
SRC_URI[aarch64_kf6-knotifyconfig-devel.sha256sum] = "377d0bd81320184504403a7b784e7b1138fc33a62caa4c502a695692ee71b13c"

URI_aarch64_kf6-knotifyconfig-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-knotifyconfig-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-doc}"
SRC_URI[aarch64_kf6-knotifyconfig-doc.sha256sum] = "d1b3bf51039a1af8616e7cc73e27495037f462e0298bd54a597a74d0dfa209a1"

URI_aarch64_kf6-knotifyconfig-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-knotifyconfig-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-html}"
SRC_URI[aarch64_kf6-knotifyconfig-html.sha256sum] = "3e142579eeee8f5e7960f5384feb7dacadc54c94a74437f8bfc1a303493a6858"

RDEPENDS:kf6-knotifyconfig = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 libcanberra \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-knotifyconfig-devel = " \
 cmake-filesystem \
 kf6-knotifyconfig \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-knotifyconfig-doc = " \
 "
RDEPENDS:kf6-knotifyconfig-html = " \
 "
