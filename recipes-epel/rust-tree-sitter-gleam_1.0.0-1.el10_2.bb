# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-gleam"
PV = "1.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-gleam+default-devel \
 rust-tree-sitter-gleam-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-gleam-1.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c55e069735c8af6d73d2bf93bb263e0c203aefe0afe7111dfdce76dbebc33864"

URI_x86_64_v2_rust-tree-sitter-gleam+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-gleam+default-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-gleam+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-gleam+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-gleam+default-devel.sha256sum] = "a0c2f694fc481efbd8e2c30a83fadac08cb4d4a9885bdbc499e49aa9dc59f865"

URI_x86_64_v2_rust-tree-sitter-gleam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-gleam-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-gleam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-gleam-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-gleam-devel.sha256sum] = "6a854bcfc105563da91505a9c39a882314b2be3ded412f5f8da33142193db64a"

URI_aarch64_rust-tree-sitter-gleam+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-gleam+default-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-gleam+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-gleam+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-gleam+default-devel.sha256sum] = "7f798ca94c0ba336da5bc3f571da547dc19b30b31468b78951957899edd529f2"

URI_aarch64_rust-tree-sitter-gleam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-gleam-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-gleam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-gleam-devel}"
SRC_URI[aarch64_rust-tree-sitter-gleam-devel.sha256sum] = "b5b53a57012056613443978541278d419d155495f8844f96ed15b267270a814e"

RDEPENDS:rust-tree-sitter-gleam+default-devel = " \
 cargo \
 rust-tree-sitter-gleam-devel \
 "
RDEPENDS:rust-tree-sitter-gleam-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
