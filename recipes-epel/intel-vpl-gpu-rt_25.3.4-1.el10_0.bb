# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-vpl-gpu-rt"
PV = "25.3.4"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 intel-vpl-gpu-rt \
 intel-vpl-gpu-rt-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-vpl-gpu-rt-25.3.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3decd17e9fe3cdcc83cbe1faf6f4161f8ac4c91cef9edc9310c7ee87e97f2ef6"

URI_x86_64_v2_intel-vpl-gpu-rt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-vpl-gpu-rt-25.3.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-vpl-gpu-rt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-vpl-gpu-rt}"
SRC_URI[x86_64_v2_intel-vpl-gpu-rt.sha256sum] = "3c265501cc3a36030c393e31f68d52ef8c0c5444f164fe720db7691c23e8be40"

URI_x86_64_v2_intel-vpl-gpu-rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-vpl-gpu-rt-devel-25.3.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-vpl-gpu-rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-vpl-gpu-rt-devel}"
SRC_URI[x86_64_v2_intel-vpl-gpu-rt-devel.sha256sum] = "4d2dd21194bc2ee0c6b4a2581f3b08bdb6fe0dc44e451b9e312704d203945739"

RDEPENDS:intel-vpl-gpu-rt = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libva \
 libvpl \
 "
RDEPENDS:intel-vpl-gpu-rt-devel = " \
 intel-vpl-gpu-rt \
 pkgconf-pkg-config \
 "
