# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openldap"
PV = "2.6.9"
PR = "1.el10"
PACKAGES = " \
 openldap \
 openldap-clients \
 openldap-compat \
 openldap-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openldap-2.6.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "faecfb77b2793bbc17896e7ea30889f4911b1e69d23d0733d9d0af76d4ff94d8"

URI_x86_64_v2_openldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-2.6.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap}"
SRC_URI[x86_64_v2_openldap.sha256sum] = "790682cc18bd2276e437ea5ef5c2463f39bf9443b33d44aff29a9b58559c5b04"

URI_x86_64_v2_openldap-clients = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-clients-2.6.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-clients}"
SRC_URI[x86_64_v2_openldap-clients.sha256sum] = "43559bfcbc55d51207a29f894f6f121552b13505baf740fa2432880b1048b29c"

URI_x86_64_v2_openldap-compat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-compat-2.6.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-compat}"
SRC_URI[x86_64_v2_openldap-compat.sha256sum] = "de452a10d37e0998fe8152f2d83c9b697a443f3ca0d332496bb9e131eba24f82"

URI_x86_64_v2_openldap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openldap-devel-2.6.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-devel}"
SRC_URI[x86_64_v2_openldap-devel.sha256sum] = "1cd5772494398f86d38881a3354b5a97df9ac0e03d9be6493d9441824d5a30c9"

URI_aarch64_openldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-2.6.9-1.el10.aarch64.rpm;name=aarch64_openldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap}"
SRC_URI[aarch64_openldap.sha256sum] = "501e294ed1b805471cb2e0bbafb5cfd197d12563fb1d2535c7cfc1ad997b8f69"

URI_aarch64_openldap-clients = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-clients-2.6.9-1.el10.aarch64.rpm;name=aarch64_openldap-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-clients}"
SRC_URI[aarch64_openldap-clients.sha256sum] = "5448741e73a55e788b9e03bb7ca155fa848af5ac77b72a3cd3b97b8284538818"

URI_aarch64_openldap-compat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-compat-2.6.9-1.el10.aarch64.rpm;name=aarch64_openldap-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-compat}"
SRC_URI[aarch64_openldap-compat.sha256sum] = "ae175818cc67620f53a7546f3126cc5509d68b1bc6fccb9182952cb842a5d3c9"

URI_aarch64_openldap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openldap-devel-2.6.9-1.el10.aarch64.rpm;name=aarch64_openldap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-devel}"
SRC_URI[aarch64_openldap-devel.sha256sum] = "8a288a64898ad66daebf1cd80f4cd22c6f642024e3715a8dc9e062a615f7bc8c"

RDEPENDS:openldap = " \
 cyrus-sasl-lib \
 glibc \
 libevent \
 openssl-libs \
 shadow-utils \
 "
RDEPENDS:openldap-clients = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 "
RDEPENDS:openldap-compat = " \
 glibc \
 openldap \
 "
RDEPENDS:openldap-devel = " \
 cyrus-sasl-devel \
 openldap \
 openldap-devel \
 pkgconf-pkg-config \
 "
