# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-utils"
PV = "1.2.14"
PR = "2.el10"
PACKAGES = " \
 alsa-ucm-utils \
 alsa-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-utils-1.2.14-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b693e142fb70c9e662f9e3afd2d9118d2b641b9f1006f46a23fb4f41ef9a7dd"

URI_x86_64_v2_alsa-ucm-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-ucm-utils-1.2.14-2.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-ucm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-ucm-utils}"
SRC_URI[x86_64_v2_alsa-ucm-utils.sha256sum] = "d4a5c6e6d4a00cb55f336262cf649ad9181f92cc94fdd63cfdaa88839fe3dc99"

URI_x86_64_v2_alsa-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-utils-1.2.14-2.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-utils}"
SRC_URI[x86_64_v2_alsa-utils.sha256sum] = "7d6c640ff1c60cb964230a699936f2432cf8b8ed17d880c658690f0c09142021"

URI_aarch64_alsa-ucm-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-ucm-utils-1.2.14-2.el10.aarch64.rpm;name=aarch64_alsa-ucm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-ucm-utils}"
SRC_URI[aarch64_alsa-ucm-utils.sha256sum] = "435b9d2eeac270e0250f52c9c64800e6ceccc1faeece3e58ba543faa3e2e867e"

URI_aarch64_alsa-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-utils-1.2.14-2.el10.aarch64.rpm;name=aarch64_alsa-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-utils}"
SRC_URI[aarch64_alsa-utils.sha256sum] = "2e20f501faf8175fdcdf970c473acc2d3dbefab0d700881a08ee1f7f35fe19e9"

RDEPENDS:alsa-ucm-utils = " \
 alsa-lib \
 glibc \
 "
RDEPENDS:alsa-utils = " \
 alsa-lib \
 alsa-ucm \
 bash \
 glibc \
 libsamplerate \
 ncurses-libs \
 systemd \
 "
