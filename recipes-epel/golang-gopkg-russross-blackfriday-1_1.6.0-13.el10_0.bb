# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-russross-blackfriday-1"
PV = "1.6.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-gopkg-russross-blackfriday-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-russross-blackfriday-1-1.6.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afb9ced033bd5ce5fd33c63cf7d3fd3aefb9aa29e19c3963b2f13cf4e6397065"

URI_x86_64_v2_golang-gopkg-russross-blackfriday-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-russross-blackfriday-1-devel-1.6.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-russross-blackfriday-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-russross-blackfriday-1-devel}"
SRC_URI[x86_64_v2_golang-gopkg-russross-blackfriday-1-devel.sha256sum] = "3c5e009247c67786d7c870f95ab58d8df6dae9a93a1f362569e2ae7506537386"

URI_aarch64_golang-gopkg-russross-blackfriday-1-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-russross-blackfriday-1-devel-1.6.0-13.el10_0.noarch.rpm;name=aarch64_golang-gopkg-russross-blackfriday-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-russross-blackfriday-1-devel}"
SRC_URI[aarch64_golang-gopkg-russross-blackfriday-1-devel.sha256sum] = "fc269a5953c7870a1acbf12ea6c145f01313859b6c7a86e78867542e90584e73"

RDEPENDS:golang-gopkg-russross-blackfriday-1-devel = " \
 go-filesystem \
 "
