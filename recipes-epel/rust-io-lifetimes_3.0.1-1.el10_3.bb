# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-io-lifetimes"
PV = "3.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-io-lifetimes+async-std-devel \
 rust-io-lifetimes+close-devel \
 rust-io-lifetimes+default-devel \
 rust-io-lifetimes+libc-devel \
 rust-io-lifetimes+mio-devel \
 rust-io-lifetimes+os_pipe-devel \
 rust-io-lifetimes+socket2-devel \
 rust-io-lifetimes+tokio-devel \
 rust-io-lifetimes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-io-lifetimes-3.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70030554756f3f3b130f38674583afc069d150474c7f1d11ead1ef6b1464f06d"

URI_aarch64_rust-io-lifetimes+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+async-std-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-io-lifetimes+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+async-std-devel}"
SRC_URI[aarch64_rust-io-lifetimes+async-std-devel.sha256sum] = "3815deb2c47e9b9e8e912cac9eb0bb934b36e0de6c965adebc13fbde14c74644"

URI_aarch64_rust-io-lifetimes+close-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+close-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-io-lifetimes+close-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+close-devel}"
SRC_URI[aarch64_rust-io-lifetimes+close-devel.sha256sum] = "3583b0db7d9ab68aaee54688f0878ffd9227f5dfc2a11562857e1bf7adf562f1"

URI_aarch64_rust-io-lifetimes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+default-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-io-lifetimes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+default-devel}"
SRC_URI[aarch64_rust-io-lifetimes+default-devel.sha256sum] = "2b8fe0bcc9c6b8609cb359e87eedd95acdc8cd2b4440389c85c1b25e18a496e4"

URI_aarch64_rust-io-lifetimes+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+libc-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-io-lifetimes+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+libc-devel}"
SRC_URI[aarch64_rust-io-lifetimes+libc-devel.sha256sum] = "f3cc35e95372e1d49cc02d292f2b24eff7293458a48435330644d1625d023e41"

URI_aarch64_rust-io-lifetimes+mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+mio-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-io-lifetimes+mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+mio-devel}"
SRC_URI[aarch64_rust-io-lifetimes+mio-devel.sha256sum] = "fdb9043fa6373edef79bea4f1fd03c26c766bfb473548e52b27f65f15ca57c6a"

URI_aarch64_rust-io-lifetimes+os_pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+os_pipe-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-io-lifetimes+os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+os_pipe-devel}"
SRC_URI[aarch64_rust-io-lifetimes+os_pipe-devel.sha256sum] = "4fb4c09b95a099b9f5cd6d67530c487070fd8cd8d0e8fd63876c595cf0ab9f95"

URI_aarch64_rust-io-lifetimes+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+socket2-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-io-lifetimes+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+socket2-devel}"
SRC_URI[aarch64_rust-io-lifetimes+socket2-devel.sha256sum] = "2df389e1f444a719f411a9b10ed44bc794d51c0bcb1a72442dd8ea0f6bdbb467"

URI_aarch64_rust-io-lifetimes+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes+tokio-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-io-lifetimes+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes+tokio-devel}"
SRC_URI[aarch64_rust-io-lifetimes+tokio-devel.sha256sum] = "a5d2347b87f1a6e1c247e13acd344b1d60b69124b4d1531554a97fb479cffcd7"

URI_aarch64_rust-io-lifetimes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-lifetimes-devel-3.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-io-lifetimes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-lifetimes-devel}"
SRC_URI[aarch64_rust-io-lifetimes-devel.sha256sum] = "8a27c1e602fe42caba20e699a6cb75b6ecb948bee1989e33e7bd74154273c4b0"

RDEPENDS:rust-io-lifetimes+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-async-std+io_safety-devel \
 rust-io-lifetimes-devel \
 "
RDEPENDS:rust-io-lifetimes+close-devel = " \
 cargo \
 rust-io-lifetimes+libc-devel \
 rust-io-lifetimes-devel \
 "
RDEPENDS:rust-io-lifetimes+default-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 "
RDEPENDS:rust-io-lifetimes+libc-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-io-lifetimes+mio-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 rust-mio+default-devel \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 "
RDEPENDS:rust-io-lifetimes+os_pipe-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 rust-os_pipe+default-devel \
 rust-os_pipe+io_safety-devel \
 "
RDEPENDS:rust-io-lifetimes+socket2-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 rust-socket2+default-devel \
 "
RDEPENDS:rust-io-lifetimes+tokio-devel = " \
 cargo \
 rust-io-lifetimes-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-std-devel \
 rust-tokio+net-devel \
 rust-tokio+process-devel \
 "
RDEPENDS:rust-io-lifetimes-devel = " \
 cargo \
 rust \
 "
