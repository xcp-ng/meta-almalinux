# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-xo-terminfo"
PV = "0"
PR = "0.15.20241115gitabceb7e.el10_0"
PACKAGES = " \
 golang-github-xo-terminfo \
 golang-github-xo-terminfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-xo-terminfo-0-0.15.20241115gitabceb7e.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2b9011b7e2f737a6eeab6c999bc3ab6781d01a97e1bab944b30d0600be547e4"

URI_aarch64_golang-github-xo-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-xo-terminfo-0-0.15.20241115gitabceb7e.el10_0.aarch64.rpm;name=aarch64_golang-github-xo-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-xo-terminfo}"
SRC_URI[aarch64_golang-github-xo-terminfo.sha256sum] = "b6e11841767236d477790538d43776070d2ff9c719722489fcf0d95ba6924f00"

URI_aarch64_golang-github-xo-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-xo-terminfo-devel-0-0.15.20241115gitabceb7e.el10_0.noarch.rpm;name=aarch64_golang-github-xo-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-xo-terminfo-devel}"
SRC_URI[aarch64_golang-github-xo-terminfo-devel.sha256sum] = "3d633f0448e4d8ec956a627da694b969d9986718c02a195906fc2bf9c3d5c016"

RDEPENDS:golang-github-xo-terminfo = " \
 glibc \
 "
RDEPENDS:golang-github-xo-terminfo-devel = " \
 go-filesystem \
 "
