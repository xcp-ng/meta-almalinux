# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnscrypt-proxy"
PV = "2.1.14"
PR = "2.el10_2"
PACKAGES = " \
 dnscrypt-proxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnscrypt-proxy-2.1.14-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98eccdd9be5f63162a508805799ee8b1f48c9b24c4295bb1b69884607b28161d"

URI_x86_64_v2_dnscrypt-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnscrypt-proxy-2.1.14-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnscrypt-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnscrypt-proxy}"
SRC_URI[x86_64_v2_dnscrypt-proxy.sha256sum] = "4344f65a123dfdee236814848247e5e6f98a7f288c184ffa361635b24fdd3320"

URI_aarch64_dnscrypt-proxy = "${EPEL_MIRROR}/aarch64/Packages/d/dnscrypt-proxy-2.1.14-2.el10_2.aarch64.rpm;name=aarch64_dnscrypt-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnscrypt-proxy}"
SRC_URI[aarch64_dnscrypt-proxy.sha256sum] = "fcca031651222edc1bdba9e60a3c2db2a49e0c202d8ace53ae762c6d02c26437"

RDEPENDS:dnscrypt-proxy = " \
 bash \
 glibc \
 "
