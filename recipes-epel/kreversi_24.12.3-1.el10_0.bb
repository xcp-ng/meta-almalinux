# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kreversi"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kreversi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kreversi-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18803a2952c6a0374a2bdad62fb189ac0c0fa27a1bbdb34a249f0ebba5eb9587"

URI_x86_64_v2_kreversi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kreversi-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kreversi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kreversi}"
SRC_URI[x86_64_v2_kreversi.sha256sum] = "c507f36d7e7b713220016b4907fa30fcf5d849946049f75431d188e4f7e3eb30"

URI_aarch64_kreversi = "${EPEL_MIRROR}/aarch64/Packages/k/kreversi-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kreversi;unpack=0"
SRC_URI:append = " ${URI_aarch64_kreversi}"
SRC_URI[aarch64_kreversi.sha256sum] = "5e8159442736e981c8ab73b305baff6c7590907809fe4f92e3b061b06c2aca22"

RDEPENDS:kreversi = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
