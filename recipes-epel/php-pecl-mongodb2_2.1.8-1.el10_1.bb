# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mongodb2"
PV = "2.1.8"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-mongodb2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mongodb2-2.1.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de21105f868a03e594e7c64f61e33f3221070a5a4c255fa0ef7a476f2031ddfe"

URI_x86_64_v2_php-pecl-mongodb2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mongodb2-2.1.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mongodb2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mongodb2}"
SRC_URI[x86_64_v2_php-pecl-mongodb2.sha256sum] = "1a4443e16123a32e4fca51e8fe17b8621daf554fb29d09f96a105a63e33ac393"

URI_aarch64_php-pecl-mongodb2 = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mongodb2-2.1.8-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-mongodb2;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mongodb2}"
SRC_URI[aarch64_php-pecl-mongodb2.sha256sum] = "99f088d3f0188e2e17c78da0beeb8660302fc856f95e24928a6ceaa2111af345"

RDEPENDS:php-pecl-mongodb2 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 "
