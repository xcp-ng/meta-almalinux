# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktimer"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ktimer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktimer-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9435379008ec5161cbf0cffb4677df94286a99acf0e9ec846d94a023b2499e68"

URI_x86_64_v2_ktimer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktimer-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktimer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktimer}"
SRC_URI[x86_64_v2_ktimer.sha256sum] = "ee9ceb848893fd8958b639830c83e6b029329b395741485e25190c587ad13031"

URI_aarch64_ktimer = "${EPEL_MIRROR}/aarch64/Packages/k/ktimer-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ktimer;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktimer}"
SRC_URI[aarch64_ktimer.sha256sum] = "f2aeba470a253d01a4eb24ed566dc626ce76c6efeb19707f4baf43da7db721ac"

RDEPENDS:ktimer = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
