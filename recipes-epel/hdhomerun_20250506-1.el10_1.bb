# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hdhomerun"
PV = "20250506"
PR = "1.el10_1"
PACKAGES = " \
 hdhomerun \
 hdhomerun-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hdhomerun-20250506-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "987f84d54aa09d3c8ad11ae82b69851b323a653eca0dc02ea7b543b66289006d"

URI_x86_64_v2_hdhomerun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdhomerun-20250506-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdhomerun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdhomerun}"
SRC_URI[x86_64_v2_hdhomerun.sha256sum] = "65fe8b31cda37fe4195c75655df7992130c1dcc773a248188d31c5072e056888"

URI_x86_64_v2_hdhomerun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdhomerun-devel-20250506-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdhomerun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdhomerun-devel}"
SRC_URI[x86_64_v2_hdhomerun-devel.sha256sum] = "33854bcec663ceacdabba8d821d72e70e525bf0a363a56f237f475aa56d56399"

URI_aarch64_hdhomerun = "${EPEL_MIRROR}/aarch64/Packages/h/hdhomerun-20250506-1.el10_1.aarch64.rpm;name=aarch64_hdhomerun;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdhomerun}"
SRC_URI[aarch64_hdhomerun.sha256sum] = "90a306a4e593761953c17c5b3181665c8c0d1e9c0f62268014aff9a0940450ed"

URI_aarch64_hdhomerun-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hdhomerun-devel-20250506-1.el10_1.aarch64.rpm;name=aarch64_hdhomerun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdhomerun-devel}"
SRC_URI[aarch64_hdhomerun-devel.sha256sum] = "513a3c51b1573aea0b7fe56605ddbb0d5c104213169edf5b1ac141da2fea6263"

RDEPENDS:hdhomerun = " \
 glib2 \
 glibc \
 gtk2 \
 libgcc \
 libstdc++ \
 "
RDEPENDS:hdhomerun-devel = " \
 hdhomerun \
 "
