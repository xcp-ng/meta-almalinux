# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kshisen"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kshisen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kshisen-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cc947247fe3d3c7ac7493b4912471632a3744eecd7192d5d4161a6cc20edbb8"

URI_x86_64_v2_kshisen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kshisen-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kshisen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kshisen}"
SRC_URI[x86_64_v2_kshisen.sha256sum] = "931471361c5659a1748fda2a9b18a3c7db6c0a949a5f2d471acbcf6f8dacb059"

URI_aarch64_kshisen = "${EPEL_MIRROR}/aarch64/Packages/k/kshisen-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kshisen;unpack=0"
SRC_URI:append = " ${URI_aarch64_kshisen}"
SRC_URI[aarch64_kshisen.sha256sum] = "1e2eb905b761f1abd690fec2c8c7d9ecbc431ca5cd913305accdd6b6da2f8e71"

RDEPENDS:kshisen = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libkmahjongg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
