# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Any-URI-Escape"
PV = "0.01"
PR = "35.el10_0"
PACKAGES = " \
 perl-Any-URI-Escape \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Any-URI-Escape-0.01-35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c79443fdc66db7116a6e6d30cce7250f45b48e72b82950e4433df42c0886d78e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Any-URI-Escape-0.01-35.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Any-URI-Escape;unpack=0"
SRC_URI[x86_64_v2_perl-Any-URI-Escape.sha256sum] = "88a15ae3323312d922fd91e591974a043cccce6bfa0d5855017687ffbff46f23"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Any-URI-Escape-0.01-35.el10_0.noarch.rpm;name=aarch64_perl-Any-URI-Escape;unpack=0"
SRC_URI[aarch64_perl-Any-URI-Escape.sha256sum] = "132e91eb2b3fff49c54e3fb2e8f703e88465ecca3c0287d79f366310ec53320e"

RDEPENDS:perl-Any-URI-Escape = " \
 perl-Exporter \
 perl-URI \
 perl-base \
 perl-libs \
 "
