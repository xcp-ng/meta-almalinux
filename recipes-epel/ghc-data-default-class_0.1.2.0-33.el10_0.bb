# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-data-default-class"
PV = "0.1.2.0"
PR = "33.el10_0"
PACKAGES = " \
 ghc-data-default-class \
 ghc-data-default-class-devel \
 ghc-data-default-class-doc \
 ghc-data-default-class-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-data-default-class-0.1.2.0-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "360d9115e07fd27f91c1f8956b8c909e6b35303f132bc2e9d65c6027c044f548"

URI_x86_64_v2_ghc-data-default-class = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-class-0.1.2.0-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-class;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-class}"
SRC_URI[x86_64_v2_ghc-data-default-class.sha256sum] = "32569df1fdab0aa708d6c9bd1fc0249abba083a70e0049dac740c93914dfec63"

URI_x86_64_v2_ghc-data-default-class-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-class-devel-0.1.2.0-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-class-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-class-devel}"
SRC_URI[x86_64_v2_ghc-data-default-class-devel.sha256sum] = "5624ebb896e5e892d0781d39051633d850db04d772747b86fb5473349e8d5abd"

URI_x86_64_v2_ghc-data-default-class-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-class-doc-0.1.2.0-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-data-default-class-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-class-doc}"
SRC_URI[x86_64_v2_ghc-data-default-class-doc.sha256sum] = "95608df3936dbee0f214895dedf7b1528b5ee1b261e8975999bc69d42266cfaf"

URI_x86_64_v2_ghc-data-default-class-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-class-prof-0.1.2.0-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-class-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-class-prof}"
SRC_URI[x86_64_v2_ghc-data-default-class-prof.sha256sum] = "d73c2d338edb55bca07d8eb4e7cac752501ca39b54b4aa15cc29a99f8deaa89e"

URI_aarch64_ghc-data-default-class = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-class-0.1.2.0-33.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-class;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-class}"
SRC_URI[aarch64_ghc-data-default-class.sha256sum] = "08ee8de149808fdf0fb271722504ee38be98acd087b74ca75e716f8cb39fdf4f"

URI_aarch64_ghc-data-default-class-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-class-devel-0.1.2.0-33.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-class-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-class-devel}"
SRC_URI[aarch64_ghc-data-default-class-devel.sha256sum] = "dabc1509addaf8990f46b2c3e880cb41e219326a0e9a5bb12d6409b809b3de30"

URI_aarch64_ghc-data-default-class-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-class-doc-0.1.2.0-33.el10_0.noarch.rpm;name=aarch64_ghc-data-default-class-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-class-doc}"
SRC_URI[aarch64_ghc-data-default-class-doc.sha256sum] = "288b2bd36b1f10c5dd64b03edc37a6b7c7dccfc5d0ad22fd5d6e028be4dcc8f7"

URI_aarch64_ghc-data-default-class-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-class-prof-0.1.2.0-33.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-class-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-class-prof}"
SRC_URI[aarch64_ghc-data-default-class-prof.sha256sum] = "2ba7cefe4145ea9a0c7ffc5c32223907c743cc7237c37822bc11c223c2037c19"

RDEPENDS:ghc-data-default-class = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-data-default-class-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-data-default-class \
 "
RDEPENDS:ghc-data-default-class-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-data-default-class-prof = " \
 ghc-base-prof \
 ghc-data-default-class-devel \
 "
