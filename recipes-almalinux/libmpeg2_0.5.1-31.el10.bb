# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmpeg2"
PV = "0.5.1"
PR = "31.el10"
PACKAGES = " \
 libmpeg2 \
 libmpeg2-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/libmpeg2-0.5.1-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f76b53d61c0184d63838d70a8da934deeceace67435844b3b17ea4e031d7a53"

URI_x86_64_v2_libmpeg2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmpeg2-0.5.1-31.el10.x86_64_v2.rpm;name=x86_64_v2_libmpeg2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmpeg2}"
SRC_URI[x86_64_v2_libmpeg2.sha256sum] = "383dc3935e52fb57266c69e06c75831b6ea50ae79ce6a369f2e69f30e5d6ff21"

URI_x86_64_v2_libmpeg2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmpeg2-devel-0.5.1-31.el10.x86_64_v2.rpm;name=x86_64_v2_libmpeg2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmpeg2-devel}"
SRC_URI[x86_64_v2_libmpeg2-devel.sha256sum] = "5d5f4d86829b2be0beaa0a270fe09b403e846fe3286acf07fd1f4211da00a369"

URI_aarch64_libmpeg2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmpeg2-0.5.1-31.el10.aarch64.rpm;name=aarch64_libmpeg2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmpeg2}"
SRC_URI[aarch64_libmpeg2.sha256sum] = "959d8226add8c1752cfce1d8869326e2f418097660a71fdaaac6da9124ff29a1"

URI_aarch64_libmpeg2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmpeg2-devel-0.5.1-31.el10.aarch64.rpm;name=aarch64_libmpeg2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmpeg2-devel}"
SRC_URI[aarch64_libmpeg2-devel.sha256sum] = "dee2ca3f4efb7e5b6b67f2c3c61d5083b411d6cf0ec1e03ed6fa4118b96f3fa5"

RDEPENDS:libmpeg2 = " \
 glibc \
 "
RDEPENDS:libmpeg2-devel = " \
 libmpeg2 \
 pkgconf-pkg-config \
 "
