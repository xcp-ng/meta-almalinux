# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger0.9"
PV = "0.9.3"
PR = "9.el10_1"
PACKAGES = " \
 rust-env_logger0.9+atty-devel \
 rust-env_logger0.9+default-devel \
 rust-env_logger0.9+humantime-devel \
 rust-env_logger0.9+regex-devel \
 rust-env_logger0.9+termcolor-devel \
 rust-env_logger0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger0.9-0.9.3-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f90863f7dd75928839b5fa00962e803e24d61cfdc119f17af0dde8bbc9e8b92a"

URI_x86_64_v2_rust-env_logger0.9+atty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+atty-devel-0.9.3-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+atty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+atty-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+atty-devel.sha256sum] = "c3aedbf4d082e8690e25a98638789f2277fb588017f856724f11eda1a330238f"

URI_x86_64_v2_rust-env_logger0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+default-devel-0.9.3-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+default-devel.sha256sum] = "a7a3412365abd71342a4dfbff0e5b5ca05d84baacf80202b17172ccfdf009042"

URI_x86_64_v2_rust-env_logger0.9+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+humantime-devel-0.9.3-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+humantime-devel.sha256sum] = "e8c7931c6cceab5c9940a477ea35a32f6172c008ad13568d40d90621172a6c22"

URI_x86_64_v2_rust-env_logger0.9+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+regex-devel-0.9.3-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+regex-devel.sha256sum] = "8532628e3825e9a49ff0795b5421959bd731b4e496efad41225503aa3696c498"

URI_x86_64_v2_rust-env_logger0.9+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+termcolor-devel-0.9.3-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+termcolor-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+termcolor-devel.sha256sum] = "0ab33fcb844428ed0231d1fe9fa033dcf619f62e205d69863a6a78ed9b5eea58"

URI_x86_64_v2_rust-env_logger0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9-devel-0.9.3-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9-devel.sha256sum] = "dceb21d9f3d4cc2b26639a0f623685efc54a7f93c970e8d50be3eec524d71670"
RPROVIDES:rust-env_logger0.9-devel:append:x86_64_v2 = " virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger0.9+atty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+atty-devel-0.9.3-9.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.9+atty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+atty-devel}"
SRC_URI[aarch64_rust-env_logger0.9+atty-devel.sha256sum] = "f00ca5c577a9673a6f80654f809e411a01c466c32242217a3816f1924376b5f2"

URI_aarch64_rust-env_logger0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+default-devel-0.9.3-9.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+default-devel}"
SRC_URI[aarch64_rust-env_logger0.9+default-devel.sha256sum] = "a374ba72ae099c8ed00972a6493d921ee9595f50b17b3a76821b2ef08d0b4112"

URI_aarch64_rust-env_logger0.9+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+humantime-devel-0.9.3-9.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.9+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+humantime-devel}"
SRC_URI[aarch64_rust-env_logger0.9+humantime-devel.sha256sum] = "95893983cb479179a3f7b2ec5de46f75d38d4e9552505201690c6d6ae2bcc365"

URI_aarch64_rust-env_logger0.9+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+regex-devel-0.9.3-9.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.9+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+regex-devel}"
SRC_URI[aarch64_rust-env_logger0.9+regex-devel.sha256sum] = "7cc64600e8dcefce8c6fe085c9329107b033d3e86412b034c2219a2a2a87b74a"

URI_aarch64_rust-env_logger0.9+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+termcolor-devel-0.9.3-9.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.9+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+termcolor-devel}"
SRC_URI[aarch64_rust-env_logger0.9+termcolor-devel.sha256sum] = "1de6089d8c34baf311d46848cb0c9a93d61aabfc0d66ddb471370b9bb001e507"

URI_aarch64_rust-env_logger0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9-devel-0.9.3-9.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9-devel}"
SRC_URI[aarch64_rust-env_logger0.9-devel.sha256sum] = "da05e802f915d8395d623e03c1b7bba088cbdaab80b2b85d698c40a6276cab0d"
RPROVIDES:rust-env_logger0.9-devel:append:aarch64 = " virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger0.9+atty-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 "
RDEPENDS:rust-env_logger0.9+default-devel = " \
 cargo \
 rust-env_logger0.9+atty-devel \
 rust-env_logger0.9+humantime-devel \
 rust-env_logger0.9+regex-devel \
 rust-env_logger0.9+termcolor-devel \
 rust-env_logger0.9-devel \
 "
RDEPENDS:rust-env_logger0.9+humantime-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-humantime+default-devel \
 "
RDEPENDS:rust-env_logger0.9+regex-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_logger0.9+termcolor-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-env_logger0.9-devel = " \
 cargo \
 rust-log+default-devel \
 rust-log+std-devel \
 "
