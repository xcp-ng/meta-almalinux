# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiff"
PV = "0.2.24"
PR = "1.el10_1"
PACKAGES = " \
 rust-jiff+alloc-devel \
 rust-jiff+default-devel \
 rust-jiff+logging-devel \
 rust-jiff+perf-inline-devel \
 rust-jiff+serde-devel \
 rust-jiff+std-devel \
 rust-jiff+tz-fat-devel \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jiff-0.2.24-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "103b3cc5c758d54418fcea14072e2cbe93cc072e270cb60eda461c8a3dffe799"

URI_x86_64_v2_rust-jiff+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+alloc-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+alloc-devel}"
SRC_URI[x86_64_v2_rust-jiff+alloc-devel.sha256sum] = "1dbf82c5f880fc6d19d1885a93d48dd95373aa6c9f5a8b5c7072e98e4cec97d7"

URI_x86_64_v2_rust-jiff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+default-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+default-devel}"
SRC_URI[x86_64_v2_rust-jiff+default-devel.sha256sum] = "31a0cedea1c0afb4872c4025b8130d94ccec00fc1307e4f0661e399a9ef3d7f3"

URI_x86_64_v2_rust-jiff+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+logging-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+logging-devel}"
SRC_URI[x86_64_v2_rust-jiff+logging-devel.sha256sum] = "dce0762deadfb986acd3d2731d62b182fe6dfd167d235664953e094b3e902b73"

URI_x86_64_v2_rust-jiff+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+perf-inline-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-jiff+perf-inline-devel.sha256sum] = "013cf7ebff105828dcd31f5cf5c26228be62c937c79276807f851f3b59032fae"

URI_x86_64_v2_rust-jiff+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+serde-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+serde-devel}"
SRC_URI[x86_64_v2_rust-jiff+serde-devel.sha256sum] = "bb3dd3575f9d4f7278884e37deb0a198861a789c24582ce237d822ab5f9cbef7"

URI_x86_64_v2_rust-jiff+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+std-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+std-devel}"
SRC_URI[x86_64_v2_rust-jiff+std-devel.sha256sum] = "e29ff95e7d59c29dd9f39aa5e49212c2745395a350286ac839a2db099947f4d7"

URI_x86_64_v2_rust-jiff+tz-fat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tz-fat-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tz-fat-devel}"
SRC_URI[x86_64_v2_rust-jiff+tz-fat-devel.sha256sum] = "916bfbba2baa7e9bff865d68a8ae50ec16f110f736dbb6eb71dc36c7ff912ae4"

URI_x86_64_v2_rust-jiff+tz-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tz-system-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tz-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tz-system-devel}"
SRC_URI[x86_64_v2_rust-jiff+tz-system-devel.sha256sum] = "c79552c2f2f92f985be1473a30553c3007cd96c2cd2a600a4aa386ca13816e8e"

URI_x86_64_v2_rust-jiff+tzdb-bundle-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-bundle-platform-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-bundle-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-bundle-platform-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-bundle-platform-devel.sha256sum] = "bdda0084723ecc8c4eede86f9fac536252cd604c915010d7f4df1be5f3b8c0d8"

URI_x86_64_v2_rust-jiff+tzdb-concatenated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-concatenated-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-concatenated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-concatenated-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-concatenated-devel.sha256sum] = "6d3bbdc8e826e278e8e916320991645cd73883f51320dadc1dc6d541f0fc3554"

URI_x86_64_v2_rust-jiff+tzdb-zoneinfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-zoneinfo-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-zoneinfo-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-zoneinfo-devel.sha256sum] = "223d40f463001b3a77df79f88279d0edcc07a92335cf8ba3ebde0682d06b6c9d"

URI_x86_64_v2_rust-jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-devel-0.2.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-devel}"
SRC_URI[x86_64_v2_rust-jiff-devel.sha256sum] = "2a1803bbbbea396bbd52d55431e577866a06f37173ee9c2382701cd3e20a5614"

URI_aarch64_rust-jiff+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+alloc-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+alloc-devel}"
SRC_URI[aarch64_rust-jiff+alloc-devel.sha256sum] = "30d8c8115d651da0a82015979349e7c206a151f318810e5a251c15981da2a604"

URI_aarch64_rust-jiff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+default-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+default-devel}"
SRC_URI[aarch64_rust-jiff+default-devel.sha256sum] = "87420a1116909a37c718e260b48c52f6f0285d34e605c7fea8b5c09f94a3151f"

URI_aarch64_rust-jiff+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+logging-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+logging-devel}"
SRC_URI[aarch64_rust-jiff+logging-devel.sha256sum] = "e24411737e5dfb9c4694f7315e71662a8085c52000cbe3a9683b824090fefb5f"

URI_aarch64_rust-jiff+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+perf-inline-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+perf-inline-devel}"
SRC_URI[aarch64_rust-jiff+perf-inline-devel.sha256sum] = "e87deaea40d4fe52d03c8373b59790ced52e09e500283bb23082688323e5c504"

URI_aarch64_rust-jiff+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+serde-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+serde-devel}"
SRC_URI[aarch64_rust-jiff+serde-devel.sha256sum] = "0809c858a0045f0f82d2ebd4df8d959d983ced8453d3acc05fde4d6e01b035f9"

URI_aarch64_rust-jiff+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+std-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+std-devel}"
SRC_URI[aarch64_rust-jiff+std-devel.sha256sum] = "d260dc05f4cbce2d0e8488c17ba8b91b370a6c509b0b405183e9de70a60f5a8f"

URI_aarch64_rust-jiff+tz-fat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tz-fat-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tz-fat-devel}"
SRC_URI[aarch64_rust-jiff+tz-fat-devel.sha256sum] = "d35358e88aafdc65a069f55dc1585dc552539f1b91d78ea945ba9501d9a8e2b9"

URI_aarch64_rust-jiff+tz-system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tz-system-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+tz-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tz-system-devel}"
SRC_URI[aarch64_rust-jiff+tz-system-devel.sha256sum] = "04e03ad25c53eccd9bc99edc6d94154927f3d4a2717ba81f2a3bbf9ec13b1aa5"

URI_aarch64_rust-jiff+tzdb-bundle-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-bundle-platform-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+tzdb-bundle-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-bundle-platform-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-bundle-platform-devel.sha256sum] = "13c4af8295c2bc05ed263fc2ec2cf756edce386195be9da2825bfcf1a4e36216"

URI_aarch64_rust-jiff+tzdb-concatenated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-concatenated-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+tzdb-concatenated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-concatenated-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-concatenated-devel.sha256sum] = "e06f9c3d548b8fcc07a1a647a6c8c47e589a12e5a12e4edfc5bb3b3b236d5a04"

URI_aarch64_rust-jiff+tzdb-zoneinfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-zoneinfo-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff+tzdb-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-zoneinfo-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-zoneinfo-devel.sha256sum] = "c4cc48b619e6a61e7098923f91d49bcc2699aa769c812355460fa107505896f5"

URI_aarch64_rust-jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-devel-0.2.24-1.el10_1.noarch.rpm;name=aarch64_rust-jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-devel}"
SRC_URI[aarch64_rust-jiff-devel.sha256sum] = "bba1815885863b5b9b4064beb24c032ff830f88792ec50770e02acd660e2ed1f"

RDEPENDS:rust-jiff+alloc-devel = " \
 cargo \
 rust-jiff-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+default-devel = " \
 cargo \
 rust-jiff+perf-inline-devel \
 rust-jiff+std-devel \
 rust-jiff+tz-fat-devel \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+logging-devel = " \
 cargo \
 rust-jiff-devel \
 rust-log-devel \
 "
RDEPENDS:rust-jiff+perf-inline-devel = " \
 cargo \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+serde-devel = " \
 cargo \
 rust-jiff-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+std-devel = " \
 cargo \
 rust-jiff+alloc-devel \
 rust-jiff-devel \
 rust-log+std-devel \
 rust-log-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+tz-fat-devel = " \
 cargo \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tz-system-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-bundle-platform-devel = " \
 cargo \
 rust-jiff+alloc-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-concatenated-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-zoneinfo-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff-devel = " \
 cargo \
 rust \
 "
