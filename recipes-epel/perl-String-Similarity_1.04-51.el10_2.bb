# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-String-Similarity"
PV = "1.04"
PR = "51.el10_2"
PACKAGES = " \
 perl-String-Similarity \
 perl-String-Similarity-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-String-Similarity-1.04-51.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4927038996802c0671accdacab7a2f4e131de8199669b395b9f0f12166dc624"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-String-Similarity-1.04-51.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-String-Similarity;unpack=0"
SRC_URI[x86_64_v2_perl-String-Similarity.sha256sum] = "c37bccb2dde016a8a6c7c5ba7649e672bddff0e9e4ca1af06bd585a04c392cb0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-String-Similarity-tests-1.04-51.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-String-Similarity-tests;unpack=0"
SRC_URI[x86_64_v2_perl-String-Similarity-tests.sha256sum] = "2f3e6db35894b6fcb14274c3577736b532091ab407cf7f6f1e079732ace37dc3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-String-Similarity-1.04-51.el10_2.aarch64.rpm;name=aarch64_perl-String-Similarity;unpack=0"
SRC_URI[aarch64_perl-String-Similarity.sha256sum] = "09509c21bd54680b95acaefa65dcb84364ca47a84d44e404d30794c714c2564a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-String-Similarity-tests-1.04-51.el10_2.noarch.rpm;name=aarch64_perl-String-Similarity-tests;unpack=0"
SRC_URI[aarch64_perl-String-Similarity-tests.sha256sum] = "6914197887d68d61ee0691176b548fda36c5123517b630255adb566d6f7d8694"

RDEPENDS:perl-String-Similarity = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-String-Similarity-tests = " \
 bash \
 perl-Encode \
 perl-String-Similarity \
 perl-Test-Harness \
 perl-libs \
 "
