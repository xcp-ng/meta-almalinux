# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy-derive"
PV = "0.8.57"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-derive-0.8.57-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ca65fd81075dd96061245c35f6cca4c2e04a0f1df44581bb6c59f4a8c4ec4242"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive+default-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy-derive+default-devel.sha256sum] = "f41fb1cdcfb1e64fed127d28f8f808438ec0e6249d56382a2f1def0da62aed81"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive-devel-0.8.57-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zerocopy-derive-devel.sha256sum] = "72adc8a09deeae0d572dfbf1c9bf802304227908084bd803c5e14fddfb82c3c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive+default-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy-derive+default-devel.sha256sum] = "df6c7792d8d36ab953f7002ea188314e5fa4006ad769acbabdda18cef1097dbd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive-devel-0.8.57-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy-derive-devel;unpack=0"
SRC_URI[aarch64_rust-zerocopy-derive-devel.sha256sum] = "e5518f60090e87d2578a131b131acab54ac55598ba6d8284d9ede96ee7c0d8a1"

RDEPENDS:rust-zerocopy-derive+default-devel = " \
 cargo \
 rust-zerocopy-derive-devel \
 "
RDEPENDS:rust-zerocopy-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
