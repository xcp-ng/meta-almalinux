# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdepim-addons"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdepim-addons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdepim-addons-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49f7f4f81efc71a87a1a421ee7e70443457c47216e7f793cece6e67d7c4cb063"

URI_x86_64_v2_kdepim-addons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-addons-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdepim-addons}"
SRC_URI[x86_64_v2_kdepim-addons.sha256sum] = "c5489148f02b5c1ca718524b9d0099231fa6c559ba0cb8d0f68216a87046176c"

URI_aarch64_kdepim-addons = "${EPEL_MIRROR}/aarch64/Packages/k/kdepim-addons-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdepim-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdepim-addons}"
SRC_URI[aarch64_kdepim-addons.sha256sum] = "d4a10e8774faba5f67ec664bc41def09d505586e575103aa655290cf92e44a92"

RDEPENDS:kdepim-addons = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-import-wizard \
 akonadi-mime \
 akonadi-server \
 bash \
 calendarsupport \
 glibc \
 gpgme2pp \
 grantleetheme \
 incidenceeditor \
 kaddressbook-libs \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdeclarative \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-prison \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kimap \
 kitinerary \
 kldap \
 kmailtransport \
 kmime \
 kpimtextedit \
 kpkpass \
 ktextaddons-qt6 \
 ktnef \
 libgcc \
 libgravatar \
 libkleo \
 libksieve \
 libmarkdown \
 libstdc++ \
 mailcommon \
 mailimporter \
 messagelib \
 pimcommon \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
