# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-temp_testdir"
PV = "0.2.3"
PR = "6.el10_0"
PACKAGES = " \
 rust-temp_testdir+default-devel \
 rust-temp_testdir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-temp_testdir-0.2.3-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e311d4b27133967c4635a67b78abc2f00048c90a4bd05e384243d6e753a407cd"

URI_x86_64_v2_rust-temp_testdir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-temp_testdir+default-devel-0.2.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-temp_testdir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-temp_testdir+default-devel}"
SRC_URI[x86_64_v2_rust-temp_testdir+default-devel.sha256sum] = "f4f75b7047bbb5c8fe5f5f829c825d57515a84e2fb90787c83de64db4e975de6"

URI_x86_64_v2_rust-temp_testdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-temp_testdir-devel-0.2.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-temp_testdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-temp_testdir-devel}"
SRC_URI[x86_64_v2_rust-temp_testdir-devel.sha256sum] = "32ec4d091efbeb4672b8a7464e2ae09020ec6015fdf89c409c29f740d66ad766"

URI_aarch64_rust-temp_testdir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-temp_testdir+default-devel-0.2.3-6.el10_0.noarch.rpm;name=aarch64_rust-temp_testdir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-temp_testdir+default-devel}"
SRC_URI[aarch64_rust-temp_testdir+default-devel.sha256sum] = "e6d6aa698e5a256a1697db2d9880ca8aebe7290929d5f1c3f370183b6bd6f0dc"

URI_aarch64_rust-temp_testdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-temp_testdir-devel-0.2.3-6.el10_0.noarch.rpm;name=aarch64_rust-temp_testdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-temp_testdir-devel}"
SRC_URI[aarch64_rust-temp_testdir-devel.sha256sum] = "12e6e219f14737304a787f6fd14a52687ed2dff4fcf7c8a590f32d74fc1a23d5"

RDEPENDS:rust-temp_testdir+default-devel = " \
 cargo \
 rust-temp_testdir-devel \
 "
RDEPENDS:rust-temp_testdir-devel = " \
 cargo \
 "
