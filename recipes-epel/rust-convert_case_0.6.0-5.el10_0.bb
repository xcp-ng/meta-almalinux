# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-convert_case"
PV = "0.6.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-convert_case+default-devel \
 rust-convert_case+rand-devel \
 rust-convert_case+random-devel \
 rust-convert_case-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-convert_case-0.6.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "121aa521a3d245eb2ab98ae22dab6e894a56f89218171f1e56953f58a76edf8a"

URI_x86_64_v2_rust-convert_case+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case+default-devel-0.6.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case+default-devel}"
SRC_URI[x86_64_v2_rust-convert_case+default-devel.sha256sum] = "de32d8bf84ea829cbcf7e286c362664cb40ff83235c90854dfc2a3cc9ded905e"

URI_x86_64_v2_rust-convert_case+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case+rand-devel-0.6.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case+rand-devel}"
SRC_URI[x86_64_v2_rust-convert_case+rand-devel.sha256sum] = "31e99eccca3fd16c98d20f534fa314d6edce0e224a61656ddf89548646502751"

URI_x86_64_v2_rust-convert_case+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case+random-devel-0.6.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case+random-devel}"
SRC_URI[x86_64_v2_rust-convert_case+random-devel.sha256sum] = "eca58fe96176b8c0ad5dc9dc6e21d9582ab854f501e7ba2cadb0a82636109261"

URI_x86_64_v2_rust-convert_case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-convert_case-devel-0.6.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-convert_case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-convert_case-devel}"
SRC_URI[x86_64_v2_rust-convert_case-devel.sha256sum] = "e8c20e5fec6bb3a27c6b2907a30e386a1fec1e9fef216bf524758bd4ef6c46fd"

URI_aarch64_rust-convert_case+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case+default-devel-0.6.0-5.el10_0.noarch.rpm;name=aarch64_rust-convert_case+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case+default-devel}"
SRC_URI[aarch64_rust-convert_case+default-devel.sha256sum] = "974ebac3b0a3cc55389e6537a119bc8da0b77f0c2eb7cb019762ee57bf290e5e"

URI_aarch64_rust-convert_case+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case+rand-devel-0.6.0-5.el10_0.noarch.rpm;name=aarch64_rust-convert_case+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case+rand-devel}"
SRC_URI[aarch64_rust-convert_case+rand-devel.sha256sum] = "8c871d6650d9ffb7c4fe35d461b4bdc90ebce0dc7e49716af99bde4be9c14592"

URI_aarch64_rust-convert_case+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case+random-devel-0.6.0-5.el10_0.noarch.rpm;name=aarch64_rust-convert_case+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case+random-devel}"
SRC_URI[aarch64_rust-convert_case+random-devel.sha256sum] = "7e69a47158854d4d9f758fdbf0edd546c242af699a6146a1fe930b25e06f371a"

URI_aarch64_rust-convert_case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-convert_case-devel-0.6.0-5.el10_0.noarch.rpm;name=aarch64_rust-convert_case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-convert_case-devel}"
SRC_URI[aarch64_rust-convert_case-devel.sha256sum] = "afe2d4a0924a10094b89a7f31be13fefc0fd5d92e634c64d97eef524f4a2de58"

RDEPENDS:rust-convert_case+default-devel = " \
 cargo \
 rust-convert_case-devel \
 "
RDEPENDS:rust-convert_case+rand-devel = " \
 cargo \
 rust-convert_case-devel \
 rust-rand0.7+default-devel \
 "
RDEPENDS:rust-convert_case+random-devel = " \
 cargo \
 rust-convert_case+rand-devel \
 rust-convert_case-devel \
 "
RDEPENDS:rust-convert_case-devel = " \
 cargo \
 rust-unicode-segmentation+default-devel \
 "
