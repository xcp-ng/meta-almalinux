# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scl-utils"
PE = "1"
PV = "2.0.3"
PR = "5.el10"
PACKAGES = " \
 scl-utils \
 scl-utils-build \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/scl-utils-2.0.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9269080b4ed62c815f2c1d7eeda0ba57b93da492de3932f4a24c8457448f3119"

URI_x86_64_v2_scl-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scl-utils-2.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_scl-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scl-utils}"
SRC_URI[x86_64_v2_scl-utils.sha256sum] = "1dc4e70be124c7e7087b86fcc622b3ed0c7e302c95d8f4676cb060c53103c62a"

URI_x86_64_v2_scl-utils-build = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scl-utils-build-2.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_scl-utils-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scl-utils-build}"
SRC_URI[x86_64_v2_scl-utils-build.sha256sum] = "36759722bcafb16d0037c2fccd4a3e38859b8485c982f8bfb6e02dac8b1f3bdc"

URI_aarch64_scl-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scl-utils-2.0.3-5.el10.aarch64.rpm;name=aarch64_scl-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_scl-utils}"
SRC_URI[aarch64_scl-utils.sha256sum] = "1a766d9752ba04c1c12c81e689cd2f431c3a9cf41146fdcbad90d9d2c614bdc4"

URI_aarch64_scl-utils-build = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scl-utils-build-2.0.3-5.el10.aarch64.rpm;name=aarch64_scl-utils-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_scl-utils-build}"
SRC_URI[aarch64_scl-utils-build.sha256sum] = "cfa02b32cc2d9ef0dd7d1479b3cf36c66be054906f4ba0901d8da43848eeedec"

RDEPENDS:scl-utils = " \
 bash \
 environment-modules \
 glibc \
 rpm-libs \
 "
RDEPENDS:scl-utils-build = " \
 bash \
 iso-codes \
 redhat-rpm-config \
 "
