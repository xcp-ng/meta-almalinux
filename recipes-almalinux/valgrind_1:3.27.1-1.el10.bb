# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valgrind"
PE = "1"
PV = "3.27.1"
PR = "1.el10"
PACKAGES = " \
 valgrind \
 valgrind-devel \
 valgrind-docs \
 valgrind-gdb \
 valgrind-scripts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valgrind-3.27.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff5fec65d36373e6f0180fe9592c7d4cde0c61bc137507297315d37982f4372b"

URI_x86_64_v2_valgrind = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-3.27.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind}"
SRC_URI[x86_64_v2_valgrind.sha256sum] = "49763c040acb50945425841aade10c9f647a129a6684b943032cd9cdf68d7bcf"

URI_x86_64_v2_valgrind-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-devel-3.27.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-devel}"
SRC_URI[x86_64_v2_valgrind-devel.sha256sum] = "d63256795c35f37a5ae6896b05e58be4ecf1b95bd234b6f7f0fa7f90a826a939"

URI_x86_64_v2_valgrind-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-docs-3.27.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-docs}"
SRC_URI[x86_64_v2_valgrind-docs.sha256sum] = "7d3f5873983861b0c31a312f0d74068adf25638c4e1a79a65c0fd79f33b95ec5"

URI_x86_64_v2_valgrind-gdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-gdb-3.27.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-gdb}"
SRC_URI[x86_64_v2_valgrind-gdb.sha256sum] = "c853688b0fb65670887425e2cd78994d8b264db5967a406e5fcd1f6166812265"

URI_x86_64_v2_valgrind-scripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-scripts-3.27.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-scripts}"
SRC_URI[x86_64_v2_valgrind-scripts.sha256sum] = "ed273d0859182d75a8d24246d0b3a7fd511e435e7903b174499047a76f4b2f17"

URI_aarch64_valgrind = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-3.27.1-1.el10.aarch64.rpm;name=aarch64_valgrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind}"
SRC_URI[aarch64_valgrind.sha256sum] = "b89eb6307710762b2b3947f31fd0ce689d45a6a9a675c4ba5fc1227fab1bd7bd"

URI_aarch64_valgrind-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-devel-3.27.1-1.el10.aarch64.rpm;name=aarch64_valgrind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-devel}"
SRC_URI[aarch64_valgrind-devel.sha256sum] = "d4cebae23cb658fb07dd8cfddfea659d2ed7b1bc9a83873a263ae1770a07a8b5"

URI_aarch64_valgrind-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-docs-3.27.1-1.el10.aarch64.rpm;name=aarch64_valgrind-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-docs}"
SRC_URI[aarch64_valgrind-docs.sha256sum] = "a092b01ab85abfc568c7b0c29da09e0927831aff41304553e92b303aa972be11"

URI_aarch64_valgrind-gdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-gdb-3.27.1-1.el10.aarch64.rpm;name=aarch64_valgrind-gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-gdb}"
SRC_URI[aarch64_valgrind-gdb.sha256sum] = "bb4cc19d25715ca1c6e85ec03288b519df9308511b3ce2e43f94ac57bb53b3d3"

URI_aarch64_valgrind-scripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-scripts-3.27.1-1.el10.aarch64.rpm;name=aarch64_valgrind-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-scripts}"
SRC_URI[aarch64_valgrind-scripts.sha256sum] = "faf289e7dd71a940f261bbae599c96821748e6aa6305ce1a02037b85f72dcb64"

RDEPENDS:valgrind = " \
 glibc \
 "
RDEPENDS:valgrind-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:valgrind-docs = " \
 "
RDEPENDS:valgrind-gdb = " \
 bash \
 glibc \
 libgcc \
 valgrind \
 "
RDEPENDS:valgrind-scripts = " \
 perl-interpreter \
 python3 \
 "
