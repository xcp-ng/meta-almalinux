# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "root"
PV = "6.40.02"
PR = "1.el10_2"
PACKAGES = " \
 python3-root \
 python3-root+distrdf \
 python3-root+jupyroot \
 root \
 root-cli \
 root-cling \
 root-core \
 root-fftw \
 root-foam \
 root-font-files \
 root-fumili \
 root-gdml \
 root-genetic \
 root-genvector \
 root-geom \
 root-geom-builder \
 root-geom-checker \
 root-geom-painter \
 root-geom-webviewer \
 root-graf \
 root-graf-asimage \
 root-graf-fitsio \
 root-graf-gpad \
 root-graf-gpadv7 \
 root-graf-gviz \
 root-graf-postscript \
 root-graf-primitives \
 root-graf-x11 \
 root-graf3d \
 root-graf3d-csg \
 root-graf3d-eve \
 root-graf3d-eve7 \
 root-graf3d-gl \
 root-graf3d-glad \
 root-graf3d-gviz3d \
 root-graf3d-x3d \
 root-gui \
 root-gui-browsable \
 root-gui-browsable-v7 \
 root-gui-browserv7 \
 root-gui-browserv7-v7 \
 root-gui-builder \
 root-gui-canvaspainter \
 root-gui-fitpanel \
 root-gui-fitpanelv7 \
 root-gui-ged \
 root-gui-html \
 root-gui-qt6webdisplay \
 root-gui-recorder \
 root-gui-treemap \
 root-gui-webdisplay \
 root-gui-webgui6 \
 root-hbook \
 root-hist \
 root-hist-factory \
 root-hist-painter \
 root-histv7 \
 root-histv7util \
 root-icons \
 root-io \
 root-io-dcache \
 root-io-sql \
 root-io-xml \
 root-io-xmlparser \
 root-mathcore \
 root-mathmore \
 root-matrix \
 root-minuit \
 root-minuit2 \
 root-mlp \
 root-montecarlo-eg \
 root-montecarlo-pythia8 \
 root-multiproc \
 root-net \
 root-net-auth \
 root-net-curl \
 root-net-davix \
 root-net-http \
 root-net-httpsniff \
 root-net-rpdutils \
 root-netx \
 root-physics \
 root-quadp \
 root-r \
 root-r-tools \
 root-roofit \
 root-roofit-batchcompute \
 root-roofit-codegen \
 root-roofit-core \
 root-roofit-hs3 \
 root-roofit-jsoninterface \
 root-roofit-more \
 root-roofit-multiprocess \
 root-roofit-zmq \
 root-roostats \
 root-smatrix \
 root-spectrum \
 root-spectrum-painter \
 root-splot \
 root-sql-sqlite \
 root-testsupport \
 root-tmva \
 root-tmva-gui \
 root-tmva-python \
 root-tmva-r \
 root-tmva-sofie \
 root-tmva-sofie-parser \
 root-tmva-sofie-parser-python \
 root-tmva-utils \
 root-tpython \
 root-tree \
 root-tree-dataframe \
 root-tree-ml \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 root-tree-ntuple-utils \
 root-tree-player \
 root-tree-viewer \
 root-tree-webviewer \
 root-tutorial \
 root-unfold \
 root-unuran \
 root-vecops \
 root-xroofit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/root-6.40.02-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d65a6a61373eaa50e837c4a9584c8ac547be2a30ce44a714838a92f487fe13dc"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - root-netx: libXrdCl.so.6()(64bit)
# - root-netx: libXrdUtils.so.6()(64bit)

URI_x86_64_v2_python3-root = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-root}"
SRC_URI[x86_64_v2_python3-root.sha256sum] = "c9ff00e47e9cd8ad593d75b317a975eebe5fa44ac8ecf50b4b8bf6f9cdc54141"

URI_x86_64_v2_python3-root+distrdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root+distrdf-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root+distrdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-root+distrdf}"
SRC_URI[x86_64_v2_python3-root+distrdf.sha256sum] = "b911c43b4eefd6c508078818504131de0876bb3fed02fbf52a019d258c4ca2f5"

URI_x86_64_v2_python3-root+jupyroot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root+jupyroot-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root+jupyroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-root+jupyroot}"
SRC_URI[x86_64_v2_python3-root+jupyroot.sha256sum] = "16c5828becb7fe04b889f4fa488ed3202cdb0534b83929dbf07570140659103b"

URI_x86_64_v2_root = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root}"
SRC_URI[x86_64_v2_root.sha256sum] = "77d8fcf02af8906f33ce22ea0fdf47e36fa779c4f37c5fe4077966c3cdf9f73c"

URI_x86_64_v2_root-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-cli-6.40.02-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_root-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-cli}"
SRC_URI[x86_64_v2_root-cli.sha256sum] = "1186320070f49e738362bac249445d3e5a1e731c83770af758586810382c70fd"

URI_x86_64_v2_root-cling = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-cling-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-cling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-cling}"
SRC_URI[x86_64_v2_root-cling.sha256sum] = "f31dd8bcfbf2e84e318094f3f71dd1455f78095cf6ea545523772574ba634f6b"

URI_x86_64_v2_root-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-core-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-core}"
SRC_URI[x86_64_v2_root-core.sha256sum] = "1d581d3ce9b23b60fc67f35abb8b0a692fd8bb36f68ab204ce5cbdd7c78b413a"

URI_x86_64_v2_root-fftw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-fftw-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-fftw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-fftw}"
SRC_URI[x86_64_v2_root-fftw.sha256sum] = "91c1cf857e7c9c1c36c6e906c7ba26def490a051b8f82dbbe7b9a14520d83dbe"

URI_x86_64_v2_root-foam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-foam-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-foam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-foam}"
SRC_URI[x86_64_v2_root-foam.sha256sum] = "9d8c81844c1b2128c336ad748e43e3d92409a3bb96f2cc3e79d6310ecd29dcb1"

URI_x86_64_v2_root-font-files = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-font-files-6.40.02-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_root-font-files;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-font-files}"
SRC_URI[x86_64_v2_root-font-files.sha256sum] = "1dc2ebb3898885117f89fe7d5dd7bfb1e7d1d28201933e073c1a41ec47b5b084"

URI_x86_64_v2_root-fumili = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-fumili-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-fumili;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-fumili}"
SRC_URI[x86_64_v2_root-fumili.sha256sum] = "2d86a2e7b42086af9c7b2ddc4d1676c65add0fdaad0402c7028f8cde00357e18"

URI_x86_64_v2_root-gdml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gdml-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gdml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gdml}"
SRC_URI[x86_64_v2_root-gdml.sha256sum] = "58d5405777dd7b938592cc098c6947dfccd888bbeebaae42abdb48ffc8cd92c2"

URI_x86_64_v2_root-genetic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-genetic-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-genetic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-genetic}"
SRC_URI[x86_64_v2_root-genetic.sha256sum] = "92dff9dea3d2ea917139237d9977d112efa94dd38f2c3c6d33213e09c41a0e2f"

URI_x86_64_v2_root-genvector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-genvector-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-genvector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-genvector}"
SRC_URI[x86_64_v2_root-genvector.sha256sum] = "2bfa2e8bc0c2cc7f4750fe43df7a3cb5317582b5225def470a1e02cbef6dc426"

URI_x86_64_v2_root-geom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom}"
SRC_URI[x86_64_v2_root-geom.sha256sum] = "2f55da0c0a07d459316f71b51893ac2e68a7abdded72be572a058419935c0778"

URI_x86_64_v2_root-geom-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-builder-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-builder}"
SRC_URI[x86_64_v2_root-geom-builder.sha256sum] = "d4e2b95970e3aa60a243defb9e99b8a64b961fe2ad2d49e00d2c4b492454dda2"

URI_x86_64_v2_root-geom-checker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-checker-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-checker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-checker}"
SRC_URI[x86_64_v2_root-geom-checker.sha256sum] = "2523251dc1eab8e678fbed96e4c14694e9af0a956883b624144d87093174d05f"

URI_x86_64_v2_root-geom-painter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-painter-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-painter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-painter}"
SRC_URI[x86_64_v2_root-geom-painter.sha256sum] = "d18542f0d0b2f8daecaefd757ea74a607ecc655c073a90231ba1b52e18c72923"

URI_x86_64_v2_root-geom-webviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-webviewer-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-webviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-webviewer}"
SRC_URI[x86_64_v2_root-geom-webviewer.sha256sum] = "fb76608c4553cfe94e81947b4fe3659f086faedce13d05363cd3b508c67147f7"

URI_x86_64_v2_root-graf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf}"
SRC_URI[x86_64_v2_root-graf.sha256sum] = "7580e20901e136bb7ea90e49eb1da53426322804e80b3cab3c33d791725a4cf5"

URI_x86_64_v2_root-graf-asimage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-asimage-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-asimage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-asimage}"
SRC_URI[x86_64_v2_root-graf-asimage.sha256sum] = "e3b0f5a0fca9bcece9ab111c5c6eb6d47f208c6c7996a921f4e7e1239e0c603f"

URI_x86_64_v2_root-graf-fitsio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-fitsio-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-fitsio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-fitsio}"
SRC_URI[x86_64_v2_root-graf-fitsio.sha256sum] = "6e9a8c35d49a452f687b1febf9da7eee1a126d77bf56d70ef8626c64ff453ff2"

URI_x86_64_v2_root-graf-gpad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gpad-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gpad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-gpad}"
SRC_URI[x86_64_v2_root-graf-gpad.sha256sum] = "7adcf440f13c0e3264489094540b2e19bc371fe420925e91449e115ee80404e6"

URI_x86_64_v2_root-graf-gpadv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gpadv7-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gpadv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-gpadv7}"
SRC_URI[x86_64_v2_root-graf-gpadv7.sha256sum] = "2bbd0ee7a504322b39d62f6cfa910b507d06a0db1d2fdacf470c5bc388d28633"

URI_x86_64_v2_root-graf-gviz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gviz-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gviz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-gviz}"
SRC_URI[x86_64_v2_root-graf-gviz.sha256sum] = "911c0c4930c273c664a7c023d829e249c1e20629cd432e87c87cd26a38b700a5"

URI_x86_64_v2_root-graf-postscript = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-postscript-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-postscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-postscript}"
SRC_URI[x86_64_v2_root-graf-postscript.sha256sum] = "e582abaaab706f07e9bd2560a6a73e5077226d98c5f328d43a88abffd1546d99"

URI_x86_64_v2_root-graf-primitives = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-primitives-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-primitives;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-primitives}"
SRC_URI[x86_64_v2_root-graf-primitives.sha256sum] = "0ceaf75ad47486ea8b0eeac038ef25e1d8542bd44a86de137d17e329e4f922eb"

URI_x86_64_v2_root-graf-x11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-x11-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-x11}"
SRC_URI[x86_64_v2_root-graf-x11.sha256sum] = "4c2d5f602ea7488a537b1e3ff59c8dbe0720b6b897739111e227527830fc6eb1"

URI_x86_64_v2_root-graf3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d}"
SRC_URI[x86_64_v2_root-graf3d.sha256sum] = "c89f2600d47e934ac38f4264d79874800812c07ae24ad5642693a5b8f0da7cca"

URI_x86_64_v2_root-graf3d-csg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-csg-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-csg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-csg}"
SRC_URI[x86_64_v2_root-graf3d-csg.sha256sum] = "31cbb1ef4c61e16c84e6e19c114bdc1566635f6bb7e1ccb745492647e80bc7bf"

URI_x86_64_v2_root-graf3d-eve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-eve-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-eve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-eve}"
SRC_URI[x86_64_v2_root-graf3d-eve.sha256sum] = "19241f310e58994d3dbe3f13a2fd4dd2369cc452287645ddd755b457a5f2e261"

URI_x86_64_v2_root-graf3d-eve7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-eve7-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-eve7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-eve7}"
SRC_URI[x86_64_v2_root-graf3d-eve7.sha256sum] = "ed865a705b5f8d56955eff3a4d785980fc00e7e940d2f66ea69ea069529b83f7"

URI_x86_64_v2_root-graf3d-gl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-gl-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-gl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-gl}"
SRC_URI[x86_64_v2_root-graf3d-gl.sha256sum] = "3b7fa5fa747f8ef6345a06519484ec61c32fa7791d4bad5f5fd90396e092427b"

URI_x86_64_v2_root-graf3d-glad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-glad-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-glad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-glad}"
SRC_URI[x86_64_v2_root-graf3d-glad.sha256sum] = "d16256c2b520ed88ee59443c86e2b0c10920acae0ac783f4a267baaf00bf1433"

URI_x86_64_v2_root-graf3d-gviz3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-gviz3d-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-gviz3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-gviz3d}"
SRC_URI[x86_64_v2_root-graf3d-gviz3d.sha256sum] = "692e7c802eb0034e17745fc3fb577167b89da6ae03165b810df219e518333411"

URI_x86_64_v2_root-graf3d-x3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-x3d-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-x3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-x3d}"
SRC_URI[x86_64_v2_root-graf3d-x3d.sha256sum] = "e1401328443e343c5136be12429a21c78ff626573b3b1c6070a18a5d2c9c70f7"

URI_x86_64_v2_root-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui}"
SRC_URI[x86_64_v2_root-gui.sha256sum] = "6bf861bdd8155c5b481068071d46c2bff20047277ec3fa005cb5a005a7beb703"

URI_x86_64_v2_root-gui-browsable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browsable-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browsable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browsable}"
SRC_URI[x86_64_v2_root-gui-browsable.sha256sum] = "d71150720dd2bca22bfd88d395d1e6644e9a53d8ca9c0e8aeb61c04b14f78b67"

URI_x86_64_v2_root-gui-browsable-v7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browsable-v7-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browsable-v7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browsable-v7}"
SRC_URI[x86_64_v2_root-gui-browsable-v7.sha256sum] = "e7204a9d14b99732c9f01011a54be3f4c68b3184e9acaa95f6f5fa1e1d36d0f1"

URI_x86_64_v2_root-gui-browserv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browserv7-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browserv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browserv7}"
SRC_URI[x86_64_v2_root-gui-browserv7.sha256sum] = "6ce91461e34789ad95a9e3df59d6e2425f9ed0f84f84638226461704e39a9b50"

URI_x86_64_v2_root-gui-browserv7-v7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browserv7-v7-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browserv7-v7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browserv7-v7}"
SRC_URI[x86_64_v2_root-gui-browserv7-v7.sha256sum] = "6a3c39c49bfb963f9205ee47b4b6b3a6fcc8a4239cc925aff32805045ce2c5f1"

URI_x86_64_v2_root-gui-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-builder-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-builder}"
SRC_URI[x86_64_v2_root-gui-builder.sha256sum] = "0585a66bc8547356452f16eff193c8fb9daedaa345192856adf5bf0421905bdd"

URI_x86_64_v2_root-gui-canvaspainter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-canvaspainter-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-canvaspainter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-canvaspainter}"
SRC_URI[x86_64_v2_root-gui-canvaspainter.sha256sum] = "88826bd812c48c26d5f5e66f2ab54a92fcd208f9aacd2a2c4ea62bf157f3661d"

URI_x86_64_v2_root-gui-fitpanel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-fitpanel-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-fitpanel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-fitpanel}"
SRC_URI[x86_64_v2_root-gui-fitpanel.sha256sum] = "6bfe65105abafbd2a3404c868cc79bf89c44f89bc22485ccf4391cdc8dab0f9f"

URI_x86_64_v2_root-gui-fitpanelv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-fitpanelv7-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-fitpanelv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-fitpanelv7}"
SRC_URI[x86_64_v2_root-gui-fitpanelv7.sha256sum] = "ec06cb88a7bf41b349f973ef82d4f1f3b6de03bffda0faf57aa26a1385610893"

URI_x86_64_v2_root-gui-ged = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-ged-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-ged;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-ged}"
SRC_URI[x86_64_v2_root-gui-ged.sha256sum] = "1a1802be3c429e41a86f65b7056745f7e6144b1e1c916ae4c376bce211d90111"

URI_x86_64_v2_root-gui-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-html-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-html}"
SRC_URI[x86_64_v2_root-gui-html.sha256sum] = "1910634051ae2a452ce36b93cefac57a5a9b991a8df7526873827824816edb4b"

URI_x86_64_v2_root-gui-qt6webdisplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-qt6webdisplay-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-qt6webdisplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-qt6webdisplay}"
SRC_URI[x86_64_v2_root-gui-qt6webdisplay.sha256sum] = "91a1ae5c4246b1b8d5569765f5484d8e39128e23fc70ee916f1778fc18aecade"

URI_x86_64_v2_root-gui-recorder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-recorder-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-recorder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-recorder}"
SRC_URI[x86_64_v2_root-gui-recorder.sha256sum] = "cc32dd0d254744c85e12814eeb850e933095c3cff35bdb0e8814699724e4729e"

URI_x86_64_v2_root-gui-treemap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-treemap-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-treemap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-treemap}"
SRC_URI[x86_64_v2_root-gui-treemap.sha256sum] = "85041c1777b32b8e9a726b2280901c8d02243415c7ddc3211915bd7abb5755cc"

URI_x86_64_v2_root-gui-webdisplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-webdisplay-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-webdisplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-webdisplay}"
SRC_URI[x86_64_v2_root-gui-webdisplay.sha256sum] = "53705a6f5f8bb7a12b01957eb0453e7099635848ef3156e92a8ac45a29a17228"

URI_x86_64_v2_root-gui-webgui6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-webgui6-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-webgui6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-webgui6}"
SRC_URI[x86_64_v2_root-gui-webgui6.sha256sum] = "2abba47583187c4dc8eff34dfe222698f4ff1adb81567fe683cf49b9187f6170"

URI_x86_64_v2_root-hbook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hbook-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hbook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hbook}"
SRC_URI[x86_64_v2_root-hbook.sha256sum] = "61c34521da95cfa6aaa674309705e6961d4756b1859ed297e9183d3f7f128d2c"

URI_x86_64_v2_root-hist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hist}"
SRC_URI[x86_64_v2_root-hist.sha256sum] = "3acf950c6999f19d9e825bbf359ce9bcd1676ec74139f0658ae89b2b2d9c6f60"

URI_x86_64_v2_root-hist-factory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-factory-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist-factory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hist-factory}"
SRC_URI[x86_64_v2_root-hist-factory.sha256sum] = "036a60993d4cb109ef06dc14a4ac97cbd3a0df38af483462459b94483ee1a13e"

URI_x86_64_v2_root-hist-painter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-painter-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist-painter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hist-painter}"
SRC_URI[x86_64_v2_root-hist-painter.sha256sum] = "5e3913625b423b341a013de30070b085e97265aab15ed4141aaeab50e9fca2ba"

URI_x86_64_v2_root-histv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-histv7-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-histv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-histv7}"
SRC_URI[x86_64_v2_root-histv7.sha256sum] = "ff3f10e1382b3629b2df967d94a83225ecb8e9ef821554aad38879243a27d221"

URI_x86_64_v2_root-histv7util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-histv7util-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-histv7util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-histv7util}"
SRC_URI[x86_64_v2_root-histv7util.sha256sum] = "88b4de523e22dfc56dfcb8bf8982f9f7c174a8182d6f17c057e1a603ddbcda1b"

URI_x86_64_v2_root-icons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-icons-6.40.02-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_root-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-icons}"
SRC_URI[x86_64_v2_root-icons.sha256sum] = "568bdd4f6803ef0139b079f62e64bcc506ea6d0c48484e417f0b1407ae40cd40"

URI_x86_64_v2_root-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io}"
SRC_URI[x86_64_v2_root-io.sha256sum] = "20ba566ce48dbac6a187189bc34d614fecbd9d1718860fbf79f13b91daa0026c"

URI_x86_64_v2_root-io-dcache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-dcache-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-dcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-dcache}"
SRC_URI[x86_64_v2_root-io-dcache.sha256sum] = "3942a06a07032911a2a5221f4ab79f8a71bbc86aafcf8ee6955f503d077e1418"

URI_x86_64_v2_root-io-sql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-sql-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-sql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-sql}"
SRC_URI[x86_64_v2_root-io-sql.sha256sum] = "fe380395f44db885b830f6a186c984a8feff996fd4c1b422108c7a86bb835111"

URI_x86_64_v2_root-io-xml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-xml-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-xml}"
SRC_URI[x86_64_v2_root-io-xml.sha256sum] = "128de3415e5e377ff5396047d4c23ad62dec692930fd077237283fa561231325"

URI_x86_64_v2_root-io-xmlparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-xmlparser-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-xmlparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-xmlparser}"
SRC_URI[x86_64_v2_root-io-xmlparser.sha256sum] = "af0bf428cab56638dd12197361ce3c048913fcbcedfaa85b977618bc0528b5a8"

URI_x86_64_v2_root-mathcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mathcore-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mathcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-mathcore}"
SRC_URI[x86_64_v2_root-mathcore.sha256sum] = "f5dd8d3684e32eae76db4a34da9a291bc3124dcaa0b25061a47300c1b62c0204"

URI_x86_64_v2_root-mathmore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mathmore-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mathmore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-mathmore}"
SRC_URI[x86_64_v2_root-mathmore.sha256sum] = "d2b5b230771634fc2b2c683458564d0e320a61ffd848abc437ab1fe89d5ed3fc"

URI_x86_64_v2_root-matrix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-matrix-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-matrix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-matrix}"
SRC_URI[x86_64_v2_root-matrix.sha256sum] = "855e205224274dc0016642d48983df030a88a0f5c6ad23642bffa7267cfe17c6"

URI_x86_64_v2_root-minuit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-minuit-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-minuit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-minuit}"
SRC_URI[x86_64_v2_root-minuit.sha256sum] = "9cb429654b3d8ae13a91fbed7fb38c51b6a9bfe6efdb7492773a0f14083793d1"

URI_x86_64_v2_root-minuit2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-minuit2-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-minuit2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-minuit2}"
SRC_URI[x86_64_v2_root-minuit2.sha256sum] = "f4161d566c070e128721478a8735f9e3a35319090a83d67d895e5304c1ed5d34"

URI_x86_64_v2_root-mlp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mlp-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mlp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-mlp}"
SRC_URI[x86_64_v2_root-mlp.sha256sum] = "c7a6c46a7d75d06916c173ad4bc2c49876fe73a02545d6378fceab2597028eb3"

URI_x86_64_v2_root-montecarlo-eg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-montecarlo-eg-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-montecarlo-eg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-montecarlo-eg}"
SRC_URI[x86_64_v2_root-montecarlo-eg.sha256sum] = "a43ed9cba25a2f8011b2f2dcfa8330915237c91c5190187a65db36c9be66b807"

URI_x86_64_v2_root-montecarlo-pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-montecarlo-pythia8-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-montecarlo-pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-montecarlo-pythia8}"
SRC_URI[x86_64_v2_root-montecarlo-pythia8.sha256sum] = "1744cd40f061848c3da6f4b8a71fd8f66ec867217e03085cc93e7fdf177d5734"

URI_x86_64_v2_root-multiproc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-multiproc-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-multiproc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-multiproc}"
SRC_URI[x86_64_v2_root-multiproc.sha256sum] = "5b5b06dd140324e5971b96cf8108a5107cc92f2a3883b016677cf13b756283ed"

URI_x86_64_v2_root-net = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net}"
SRC_URI[x86_64_v2_root-net.sha256sum] = "7137ec2cb195e88c55c38fb54e946ccb300cdaba3b3f0048b3acc94ab81e9390"

URI_x86_64_v2_root-net-auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-auth-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-auth}"
SRC_URI[x86_64_v2_root-net-auth.sha256sum] = "4678c6930d7ac1fd702a94a6a9aa6be0e3fb958828a9fe138e4bbc6803889955"

URI_x86_64_v2_root-net-curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-curl-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-curl}"
SRC_URI[x86_64_v2_root-net-curl.sha256sum] = "843806dbf0342564a9914ec33b706f1a8fe676804e75d8d7b9cc086e7485848d"

URI_x86_64_v2_root-net-davix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-davix-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-davix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-davix}"
SRC_URI[x86_64_v2_root-net-davix.sha256sum] = "f17eb2000f626c73594420670307beb6a9cb90c99d381643a4c94202fb01c39f"

URI_x86_64_v2_root-net-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-http-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-http}"
SRC_URI[x86_64_v2_root-net-http.sha256sum] = "ba4678416f0f248b7f09f521c6a1a62cd0f569db17fc287be0c41f451786f034"

URI_x86_64_v2_root-net-httpsniff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-httpsniff-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-httpsniff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-httpsniff}"
SRC_URI[x86_64_v2_root-net-httpsniff.sha256sum] = "a9045373ed8a5b35702e204067cd6ca13ab127511d20ea166730795d214498f5"

URI_x86_64_v2_root-net-rpdutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-rpdutils-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-rpdutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-rpdutils}"
SRC_URI[x86_64_v2_root-net-rpdutils.sha256sum] = "b9855908d285c3ebf9fb0ccab5b608356ea5c72a8a410a1c542fbc2f9bdf2bc6"

URI_x86_64_v2_root-netx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-netx-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-netx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-netx}"
SRC_URI[x86_64_v2_root-netx.sha256sum] = "daf05b6eb5fc9b508652c6f715afde4be56765622c67c16ceb5bdc949987b40f"

URI_x86_64_v2_root-physics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-physics-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-physics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-physics}"
SRC_URI[x86_64_v2_root-physics.sha256sum] = "791bff1e372dd0907fdd29234e2142472f3238ea079b3355699b988a247b6aa8"

URI_x86_64_v2_root-quadp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-quadp-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-quadp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-quadp}"
SRC_URI[x86_64_v2_root-quadp.sha256sum] = "fe42b8db840c33da26110f433922dcdd81d247738daef26e548cfdd4b02a68f8"

URI_x86_64_v2_root-r = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-r-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-r;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-r}"
SRC_URI[x86_64_v2_root-r.sha256sum] = "f963b7ff5e22e83e2d3695a4e03984ac8724dbe7ff0f01d7a15a69f473ad00cf"

URI_x86_64_v2_root-r-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-r-tools-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-r-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-r-tools}"
SRC_URI[x86_64_v2_root-r-tools.sha256sum] = "85f068471107b40842fc8447f22ccecbe6c41f59b738a1e935500907cd77251d"

URI_x86_64_v2_root-roofit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit}"
SRC_URI[x86_64_v2_root-roofit.sha256sum] = "eec6844f6628f1bf7b7b468c73e1bfbf4a890715914a69b90ee082194d2bf62f"

URI_x86_64_v2_root-roofit-batchcompute = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-batchcompute-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-batchcompute;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-batchcompute}"
SRC_URI[x86_64_v2_root-roofit-batchcompute.sha256sum] = "f299bf543871ef38cc0c4d30df0e3a2dd4d5d5dbf7bef505439e897edf373997"

URI_x86_64_v2_root-roofit-codegen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-codegen-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-codegen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-codegen}"
SRC_URI[x86_64_v2_root-roofit-codegen.sha256sum] = "0bba49e34a69b9f838fb8c44c809dc0bfafa0cc32d4ff0b657685e244bfaa39a"

URI_x86_64_v2_root-roofit-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-core-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-core}"
SRC_URI[x86_64_v2_root-roofit-core.sha256sum] = "41a315abcd11ab5a4a188a8c3ff9ede6a42dfe31c9841fcc04fa7acea9bfada9"

URI_x86_64_v2_root-roofit-hs3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-hs3-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-hs3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-hs3}"
SRC_URI[x86_64_v2_root-roofit-hs3.sha256sum] = "2dd5f2e69067357331ff709e43a18df48a834987a87516827ed7815bf59f6516"

URI_x86_64_v2_root-roofit-jsoninterface = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-jsoninterface-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-jsoninterface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-jsoninterface}"
SRC_URI[x86_64_v2_root-roofit-jsoninterface.sha256sum] = "b655c3d5cda6df02cedabeff678a1ead6adb39c0c819863d7d789f5d6028441f"

URI_x86_64_v2_root-roofit-more = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-more-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-more;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-more}"
SRC_URI[x86_64_v2_root-roofit-more.sha256sum] = "9ec02f23c737d95465b6cacca39cf213cbb3a163da3e10eca5126ffcb66ebeb3"

URI_x86_64_v2_root-roofit-multiprocess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-multiprocess-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-multiprocess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-multiprocess}"
SRC_URI[x86_64_v2_root-roofit-multiprocess.sha256sum] = "71db0732cc3198e761dfc1f81f162ee4050ef5107f79c614096c50e0671d927f"

URI_x86_64_v2_root-roofit-zmq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-zmq-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-zmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-zmq}"
SRC_URI[x86_64_v2_root-roofit-zmq.sha256sum] = "db8f2191fd3adfc3d602e2aec25dfbf9b5b6853fe9565d96894bcd47176ff8a8"

URI_x86_64_v2_root-roostats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roostats-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roostats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roostats}"
SRC_URI[x86_64_v2_root-roostats.sha256sum] = "f20c7f19c16c2f05c56cdc7030b91f9c84ca618c901372e19afbb6089bfa7f29"

URI_x86_64_v2_root-smatrix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-smatrix-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-smatrix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-smatrix}"
SRC_URI[x86_64_v2_root-smatrix.sha256sum] = "1066f449a0c1c211e7d470fc28b1b9eb71e058be98ce022caf683edf1ae4b032"

URI_x86_64_v2_root-spectrum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-spectrum-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-spectrum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-spectrum}"
SRC_URI[x86_64_v2_root-spectrum.sha256sum] = "21fb6d5d2adbaa41351ee33076e5af7fa020b122eb549690a4d467d41c9e6313"

URI_x86_64_v2_root-spectrum-painter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-spectrum-painter-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-spectrum-painter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-spectrum-painter}"
SRC_URI[x86_64_v2_root-spectrum-painter.sha256sum] = "14854deed9f6d227fd4f61eb1286b1f6073be795651aeb248d10bfaad6368048"

URI_x86_64_v2_root-splot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-splot-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-splot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-splot}"
SRC_URI[x86_64_v2_root-splot.sha256sum] = "d75b780780e8b53e4f93b28ed4614811286c7189d89dc21565aa4085cbe4894f"

URI_x86_64_v2_root-sql-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-sql-sqlite-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-sql-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-sql-sqlite}"
SRC_URI[x86_64_v2_root-sql-sqlite.sha256sum] = "b66a3b32e6ed2b5b476cadc68e0cb777df980fbcf68b3f44a296a6624636379a"

URI_x86_64_v2_root-testsupport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-testsupport-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-testsupport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-testsupport}"
SRC_URI[x86_64_v2_root-testsupport.sha256sum] = "cd6c4903b2ca7974bff74877e1b677b651f865bf7ad5eb20a12e5f658507dce5"

URI_x86_64_v2_root-tmva = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva}"
SRC_URI[x86_64_v2_root-tmva.sha256sum] = "972f44d489d6a7581ab29c3ce30974eb257ed596caa8a777dccb097451714ec6"

URI_x86_64_v2_root-tmva-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-gui-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-gui}"
SRC_URI[x86_64_v2_root-tmva-gui.sha256sum] = "f86af8969773af66509ec6f113b12fac66b0039d27fb167671240d067cd9509c"

URI_x86_64_v2_root-tmva-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-python-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-python}"
SRC_URI[x86_64_v2_root-tmva-python.sha256sum] = "d9a0b7574cc4822dd724d7c57cdb4172c198a2e6d039baee924e9974ee78eece"

URI_x86_64_v2_root-tmva-r = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-r-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-r;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-r}"
SRC_URI[x86_64_v2_root-tmva-r.sha256sum] = "678a3ad8a1deda345c262f4369b7cdf5cc1c78f3794b5167aca2b34532715348"

URI_x86_64_v2_root-tmva-sofie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-sofie}"
SRC_URI[x86_64_v2_root-tmva-sofie.sha256sum] = "3abb13b3d7aa32c9d7af9e65178694d4f9d9b39b7615de25266cc281fb76b1e9"

URI_x86_64_v2_root-tmva-sofie-parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-parser-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie-parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-sofie-parser}"
SRC_URI[x86_64_v2_root-tmva-sofie-parser.sha256sum] = "769269ba0bc64fb923eb36f2423c29b28c03fe5fef55b7f1bde9a7be4cbe18bd"

URI_x86_64_v2_root-tmva-sofie-parser-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-parser-python-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie-parser-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-sofie-parser-python}"
SRC_URI[x86_64_v2_root-tmva-sofie-parser-python.sha256sum] = "23ae97f80683b8110d61fbfe916db803063468222507b3aef309629be51ed13f"

URI_x86_64_v2_root-tmva-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-utils-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-utils}"
SRC_URI[x86_64_v2_root-tmva-utils.sha256sum] = "2061ad9e20c70b56c325e40dbac27903e057ef6ee850decc714eafb60be2eb69"

URI_x86_64_v2_root-tpython = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tpython-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tpython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tpython}"
SRC_URI[x86_64_v2_root-tpython.sha256sum] = "6613e61b6d16d893ea5993344bfa117ba97f90740a9d810880489aa29c654c5d"

URI_x86_64_v2_root-tree = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree}"
SRC_URI[x86_64_v2_root-tree.sha256sum] = "728b6576a3b7c68506bb2630b7846c26d5c34709270b87c13e5c038b6001ce31"

URI_x86_64_v2_root-tree-dataframe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-dataframe-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-dataframe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-dataframe}"
SRC_URI[x86_64_v2_root-tree-dataframe.sha256sum] = "d0e3128ed1e05336579f16185a41ebdeee6b505b2877669352d16287b2406411"

URI_x86_64_v2_root-tree-ml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ml-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ml}"
SRC_URI[x86_64_v2_root-tree-ml.sha256sum] = "835826eff7d02a44acf86c969ee18b05208edf7777172d2d22be7b781b11b8b3"

URI_x86_64_v2_root-tree-ntuple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ntuple}"
SRC_URI[x86_64_v2_root-tree-ntuple.sha256sum] = "9911789f287987aeb30eeb0b4918f7799f7dbecb8c6f33655e9324bb945a6861"

URI_x86_64_v2_root-tree-ntuple-browse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-browse-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple-browse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ntuple-browse}"
SRC_URI[x86_64_v2_root-tree-ntuple-browse.sha256sum] = "5360bf8e7e711f5fbed9b4ad81fd1e17b6ed3ff58084b767fbd1666f6b1f8b1c"

URI_x86_64_v2_root-tree-ntuple-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-utils-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ntuple-utils}"
SRC_URI[x86_64_v2_root-tree-ntuple-utils.sha256sum] = "f0cce64cf45c8a639f33afc2c9180d4dbaff32027f8e8b87875cccff8e055ab3"

URI_x86_64_v2_root-tree-player = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-player-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-player;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-player}"
SRC_URI[x86_64_v2_root-tree-player.sha256sum] = "df1994b315f035eb2dca1b6628a689d37e8db4f7658510ca08cb83d1f2aba1ca"

URI_x86_64_v2_root-tree-viewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-viewer-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-viewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-viewer}"
SRC_URI[x86_64_v2_root-tree-viewer.sha256sum] = "fa4e3eed2d0a0e7aea88fb903bb8b71d5a5b46e47cb446188e086845da8e83d5"

URI_x86_64_v2_root-tree-webviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-webviewer-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-webviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-webviewer}"
SRC_URI[x86_64_v2_root-tree-webviewer.sha256sum] = "b3a245c8d9e35c67c66fba4f74ecc8df3bc260f533afb0c8cdb0a3c35627b843"

URI_x86_64_v2_root-tutorial = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tutorial-6.40.02-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_root-tutorial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tutorial}"
SRC_URI[x86_64_v2_root-tutorial.sha256sum] = "dbba420bd51a04d0eb74e7ed192a0760eb0be424bf400781ebd555850a5f46cc"

URI_x86_64_v2_root-unfold = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-unfold-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-unfold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-unfold}"
SRC_URI[x86_64_v2_root-unfold.sha256sum] = "18106d78bff9032e533219c80a93bc0f052ff4fa32a39988e8f82b72525ece08"

URI_x86_64_v2_root-unuran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-unuran-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-unuran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-unuran}"
SRC_URI[x86_64_v2_root-unuran.sha256sum] = "15377aee5b6d79cc6848d21f74cca856e24ba4a295961e8f20b93f3733215d31"

URI_x86_64_v2_root-vecops = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-vecops-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-vecops;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-vecops}"
SRC_URI[x86_64_v2_root-vecops.sha256sum] = "b4184c10040b5875aec6f90e89346add88555b08c07d6a25acfe420438fbbdc3"

URI_x86_64_v2_root-xroofit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-xroofit-6.40.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-xroofit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-xroofit}"
SRC_URI[x86_64_v2_root-xroofit.sha256sum] = "8ec0b0ca74cff866f6695033d1bcb30423ddb3ee2c4ef724a16cf8b2b78d0a60"

URI_aarch64_python3-root = "${EPEL_MIRROR}/aarch64/Packages/p/python3-root-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_python3-root;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-root}"
SRC_URI[aarch64_python3-root.sha256sum] = "bb11f33c2afd1c83846a19be34efa73fce53ad421a63b8a456601b3ba8bd4dd3"

URI_aarch64_python3-root+distrdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-root+distrdf-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_python3-root+distrdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-root+distrdf}"
SRC_URI[aarch64_python3-root+distrdf.sha256sum] = "7e0fbd802fd2577ca09612ac6259f11d3f090b086821e71b0f403356a27b0959"

URI_aarch64_python3-root+jupyroot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-root+jupyroot-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_python3-root+jupyroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-root+jupyroot}"
SRC_URI[aarch64_python3-root+jupyroot.sha256sum] = "857ba13d7a719fdc972ba34064145d40baaba0de85dcde80018d21a52b02c8aa"

URI_aarch64_root = "${EPEL_MIRROR}/aarch64/Packages/r/root-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root;unpack=0"
SRC_URI:append = " ${URI_aarch64_root}"
SRC_URI[aarch64_root.sha256sum] = "779df75227fd5c096d701268b33eef65bbb0dd5f7ddd69785a18b6ac88c7baa2"

URI_aarch64_root-cli = "${EPEL_MIRROR}/aarch64/Packages/r/root-cli-6.40.02-1.el10_2.noarch.rpm;name=aarch64_root-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-cli}"
SRC_URI[aarch64_root-cli.sha256sum] = "d8bed476d6b3faba9c2e64874a8d439e72133dad292d53b00538757958368c02"

URI_aarch64_root-cling = "${EPEL_MIRROR}/aarch64/Packages/r/root-cling-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-cling;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-cling}"
SRC_URI[aarch64_root-cling.sha256sum] = "22032b75cb767a248bd5ae985637f3a9d37e66ddda7566937fa020707445698a"

URI_aarch64_root-core = "${EPEL_MIRROR}/aarch64/Packages/r/root-core-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-core}"
SRC_URI[aarch64_root-core.sha256sum] = "d2696195a23119ce51a8a89e09d592f22a93a1023171be23db846cd19f4e8a4c"

URI_aarch64_root-fftw = "${EPEL_MIRROR}/aarch64/Packages/r/root-fftw-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-fftw;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-fftw}"
SRC_URI[aarch64_root-fftw.sha256sum] = "283ab0912bf3a9d465b58f78d81a3716e95ba9b0d08d79c7f89d912306823817"

URI_aarch64_root-foam = "${EPEL_MIRROR}/aarch64/Packages/r/root-foam-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-foam;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-foam}"
SRC_URI[aarch64_root-foam.sha256sum] = "3fd13fb3b1829a2be3afefd7ac9da5afe513deea24f47923796593f09b9b1287"

URI_aarch64_root-font-files = "${EPEL_MIRROR}/aarch64/Packages/r/root-font-files-6.40.02-1.el10_2.noarch.rpm;name=aarch64_root-font-files;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-font-files}"
SRC_URI[aarch64_root-font-files.sha256sum] = "b3d3f3c4a0a702d1b7606cb08ce7d87ae601e2dc5f7f94b81030490bf714b1b7"

URI_aarch64_root-fumili = "${EPEL_MIRROR}/aarch64/Packages/r/root-fumili-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-fumili;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-fumili}"
SRC_URI[aarch64_root-fumili.sha256sum] = "9901d3e00cc8808ccfa021779acc511289cc09e5dcab2636c10a3098be2cab70"

URI_aarch64_root-gdml = "${EPEL_MIRROR}/aarch64/Packages/r/root-gdml-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gdml;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gdml}"
SRC_URI[aarch64_root-gdml.sha256sum] = "98f1f5cc3d1233ffb9aac3c4403a9fa92428fcb09b1bcb911f8775c59e4ed604"

URI_aarch64_root-genetic = "${EPEL_MIRROR}/aarch64/Packages/r/root-genetic-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-genetic;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-genetic}"
SRC_URI[aarch64_root-genetic.sha256sum] = "7f046152d4e78fb60a223313cbdb4b11bf7ba3c6157a5a36931c970b32bb1ac7"

URI_aarch64_root-genvector = "${EPEL_MIRROR}/aarch64/Packages/r/root-genvector-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-genvector;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-genvector}"
SRC_URI[aarch64_root-genvector.sha256sum] = "8f632d3dde3b6ced6127136e97a608dcad93d1f416354175e20793d2c71b4708"

URI_aarch64_root-geom = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-geom;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom}"
SRC_URI[aarch64_root-geom.sha256sum] = "199cd97f45215524fa24bd5e4265d77b52ff8d4997fddcb493b9c7d660805647"

URI_aarch64_root-geom-builder = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-builder-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-geom-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-builder}"
SRC_URI[aarch64_root-geom-builder.sha256sum] = "0db3d93c2e54b20caf14efff0caa762be8d574a71a4ec931139488c83388001a"

URI_aarch64_root-geom-checker = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-checker-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-geom-checker;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-checker}"
SRC_URI[aarch64_root-geom-checker.sha256sum] = "58057b859e74598daba0c636ffe6b65833617a5784ee5953af705ec6b7a0cd50"

URI_aarch64_root-geom-painter = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-painter-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-geom-painter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-painter}"
SRC_URI[aarch64_root-geom-painter.sha256sum] = "8d4705323e272cfa56002ae82068e7356b14b3bb819ef43b10ca09a5ce7ea1cb"

URI_aarch64_root-geom-webviewer = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-webviewer-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-geom-webviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-webviewer}"
SRC_URI[aarch64_root-geom-webviewer.sha256sum] = "d02c36371fc3b5a39514ad199c6ab9fb16faccba65479a60832ec62d6dd02033"

URI_aarch64_root-graf = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf}"
SRC_URI[aarch64_root-graf.sha256sum] = "2815ba7c5338b5b3f81be48bdcda35e6a1e5a26cd6984c5513708a30f8c2e69d"

URI_aarch64_root-graf-asimage = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-asimage-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf-asimage;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-asimage}"
SRC_URI[aarch64_root-graf-asimage.sha256sum] = "484f28756d74fbdb9e453be623017309eb84bd6b3cea5b96eecc870593d41436"

URI_aarch64_root-graf-fitsio = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-fitsio-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf-fitsio;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-fitsio}"
SRC_URI[aarch64_root-graf-fitsio.sha256sum] = "8280bfb5e018b6bdf6a41ec530f50c43dca765419289e72930c7e8df2d9f2e9c"

URI_aarch64_root-graf-gpad = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gpad-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf-gpad;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-gpad}"
SRC_URI[aarch64_root-graf-gpad.sha256sum] = "45de985ae6eb3d464b634d069077aeac43fd5da06412b7ae0b0275730f7249dc"

URI_aarch64_root-graf-gpadv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gpadv7-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf-gpadv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-gpadv7}"
SRC_URI[aarch64_root-graf-gpadv7.sha256sum] = "d979b876438b53a589fd2ef4399aec45f39766512addd4f4326d4fcda35d1aff"

URI_aarch64_root-graf-gviz = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gviz-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf-gviz;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-gviz}"
SRC_URI[aarch64_root-graf-gviz.sha256sum] = "c218f6afd1abcf499ac639ab8b6cae9c6cb8dc9df9afdfb7be07297e890ed3a7"

URI_aarch64_root-graf-postscript = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-postscript-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf-postscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-postscript}"
SRC_URI[aarch64_root-graf-postscript.sha256sum] = "b064d014388580413e61231bc751cf257267b57e9c72f864b7a95805127cac2f"

URI_aarch64_root-graf-primitives = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-primitives-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf-primitives;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-primitives}"
SRC_URI[aarch64_root-graf-primitives.sha256sum] = "996f22a73956dd4abb41c7c30baad51607c4b01a1953e5349d405cc6cdc02f29"

URI_aarch64_root-graf-x11 = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-x11-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-x11}"
SRC_URI[aarch64_root-graf-x11.sha256sum] = "e35ca9a6d5c0fd18b17f32fd35932d6ff8646c9fc9f70ae0f8148dffdaa05613"

URI_aarch64_root-graf3d = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d}"
SRC_URI[aarch64_root-graf3d.sha256sum] = "382ff78ad0676fd43c37bb894a879e9e63e42736a3b0966a5747b3bc89e1043b"

URI_aarch64_root-graf3d-csg = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-csg-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-csg;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-csg}"
SRC_URI[aarch64_root-graf3d-csg.sha256sum] = "5d460542633bf9fed64bb808ab4e5d152e7e05cfe1fb06c7bdee8550d8781fc2"

URI_aarch64_root-graf3d-eve = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-eve-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-eve;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-eve}"
SRC_URI[aarch64_root-graf3d-eve.sha256sum] = "232e899e98dfc177579de3de38ffd398f26e6dd964d3f934afd2d9ec56b95ee4"

URI_aarch64_root-graf3d-eve7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-eve7-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-eve7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-eve7}"
SRC_URI[aarch64_root-graf3d-eve7.sha256sum] = "7120fecde3bfad0bed3aec458b7e7150257d7447845b44a9a93cba0bbf113fc9"

URI_aarch64_root-graf3d-gl = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-gl-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-gl;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-gl}"
SRC_URI[aarch64_root-graf3d-gl.sha256sum] = "e25632c7d4c53d8777e3f3483fc0c9f0c0a47ec6fb5678f72f27edf9cccfab16"

URI_aarch64_root-graf3d-glad = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-glad-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-glad;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-glad}"
SRC_URI[aarch64_root-graf3d-glad.sha256sum] = "0e10cced3ff857a56f0103244e75a1cfc3edfa315192cda919b733992e469334"

URI_aarch64_root-graf3d-gviz3d = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-gviz3d-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-gviz3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-gviz3d}"
SRC_URI[aarch64_root-graf3d-gviz3d.sha256sum] = "1cc5b1de97e8d7020ee36832336aa097d0a3626776697aed9fd714b2bd3e5a64"

URI_aarch64_root-graf3d-x3d = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-x3d-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-graf3d-x3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-x3d}"
SRC_URI[aarch64_root-graf3d-x3d.sha256sum] = "66911c9d09934bcd9abbe973bff8792ecc452ea5c744138010e653eea1e91a7b"

URI_aarch64_root-gui = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui}"
SRC_URI[aarch64_root-gui.sha256sum] = "dbdd8a784a17a364d579fdda16099001d32ef615192c7f6dcbf957d764fade69"

URI_aarch64_root-gui-browsable = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browsable-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-browsable;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browsable}"
SRC_URI[aarch64_root-gui-browsable.sha256sum] = "9e7ecfb9793ec2d3ffccfcbb24a41cd9051425b41954674d281148365f696ce5"

URI_aarch64_root-gui-browsable-v7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browsable-v7-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-browsable-v7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browsable-v7}"
SRC_URI[aarch64_root-gui-browsable-v7.sha256sum] = "0190c02f6439106adc2fb29d6a803a1ddfb7b96790dbbebeadd9215b8de38a26"

URI_aarch64_root-gui-browserv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browserv7-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-browserv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browserv7}"
SRC_URI[aarch64_root-gui-browserv7.sha256sum] = "9c3246dbec21a4a417b0521ee68452202e1ea0f14e5ad02a19e2662b6c462a48"

URI_aarch64_root-gui-browserv7-v7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browserv7-v7-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-browserv7-v7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browserv7-v7}"
SRC_URI[aarch64_root-gui-browserv7-v7.sha256sum] = "39774e2eff579b67791c8d470f176c67255cb808ba44c28109a7bac705a638c6"

URI_aarch64_root-gui-builder = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-builder-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-builder}"
SRC_URI[aarch64_root-gui-builder.sha256sum] = "1cdf97199a55dd8131fd3f36f86139783c414b031178b772a93b2f4114a979bc"

URI_aarch64_root-gui-canvaspainter = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-canvaspainter-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-canvaspainter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-canvaspainter}"
SRC_URI[aarch64_root-gui-canvaspainter.sha256sum] = "e272ad4b4db1228bf0f80a2559ee15a87f58a73b2d147000ff9c3106cfec2c23"

URI_aarch64_root-gui-fitpanel = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-fitpanel-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-fitpanel;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-fitpanel}"
SRC_URI[aarch64_root-gui-fitpanel.sha256sum] = "2245b7cde4e2c93925b9a04a4de2c8c5ef6064a08ea079053d475551c7fa308d"

URI_aarch64_root-gui-fitpanelv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-fitpanelv7-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-fitpanelv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-fitpanelv7}"
SRC_URI[aarch64_root-gui-fitpanelv7.sha256sum] = "1dd59ebba40885174483b7d82e58e1d2749104ede18f5f31fb5ac67d86dcc7b8"

URI_aarch64_root-gui-ged = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-ged-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-ged;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-ged}"
SRC_URI[aarch64_root-gui-ged.sha256sum] = "9cd0fe54bb036e9c52d7d57e292a784134eb6e2f6ab6588ff5f5937cea5f0e1a"

URI_aarch64_root-gui-html = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-html-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-html}"
SRC_URI[aarch64_root-gui-html.sha256sum] = "6efc70b9b6f023388ad105c0b9536b7cef72ff8d571e99338b08721713e2ef9e"

URI_aarch64_root-gui-qt6webdisplay = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-qt6webdisplay-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-qt6webdisplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-qt6webdisplay}"
SRC_URI[aarch64_root-gui-qt6webdisplay.sha256sum] = "1a2a93966ce4ea1de143ce6e5c1baba70ec6c8af99811c546b31ef53e3ad0ffa"

URI_aarch64_root-gui-recorder = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-recorder-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-recorder;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-recorder}"
SRC_URI[aarch64_root-gui-recorder.sha256sum] = "06c5afc2697806f1fc7afe0fe2b2bc813cab1de7ddac536349fdf6665ea01b45"

URI_aarch64_root-gui-treemap = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-treemap-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-treemap;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-treemap}"
SRC_URI[aarch64_root-gui-treemap.sha256sum] = "24d15486640f9c4fa21eb0cf75148bc99dadd112d51ade06d1524a8560921a82"

URI_aarch64_root-gui-webdisplay = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-webdisplay-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-webdisplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-webdisplay}"
SRC_URI[aarch64_root-gui-webdisplay.sha256sum] = "43c2ae40cfa6df27edf8fbe74f854155c6babf94d66e19727a89f26c615c22e9"

URI_aarch64_root-gui-webgui6 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-webgui6-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-gui-webgui6;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-webgui6}"
SRC_URI[aarch64_root-gui-webgui6.sha256sum] = "ab4e81c5a1c159e5af3e89e499744c211a408d4439acb46bf3d1c706d60ba630"

URI_aarch64_root-hbook = "${EPEL_MIRROR}/aarch64/Packages/r/root-hbook-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-hbook;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hbook}"
SRC_URI[aarch64_root-hbook.sha256sum] = "834900ab5d175082cc70f7c6b0f7d43746de0557b5c1e07ef9ab828891e8227b"

URI_aarch64_root-hist = "${EPEL_MIRROR}/aarch64/Packages/r/root-hist-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-hist;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hist}"
SRC_URI[aarch64_root-hist.sha256sum] = "b0ada8bd7b583cbf158e2bb06743b9812d126116917153d1ba11ea84aa6f63f8"

URI_aarch64_root-hist-factory = "${EPEL_MIRROR}/aarch64/Packages/r/root-hist-factory-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-hist-factory;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hist-factory}"
SRC_URI[aarch64_root-hist-factory.sha256sum] = "0de0929fff6b9514c7c681cc04b87232b27f78d0ee9825aa5e62ab14cddf5153"

URI_aarch64_root-hist-painter = "${EPEL_MIRROR}/aarch64/Packages/r/root-hist-painter-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-hist-painter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hist-painter}"
SRC_URI[aarch64_root-hist-painter.sha256sum] = "769055722844ad155d026275958078c8aaea3c4d30332b53a07877d864e45a48"

URI_aarch64_root-histv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-histv7-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-histv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-histv7}"
SRC_URI[aarch64_root-histv7.sha256sum] = "e98cf6ab76b7a6de72e1fd136557c0012aaa1b1c974bcf66eb1f6f20ad0fc42a"

URI_aarch64_root-histv7util = "${EPEL_MIRROR}/aarch64/Packages/r/root-histv7util-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-histv7util;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-histv7util}"
SRC_URI[aarch64_root-histv7util.sha256sum] = "04139bad467bd0f36c31320dae75cb9a7ecf774d96f4e3c7af620fde82d1a408"

URI_aarch64_root-icons = "${EPEL_MIRROR}/aarch64/Packages/r/root-icons-6.40.02-1.el10_2.noarch.rpm;name=aarch64_root-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-icons}"
SRC_URI[aarch64_root-icons.sha256sum] = "9d338e97c2e87ec26e51df761fac78cdca53f751a44c0baf368aa501cf50e65f"

URI_aarch64_root-io = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io}"
SRC_URI[aarch64_root-io.sha256sum] = "427075411faba443f625023c1c8e44f035cdf415d0371bbdbddcdc0feeb0e947"

URI_aarch64_root-io-dcache = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-dcache-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-io-dcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-dcache}"
SRC_URI[aarch64_root-io-dcache.sha256sum] = "dcbc72763f98ede6b6a1a4e9bd86a468f92d383da4eec344be0fb45a874794d2"

URI_aarch64_root-io-sql = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-sql-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-io-sql;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-sql}"
SRC_URI[aarch64_root-io-sql.sha256sum] = "929eded35f16b4fb1583a5b70b4a89d1e6469e17a4b547e6390e9b467194eee0"

URI_aarch64_root-io-xml = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-xml-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-io-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-xml}"
SRC_URI[aarch64_root-io-xml.sha256sum] = "017f0f8c5a98c01fce700a3013dc270b893fd6e52ff0dc1de4285f75a3f9a611"

URI_aarch64_root-io-xmlparser = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-xmlparser-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-io-xmlparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-xmlparser}"
SRC_URI[aarch64_root-io-xmlparser.sha256sum] = "5eca48fbcdd71a5bbaff751b3eda66003488a235ee9a955bfdfc5cb71074fd9b"

URI_aarch64_root-mathcore = "${EPEL_MIRROR}/aarch64/Packages/r/root-mathcore-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-mathcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-mathcore}"
SRC_URI[aarch64_root-mathcore.sha256sum] = "9cd7f64bf9115cc070b21238bdc9c6b077a982d22a990fea5babc797235e3f5d"

URI_aarch64_root-mathmore = "${EPEL_MIRROR}/aarch64/Packages/r/root-mathmore-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-mathmore;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-mathmore}"
SRC_URI[aarch64_root-mathmore.sha256sum] = "acd8d0a7dfe393f5c21d4ebe2674a02e6287f2fda1d6fae8318f0ca059356831"

URI_aarch64_root-matrix = "${EPEL_MIRROR}/aarch64/Packages/r/root-matrix-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-matrix;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-matrix}"
SRC_URI[aarch64_root-matrix.sha256sum] = "32eaaba6bd463c0942c9593b5c5a9def31b011b04d66729d5cc3c1920fd61e37"

URI_aarch64_root-minuit = "${EPEL_MIRROR}/aarch64/Packages/r/root-minuit-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-minuit;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-minuit}"
SRC_URI[aarch64_root-minuit.sha256sum] = "89680db416438d0c00153a40ec35076d1653badb509bf3db79626a6b765aa37a"

URI_aarch64_root-minuit2 = "${EPEL_MIRROR}/aarch64/Packages/r/root-minuit2-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-minuit2;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-minuit2}"
SRC_URI[aarch64_root-minuit2.sha256sum] = "5817966db0c6745fc6ea233d48daa3c751bd4b9b9b718e421039c616bd7d16cc"

URI_aarch64_root-mlp = "${EPEL_MIRROR}/aarch64/Packages/r/root-mlp-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-mlp;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-mlp}"
SRC_URI[aarch64_root-mlp.sha256sum] = "48b6833923470aa9e4b32d84f9f74a10599cc33cdf8a1c122f12c87f6ef66f4d"

URI_aarch64_root-montecarlo-eg = "${EPEL_MIRROR}/aarch64/Packages/r/root-montecarlo-eg-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-montecarlo-eg;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-montecarlo-eg}"
SRC_URI[aarch64_root-montecarlo-eg.sha256sum] = "73d3f3b159402439110d78b38a9bc405963bce77434eb6ec0d95e94f243eff0d"

URI_aarch64_root-montecarlo-pythia8 = "${EPEL_MIRROR}/aarch64/Packages/r/root-montecarlo-pythia8-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-montecarlo-pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-montecarlo-pythia8}"
SRC_URI[aarch64_root-montecarlo-pythia8.sha256sum] = "0c78b402a78a19452e971ad42bceb73e873221f90f6e3c76b1e2df9a8408509b"

URI_aarch64_root-multiproc = "${EPEL_MIRROR}/aarch64/Packages/r/root-multiproc-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-multiproc;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-multiproc}"
SRC_URI[aarch64_root-multiproc.sha256sum] = "8a7c301678962b060882710e6215dd9394a86e7767be35f832b532578f9a6407"

URI_aarch64_root-net = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-net;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net}"
SRC_URI[aarch64_root-net.sha256sum] = "fc36c11b79451739e614aee1407eebaeec772e751a89864dcca79094fb034bea"

URI_aarch64_root-net-auth = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-auth-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-net-auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-auth}"
SRC_URI[aarch64_root-net-auth.sha256sum] = "005328184d6857931c038bd7db0895ab349a2b0f0f9fb021851943b5f129dfec"

URI_aarch64_root-net-curl = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-curl-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-net-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-curl}"
SRC_URI[aarch64_root-net-curl.sha256sum] = "aaa8d1c562e33ff2f77640d1f1fd86cbf40378b53f8d680c595e0f354ea20381"

URI_aarch64_root-net-davix = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-davix-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-net-davix;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-davix}"
SRC_URI[aarch64_root-net-davix.sha256sum] = "ea0c4a7c824114b7704fa108c572be024d30e850a3c5303a4958ed8f8e028772"

URI_aarch64_root-net-http = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-http-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-net-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-http}"
SRC_URI[aarch64_root-net-http.sha256sum] = "5490777d35dfa5283c01936ff40f6cff4e50d971144ba98351f335206b6569b7"

URI_aarch64_root-net-httpsniff = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-httpsniff-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-net-httpsniff;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-httpsniff}"
SRC_URI[aarch64_root-net-httpsniff.sha256sum] = "6b089615b1eb73de39601015cbdc9209798c54068c5cea0c7a6e3e513ea3df0c"

URI_aarch64_root-net-rpdutils = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-rpdutils-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-net-rpdutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-rpdutils}"
SRC_URI[aarch64_root-net-rpdutils.sha256sum] = "8345aa9917ad55be8736a40a12e5515cc776380fc3df844403c43a35768d37e9"

URI_aarch64_root-netx = "${EPEL_MIRROR}/aarch64/Packages/r/root-netx-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-netx;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-netx}"
SRC_URI[aarch64_root-netx.sha256sum] = "3368256c87a694c80c2006884c3029249f0c8acb33b337b9755b6b5878b732a3"

URI_aarch64_root-physics = "${EPEL_MIRROR}/aarch64/Packages/r/root-physics-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-physics;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-physics}"
SRC_URI[aarch64_root-physics.sha256sum] = "d425099c429418cf61230896d907c0e12138d1b8a25d7983f621688333f178b5"

URI_aarch64_root-quadp = "${EPEL_MIRROR}/aarch64/Packages/r/root-quadp-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-quadp;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-quadp}"
SRC_URI[aarch64_root-quadp.sha256sum] = "07abb48e38149ff8180d42e46d014120078fb7b4de939d9adca320edd05c87f3"

URI_aarch64_root-r = "${EPEL_MIRROR}/aarch64/Packages/r/root-r-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-r;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-r}"
SRC_URI[aarch64_root-r.sha256sum] = "38c89bbb41e09ebb302deb7b4f770815dd3a81b7a6ffb26ce56a8c21d938aafb"

URI_aarch64_root-r-tools = "${EPEL_MIRROR}/aarch64/Packages/r/root-r-tools-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-r-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-r-tools}"
SRC_URI[aarch64_root-r-tools.sha256sum] = "44cb0d396076dddea722f963b75d2d101b9702c7e03c2efe84ced45e45c9c227"

URI_aarch64_root-roofit = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-roofit;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit}"
SRC_URI[aarch64_root-roofit.sha256sum] = "88407844db6d8ad1fc263a678df6b3f7aaafa0ba399ae969c396947f2a934bc9"

URI_aarch64_root-roofit-batchcompute = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-batchcompute-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-batchcompute;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-batchcompute}"
SRC_URI[aarch64_root-roofit-batchcompute.sha256sum] = "c4c1a7f476011622f7d5ab5cf95f4d3d6a73b4857e08eacf5bfe840822819447"

URI_aarch64_root-roofit-codegen = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-codegen-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-codegen;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-codegen}"
SRC_URI[aarch64_root-roofit-codegen.sha256sum] = "422fcef28d26ad46013e5662f25b458da236bce7dbc17e66a20d63b46acf0d93"

URI_aarch64_root-roofit-core = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-core-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-core}"
SRC_URI[aarch64_root-roofit-core.sha256sum] = "8ff977636467cd74adc83e928a414faa9f1cf7a4ff230351bd0d03757f3a88f5"

URI_aarch64_root-roofit-hs3 = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-hs3-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-hs3;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-hs3}"
SRC_URI[aarch64_root-roofit-hs3.sha256sum] = "c8771880cba7499ff07ec9d26470dcd4924114fee613b3df8fde5d7660c62935"

URI_aarch64_root-roofit-jsoninterface = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-jsoninterface-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-jsoninterface;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-jsoninterface}"
SRC_URI[aarch64_root-roofit-jsoninterface.sha256sum] = "dc5d626151ccd4e6099ea977b0ed9781f65cb46a4edd7b0ef2dd92e1443cddce"

URI_aarch64_root-roofit-more = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-more-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-more;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-more}"
SRC_URI[aarch64_root-roofit-more.sha256sum] = "10c3dfd5604ed53bb5e0482cb8f4dcd0c8102c8f408986be1a3d6c81a2be3dc4"

URI_aarch64_root-roofit-multiprocess = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-multiprocess-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-multiprocess;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-multiprocess}"
SRC_URI[aarch64_root-roofit-multiprocess.sha256sum] = "45daf381614588705cbca45f10312631e87bc587a54fd7b3730c9b841a9d1be9"

URI_aarch64_root-roofit-zmq = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-zmq-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-roofit-zmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-zmq}"
SRC_URI[aarch64_root-roofit-zmq.sha256sum] = "68f7175cc8b6ec7ca3c93f3535b9d8eadc93d602b2950a41af27fc1149e5dfb9"

URI_aarch64_root-roostats = "${EPEL_MIRROR}/aarch64/Packages/r/root-roostats-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-roostats;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roostats}"
SRC_URI[aarch64_root-roostats.sha256sum] = "99e3fd61ba68ed538c1aa04d92e20b932996b5a40a637cc3deb2fc157c8e8158"

URI_aarch64_root-smatrix = "${EPEL_MIRROR}/aarch64/Packages/r/root-smatrix-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-smatrix;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-smatrix}"
SRC_URI[aarch64_root-smatrix.sha256sum] = "3ada3c714c48a91f2f6916fc2bbb3c652bd09adc1d28d9e8138587f33156c9ae"

URI_aarch64_root-spectrum = "${EPEL_MIRROR}/aarch64/Packages/r/root-spectrum-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-spectrum;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-spectrum}"
SRC_URI[aarch64_root-spectrum.sha256sum] = "d0104b5e8318351db3d5c6e8181eae79e2dbae025c934f01fdb1ef19b39782f5"

URI_aarch64_root-spectrum-painter = "${EPEL_MIRROR}/aarch64/Packages/r/root-spectrum-painter-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-spectrum-painter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-spectrum-painter}"
SRC_URI[aarch64_root-spectrum-painter.sha256sum] = "85ca60659dbb69cd7ed9066b0f3e94fade576d1af34a4f0189fb17be86a443b1"

URI_aarch64_root-splot = "${EPEL_MIRROR}/aarch64/Packages/r/root-splot-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-splot;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-splot}"
SRC_URI[aarch64_root-splot.sha256sum] = "3d3e17538f0050670beccae8f78cebc5c14aa4192eb146ef7cc1339fd1215e6d"

URI_aarch64_root-sql-sqlite = "${EPEL_MIRROR}/aarch64/Packages/r/root-sql-sqlite-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-sql-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-sql-sqlite}"
SRC_URI[aarch64_root-sql-sqlite.sha256sum] = "5c23b7aa36bf8f6edbd493dd67620ad238e56d3898768e9a48904f386b1792d4"

URI_aarch64_root-testsupport = "${EPEL_MIRROR}/aarch64/Packages/r/root-testsupport-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-testsupport;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-testsupport}"
SRC_URI[aarch64_root-testsupport.sha256sum] = "077b9ba4d5741af397c9ecb3dd8a1e17816c3663431f8bee4650e28486cb3004"

URI_aarch64_root-tmva = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tmva;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva}"
SRC_URI[aarch64_root-tmva.sha256sum] = "42676c2f89aeb11080c0773769da46d15f6d1f067eab3162ef60f7400cca8eb0"

URI_aarch64_root-tmva-gui = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-gui-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-gui}"
SRC_URI[aarch64_root-tmva-gui.sha256sum] = "7a17b5b1b354e3353fb2964ad7cc5d424be0bcf169afbdbffa56596aa2b33ab7"

URI_aarch64_root-tmva-python = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-python-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-python}"
SRC_URI[aarch64_root-tmva-python.sha256sum] = "6c38af13bf1b698993f1c022ba8c6cd6a8687b3bfc2a2aa6dc65422216193888"

URI_aarch64_root-tmva-r = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-r-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-r;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-r}"
SRC_URI[aarch64_root-tmva-r.sha256sum] = "99d27e7626082e8a16c06cb3b2e12f32aacd2ee83ba993dad7625ef867a86050"

URI_aarch64_root-tmva-sofie = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-sofie;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-sofie}"
SRC_URI[aarch64_root-tmva-sofie.sha256sum] = "6d073a0cf4d0b8f83f327742e27f242919b739955f9fcf50911fb42bc3aa110f"

URI_aarch64_root-tmva-sofie-parser = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-parser-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-sofie-parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-sofie-parser}"
SRC_URI[aarch64_root-tmva-sofie-parser.sha256sum] = "1a9829135623da9e3d496c57bf517c6ccd26d8587f81347e42a7dc660bbb9bc0"

URI_aarch64_root-tmva-sofie-parser-python = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-parser-python-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-sofie-parser-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-sofie-parser-python}"
SRC_URI[aarch64_root-tmva-sofie-parser-python.sha256sum] = "31aa10c0e9b29a4b4ce710088524f432cf6ef185e742b372ff6772e0fa4545bc"

URI_aarch64_root-tmva-utils = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-utils-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tmva-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-utils}"
SRC_URI[aarch64_root-tmva-utils.sha256sum] = "d1d5c4761a60e82d6e8c4ed61d5e2d9e83ff2b01ab73ca1a7dd3036e0cf0214b"

URI_aarch64_root-tpython = "${EPEL_MIRROR}/aarch64/Packages/r/root-tpython-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tpython;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tpython}"
SRC_URI[aarch64_root-tpython.sha256sum] = "23fa0e144b8e76143d0df2a35fba13df8ce5d58ecf61fc4bf457805b00d3a40e"

URI_aarch64_root-tree = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tree;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree}"
SRC_URI[aarch64_root-tree.sha256sum] = "0f76fdb56f1f4a24859fb49a598be9eb29b11ff9f43c4cc6cebfce0b68ae5031"

URI_aarch64_root-tree-dataframe = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-dataframe-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tree-dataframe;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-dataframe}"
SRC_URI[aarch64_root-tree-dataframe.sha256sum] = "f5c26500f896e165c13a9d40c9bf7d6b77416f5f7f151cfd962649719889c04b"

URI_aarch64_root-tree-ml = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ml-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tree-ml;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ml}"
SRC_URI[aarch64_root-tree-ml.sha256sum] = "3cf4124e78a9380ea8bce5079dd716257e956e78c59a32b2d7c645ce6316c9e2"

URI_aarch64_root-tree-ntuple = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tree-ntuple;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ntuple}"
SRC_URI[aarch64_root-tree-ntuple.sha256sum] = "82e51ab0cc97fbd7a6b6090ae3bceb5b98a9145d941ea2781feab2d5c28c1d71"

URI_aarch64_root-tree-ntuple-browse = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-browse-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tree-ntuple-browse;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ntuple-browse}"
SRC_URI[aarch64_root-tree-ntuple-browse.sha256sum] = "a3f6638121754c12d467315be9969a5bc2e73c620dc6244284801b10a778addb"

URI_aarch64_root-tree-ntuple-utils = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-utils-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tree-ntuple-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ntuple-utils}"
SRC_URI[aarch64_root-tree-ntuple-utils.sha256sum] = "0161607f7365d0e9c8bedb5e870b41b8b31b64d0ede387b09cc192aa802f57cb"

URI_aarch64_root-tree-player = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-player-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tree-player;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-player}"
SRC_URI[aarch64_root-tree-player.sha256sum] = "810da14aba075620c770e3eafb0c6cca9f2986cae8722a96c7fd1b217176679b"

URI_aarch64_root-tree-viewer = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-viewer-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tree-viewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-viewer}"
SRC_URI[aarch64_root-tree-viewer.sha256sum] = "b0cc96617a77e31153d65c9bb8565a789dcac7964d1eed6702adf8b9f9698d0a"

URI_aarch64_root-tree-webviewer = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-webviewer-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-tree-webviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-webviewer}"
SRC_URI[aarch64_root-tree-webviewer.sha256sum] = "f9958d6eecbce1f361b8833e33047c2903b2d62ff40e56603e7e23366969054a"

URI_aarch64_root-tutorial = "${EPEL_MIRROR}/aarch64/Packages/r/root-tutorial-6.40.02-1.el10_2.noarch.rpm;name=aarch64_root-tutorial;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tutorial}"
SRC_URI[aarch64_root-tutorial.sha256sum] = "1f924fab6822e63d1c0401a8efc2792a649fd1f86776c4040d100c2092cb9d38"

URI_aarch64_root-unfold = "${EPEL_MIRROR}/aarch64/Packages/r/root-unfold-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-unfold;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-unfold}"
SRC_URI[aarch64_root-unfold.sha256sum] = "0784e79d170359d75e2992b03fdb6edd6c83553a65f52799059da6772d8a4595"

URI_aarch64_root-unuran = "${EPEL_MIRROR}/aarch64/Packages/r/root-unuran-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-unuran;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-unuran}"
SRC_URI[aarch64_root-unuran.sha256sum] = "ad5d8ed66a1d7b99a75017a9212282da353ed09832d31059899ae00cc377a7fe"

URI_aarch64_root-vecops = "${EPEL_MIRROR}/aarch64/Packages/r/root-vecops-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-vecops;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-vecops}"
SRC_URI[aarch64_root-vecops.sha256sum] = "a9abfc94bcbc2278306acd4029cad14fdfa71697365dc134eb65f5c8bad35f25"

URI_aarch64_root-xroofit = "${EPEL_MIRROR}/aarch64/Packages/r/root-xroofit-6.40.02-1.el10_2.aarch64.rpm;name=aarch64_root-xroofit;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-xroofit}"
SRC_URI[aarch64_root-xroofit.sha256sum] = "115c49aac35a1f28932b81409facc24cc8a90094085c5d4440dd09e4bbe54b89"

RDEPENDS:python3-root = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 root-core \
 root-io \
 root-tree \
 "
RDEPENDS:python3-root+distrdf = " \
 python3 \
 python3-root \
 root-tree-dataframe \
 "
RDEPENDS:python3-root+jupyroot = " \
 bash \
 js-jsroot \
 python-jupyter-filesystem \
 python3 \
 python3-ipython \
 python3-metakernel \
 python3-notebook \
 python3-root \
 root-core \
 "
RDEPENDS:root = " \
 bash \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 root-multiproc \
 root-net \
 root-tree \
 root-tree-ntuple \
 root-tree-player \
 "
RDEPENDS:root-cli = " \
 python3 \
 python3-root \
 "
RDEPENDS:root-cling = " \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 python3 \
 redhat-rpm-config \
 root-core \
 root-io \
 zlib-ng-compat \
 "
RDEPENDS:root-core = " \
 bash \
 glibc \
 gnu-free-mono-fonts \
 gnu-free-sans-fonts \
 gnu-free-serif-fonts \
 google-droid-sans-fonts \
 json-devel \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 pcre2 \
 root-cling \
 root-font-files \
 root-graf \
 root-graf-asimage \
 root-graf-gpad \
 root-graf-postscript \
 root-graf3d \
 root-hist \
 root-icons \
 root-io \
 root-mathcore \
 root-matrix \
 root-multiproc \
 root-net \
 root-physics \
 root-tree \
 root-tree-dataframe \
 root-tree-ntuple \
 root-tree-ntuple-utils \
 root-tree-player \
 root-vecops \
 tbb \
 urw-base35-d050000l-fonts \
 urw-base35-standard-symbols-ps-fonts \
 urw-base35-z003-fonts \
 xorg-x11-fonts-ISO8859-1-75dpi \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:root-fftw = " \
 fftw-libs-double \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-foam = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-font-files = " \
 root-core \
 "
RDEPENDS:root-fumili = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-gdml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-hist \
 root-io-xml \
 "
RDEPENDS:root-genetic = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-tmva \
 "
RDEPENDS:root-genvector = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-geom = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-geom-builder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-gui \
 root-gui-ged \
 "
RDEPENDS:root-geom-checker = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 "
RDEPENDS:root-geom-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 "
RDEPENDS:root-geom-webviewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-painter \
 root-graf3d-csg \
 root-gui-webdisplay \
 root-io \
 "
RDEPENDS:root-graf = " \
 fontconfig \
 freetype \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-asimage = " \
 fontconfig \
 freetype \
 giflib \
 glibc \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf-postscript \
 root-gui \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-fitsio = " \
 cfitsio \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-matrix \
 "
RDEPENDS:root-graf-gpad = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-postscript \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-gpadv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-graf-gviz = " \
 glibc \
 graphviz \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
 "
RDEPENDS:root-graf-postscript = " \
 fontconfig \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 zlib-ng-compat \
 "
RDEPENDS:root-graf-primitives = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 "
RDEPENDS:root-graf-x11 = " \
 freetype \
 glibc \
 libX11 \
 libXext \
 libXft \
 libXpm \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 "
RDEPENDS:root-graf3d = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-graf3d-csg = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-graf3d-eve = " \
 glibc \
 libgcc \
 libstdc++ \
 mesa-libGLU \
 root-core \
 root-geom \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-gl \
 root-graf3d-glad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-io \
 root-mathcore \
 root-montecarlo-eg \
 root-physics \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-graf3d-eve7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-webviewer \
 root-graf \
 root-graf3d \
 root-graf3d-csg \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-mathcore \
 root-montecarlo-eg \
 root-net-http \
 root-physics \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-graf3d-gl = " \
 fontconfig \
 ftgl \
 gl2ps \
 glibc \
 libX11 \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 mesa-libGLU \
 root-core \
 root-graf \
 root-graf-asimage \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-csg \
 root-graf3d-glad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-mathcore \
 root-tree \
 "
RDEPENDS:root-graf3d-glad = " \
 glibc \
 libX11 \
 root-core \
 "
RDEPENDS:root-graf3d-gviz3d = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-gl \
 root-gui \
 root-gui-ged \
 "
RDEPENDS:root-graf3d-x3d = " \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 root-core \
 root-graf3d \
 root-gui \
 "
RDEPENDS:root-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf-x11 \
 root-gui-ged \
 root-io \
 root-mathcore \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browsable = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-gui-treemap \
 root-hist \
 root-io \
 root-tree \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browsable-v7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-browsable \
 root-gui-treemap \
 root-hist \
 root-tree \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browserv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-webviewer \
 root-graf-gpad \
 root-gui-browsable \
 root-gui-webdisplay \
 root-gui-webgui6 \
 root-io \
 root-tree \
 root-tree-webviewer \
 "
RDEPENDS:root-gui-browserv7-v7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-browsable \
 root-gui-browserv7 \
 "
RDEPENDS:root-gui-builder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-gui \
 root-mathcore \
 "
RDEPENDS:root-gui-canvaspainter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-webdisplay \
 root-io \
 "
RDEPENDS:root-gui-fitpanel = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-mathcore \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-gui-fitpanelv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-graf-gpadv7 \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-gui-ged = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-gui-html = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-gui \
 root-net \
 "
RDEPENDS:root-gui-qt6webdisplay = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 root-core \
 root-gui-webdisplay \
 root-net-http \
 "
RDEPENDS:root-gui-recorder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-gui \
 root-io \
 root-tree \
 "
RDEPENDS:root-gui-treemap = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 "
RDEPENDS:root-gui-webdisplay = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 root-net \
 root-net-http \
 "
RDEPENDS:root-gui-webgui6 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-net-http \
 "
RDEPENDS:root-hbook = " \
 glibc \
 libgcc \
 libgfortran \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-tree \
 "
RDEPENDS:root-hist = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist-painter \
 root-io \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-hist-factory = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-io-xmlparser \
 root-roofit \
 root-roofit-core \
 root-roostats \
 "
RDEPENDS:root-hist-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-histv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-histv7util = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 "
RDEPENDS:root-icons = " \
 root-core \
 "
RDEPENDS:root-io = " \
 glibc \
 libgcc \
 libstdc++ \
 liburing \
 liburing-devel \
 root-core \
 "
RDEPENDS:root-io-dcache = " \
 dcap-libs \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-io-sql = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-io-xml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-io-xmlparser = " \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 root-core \
 "
RDEPENDS:root-mathcore = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathmore \
 root-minuit2 \
 "
RDEPENDS:root-mathmore = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 "
RDEPENDS:root-matrix = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 "
RDEPENDS:root-minuit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-minuit2 = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-mlp = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 root-matrix \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-montecarlo-eg = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-mathcore \
 "
RDEPENDS:root-montecarlo-pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 root-core \
 root-montecarlo-eg \
 "
RDEPENDS:root-multiproc = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-net = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 root-core \
 root-io \
 "
RDEPENDS:root-net-auth = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 root-core \
 root-net \
 "
RDEPENDS:root-net-curl = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:root-net-davix = " \
 davix-libs \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-net-http = " \
 bash \
 fcgi \
 glibc \
 js-jsroot \
 libgcc \
 libstdc++ \
 openssl-libs \
 root-core \
 root-io \
 "
RDEPENDS:root-net-httpsniff = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-io-xml \
 root-net-http \
 root-tree \
 "
RDEPENDS:root-net-rpdutils = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 root-core \
 root-net \
 "
RDEPENDS:root-netx:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
"
RDEPENDS:root-netx:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 xrootd-client-libs \
 xrootd-libs \
"
RDEPENDS:root-physics = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-quadp = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-matrix \
 "
RDEPENDS:root-r = " \
 R-RInside \
 R-Rcpp \
 R-core \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 readline \
 root-core \
 root-matrix \
 "
RDEPENDS:root-r-tools = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-matrix \
 root-r \
 "
RDEPENDS:root-roofit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-roofit-batchcompute \
 root-roofit-core \
 root-tree \
 "
RDEPENDS:root-roofit-batchcompute = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-roofit-codegen = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist-factory \
 root-roofit \
 root-roofit-core \
 "
RDEPENDS:root-roofit-core = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-foam \
 root-graf \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-minuit2 \
 root-roofit-batchcompute \
 root-roofit-multiprocess \
 root-roofit-zmq \
 root-tree \
 zeromq \
 "
RDEPENDS:root-roofit-hs3 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-hist-factory \
 root-matrix \
 root-roofit \
 root-roofit-core \
 root-roofit-jsoninterface \
 "
RDEPENDS:root-roofit-jsoninterface = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-roofit-more = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-mathmore \
 root-roofit-core \
 "
RDEPENDS:root-roofit-multiprocess = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-roofit-zmq \
 zeromq \
 "
RDEPENDS:root-roofit-zmq = " \
 glibc \
 libgcc \
 libstdc++ \
 zeromq \
 "
RDEPENDS:root-roostats = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-minuit \
 root-roofit \
 root-roofit-core \
 root-tree \
 "
RDEPENDS:root-smatrix = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-spectrum = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 "
RDEPENDS:root-spectrum-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
 "
RDEPENDS:root-splot = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-matrix \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-sql-sqlite = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-net \
 sqlite-libs \
 "
RDEPENDS:root-testsupport = " \
 root-core \
 "
RDEPENDS:root-tmva = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-io-xml \
 root-mathcore \
 root-matrix \
 root-minuit \
 root-mlp \
 root-multiproc \
 root-net \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-tmva-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-io \
 root-io-xml \
 root-matrix \
 root-tmva \
 root-tree \
 root-tree-viewer \
 "
RDEPENDS:root-tmva-python = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-numpy \
 root-core \
 root-tmva \
 root-tree \
 "
RDEPENDS:root-tmva-r = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-matrix \
 root-r \
 root-tmva \
 "
RDEPENDS:root-tmva-sofie = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-tmva-sofie-parser = " \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 root-core \
 root-tmva-sofie \
 "
RDEPENDS:root-tmva-sofie-parser-python = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-numpy \
 root-core \
 root-tmva-sofie \
 "
RDEPENDS:root-tmva-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-tpython = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-root \
 root-core \
 "
RDEPENDS:root-tree = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-tree-dataframe = " \
 glibc \
 libarrow \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 root-tree-ntuple \
 root-tree-player \
 root-vecops \
 sqlite-libs \
 "
RDEPENDS:root-tree-ml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-vecops \
 "
RDEPENDS:root-tree-ntuple = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 root-core \
 root-io \
 xxhash-libs \
 "
RDEPENDS:root-tree-ntuple-browse = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui-treemap \
 root-hist \
 root-io \
 root-tree-ntuple \
 root-tree-ntuple-utils \
 "
RDEPENDS:root-tree-ntuple-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-tree \
 root-tree-ntuple \
 "
RDEPENDS:root-tree-player = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 root-io \
 root-mathcore \
 root-multiproc \
 root-net \
 root-tree \
 "
RDEPENDS:root-tree-viewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-tree-webviewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-tree \
 "
RDEPENDS:root-tutorial = " \
 root \
 "
RDEPENDS:root-unfold = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io-xmlparser \
 root-matrix \
 "
RDEPENDS:root-unuran = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 unuran \
 "
RDEPENDS:root-vecops = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-xroofit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-gui-fitpanel \
 root-gui-ged \
 root-hist \
 root-hist-factory \
 root-io \
 root-mathcore \
 root-matrix \
 root-roofit \
 root-roofit-core \
 root-roofit-hs3 \
 root-roostats \
 root-tree \
 "
