# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby4.0"
PV = "4.0.6"
PR = "36.el10"
PACKAGES = " \
 ruby4.0 \
 ruby4.0-devel \
 ruby4.0-doc \
 ruby4.0-rubygem-mysql2 \
 ruby4.0-rubygem-pg \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ruby4.0-4.0.6-36.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "00dac399918a0a4ffce9fa6de020315070b5ff3daaab165766f51b499459904f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-4.0.6-36.el10.x86_64_v2.rpm;name=x86_64_v2_ruby4.0;unpack=0"
SRC_URI[x86_64_v2_ruby4.0.sha256sum] = "e5592b3908bc7734d32b76330d474512ea16179b7191e31645acabf8f5a47eaf"
RPROVIDES:ruby4.0:append:x86_64_v2 = " virtual/ruby_release_ virtual/ruby_runtime_executable_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-devel-4.0.6-36.el10.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-devel;unpack=0"
SRC_URI[x86_64_v2_ruby4.0-devel.sha256sum] = "bf2ddb2556b9ba67057bec7b54be73cc11a62d0fb93efe4ae816173e3ff58b0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ruby4.0-doc-4.0.6-36.el10.noarch.rpm;name=x86_64_v2_ruby4.0-doc;unpack=0"
SRC_URI[x86_64_v2_ruby4.0-doc.sha256sum] = "fd5ac41dbdad2d99b1acd7b992b528aff96c719ee881afcbd82b2926975f9810"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-rubygem-mysql2-0.5.7-36.el10.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-rubygem-mysql2;unpack=0"
SRC_URI[x86_64_v2_ruby4.0-rubygem-mysql2.sha256sum] = "d995a365f8c316e9ab33c00fa507e76c585de2564fbf8d256b2f959dfeca754c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-rubygem-pg-1.6.3-36.el10.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-rubygem-pg;unpack=0"
SRC_URI[x86_64_v2_ruby4.0-rubygem-pg.sha256sum] = "8f1ce32ba1b7f0ab62c7a2bfc06bddda4a9f777cd29908e566973b8b2cf01dba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-4.0.6-36.el10.aarch64.rpm;name=aarch64_ruby4.0;unpack=0"
SRC_URI[aarch64_ruby4.0.sha256sum] = "8df0f4f068d005e8f437fdcc7d44438ff9f87a91c10e3cec5e89645563252cd6"
RPROVIDES:ruby4.0:append:aarch64 = " virtual/ruby_release_ virtual/ruby_runtime_executable_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-devel-4.0.6-36.el10.aarch64.rpm;name=aarch64_ruby4.0-devel;unpack=0"
SRC_URI[aarch64_ruby4.0-devel.sha256sum] = "fcca9680fc8582270de360aa569714f1fa9d2eb4118115cfb092181381c6ccc7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ruby4.0-doc-4.0.6-36.el10.noarch.rpm;name=aarch64_ruby4.0-doc;unpack=0"
SRC_URI[aarch64_ruby4.0-doc.sha256sum] = "fd5ac41dbdad2d99b1acd7b992b528aff96c719ee881afcbd82b2926975f9810"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-rubygem-mysql2-0.5.7-36.el10.aarch64.rpm;name=aarch64_ruby4.0-rubygem-mysql2;unpack=0"
SRC_URI[aarch64_ruby4.0-rubygem-mysql2.sha256sum] = "b4e102d0ea0bd6eb3dcb7092eaab8fd024bf8eed900a2fe0c2a5c4c490a791e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-rubygem-pg-1.6.3-36.el10.aarch64.rpm;name=aarch64_ruby4.0-rubygem-pg;unpack=0"
SRC_URI[aarch64_ruby4.0-rubygem-pg.sha256sum] = "a0b8a106ca536c4e2771c32596a720d87e4f2cec6b3465f2e0eb854391c232ce"

RDEPENDS:ruby4.0 = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 libyaml \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby4.0-devel = " \
 pkgconf-pkg-config \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-doc = " \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-rubygem-mysql2 = " \
 glibc \
 mariadb-connector-c \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-rubygem-pg = " \
 glibc \
 libpq \
 ruby4.0 \
 "
