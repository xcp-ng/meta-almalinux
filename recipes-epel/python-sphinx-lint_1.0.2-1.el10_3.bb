# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-lint"
PV = "1.0.2"
PR = "1.el10_3"
PACKAGES = " \
 python3-sphinx-lint \
 python3-sphinx-lint+tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-lint-1.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5a9886467409320f0f525561e0aba590e1e8a6d37d2a0d3e9a71f712a28ea8dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-lint-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-lint;unpack=0"
SRC_URI[x86_64_v2_python3-sphinx-lint.sha256sum] = "e51ed5c573c586af6e5574c0d272315296b0bccdbc569c53ca0851177beaedbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-lint+tests-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-lint+tests;unpack=0"
SRC_URI[x86_64_v2_python3-sphinx-lint+tests.sha256sum] = "3d0bdb5c4fd318a57f94d9eaac3e701c0e6f2083b3c6f11e421b957e7dcf2636"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-lint-1.0.2-1.el10_3.noarch.rpm;name=aarch64_python3-sphinx-lint;unpack=0"
SRC_URI[aarch64_python3-sphinx-lint.sha256sum] = "42b2763a45f7603d46915536875901d84ccdad3843b20aca3c327e5e9cdda1f3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-lint+tests-1.0.2-1.el10_3.noarch.rpm;name=aarch64_python3-sphinx-lint+tests;unpack=0"
SRC_URI[aarch64_python3-sphinx-lint+tests.sha256sum] = "82226dc032d795e6680cf3b6b642dfbe9b59f9043ea41f181f65068539fca3ab"

RDEPENDS:python3-sphinx-lint = " \
 python3 \
 python3-polib \
 python3-regex \
 "
RDEPENDS:python3-sphinx-lint+tests = " \
 python3 \
 python3-pytest \
 python3-pytest-cov \
 python3-sphinx-lint \
 "
