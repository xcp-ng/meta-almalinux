# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-once_cell"
PV = "1.21.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-once_cell+alloc-devel \
 rust-once_cell+atomic-polyfill-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell+default-devel \
 rust-once_cell+parking_lot-devel \
 rust-once_cell+portable-atomic-devel \
 rust-once_cell+race-devel \
 rust-once_cell+std-devel \
 rust-once_cell+unstable-devel \
 rust-once_cell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-once_cell-1.21.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a78ea518fd2dc2ec1e782f55527660e1656f97ed2d72fa878a33e868da3df51"

URI_x86_64_v2_rust-once_cell+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+alloc-devel-1.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+alloc-devel}"
SRC_URI[x86_64_v2_rust-once_cell+alloc-devel.sha256sum] = "f0145c86cc97b18ed903921c31afa9fc13fe3d69c9a7fdfc3cd33b79081a681c"

URI_x86_64_v2_rust-once_cell+atomic-polyfill-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+atomic-polyfill-devel-1.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+atomic-polyfill-devel}"
SRC_URI[x86_64_v2_rust-once_cell+atomic-polyfill-devel.sha256sum] = "f5500affedaaa99a5a75a162302055257c70273cef10bc282577a8dbf9aa3fcc"

URI_x86_64_v2_rust-once_cell+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+critical-section-devel-1.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+critical-section-devel}"
SRC_URI[x86_64_v2_rust-once_cell+critical-section-devel.sha256sum] = "2e7ada8071f0b2bdd5acb94a3e0245e5549677b618543350187d71fcc91c2491"

URI_x86_64_v2_rust-once_cell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+default-devel-1.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+default-devel}"
SRC_URI[x86_64_v2_rust-once_cell+default-devel.sha256sum] = "105f27e9bb079b53255348705c1d85b41e08b330e699e071bc43b841e7ac4b17"

URI_x86_64_v2_rust-once_cell+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+parking_lot-devel-1.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-once_cell+parking_lot-devel.sha256sum] = "4419c476b8970b548ad4f686367c62b185ad862464ece362c441a37afcb50a44"

URI_x86_64_v2_rust-once_cell+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+portable-atomic-devel-1.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-once_cell+portable-atomic-devel.sha256sum] = "219aa3ea4bb2a7abcfe7d4287b2539ce717dc23560d21a9a1c00796aa09a6bbb"

URI_x86_64_v2_rust-once_cell+race-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+race-devel-1.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+race-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+race-devel}"
SRC_URI[x86_64_v2_rust-once_cell+race-devel.sha256sum] = "8a15b11c41ab4920ccd230ff4e28991e6e61b12814994027657002a4dbb1cc1a"

URI_x86_64_v2_rust-once_cell+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+std-devel-1.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+std-devel}"
SRC_URI[x86_64_v2_rust-once_cell+std-devel.sha256sum] = "c2c7547b766c72c5e5631d7680ff416d81c8cbcf5dfc9a0a4370e6dfb6a323b8"

URI_x86_64_v2_rust-once_cell+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+unstable-devel-1.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+unstable-devel}"
SRC_URI[x86_64_v2_rust-once_cell+unstable-devel.sha256sum] = "87ec937ebdcd6f0ab4db38544c857c5549c89ad378ac59242d177a707bc3d302"

URI_x86_64_v2_rust-once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell-devel-1.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell-devel}"
SRC_URI[x86_64_v2_rust-once_cell-devel.sha256sum] = "bb886c20d9883bef5e9ba8946eee9edc32897c0782365d0ad1ba8a9741093294"

URI_aarch64_rust-once_cell+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+alloc-devel-1.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-once_cell+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+alloc-devel}"
SRC_URI[aarch64_rust-once_cell+alloc-devel.sha256sum] = "ddf38dde0ce00af8f089d72f7cfc877f9187910d18c34532db0feffd3e82e43f"

URI_aarch64_rust-once_cell+atomic-polyfill-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+atomic-polyfill-devel-1.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-once_cell+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+atomic-polyfill-devel}"
SRC_URI[aarch64_rust-once_cell+atomic-polyfill-devel.sha256sum] = "1d1cbd71ddb37778448e50103bba52ff54bf6d2b644d1e3b9d57dcbbd63b795e"

URI_aarch64_rust-once_cell+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+critical-section-devel-1.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-once_cell+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+critical-section-devel}"
SRC_URI[aarch64_rust-once_cell+critical-section-devel.sha256sum] = "1baa8109ecd74cb11417c51ddf77defe75585ae763d4a9dc02f37ae80d9e475b"

URI_aarch64_rust-once_cell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+default-devel-1.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-once_cell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+default-devel}"
SRC_URI[aarch64_rust-once_cell+default-devel.sha256sum] = "946b793c837b208c6b9bb643617dd4941a7f33bc5a2eb6fd6ab174d66e832202"

URI_aarch64_rust-once_cell+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+parking_lot-devel-1.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-once_cell+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+parking_lot-devel}"
SRC_URI[aarch64_rust-once_cell+parking_lot-devel.sha256sum] = "752539a7f8842a5dab6180f28f3e4ed563d6c9b5e59be13bf221bc5b782db8f3"

URI_aarch64_rust-once_cell+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+portable-atomic-devel-1.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-once_cell+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+portable-atomic-devel}"
SRC_URI[aarch64_rust-once_cell+portable-atomic-devel.sha256sum] = "7c0ba8705358b71c586a83199277d19a411a30557ef1c26165cc5d348347b18c"

URI_aarch64_rust-once_cell+race-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+race-devel-1.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-once_cell+race-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+race-devel}"
SRC_URI[aarch64_rust-once_cell+race-devel.sha256sum] = "75576335240df2b919e7d5e3bca585fbca41758de07db8488297c12d82a23641"

URI_aarch64_rust-once_cell+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+std-devel-1.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-once_cell+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+std-devel}"
SRC_URI[aarch64_rust-once_cell+std-devel.sha256sum] = "b3e69f5fc54813fe99121e95567f4aed3547be5edce4fa3370df380c6f60b5b8"

URI_aarch64_rust-once_cell+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+unstable-devel-1.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-once_cell+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+unstable-devel}"
SRC_URI[aarch64_rust-once_cell+unstable-devel.sha256sum] = "c395e8bcb9685d74429938efee9596aff3df2bddc0fd8366d81fabbfb4874e1c"

URI_aarch64_rust-once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell-devel-1.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell-devel}"
SRC_URI[aarch64_rust-once_cell-devel.sha256sum] = "540088bd4e64b0fd6509d290a7e09fc2747f6723673e3649d21b37c690b394db"

RDEPENDS:rust-once_cell+alloc-devel = " \
 cargo \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+atomic-polyfill-devel = " \
 cargo \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+critical-section-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-once_cell+portable-atomic-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+default-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+parking_lot-devel = " \
 cargo \
 rust-once_cell-devel \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-once_cell+portable-atomic-devel = " \
 cargo \
 rust-once_cell-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-once_cell+race-devel = " \
 cargo \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+std-devel = " \
 cargo \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+unstable-devel = " \
 cargo \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell-devel = " \
 cargo \
 rust \
 "
