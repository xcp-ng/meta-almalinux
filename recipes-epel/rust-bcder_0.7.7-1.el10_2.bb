# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bcder"
PV = "0.7.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-bcder+default-devel \
 rust-bcder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bcder-0.7.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d028972a97e3c02f542077d67a0d1c3fe1f2389fc867e27fcc47967ee4a1abd"

URI_x86_64_v2_rust-bcder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcder+default-devel-0.7.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcder+default-devel}"
SRC_URI[x86_64_v2_rust-bcder+default-devel.sha256sum] = "e6197f81cf27da1d0e7a6b13a90e3e715da6336f08c06299d6d62804abaf387e"

URI_x86_64_v2_rust-bcder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcder-devel-0.7.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcder-devel}"
SRC_URI[x86_64_v2_rust-bcder-devel.sha256sum] = "bf863e54468b2256eb3f15951705e7a939d4ddebd4711bfda423838d1760ad4e"

URI_aarch64_rust-bcder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcder+default-devel-0.7.7-1.el10_2.noarch.rpm;name=aarch64_rust-bcder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcder+default-devel}"
SRC_URI[aarch64_rust-bcder+default-devel.sha256sum] = "b0050c7a1d840d8fe4a5e47ff94eda63feed4ff9c9b2de95484b765218e9c717"

URI_aarch64_rust-bcder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcder-devel-0.7.7-1.el10_2.noarch.rpm;name=aarch64_rust-bcder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcder-devel}"
SRC_URI[aarch64_rust-bcder-devel.sha256sum] = "012f56988fa39b6dab844668eef00879b36cc28341a6e1140c676ac8aa201a1e"

RDEPENDS:rust-bcder+default-devel = " \
 cargo \
 rust-bcder-devel \
 "
RDEPENDS:rust-bcder-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-smallvec+default-devel \
 "
