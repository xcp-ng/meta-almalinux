# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "daala"
PV = "0"
PR = "35.20200724git694d4ce.el10_0"
PACKAGES = " \
 daala-devel \
 daala-libs \
 daala-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/daala-0-35.20200724git694d4ce.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d26bdbafae24b318b55b015fd3de728414dc6da8ffb183322824412742ff574e"

URI_x86_64_v2_daala-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-devel-0-35.20200724git694d4ce.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-devel}"
SRC_URI[x86_64_v2_daala-devel.sha256sum] = "7fec788eb817fc99ae51bdf6818c0be74950be822d51a796d8159206ffd96c4a"

URI_x86_64_v2_daala-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-libs-0-35.20200724git694d4ce.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-libs}"
SRC_URI[x86_64_v2_daala-libs.sha256sum] = "cee98f7255ea097b0ed879010200a491f9929028f4bf796d546c67795da91dcf"

URI_x86_64_v2_daala-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-tools-0-35.20200724git694d4ce.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-tools}"
SRC_URI[x86_64_v2_daala-tools.sha256sum] = "e0a4dcdd9a8af1af1ffea1bbfe2a34cad8f5fccda3b14c668b8b378fa73d6f2c"

URI_aarch64_daala-devel = "${EPEL_MIRROR}/aarch64/Packages/d/daala-devel-0-35.20200724git694d4ce.el10_0.aarch64.rpm;name=aarch64_daala-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-devel}"
SRC_URI[aarch64_daala-devel.sha256sum] = "8b84a8ec4e423213babf405c752b0a7adb4c147645cfaea63276f826a47a1607"

URI_aarch64_daala-libs = "${EPEL_MIRROR}/aarch64/Packages/d/daala-libs-0-35.20200724git694d4ce.el10_0.aarch64.rpm;name=aarch64_daala-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-libs}"
SRC_URI[aarch64_daala-libs.sha256sum] = "3b10f932bd7c2237ffb8062457f07a7e71ffa7c21144ecdac6b54c326aa2b872"

URI_aarch64_daala-tools = "${EPEL_MIRROR}/aarch64/Packages/d/daala-tools-0-35.20200724git694d4ce.el10_0.aarch64.rpm;name=aarch64_daala-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-tools}"
SRC_URI[aarch64_daala-tools.sha256sum] = "f3db70c251ea7c931e78d5fea67066a1e511781e2e1890612059e488f236b39b"

RDEPENDS:daala-devel = " \
 daala-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:daala-libs = " \
 glibc \
 "
RDEPENDS:daala-tools = " \
 daala-libs \
 glibc \
 libgcc \
 libgomp \
 libjpeg-turbo \
 libogg \
 libpng \
 "
