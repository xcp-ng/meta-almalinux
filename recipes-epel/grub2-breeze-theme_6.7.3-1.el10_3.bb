# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grub2-breeze-theme"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 grub2-breeze-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grub2-breeze-theme-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "709729fa6a7b9631775d49180514f17a688df3b3e138d523d4d0109af9f4266b"

URI_x86_64_v2_grub2-breeze-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grub2-breeze-theme-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grub2-breeze-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-breeze-theme}"
SRC_URI[x86_64_v2_grub2-breeze-theme.sha256sum] = "f7df063e13dd66a764c38598bb8e415007c7262e2854a2238f93183561762ac1"

URI_aarch64_grub2-breeze-theme = "${EPEL_MIRROR}/aarch64/Packages/g/grub2-breeze-theme-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_grub2-breeze-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-breeze-theme}"
SRC_URI[aarch64_grub2-breeze-theme.sha256sum] = "65cc078947e76e15232bd55005c24d5af0e88cbbc144203ad1c619911ee31138"

RDEPENDS:grub2-breeze-theme:x86_64_v2 = " \
 grub2-pc \
"
RDEPENDS:grub2-breeze-theme:aarch64 = " \
 grub2-efi-aa64 \
"
