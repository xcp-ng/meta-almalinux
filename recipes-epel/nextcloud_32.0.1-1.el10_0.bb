# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nextcloud"
PV = "32.0.1"
PR = "1.el10_0"
PACKAGES = " \
 nextcloud \
 nextcloud-httpd \
 nextcloud-mysql \
 nextcloud-nginx \
 nextcloud-postgresql \
 nextcloud-sqlite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nextcloud-32.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbbc23e1251c7c735b8d7369e935e9d9662bb436c97af19f88514ac318a98e5e"

URI_x86_64_v2_nextcloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-32.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud}"
SRC_URI[x86_64_v2_nextcloud.sha256sum] = "7c97635b62608669f8204160b6613cb607ba62b404a453681c14c87173ce9bda"

URI_x86_64_v2_nextcloud-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-httpd-32.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-httpd}"
SRC_URI[x86_64_v2_nextcloud-httpd.sha256sum] = "4019b0d7168e95617749e977773e9b7ad7852c2c5bd7add999517697c9122afe"
RPROVIDES:nextcloud-httpd:x86_64_v2 = "virtual/nextcloud-webserver_eq_32.0.1-1.el10_0.alma_altarch"

URI_x86_64_v2_nextcloud-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-mysql-32.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-mysql}"
SRC_URI[x86_64_v2_nextcloud-mysql.sha256sum] = "f9e2ae5158a16972aa9b64619d6a58067802a97b79d952193255f5123782a1eb"
RPROVIDES:nextcloud-mysql:x86_64_v2 = "virtual/nextcloud-database_eq_32.0.1-1.el10_0.alma_altarch"

URI_x86_64_v2_nextcloud-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-nginx-32.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-nginx}"
SRC_URI[x86_64_v2_nextcloud-nginx.sha256sum] = "819f767ed5e7388a7dfebcad7889f39732b0010aa8f95211f860e0a624522721"
RPROVIDES:nextcloud-nginx:x86_64_v2 = "virtual/nextcloud-webserver_eq_32.0.1-1.el10_0.alma_altarch"

URI_x86_64_v2_nextcloud-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-postgresql-32.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-postgresql}"
SRC_URI[x86_64_v2_nextcloud-postgresql.sha256sum] = "4ba7d215519f66ca90d33e11ca85fc9477183972cd769d964549e845ddb71eb5"
RPROVIDES:nextcloud-postgresql:x86_64_v2 = "virtual/nextcloud-database_eq_32.0.1-1.el10_0.alma_altarch"

URI_x86_64_v2_nextcloud-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-sqlite-32.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-sqlite}"
SRC_URI[x86_64_v2_nextcloud-sqlite.sha256sum] = "b9549fbd30ea04b4a64873a64420e1ac7c54324e52dec8e3250e99ec33a61426"
RPROVIDES:nextcloud-sqlite:x86_64_v2 = "virtual/nextcloud-database_eq_32.0.1-1.el10_0.alma_altarch"

URI_aarch64_nextcloud = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-32.0.1-1.el10_0.noarch.rpm;name=aarch64_nextcloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud}"
SRC_URI[aarch64_nextcloud.sha256sum] = "699af08c43c8cf2ee5a641cb631fdbe0b51815bf791b1e4ad0980e5289ac575b"

URI_aarch64_nextcloud-httpd = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-httpd-32.0.1-1.el10_0.noarch.rpm;name=aarch64_nextcloud-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-httpd}"
SRC_URI[aarch64_nextcloud-httpd.sha256sum] = "918ff99d07474352f5b659c5aac839bef6f30119bdadf78dbed4fb1237a0b7c0"
RPROVIDES:nextcloud-httpd:aarch64 = "virtual/nextcloud-webserver_eq_32.0.1-1.el10_0"

URI_aarch64_nextcloud-mysql = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-mysql-32.0.1-1.el10_0.noarch.rpm;name=aarch64_nextcloud-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-mysql}"
SRC_URI[aarch64_nextcloud-mysql.sha256sum] = "37e33647a2e014db60f8e3434bfe60fc01ae815a9b07bf11928cb505f8cf8224"
RPROVIDES:nextcloud-mysql:aarch64 = "virtual/nextcloud-database_eq_32.0.1-1.el10_0"

URI_aarch64_nextcloud-nginx = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-nginx-32.0.1-1.el10_0.noarch.rpm;name=aarch64_nextcloud-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-nginx}"
SRC_URI[aarch64_nextcloud-nginx.sha256sum] = "f4e959fe1f672f28cffcb15a3253ad959f211e851118806b84dae0e8caf2c3c6"
RPROVIDES:nextcloud-nginx:aarch64 = "virtual/nextcloud-webserver_eq_32.0.1-1.el10_0"

URI_aarch64_nextcloud-postgresql = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-postgresql-32.0.1-1.el10_0.noarch.rpm;name=aarch64_nextcloud-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-postgresql}"
SRC_URI[aarch64_nextcloud-postgresql.sha256sum] = "f15b6f7a15bf68099f6f644126cd098af1e89703bacf516fc4adbc42016aa0dd"
RPROVIDES:nextcloud-postgresql:aarch64 = "virtual/nextcloud-database_eq_32.0.1-1.el10_0"

URI_aarch64_nextcloud-sqlite = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-sqlite-32.0.1-1.el10_0.noarch.rpm;name=aarch64_nextcloud-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-sqlite}"
SRC_URI[aarch64_nextcloud-sqlite.sha256sum] = "d2612f61313e42bb7902052b27bc323253ec149f204add12b92dfa92223e3dcf"
RPROVIDES:nextcloud-sqlite:aarch64 = "virtual/nextcloud-database_eq_32.0.1-1.el10_0"

RDEPENDS:nextcloud:x86_64_v2 = " \
 bash \
 ca-certificates \
 php-bcmath \
 php-cli \
 php-common \
 php-gd \
 php-gmp \
 php-intl \
 php-ldap \
 php-mbstring \
 php-opcache \
 php-pdo \
 php-pecl-apcu \
 php-pecl-imagick \
 php-pecl-memcached \
 php-pecl-redis6 \
 php-pecl-zip \
 php-process \
 php-smbclient \
 php-xml \
 systemd \
 virtual/nextcloud-database_eq_32.0.1-1.el10_0.alma_altarch \
 virtual/nextcloud-webserver_eq_32.0.1-1.el10_0.alma_altarch \
"
RDEPENDS:nextcloud:aarch64 = " \
 bash \
 ca-certificates \
 php-bcmath \
 php-cli \
 php-common \
 php-gd \
 php-gmp \
 php-intl \
 php-ldap \
 php-mbstring \
 php-opcache \
 php-pdo \
 php-pecl-apcu \
 php-pecl-imagick \
 php-pecl-memcached \
 php-pecl-redis6 \
 php-pecl-zip \
 php-process \
 php-smbclient \
 php-xml \
 systemd \
 virtual/nextcloud-database_eq_32.0.1-1.el10_0 \
 virtual/nextcloud-webserver_eq_32.0.1-1.el10_0 \
"
RDEPENDS:nextcloud-httpd = " \
 bash \
 httpd \
 nextcloud \
 php-fpm \
 "
RDEPENDS:nextcloud-mysql = " \
 nextcloud \
 php-mysqlnd \
 "
RDEPENDS:nextcloud-nginx = " \
 bash \
 nextcloud \
 nginx \
 php-fpm \
 "
RDEPENDS:nextcloud-postgresql = " \
 nextcloud \
 php-pgsql \
 "
RDEPENDS:nextcloud-sqlite = " \
 nextcloud \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nextcloud-database_eq_32.0.1-1.el10_0.alma_altarch rpm/virtual/nextcloud-webserver_eq_32.0.1-1.el10_0.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/nextcloud-database_eq_32.0.1-1.el10_0 rpm/virtual/nextcloud-webserver_eq_32.0.1-1.el10_0"
