# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kollision"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kollision \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kollision-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "896ccaf1d77605bdc2ad93b760a37eb7aed94889140f69ef0fb5a2d9be509bdc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kollision-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kollision;unpack=0"
SRC_URI[x86_64_v2_kollision.sha256sum] = "82a6e4c46cf7465b79ba722649d7a9113d978ec5aaf2887190e2e5afbe754da5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kollision-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kollision;unpack=0"
SRC_URI[aarch64_kollision.sha256sum] = "054f56519dc6d62fde7d95480ac595fc384a51848ae48b7a8580c0e31bb7a926"

RDEPENDS:kollision = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
