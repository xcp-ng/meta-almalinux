# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "woff2"
PV = "1.0.2"
PR = "21.el10"
PACKAGES = " \
 woff2 \
 woff2-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/woff2-1.0.2-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2459bffeff1c7beadfc53af7253ee142472b8502cde12057285171cd6fc6ebf"

URI_x86_64_v2_woff2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/woff2-1.0.2-21.el10.x86_64_v2.rpm;name=x86_64_v2_woff2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_woff2}"
SRC_URI[x86_64_v2_woff2.sha256sum] = "ad24cea60e3faa6ec1fac7c18ed7cf75bce0fc1abcb7281ca654e5629e931e41"

URI_x86_64_v2_woff2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/woff2-devel-1.0.2-21.el10.x86_64_v2.rpm;name=x86_64_v2_woff2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_woff2-devel}"
SRC_URI[x86_64_v2_woff2-devel.sha256sum] = "ff2854945a84f74cc1754ddeec4dbfe49d387d9c7619307cb87b5650e4763638"

URI_aarch64_woff2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/woff2-1.0.2-21.el10.aarch64.rpm;name=aarch64_woff2;unpack=0"
SRC_URI:append = " ${URI_aarch64_woff2}"
SRC_URI[aarch64_woff2.sha256sum] = "2000f990252d2fb74821060ad5cfdb86356934f3e4a016f901401f75b53434d2"

URI_aarch64_woff2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/woff2-devel-1.0.2-21.el10.aarch64.rpm;name=aarch64_woff2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_woff2-devel}"
SRC_URI[aarch64_woff2-devel.sha256sum] = "dd627055620023bcc11224fdf559091ef7f95ead79638484d4e2f80ffb395245"

RDEPENDS:woff2 = " \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 "
RDEPENDS:woff2-devel = " \
 brotli-devel \
 pkgconf-pkg-config \
 woff2 \
 woff2-devel \
 "
