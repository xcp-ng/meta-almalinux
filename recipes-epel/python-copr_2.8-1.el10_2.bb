# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-copr"
PV = "2.8"
PR = "1.el10_2"
PACKAGES = " \
 python-copr-doc \
 python3-copr \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-copr-2.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bdb014e35afa3f865388a693da2a70ebdb31bb606e3a0ef7febc6704b104b1dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-copr-doc-2.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-copr-doc;unpack=0"
SRC_URI[x86_64_v2_python-copr-doc.sha256sum] = "8842e6617b2f23013764a4cdb5f6503a129d215e3423bca5ea5223b0d6ccff45"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-copr-2.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-copr;unpack=0"
SRC_URI[x86_64_v2_python3-copr.sha256sum] = "e57346e0bdd132af0014a21c4c2fbeaeacc4a810d6b385f8511970a7afacc96b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-copr-doc-2.8-1.el10_2.noarch.rpm;name=aarch64_python-copr-doc;unpack=0"
SRC_URI[aarch64_python-copr-doc.sha256sum] = "04a9e77cf6aa6099f49c8675b22a5542eafe3decafd7bce290e46780565194fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-copr-2.8-1.el10_2.noarch.rpm;name=aarch64_python3-copr;unpack=0"
SRC_URI[aarch64_python3-copr.sha256sum] = "829d4b7b4e7ad9d479b75ffd451a55d9ee2b1f771a2a6ce0157f4a91f89f3352"

RDEPENDS:python-copr-doc = " \
 "
RDEPENDS:python3-copr = " \
 python3 \
 python3-filelock \
 python3-munch \
 python3-requests \
 python3-requests-gssapi \
 python3-requests-toolbelt \
 python3-setuptools \
 "
