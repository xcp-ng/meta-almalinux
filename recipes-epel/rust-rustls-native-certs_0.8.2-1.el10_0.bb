# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-native-certs"
PV = "0.8.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustls-native-certs+default-devel \
 rust-rustls-native-certs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-native-certs-0.8.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84b675af76c77662a9b04353bd8c3343b3f468d40979c1d80480f492a5ba6683"

URI_x86_64_v2_rust-rustls-native-certs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-native-certs+default-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-native-certs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-native-certs+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-native-certs+default-devel.sha256sum] = "e37c05b33753496372390a6109382e185b64ed1dc440483c96dcbb2f26f179fa"

URI_x86_64_v2_rust-rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-native-certs-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-rustls-native-certs-devel.sha256sum] = "99fe0cc863ac5c56ca05305302316660656013672ae6973bc7301bc157e942fe"

URI_aarch64_rust-rustls-native-certs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-native-certs+default-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-native-certs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-native-certs+default-devel}"
SRC_URI[aarch64_rust-rustls-native-certs+default-devel.sha256sum] = "b001f956bdcca029df1ad578efa387a4d66c7cd1a47e13c2455fdad190e3b1da"

URI_aarch64_rust-rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-native-certs-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-native-certs-devel}"
SRC_URI[aarch64_rust-rustls-native-certs-devel.sha256sum] = "86e6064483481b87497b14731c9b1e1c9307f8d2cb72dd750c1fbbbf325648b3"

RDEPENDS:rust-rustls-native-certs+default-devel = " \
 cargo \
 rust-rustls-native-certs-devel \
 "
RDEPENDS:rust-rustls-native-certs-devel = " \
 cargo \
 rust \
 rust-openssl-probe+default-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 "
