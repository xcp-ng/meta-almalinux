# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "adobe-source-sans-pro-fonts"
PV = "3.052"
PR = "6.el10_1"
PACKAGES = " \
 adobe-source-sans-pro-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/adobe-source-sans-pro-fonts-3.052-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "441bdd285f489c874e25dbcb71e704a99fcc08250bc5633b7b5faef756a9bb95"

URI_x86_64_v2_adobe-source-sans-pro-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/adobe-source-sans-pro-fonts-3.052-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_adobe-source-sans-pro-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adobe-source-sans-pro-fonts}"
SRC_URI[x86_64_v2_adobe-source-sans-pro-fonts.sha256sum] = "d906eabc9063a6343735c343e42e40081f9ad9a6504bcd37eec62c5137db81ab"

URI_aarch64_adobe-source-sans-pro-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/adobe-source-sans-pro-fonts-3.052-6.el10_1.noarch.rpm;name=aarch64_adobe-source-sans-pro-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_adobe-source-sans-pro-fonts}"
SRC_URI[aarch64_adobe-source-sans-pro-fonts.sha256sum] = "8767a7767111e9b607ff3ef7742b2d78bae51aec577dd5ecadf628a30f84a42f"

RDEPENDS:adobe-source-sans-pro-fonts = " \
 fonts-filesystem \
 "
