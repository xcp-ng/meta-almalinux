# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-semantic_version"
PV = "2.10.0"
PR = "10.el10"
PACKAGES = " \
 python3-semantic_version \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-semantic_version-2.10.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b5cb3d671ed08c6026713e47025438d1847f78c20c4517de1ae16cf64aed3fa"

URI_x86_64_v2_python3-semantic_version = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-semantic_version-2.10.0-10.el10.noarch.rpm;name=x86_64_v2_python3-semantic_version;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-semantic_version}"
SRC_URI[x86_64_v2_python3-semantic_version.sha256sum] = "cb0cd3e85a21caf599d46c4bb7d9f4e6149f10075f0106a189bc228b004f043b"

URI_aarch64_python3-semantic_version = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-semantic_version-2.10.0-10.el10.noarch.rpm;name=aarch64_python3-semantic_version;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-semantic_version}"
SRC_URI[aarch64_python3-semantic_version.sha256sum] = "cb0cd3e85a21caf599d46c4bb7d9f4e6149f10075f0106a189bc228b004f043b"

RDEPENDS:python3-semantic_version = " \
 python3 \
 "
