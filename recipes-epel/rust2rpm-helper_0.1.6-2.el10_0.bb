# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust2rpm-helper"
PV = "0.1.6"
PR = "2.el10_0"
PACKAGES = " \
 rust2rpm-helper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust2rpm-helper-0.1.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f49f7c2a715e36c1b8184e5698a2925e6aced7e3ffe4d50970280d7bddd74bfb"

URI_x86_64_v2_rust2rpm-helper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust2rpm-helper-0.1.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rust2rpm-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust2rpm-helper}"
SRC_URI[x86_64_v2_rust2rpm-helper.sha256sum] = "1cd2f462a8f4e9668a3a7ca89c667b5b64f6a735a5bd51d576248423099d9500"

URI_aarch64_rust2rpm-helper = "${EPEL_MIRROR}/aarch64/Packages/r/rust2rpm-helper-0.1.6-2.el10_0.aarch64.rpm;name=aarch64_rust2rpm-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust2rpm-helper}"
SRC_URI[aarch64_rust2rpm-helper.sha256sum] = "e92cc92fb0ab09ae8f31026b0f9b5d42cd8eb1f91e54822574ef8b3b0f5a0693"

RDEPENDS:rust2rpm-helper = " \
 glibc \
 libgcc \
 "
