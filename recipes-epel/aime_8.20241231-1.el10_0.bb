# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aime"
PV = "8.20241231"
PR = "1.el10_0"
PACKAGES = " \
 aime \
 aime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aime-8.20241231-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2efb68661f71952edfbe0dc2decd65281a36e748b216a490781cfd0a62de98d4"

URI_x86_64_v2_aime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aime-8.20241231-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aime}"
SRC_URI[x86_64_v2_aime.sha256sum] = "912a89aba67a0345e351c6bb8a7af6af428a738fae17c515910f6a3ac4e458cd"

URI_x86_64_v2_aime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aime-devel-8.20241231-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aime-devel}"
SRC_URI[x86_64_v2_aime-devel.sha256sum] = "eaa40138362158164cc10d75b117f16c90abc2ff00082aad25e046f884b0b3f8"

URI_aarch64_aime = "${EPEL_MIRROR}/aarch64/Packages/a/aime-8.20241231-1.el10_0.aarch64.rpm;name=aarch64_aime;unpack=0"
SRC_URI:append = " ${URI_aarch64_aime}"
SRC_URI[aarch64_aime.sha256sum] = "95553c94f4aa68b332634a2d167614b69ef6cef61db5ec83b75feac32a0755f5"

URI_aarch64_aime-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aime-devel-8.20241231-1.el10_0.aarch64.rpm;name=aarch64_aime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aime-devel}"
SRC_URI[aarch64_aime-devel.sha256sum] = "622ac0fca7a9ab4281bb4fcb733a8fd113de082ad25f7bc0fe938efffa073bc0"

RDEPENDS:aime = " \
 glibc \
 "
RDEPENDS:aime-devel = " \
 aime \
 "
