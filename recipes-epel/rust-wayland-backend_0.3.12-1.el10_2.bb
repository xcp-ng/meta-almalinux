# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-backend"
PV = "0.3.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-wayland-backend+client_system-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-backend+dlopen-devel \
 rust-wayland-backend+log-devel \
 rust-wayland-backend+raw-window-handle-devel \
 rust-wayland-backend+rwh_06-devel \
 rust-wayland-backend+server_system-devel \
 rust-wayland-backend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-backend-0.3.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a831eafcbf8b7870abb84aec146d63800234fb19066dc6f84a81a94acf3b8e25"

URI_x86_64_v2_rust-wayland-backend+client_system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+client_system-devel-0.3.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+client_system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+client_system-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+client_system-devel.sha256sum] = "3dd61d35831983a19db13768d2807a70fe2d1455b251440d64be8fec33aba9ff"

URI_x86_64_v2_rust-wayland-backend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+default-devel-0.3.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+default-devel.sha256sum] = "bd0943dcfe685c1344cdf5e47788446ab23d959debad2bd13129fff0c2707708"

URI_x86_64_v2_rust-wayland-backend+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+dlopen-devel-0.3.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+dlopen-devel.sha256sum] = "190ad8a8aaaff719fe41e8ebe1e99ab32c6af993b948a073215c438d1696648c"

URI_x86_64_v2_rust-wayland-backend+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+log-devel-0.3.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+log-devel.sha256sum] = "b8936239abe6079556b8cb96ba639c7cc31284157bd76218bfa686ec1db82f2a"

URI_x86_64_v2_rust-wayland-backend+raw-window-handle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+raw-window-handle-devel-0.3.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+raw-window-handle-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+raw-window-handle-devel.sha256sum] = "9607e8ab48df2771f9324493de5c9a4e4d18837e3e33125fa8b1ed0913765e3e"

URI_x86_64_v2_rust-wayland-backend+rwh_06-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+rwh_06-devel-0.3.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+rwh_06-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+rwh_06-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+rwh_06-devel.sha256sum] = "509897a8945ec22485ea9d4b9f61c541a5fd6d128f541a68b3af4d4c496e7ed3"

URI_x86_64_v2_rust-wayland-backend+server_system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+server_system-devel-0.3.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+server_system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+server_system-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+server_system-devel.sha256sum] = "963cc1447a9cb1f9e2da38ab086ba394e0a53631fcac873e2dec5d8c3f751e9c"

URI_x86_64_v2_rust-wayland-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend-devel-0.3.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend-devel.sha256sum] = "79b06ebc0b666d650f744b34a1049cdd564b908add03ba000c32e8953d0186d7"

URI_aarch64_rust-wayland-backend+client_system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+client_system-devel-0.3.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-backend+client_system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+client_system-devel}"
SRC_URI[aarch64_rust-wayland-backend+client_system-devel.sha256sum] = "d6a0908a54b46af480f56c15c68b92ec0e76fc0fc80019a6e80f5e3db5fe6242"

URI_aarch64_rust-wayland-backend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+default-devel-0.3.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+default-devel}"
SRC_URI[aarch64_rust-wayland-backend+default-devel.sha256sum] = "6ba2802a789d1920a4fe896eda30213feb0467e9e6400002b4cb2b589446a58f"

URI_aarch64_rust-wayland-backend+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+dlopen-devel-0.3.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-backend+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+dlopen-devel}"
SRC_URI[aarch64_rust-wayland-backend+dlopen-devel.sha256sum] = "ca272c6f935814654c1fb43739a80c8cf73c9e1e925f568b74a996a365aa132e"

URI_aarch64_rust-wayland-backend+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+log-devel-0.3.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-backend+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+log-devel}"
SRC_URI[aarch64_rust-wayland-backend+log-devel.sha256sum] = "0f0f2c60822f68f552f8fd1acae68024e40563ca0bb9bdbc1620f3eb257c8b2f"

URI_aarch64_rust-wayland-backend+raw-window-handle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+raw-window-handle-devel-0.3.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-backend+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+raw-window-handle-devel}"
SRC_URI[aarch64_rust-wayland-backend+raw-window-handle-devel.sha256sum] = "52070c9992e782b8919dc5f82188ed7d91303f0e4b60b27afa1295ccbd401913"

URI_aarch64_rust-wayland-backend+rwh_06-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+rwh_06-devel-0.3.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-backend+rwh_06-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+rwh_06-devel}"
SRC_URI[aarch64_rust-wayland-backend+rwh_06-devel.sha256sum] = "a774e41685d09f9c4127d8a7eea2d2699001d52a39c6722833cbd0cdceaa94f5"

URI_aarch64_rust-wayland-backend+server_system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+server_system-devel-0.3.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-backend+server_system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+server_system-devel}"
SRC_URI[aarch64_rust-wayland-backend+server_system-devel.sha256sum] = "686af1d885e7ed01f45a52e7335b5c8fbe2afb2e4c981db2a3c719983dd0ece0"

URI_aarch64_rust-wayland-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend-devel-0.3.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend-devel}"
SRC_URI[aarch64_rust-wayland-backend-devel.sha256sum] = "88fa03e1689530a149e7e5128a01af58f25b6ee536ef8bd5bae6b0c93c5aa558"

RDEPENDS:rust-wayland-backend+client_system-devel = " \
 cargo \
 rust-scoped-tls+default-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+client-devel \
 "
RDEPENDS:rust-wayland-backend+default-devel = " \
 cargo \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+dlopen-devel = " \
 cargo \
 rust-wayland-backend-devel \
 rust-wayland-sys+dlopen-devel \
 "
RDEPENDS:rust-wayland-backend+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+raw-window-handle-devel = " \
 cargo \
 rust-raw-window-handle0.5+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+rwh_06-devel = " \
 cargo \
 rust-raw-window-handle+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+server_system-devel = " \
 cargo \
 rust-scoped-tls+default-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+server-devel \
 "
RDEPENDS:rust-wayland-backend-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-downcast-rs1+default-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+process-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 rust-wayland-sys+default-devel \
 "
