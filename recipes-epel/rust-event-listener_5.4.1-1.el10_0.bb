# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-event-listener"
PV = "5.4.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-event-listener+critical-section-devel \
 rust-event-listener+default-devel \
 rust-event-listener+parking-devel \
 rust-event-listener+portable-atomic-devel \
 rust-event-listener+portable-atomic-util-devel \
 rust-event-listener+portable_atomic_crate-devel \
 rust-event-listener+std-devel \
 rust-event-listener-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-event-listener-5.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64800f35de15507493363ece2ffb3f6b06a7c4b2933d3357340eb0e1ea242d45"

URI_x86_64_v2_rust-event-listener+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+critical-section-devel-5.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+critical-section-devel}"
SRC_URI[x86_64_v2_rust-event-listener+critical-section-devel.sha256sum] = "4b7d4fbd89ddd62bf91cfb70a9de7b1e087315629dbe6ac5ccc35ed585c0e2a7"

URI_x86_64_v2_rust-event-listener+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+default-devel-5.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+default-devel}"
SRC_URI[x86_64_v2_rust-event-listener+default-devel.sha256sum] = "323e35feecee4090ab01a859e5457754ffdbed9b4bc9ea6366838415fa6f1218"

URI_x86_64_v2_rust-event-listener+parking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+parking-devel-5.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+parking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+parking-devel}"
SRC_URI[x86_64_v2_rust-event-listener+parking-devel.sha256sum] = "562917a1a25246c2e0709a867dd639370704aaf0d8858895db7c07407c628284"

URI_x86_64_v2_rust-event-listener+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable-atomic-devel-5.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable-atomic-devel.sha256sum] = "3f23122541588e3c2d77c8ff1a36762c9604d29f43970f9ec0a9c1ea70886521"

URI_x86_64_v2_rust-event-listener+portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable-atomic-util-devel-5.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable-atomic-util-devel.sha256sum] = "4f79986855f251965a1c00733f082b5f2363b3ac24386860a50210c0d3084032"

URI_x86_64_v2_rust-event-listener+portable_atomic_crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable_atomic_crate-devel-5.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable_atomic_crate-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable_atomic_crate-devel.sha256sum] = "201f14e90342198d365495d535beb929c9614ec7fd4cca13013085d227abfb8f"

URI_x86_64_v2_rust-event-listener+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+std-devel-5.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+std-devel}"
SRC_URI[x86_64_v2_rust-event-listener+std-devel.sha256sum] = "710a1fd6ce794683a70dee9c3e84b7bf738a98d40c8a545e7889e65394b51317"

URI_x86_64_v2_rust-event-listener-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-devel-5.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-devel}"
SRC_URI[x86_64_v2_rust-event-listener-devel.sha256sum] = "33bfaebdddcdbd4be728167cee6298ffdda7405b37dfebefe2885eb6fd01eb82"

URI_aarch64_rust-event-listener+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+critical-section-devel-5.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+critical-section-devel}"
SRC_URI[aarch64_rust-event-listener+critical-section-devel.sha256sum] = "05f110cb7e277c023aa45a16181c9c4f777046dfa9d8a2ef625a7fc7d6e18260"

URI_aarch64_rust-event-listener+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+default-devel-5.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+default-devel}"
SRC_URI[aarch64_rust-event-listener+default-devel.sha256sum] = "dbc914b04519b1c3e588d07f4266aff84a1a1cf7e173db258a6ac26f43c0c7a8"

URI_aarch64_rust-event-listener+parking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+parking-devel-5.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener+parking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+parking-devel}"
SRC_URI[aarch64_rust-event-listener+parking-devel.sha256sum] = "1fdac703493eaaabaa67008d6e59b1596e484bc0ed9e9deffdcdb1eb88cd4125"

URI_aarch64_rust-event-listener+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable-atomic-devel-5.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable-atomic-devel}"
SRC_URI[aarch64_rust-event-listener+portable-atomic-devel.sha256sum] = "bc717bf4da966a4d11d268c35add4af970635fb07c655ef9312a952db4cf844b"

URI_aarch64_rust-event-listener+portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable-atomic-util-devel-5.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable-atomic-util-devel}"
SRC_URI[aarch64_rust-event-listener+portable-atomic-util-devel.sha256sum] = "cdeaa5fa11405d551ae7ee0b45d9a05eed68a3f694b9a5e79dfbb516ea153276"

URI_aarch64_rust-event-listener+portable_atomic_crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable_atomic_crate-devel-5.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable_atomic_crate-devel}"
SRC_URI[aarch64_rust-event-listener+portable_atomic_crate-devel.sha256sum] = "ec75b5e12d219c31e11b15bf62e899d992aedfe2eb9ef9e608cc09c8dac1417d"

URI_aarch64_rust-event-listener+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+std-devel-5.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+std-devel}"
SRC_URI[aarch64_rust-event-listener+std-devel.sha256sum] = "3869b90a2e0de0dca09323285acdb17bc20f02a4c197b5fdc41caed6436aefed"

URI_aarch64_rust-event-listener-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-devel-5.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-devel}"
SRC_URI[aarch64_rust-event-listener-devel.sha256sum] = "661a95d118936946664afbfb48c4c362d97504237c0f9953a1468fe04b89415e"

RDEPENDS:rust-event-listener+critical-section-devel = " \
 cargo \
 rust-critical-section-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+default-devel = " \
 cargo \
 rust-event-listener+std-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+parking-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-parking+default-devel \
 "
RDEPENDS:rust-event-listener+portable-atomic-devel = " \
 cargo \
 rust-concurrent-queue+portable-atomic-devel \
 rust-event-listener+portable-atomic-util-devel \
 rust-event-listener+portable_atomic_crate-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+portable-atomic-util-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-event-listener+portable_atomic_crate-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-event-listener+std-devel = " \
 cargo \
 rust-concurrent-queue+std-devel \
 rust-event-listener+parking-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener-devel = " \
 cargo \
 rust \
 rust-concurrent-queue-devel \
 rust-pin-project-lite+default-devel \
 "
