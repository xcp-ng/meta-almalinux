# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-voluptuous"
PV = "0.16.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-voluptuous \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-voluptuous-0.16.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f074362450cc839c80236740659f3adc2e76412b8f100e0cb2237f0c5159cf2"

URI_x86_64_v2_python3-voluptuous = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-voluptuous-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-voluptuous;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-voluptuous}"
SRC_URI[x86_64_v2_python3-voluptuous.sha256sum] = "1dd2ef63a9b63c700a38b29c5bf7e3a7652109a90f10fdc78f14de2f1a52b259"

URI_aarch64_python3-voluptuous = "${EPEL_MIRROR}/aarch64/Packages/p/python3-voluptuous-0.16.0-1.el10_3.noarch.rpm;name=aarch64_python3-voluptuous;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-voluptuous}"
SRC_URI[aarch64_python3-voluptuous.sha256sum] = "a01730c7eca2a17afdb1c2604b78096bf11b5dd65cf0a165fb4d77bf7b1145bb"

RDEPENDS:python3-voluptuous = " \
 python3 \
 "
