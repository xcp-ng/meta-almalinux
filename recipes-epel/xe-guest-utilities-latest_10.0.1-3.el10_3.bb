# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xe-guest-utilities-latest"
PV = "10.0.1"
PR = "3.el10_3"
PACKAGES:x86_64_v2 = " \
 xe-guest-utilities-latest \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/x/xe-guest-utilities-latest-10.0.1-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "766f8c5fedf9c0bc0fed9e815fc40e269591d7d29b28fff99da35ba21224c66f"

URI_x86_64_v2_xe-guest-utilities-latest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xe-guest-utilities-latest-10.0.1-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xe-guest-utilities-latest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xe-guest-utilities-latest}"
SRC_URI[x86_64_v2_xe-guest-utilities-latest.sha256sum] = "d5bf728ab25ef1722eaa087a9b3b5fae17fc1d67f1ce91fa566baec4051f6607"

RDEPENDS:xe-guest-utilities-latest = " \
 bash \
 systemd \
 "
