# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mailparse"
PV = "0.16.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-mailparse+default-devel \
 rust-mailparse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mailparse-0.16.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d31e0138524e7151ceb2aac850e886636942c90d10d27e301c10b4cc5355b127"

URI_x86_64_v2_rust-mailparse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mailparse+default-devel-0.16.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mailparse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mailparse+default-devel}"
SRC_URI[x86_64_v2_rust-mailparse+default-devel.sha256sum] = "7dbade4d4100fa9095864c1b650d2e324e6c6d8db5eb0f1ffa1e70b5462dd292"

URI_x86_64_v2_rust-mailparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mailparse-devel-0.16.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mailparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mailparse-devel}"
SRC_URI[x86_64_v2_rust-mailparse-devel.sha256sum] = "9ca6e29631da7d26da187118dabd41b0a696ca942da3a6df1b4de6f5ae8f11e5"

URI_aarch64_rust-mailparse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mailparse+default-devel-0.16.1-1.el10_1.noarch.rpm;name=aarch64_rust-mailparse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mailparse+default-devel}"
SRC_URI[aarch64_rust-mailparse+default-devel.sha256sum] = "c668e9becd996c59c7588848c6758297cbd4d0672217f3bd1af9ed6deec2fed9"

URI_aarch64_rust-mailparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mailparse-devel-0.16.1-1.el10_1.noarch.rpm;name=aarch64_rust-mailparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mailparse-devel}"
SRC_URI[aarch64_rust-mailparse-devel.sha256sum] = "9c7372da45228f11d52da76a5eccb74fcc8c9cf474d2a7f58fc2f014e02ac7ba"

RDEPENDS:rust-mailparse+default-devel = " \
 cargo \
 rust-mailparse-devel \
 "
RDEPENDS:rust-mailparse-devel = " \
 cargo \
 rust-charset+default-devel \
 rust-data-encoding+default-devel \
 rust-quoted_printable+default-devel \
 "
