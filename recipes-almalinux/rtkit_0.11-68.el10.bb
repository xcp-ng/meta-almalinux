# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rtkit"
PV = "0.11"
PR = "68.el10"
PACKAGES = " \
 rtkit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rtkit-0.11-68.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7eac68b8ebaf8e678958e81b3135e6aa294c0a130abab5757626af59d46c308"

URI_x86_64_v2_rtkit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rtkit-0.11-68.el10.x86_64_v2.rpm;name=x86_64_v2_rtkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rtkit}"
SRC_URI[x86_64_v2_rtkit.sha256sum] = "99e7225e51d3f46e51340b9ff91cfdb8f6d952f49f2567104b5a6eef39a6ce10"

URI_aarch64_rtkit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rtkit-0.11-68.el10.aarch64.rpm;name=aarch64_rtkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rtkit}"
SRC_URI[aarch64_rtkit.sha256sum] = "10ccb65456cfecccd7b4bbd34297a328b185300604dfc098779c0d7d4a6b8d01"

RDEPENDS:rtkit = " \
 bash \
 dbus \
 dbus-libs \
 glibc \
 libcap \
 polkit \
 shadow-utils \
 systemd-libs \
 "
