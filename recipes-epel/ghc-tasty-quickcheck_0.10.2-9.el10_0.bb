# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tasty-quickcheck"
PV = "0.10.2"
PR = "9.el10_0"
PACKAGES = " \
 ghc-tasty-quickcheck \
 ghc-tasty-quickcheck-devel \
 ghc-tasty-quickcheck-doc \
 ghc-tasty-quickcheck-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tasty-quickcheck-0.10.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84b0b3328a6197c66f67e7444f0d893ae424b6fcaeadc01dcee9d9e892980eb3"

URI_x86_64_v2_ghc-tasty-quickcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-quickcheck-0.10.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-quickcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-quickcheck}"
SRC_URI[x86_64_v2_ghc-tasty-quickcheck.sha256sum] = "11eae0742907ab8231943f04fadb27f9fb2873240fd23dbddcefc8ea4b5dd60e"

URI_x86_64_v2_ghc-tasty-quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-quickcheck-devel-0.10.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-quickcheck-devel}"
SRC_URI[x86_64_v2_ghc-tasty-quickcheck-devel.sha256sum] = "1af638acbd3c4bbbda3381f8473fe09f6c9a8d710c4318c295798afbecaebe77"

URI_x86_64_v2_ghc-tasty-quickcheck-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-quickcheck-doc-0.10.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tasty-quickcheck-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-quickcheck-doc}"
SRC_URI[x86_64_v2_ghc-tasty-quickcheck-doc.sha256sum] = "77c01ddb5000a3a68d8b39aace33f2d6c4f18946904d58673e413998238c523b"

URI_x86_64_v2_ghc-tasty-quickcheck-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-quickcheck-prof-0.10.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-quickcheck-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-quickcheck-prof}"
SRC_URI[x86_64_v2_ghc-tasty-quickcheck-prof.sha256sum] = "cfd38927f32312fb451e26a10dfe9f830cd9d52e6dc0cceaf79524269ec3a09c"

URI_aarch64_ghc-tasty-quickcheck = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-quickcheck-0.10.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-quickcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-quickcheck}"
SRC_URI[aarch64_ghc-tasty-quickcheck.sha256sum] = "d53756953b0f5d06a10d62e92b9c46d246ae96833359e680714ee9e709ad832c"

URI_aarch64_ghc-tasty-quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-quickcheck-devel-0.10.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-quickcheck-devel}"
SRC_URI[aarch64_ghc-tasty-quickcheck-devel.sha256sum] = "bd237ce8120556fa5ffb34a45667400cd0ee466d63f0bc9c379bc2f7875daf3d"

URI_aarch64_ghc-tasty-quickcheck-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-quickcheck-doc-0.10.2-9.el10_0.noarch.rpm;name=aarch64_ghc-tasty-quickcheck-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-quickcheck-doc}"
SRC_URI[aarch64_ghc-tasty-quickcheck-doc.sha256sum] = "987c8f43576d394130cb27ea20e0fd799259093145df13dc184fff4c0750c995"

URI_aarch64_ghc-tasty-quickcheck-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-quickcheck-prof-0.10.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-quickcheck-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-quickcheck-prof}"
SRC_URI[aarch64_ghc-tasty-quickcheck-prof.sha256sum] = "f9ac2657403eed944441ccaf39eab06d5c6029c179620af6ff9974455b241b76"

RDEPENDS:ghc-tasty-quickcheck = " \
 ghc-QuickCheck \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-optparse-applicative \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-process \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-tagged \
 ghc-tasty \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tasty-quickcheck-devel = " \
 ghc-QuickCheck-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-optparse-applicative-devel \
 ghc-random-devel \
 ghc-tagged-devel \
 ghc-tasty-devel \
 ghc-tasty-quickcheck \
 "
RDEPENDS:ghc-tasty-quickcheck-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tasty-quickcheck-prof = " \
 ghc-QuickCheck-prof \
 ghc-base-prof \
 ghc-optparse-applicative-prof \
 ghc-random-prof \
 ghc-tagged-prof \
 ghc-tasty-prof \
 ghc-tasty-quickcheck-devel \
 "
