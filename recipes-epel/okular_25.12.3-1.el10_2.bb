# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "okular"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 okular \
 okular-devel \
 okular-libs \
 okular-mobile \
 okular-part \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/okular-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7fcb23d7dc5e4314b9cce086609963b702afd0f6c7804bd26d8ac5f0d0cf2ec"

URI_x86_64_v2_okular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular}"
SRC_URI[x86_64_v2_okular.sha256sum] = "2172a6e1e6dff89c3186e5c427efb2c52f55a2f2d5072db673a90acfb533447f"

URI_x86_64_v2_okular-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-devel}"
SRC_URI[x86_64_v2_okular-devel.sha256sum] = "467db0fc61c0db40c87f7fb473cd4cbb128f321442e79ea978d133e48a622025"

URI_x86_64_v2_okular-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-libs}"
SRC_URI[x86_64_v2_okular-libs.sha256sum] = "5983a3bde5b47ca0a2a8c1b9354777d1f5c48798563d01eb1fa6005189a5afad"

URI_x86_64_v2_okular-mobile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-mobile-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-mobile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-mobile}"
SRC_URI[x86_64_v2_okular-mobile.sha256sum] = "9fc45802009552cc8b51327c985c2464ef0b06b4cfa41a29f8f545b092cf6ede"

URI_x86_64_v2_okular-part = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/okular-part-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_okular-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_okular-part}"
SRC_URI[x86_64_v2_okular-part.sha256sum] = "66fcfb2c57f72d26f134f344966a678753ffe6041e6b402c72e062dae2a8175d"

URI_aarch64_okular = "${EPEL_MIRROR}/aarch64/Packages/o/okular-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_okular;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular}"
SRC_URI[aarch64_okular.sha256sum] = "07ca48dcbd98cf823f04916c26b2d3fd10749c6ab7ff6d6c527778a09ebd2f59"

URI_aarch64_okular-devel = "${EPEL_MIRROR}/aarch64/Packages/o/okular-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_okular-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-devel}"
SRC_URI[aarch64_okular-devel.sha256sum] = "82d5696786d5a1cda1c07ffaa73dd5f2617f1cd73205c3b8a425872bdf4dc3b1"

URI_aarch64_okular-libs = "${EPEL_MIRROR}/aarch64/Packages/o/okular-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_okular-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-libs}"
SRC_URI[aarch64_okular-libs.sha256sum] = "307fae27f0b33c3b64f727db5be677da7a3d5e6dad6447a227332c438bf6e76a"

URI_aarch64_okular-mobile = "${EPEL_MIRROR}/aarch64/Packages/o/okular-mobile-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_okular-mobile;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-mobile}"
SRC_URI[aarch64_okular-mobile.sha256sum] = "33b31d52c4895f174b3417c50e1d6dcb05bfeb136093bc5f2426ecd3efd33a9f"

URI_aarch64_okular-part = "${EPEL_MIRROR}/aarch64/Packages/o/okular-part-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_okular-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_okular-part}"
SRC_URI[aarch64_okular-part.sha256sum] = "4697c6d8dad33a215da75194a36ec3fcc96c165760c2daa0669735c6d2a80532"

RDEPENDS:okular = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-purpose \
 libstdc++ \
 okular-part \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:okular-devel = " \
 cmake-filesystem \
 okular-libs \
 "
RDEPENDS:okular-libs = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-threadweaver \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 zlib-ng-compat \
 "
RDEPENDS:okular-mobile = " \
 glibc \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 okular-libs \
 okular-part \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:okular-part = " \
 freetype \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 libkexiv2-qt6 \
 libmarkdown \
 libspectre \
 libstdc++ \
 libtiff \
 okular-libs \
 phonon-qt6 \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
