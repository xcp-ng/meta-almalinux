# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cond_sync"
PV = "0.2.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-cond_sync+default-devel \
 rust-cond_sync-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cond_sync-0.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73c050ca7b45fcc002a5a1769a44e958a7645ee5eb688c8bcc5450df3ff6ff62"

URI_x86_64_v2_rust-cond_sync+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cond_sync+default-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cond_sync+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cond_sync+default-devel}"
SRC_URI[x86_64_v2_rust-cond_sync+default-devel.sha256sum] = "0bd2a9d1530204d034cb0f10b2e4ed587a1fb36d1cfbe4855b2ddc533de42e8d"

URI_x86_64_v2_rust-cond_sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cond_sync-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cond_sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cond_sync-devel}"
SRC_URI[x86_64_v2_rust-cond_sync-devel.sha256sum] = "274008c17c7764bf97e7ba91455652ba515abc37ec115992792d154a52fc2295"

URI_aarch64_rust-cond_sync+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cond_sync+default-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-cond_sync+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cond_sync+default-devel}"
SRC_URI[aarch64_rust-cond_sync+default-devel.sha256sum] = "6fd43ddadaff1b6ca7fc9746a439e887afc594dc2c18a4b3a33005f6b1417307"

URI_aarch64_rust-cond_sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cond_sync-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-cond_sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cond_sync-devel}"
SRC_URI[aarch64_rust-cond_sync-devel.sha256sum] = "6915a6dc94a1a763082df63a76bd57421389372148738fa2c2f6b5d838d81d5f"

RDEPENDS:rust-cond_sync+default-devel = " \
 cargo \
 rust-cond_sync-devel \
 "
RDEPENDS:rust-cond_sync-devel = " \
 cargo \
 rust \
 "
