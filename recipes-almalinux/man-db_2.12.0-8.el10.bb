# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "man-db"
PV = "2.12.0"
PR = "8.el10"
PACKAGES = " \
 man-db \
 man-db-cron \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/man-db-2.12.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4b90697bb0b285cdae73a7541af47d23c36fb15f932db84598bb54cf3bfed99"

URI_x86_64_v2_man-db = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/man-db-2.12.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_man-db;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_man-db}"
SRC_URI[x86_64_v2_man-db.sha256sum] = "1300fa1a528db8c41f9105ec4e00a569f7d49a0dcd9af3075756ec790f3780a4"

URI_x86_64_v2_man-db-cron = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/man-db-cron-2.12.0-8.el10.noarch.rpm;name=x86_64_v2_man-db-cron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_man-db-cron}"
SRC_URI[x86_64_v2_man-db-cron.sha256sum] = "2c27cf85287584f099983539c484445349b32a06c1dcc568f9370f594de71dff"

URI_aarch64_man-db = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/man-db-2.12.0-8.el10.aarch64.rpm;name=aarch64_man-db;unpack=0"
SRC_URI:append = " ${URI_aarch64_man-db}"
SRC_URI[aarch64_man-db.sha256sum] = "38d2d7e3397a58ff83ae0827c55584a5b2cab3edae6c7f60d73782ddb36c2655"

URI_aarch64_man-db-cron = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/man-db-cron-2.12.0-8.el10.noarch.rpm;name=aarch64_man-db-cron;unpack=0"
SRC_URI:append = " ${URI_aarch64_man-db-cron}"
SRC_URI[aarch64_man-db-cron.sha256sum] = "2c27cf85287584f099983539c484445349b32a06c1dcc568f9370f594de71dff"

RDEPENDS:man-db = " \
 alternatives \
 bash \
 gdbm-libs \
 glibc \
 grep \
 groff-base \
 gzip \
 less \
 libpipeline \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:man-db-cron = " \
 bash \
 crontabs \
 man-db \
 "
