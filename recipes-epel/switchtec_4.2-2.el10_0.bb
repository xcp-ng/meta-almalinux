# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "switchtec"
PV = "4.2"
PR = "2.el10_0"
PACKAGES = " \
 switchtec \
 switchtec-devel \
 switchtec-doc \
 switchtec-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/switchtec-4.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7c6f5eec8b449250bfe886127cb294119ee8f6c987f858900ae80b4cf761516c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/switchtec-4.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_switchtec;unpack=0"
SRC_URI[x86_64_v2_switchtec.sha256sum] = "bc1b2fca916139671e21d0d13039d722f6cadf04e036c94dc6ccaf645c76699d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/switchtec-devel-4.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_switchtec-devel;unpack=0"
SRC_URI[x86_64_v2_switchtec-devel.sha256sum] = "2e491a9bfc4c7fc57df253f4033a1d542bc02801137fdd5c00dcfc24d189811e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/switchtec-doc-4.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_switchtec-doc;unpack=0"
SRC_URI[x86_64_v2_switchtec-doc.sha256sum] = "3ff8439a48570e3146a8a00290dbd6600f8f7c6e01c8ec406ba768e6ab22e97b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/switchtec-libs-4.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_switchtec-libs;unpack=0"
SRC_URI[x86_64_v2_switchtec-libs.sha256sum] = "474fadcb653258b97ec4076daef7ccd79a7aca63da1756fe15a5f13d609de90f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/switchtec-4.2-2.el10_0.aarch64.rpm;name=aarch64_switchtec;unpack=0"
SRC_URI[aarch64_switchtec.sha256sum] = "a1761f2ae1635c55451c05ceaea92a9843376720137d47e060f252d5a4f0172a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/switchtec-devel-4.2-2.el10_0.aarch64.rpm;name=aarch64_switchtec-devel;unpack=0"
SRC_URI[aarch64_switchtec-devel.sha256sum] = "657bfd84cad232941f918f3e9226bdf357b8bacbe1dc0fdc3013f94c2cbae1e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/switchtec-doc-4.2-2.el10_0.noarch.rpm;name=aarch64_switchtec-doc;unpack=0"
SRC_URI[aarch64_switchtec-doc.sha256sum] = "fbafe4412edceab8316ac1613db752c039393e5c3141e5c6ad3e0057b9f361e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/switchtec-libs-4.2-2.el10_0.aarch64.rpm;name=aarch64_switchtec-libs;unpack=0"
SRC_URI[aarch64_switchtec-libs.sha256sum] = "06681fc9b71b7e83ae4773822838dbb5a4713afe8f596de87d2e10afc7ed2e46"

RDEPENDS:switchtec = " \
 glibc \
 ncurses-libs \
 openssl-libs \
 "
RDEPENDS:switchtec-devel = " \
 switchtec-libs \
 "
RDEPENDS:switchtec-doc = " \
 "
RDEPENDS:switchtec-libs = " \
 glibc \
 "
