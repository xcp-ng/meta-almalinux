# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysqltuner"
PV = "2.7.0"
PR = "2.el10_1"
PACKAGES = " \
 mysqltuner \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mysqltuner-2.7.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6a0d611f5034a10ce5f03d5b328f650f51ad484458f7a0d3772ca224e740af5"

URI_x86_64_v2_mysqltuner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mysqltuner-2.7.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mysqltuner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysqltuner}"
SRC_URI[x86_64_v2_mysqltuner.sha256sum] = "3df7b70357cce5fb8ea0a3399d297a8afb14620405693da322c6db4278a698a1"

URI_aarch64_mysqltuner = "${EPEL_MIRROR}/aarch64/Packages/m/mysqltuner-2.7.0-2.el10_1.noarch.rpm;name=aarch64_mysqltuner;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysqltuner}"
SRC_URI[aarch64_mysqltuner.sha256sum] = "6f7c09f48635139edbeaf85d94c0bd8d9115d9471756ccd37ea691ce836d09a5"

RDEPENDS:mysqltuner = " \
 mariadb \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Usage \
 perl-diagnostics \
 perl-interpreter \
 perl-libs \
 which \
 "
