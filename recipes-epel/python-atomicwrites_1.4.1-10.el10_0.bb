# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-atomicwrites"
PV = "1.4.1"
PR = "10.el10_0"
PACKAGES = " \
 python3-atomicwrites \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-atomicwrites-1.4.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f06e225d8b69e3080544ffffc2d0cc6476941daf2cd717ce40c54b4d3fceb89"

URI_x86_64_v2_python3-atomicwrites = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-atomicwrites-1.4.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-atomicwrites;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-atomicwrites}"
SRC_URI[x86_64_v2_python3-atomicwrites.sha256sum] = "472d93b81e7c63711ada6d956af96506586fa940dcb749a3b4584006b1d6879e"

URI_aarch64_python3-atomicwrites = "${EPEL_MIRROR}/aarch64/Packages/p/python3-atomicwrites-1.4.1-10.el10_0.noarch.rpm;name=aarch64_python3-atomicwrites;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-atomicwrites}"
SRC_URI[aarch64_python3-atomicwrites.sha256sum] = "5d28a42841e7090b2131e11337baa44516d9ce51ffafc9a65e73298bff08e469"

RDEPENDS:python3-atomicwrites = " \
 python3 \
 "
