# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tpm-tools"
PV = "1.3.9"
PR = "19.el10_0"
PACKAGES = " \
 tpm-tools \
 tpm-tools-devel \
 tpm-tools-pkcs11 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tpm-tools-1.3.9-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04c09b011e937e6399526be4e3a74d3118c12ed3eef61f90963f7654c1af3fad"

URI_x86_64_v2_tpm-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tpm-tools-1.3.9-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tpm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tpm-tools}"
SRC_URI[x86_64_v2_tpm-tools.sha256sum] = "408354d9d67803d0cb060e5bf67d2568e9f660713121e20462b8d95e1c8ddb98"

URI_x86_64_v2_tpm-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tpm-tools-devel-1.3.9-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tpm-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tpm-tools-devel}"
SRC_URI[x86_64_v2_tpm-tools-devel.sha256sum] = "2bcede69931b99a038e3105dec5e712ea566b697bcceee3bb0cb30ad56cd092c"

URI_x86_64_v2_tpm-tools-pkcs11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tpm-tools-pkcs11-1.3.9-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tpm-tools-pkcs11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tpm-tools-pkcs11}"
SRC_URI[x86_64_v2_tpm-tools-pkcs11.sha256sum] = "13592af3c24244ded21af20e2b5e8e7002efbc98d7f63451d05154608ab0e08c"

URI_aarch64_tpm-tools = "${EPEL_MIRROR}/aarch64/Packages/t/tpm-tools-1.3.9-19.el10_0.aarch64.rpm;name=aarch64_tpm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_tpm-tools}"
SRC_URI[aarch64_tpm-tools.sha256sum] = "15109a3d4546aebdc667d4d002187bd8286fd91e32f4b501cdedfa1599122f1d"

URI_aarch64_tpm-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/t/tpm-tools-devel-1.3.9-19.el10_0.aarch64.rpm;name=aarch64_tpm-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tpm-tools-devel}"
SRC_URI[aarch64_tpm-tools-devel.sha256sum] = "398cc2a93bc2cdfe34c05a0ebb7f4e930fd671fef876a2c56e7092e1c1b1ba27"

URI_aarch64_tpm-tools-pkcs11 = "${EPEL_MIRROR}/aarch64/Packages/t/tpm-tools-pkcs11-1.3.9-19.el10_0.aarch64.rpm;name=aarch64_tpm-tools-pkcs11;unpack=0"
SRC_URI:append = " ${URI_aarch64_tpm-tools-pkcs11}"
SRC_URI[aarch64_tpm-tools-pkcs11.sha256sum] = "68e5440e496dffd4faefac564ed135e65712fd52c3be3f5802242f0ec6a209cf"

RDEPENDS:tpm-tools = " \
 glibc \
 openssl-libs \
 trousers-lib \
 "
RDEPENDS:tpm-tools-devel = " \
 tpm-tools \
 "
RDEPENDS:tpm-tools-pkcs11 = " \
 glibc \
 opencryptoki-libs \
 openssl-libs \
 trousers-lib \
 "
