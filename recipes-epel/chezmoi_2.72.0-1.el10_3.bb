# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chezmoi"
PV = "2.72.0"
PR = "1.el10_3"
PACKAGES = " \
 chezmoi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/chezmoi-2.72.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2655233bbab087c1f2b0edd9b4e6219b573cf4c64af531abf1345871214ba605"

URI_x86_64_v2_chezmoi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chezmoi-2.72.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chezmoi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chezmoi}"
SRC_URI[x86_64_v2_chezmoi.sha256sum] = "75a5729097b0bb086b7a6e1b35b16b922c1de7255620f6af5716c8c001dabdf0"

URI_aarch64_chezmoi = "${EPEL_MIRROR}/aarch64/Packages/c/chezmoi-2.72.0-1.el10_3.aarch64.rpm;name=aarch64_chezmoi;unpack=0"
SRC_URI:append = " ${URI_aarch64_chezmoi}"
SRC_URI[aarch64_chezmoi.sha256sum] = "707e4a80a0fb918d1e99006747d29f95696917f7d9ef40c262885a9b9357f535"

RDEPENDS:chezmoi = " \
 glibc \
 "
