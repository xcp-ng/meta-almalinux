# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mock"
PV = "6.8"
PR = "1.el10_3"
PACKAGES = " \
 mock \
 mock-filesystem \
 mock-lvm \
 mock-rpmautospec \
 mock-scm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mock-6.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b36993d0c7f4695626e324774bb8eda9300708eab8eb076dd5001fd0e59b4379"

URI_x86_64_v2_mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock}"
SRC_URI[x86_64_v2_mock.sha256sum] = "0757c50b5a391adb240072e26316a7b4935d5146a233ed5a0708a47af6e8c3bb"

URI_x86_64_v2_mock-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-filesystem-6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mock-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-filesystem}"
SRC_URI[x86_64_v2_mock-filesystem.sha256sum] = "46b23a1584a80f24a957cf7c49c8911bd8109c3d2bee237e1a2cc57034a40538"

URI_x86_64_v2_mock-lvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-lvm-6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mock-lvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-lvm}"
SRC_URI[x86_64_v2_mock-lvm.sha256sum] = "3663e1e73f2bd8b9c2965d5061a0b9abf5a0bc9cc0070a073e4492952736c2af"

URI_x86_64_v2_mock-rpmautospec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-rpmautospec-6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mock-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-rpmautospec}"
SRC_URI[x86_64_v2_mock-rpmautospec.sha256sum] = "b41609bdeb55279cc325a7452ed18d857d907dd14bdc30945647eabb852316e0"

URI_x86_64_v2_mock-scm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-scm-6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mock-scm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-scm}"
SRC_URI[x86_64_v2_mock-scm.sha256sum] = "3ad32d8621af0a10b5bfae8c5990a0f383c08c15f69ec0d6ee495a85a79c6a1f"

URI_aarch64_mock = "${EPEL_MIRROR}/aarch64/Packages/m/mock-6.8-1.el10_3.noarch.rpm;name=aarch64_mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock}"
SRC_URI[aarch64_mock.sha256sum] = "54b9fe6bb2d4abb59a0256a1857a4843829eecdf37d985dc7dccdc3cf76de488"

URI_aarch64_mock-filesystem = "${EPEL_MIRROR}/aarch64/Packages/m/mock-filesystem-6.8-1.el10_3.noarch.rpm;name=aarch64_mock-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-filesystem}"
SRC_URI[aarch64_mock-filesystem.sha256sum] = "1e71f4819a2c7ff9217c9fe608fad273df902f745b455908aabd21e401750c7f"

URI_aarch64_mock-lvm = "${EPEL_MIRROR}/aarch64/Packages/m/mock-lvm-6.8-1.el10_3.noarch.rpm;name=aarch64_mock-lvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-lvm}"
SRC_URI[aarch64_mock-lvm.sha256sum] = "8a3a7e475be06b246e8254d2f81967ba4f5f578e3800155411bdc95772cb591e"

URI_aarch64_mock-rpmautospec = "${EPEL_MIRROR}/aarch64/Packages/m/mock-rpmautospec-6.8-1.el10_3.noarch.rpm;name=aarch64_mock-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-rpmautospec}"
SRC_URI[aarch64_mock-rpmautospec.sha256sum] = "f895a1320a3eaae4e7389c773b56881e3bb83f6ad5898932caaf78653d89e937"

URI_aarch64_mock-scm = "${EPEL_MIRROR}/aarch64/Packages/m/mock-scm-6.8-1.el10_3.noarch.rpm;name=aarch64_mock-scm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-scm}"
SRC_URI[aarch64_mock-scm.sha256sum] = "cf9c6f04525667e933c81b10cef30950262ace6304c47f7f9099efac34fe64e8"

RDEPENDS:mock = " \
 bash \
 createrepo_c \
 mock-core-configs \
 mock-filesystem \
 pigz \
 procps-ng \
 python3 \
 python3-backoff \
 python3-distro \
 python3-jinja2 \
 python3-pyroute2 \
 python3-requests \
 python3-rpm \
 python3-templated-dictionary \
 shadow-utils \
 systemd \
 systemd-container \
 tar \
 usermode \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:mock-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:mock-lvm = " \
 lvm2 \
 mock \
 python3 \
 "
RDEPENDS:mock-rpmautospec = " \
 mock \
 python3 \
 python3-rpmautospec-core \
 "
RDEPENDS:mock-scm = " \
 mock \
 python3 \
 "
