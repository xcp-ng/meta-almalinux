# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bullet"
PV = "3.08"
PR = "15.el10_1"
PACKAGES = " \
 bullet \
 bullet-devel \
 bullet-devel-doc \
 bullet-extras \
 bullet-extras-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bullet-3.08-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe11129fec169e2f3b35de337f209561e7a43f7d2895256854ce01b82a32d0d2"

URI_x86_64_v2_bullet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-3.08-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet}"
SRC_URI[x86_64_v2_bullet.sha256sum] = "b49adc0c99c6a64bff94433bb3575d5d897f4108ac30bbb0aabb4ec5134fba11"

URI_x86_64_v2_bullet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-devel-3.08-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-devel}"
SRC_URI[x86_64_v2_bullet-devel.sha256sum] = "0c7e8cf418088b9bdaa10ccd6470e9570780e1d1b551530caa13962b1f2b6726"

URI_x86_64_v2_bullet-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-devel-doc-3.08-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-devel-doc}"
SRC_URI[x86_64_v2_bullet-devel-doc.sha256sum] = "5f7df3fa466cd388f0be2ce1bfea03645982dd2925bf8329af91e2bc3acfd9ca"

URI_x86_64_v2_bullet-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-extras-3.08-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-extras}"
SRC_URI[x86_64_v2_bullet-extras.sha256sum] = "afcf28c56c869db3efb30579e17b998e44a27bd030570cd41b1e8446e89f7df2"

URI_x86_64_v2_bullet-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bullet-extras-devel-3.08-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bullet-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bullet-extras-devel}"
SRC_URI[x86_64_v2_bullet-extras-devel.sha256sum] = "188913de261bd1822e8edcb9c66d8e31003d2dff5672e4cc2e1ce81e40d62826"

URI_aarch64_bullet = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-3.08-15.el10_1.aarch64.rpm;name=aarch64_bullet;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet}"
SRC_URI[aarch64_bullet.sha256sum] = "6050fb10fe266d9db81f67c4a5452a59e3146ab66156768f2c3edd5c6223dc22"

URI_aarch64_bullet-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-devel-3.08-15.el10_1.aarch64.rpm;name=aarch64_bullet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-devel}"
SRC_URI[aarch64_bullet-devel.sha256sum] = "fc6d15145f0621b49a086727c22fab4c46a4c97e179777b854f0d057fe813fab"

URI_aarch64_bullet-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-devel-doc-3.08-15.el10_1.aarch64.rpm;name=aarch64_bullet-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-devel-doc}"
SRC_URI[aarch64_bullet-devel-doc.sha256sum] = "d599386f2220df11cefe26a22375adabef6f721cb5469d632d1f5aa485f4764b"

URI_aarch64_bullet-extras = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-extras-3.08-15.el10_1.aarch64.rpm;name=aarch64_bullet-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-extras}"
SRC_URI[aarch64_bullet-extras.sha256sum] = "64515941c0cb6920f8ecc2aae7c8276832c153326ba4384b778e39d72a313744"

URI_aarch64_bullet-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bullet-extras-devel-3.08-15.el10_1.aarch64.rpm;name=aarch64_bullet-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bullet-extras-devel}"
SRC_URI[aarch64_bullet-extras-devel.sha256sum] = "8933ae3e7ad3d5e593ec739bbc9f4f7c1828b635af31dd74cc8d3d2b2054f297"

RDEPENDS:bullet = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:bullet-devel = " \
 bullet \
 cmake \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:bullet-devel-doc = " \
 bullet-extras \
 "
RDEPENDS:bullet-extras = " \
 bullet \
 glibc \
 libgcc \
 libstdc++ \
 tinyxml2 \
 "
RDEPENDS:bullet-extras-devel = " \
 bullet-devel \
 bullet-extras \
 "
