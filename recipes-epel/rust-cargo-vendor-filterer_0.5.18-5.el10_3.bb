# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-vendor-filterer"
PV = "0.5.18"
PR = "5.el10_3"
PACKAGES = " \
 cargo-vendor-filterer \
 rust-cargo-vendor-filterer+default-devel \
 rust-cargo-vendor-filterer+openssl-devel \
 rust-cargo-vendor-filterer+sha-rs-devel \
 rust-cargo-vendor-filterer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-vendor-filterer-0.5.18-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1dfe2d3963397a189cb5c3e250122e255f0e62e47614c2bf5ca59d9c9476150"

URI_x86_64_v2_cargo-vendor-filterer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-vendor-filterer-0.5.18-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cargo-vendor-filterer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo-vendor-filterer}"
SRC_URI[x86_64_v2_cargo-vendor-filterer.sha256sum] = "3c6a3ea8b2a344fc885200673cec60cd2660250b7d5824f135936d88b6703258"

URI_x86_64_v2_rust-cargo-vendor-filterer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer+default-devel-0.5.18-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer+default-devel.sha256sum] = "e6ce00d342d07638730fb9c84b70182cbd4fb7767dd6954543a6a91557c60acf"

URI_x86_64_v2_rust-cargo-vendor-filterer+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer+openssl-devel-0.5.18-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer+openssl-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer+openssl-devel.sha256sum] = "4da22dbcab8d71e1fb53c64bd7c010ed81257f0f98215e8e80081222125967ad"

URI_x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer+sha-rs-devel-0.5.18-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel.sha256sum] = "12b408bfc3ceebe08e1119412b9f31d42859b5c95509c3323e56c32952d932c0"

URI_x86_64_v2_rust-cargo-vendor-filterer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer-devel-0.5.18-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer-devel.sha256sum] = "c3d918eb347e629a678ba11fa5b1c4860c2a183e456b46ea2674e63730035a2e"

URI_aarch64_cargo-vendor-filterer = "${EPEL_MIRROR}/aarch64/Packages/c/cargo-vendor-filterer-0.5.18-5.el10_3.aarch64.rpm;name=aarch64_cargo-vendor-filterer;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo-vendor-filterer}"
SRC_URI[aarch64_cargo-vendor-filterer.sha256sum] = "13d26d51e2207177e05de21476afa52f552d2d19eef730bfea62a3cd7c100b91"

URI_aarch64_rust-cargo-vendor-filterer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer+default-devel-0.5.18-5.el10_3.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer+default-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer+default-devel.sha256sum] = "3b6348eef65ac83c12d31ed691dc110d15c14a9a9a92809c8c6ad466a5f4157d"

URI_aarch64_rust-cargo-vendor-filterer+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer+openssl-devel-0.5.18-5.el10_3.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer+openssl-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer+openssl-devel.sha256sum] = "1164a93b89538e643ffc1142fbab3e34f177d2743ddc509a23db4d26febe6c3e"

URI_aarch64_rust-cargo-vendor-filterer+sha-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer+sha-rs-devel-0.5.18-5.el10_3.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer+sha-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer+sha-rs-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer+sha-rs-devel.sha256sum] = "862af91d5acff2b0f27612ec697f4300d2ad19d9bed860129a627245463d39bc"

URI_aarch64_rust-cargo-vendor-filterer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer-devel-0.5.18-5.el10_3.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer-devel.sha256sum] = "93257c8dfc954e42622ed780c3517705cc0d41ad62755bb7d63f831e17088802"

RDEPENDS:cargo-vendor-filterer = " \
 glibc \
 libgcc \
 openssl-libs \
 "
RDEPENDS:rust-cargo-vendor-filterer+default-devel = " \
 cargo \
 rust-cargo-vendor-filterer+sha-rs-devel \
 rust-cargo-vendor-filterer-devel \
 "
RDEPENDS:rust-cargo-vendor-filterer+openssl-devel = " \
 cargo \
 rust-cargo-vendor-filterer-devel \
 rust-openssl+default-devel \
 "
RDEPENDS:rust-cargo-vendor-filterer+sha-rs-devel = " \
 cargo \
 rust-cargo-vendor-filterer-devel \
 rust-sha2_0.10+default-devel \
 "
RDEPENDS:rust-cargo-vendor-filterer-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-camino+default-devel \
 rust-cargo-lock+default-devel \
 rust-cargo_metadata0.18+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+wrap_help-devel \
 rust-either+default-devel \
 rust-flate2+default-devel \
 rust-glob+default-devel \
 rust-hex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_ignored+default-devel \
 rust-serde_json+default-devel \
 rust-smallvec+default-devel \
 rust-tar-devel \
 rust-tempfile+default-devel \
 rust-toml0.8+default-devel \
 rust-walkdir+default-devel \
 "
