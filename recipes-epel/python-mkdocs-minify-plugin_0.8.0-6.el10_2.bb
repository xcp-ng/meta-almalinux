# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-minify-plugin"
PV = "0.8.0"
PR = "6.el10_2"
PACKAGES = " \
 python3-mkdocs-minify-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-minify-plugin-0.8.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f596a026e9ec28409904bd73a1d70091fbafde586f009774e3a809cb4a782231"

URI_x86_64_v2_python3-mkdocs-minify-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-minify-plugin-0.8.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-minify-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-minify-plugin}"
SRC_URI[x86_64_v2_python3-mkdocs-minify-plugin.sha256sum] = "fc8010285e58b97da246ca608d411b009c0280386fd61f5507d878627fd2412c"

URI_aarch64_python3-mkdocs-minify-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-minify-plugin-0.8.0-6.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-minify-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-minify-plugin}"
SRC_URI[aarch64_python3-mkdocs-minify-plugin.sha256sum] = "bc7b327a0a7e7a6d41adec9e8d45ff2be747dca27bf67348ecaebeafc420278c"

RDEPENDS:python3-mkdocs-minify-plugin = " \
 mkdocs \
 python3 \
 python3-csscompressor \
 python3-htmlmin2 \
 python3-jsmin \
 "
