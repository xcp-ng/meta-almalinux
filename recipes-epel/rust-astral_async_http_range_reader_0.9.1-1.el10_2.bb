# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral_async_http_range_reader"
PV = "0.9.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-astral_async_http_range_reader+default-devel \
 rust-astral_async_http_range_reader-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral_async_http_range_reader-0.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91075d0b3862a5948a3247eb888aae5a4ec84481bbe846ee47f3f3c363522715"

URI_x86_64_v2_rust-astral_async_http_range_reader+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_http_range_reader+default-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_http_range_reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_http_range_reader+default-devel}"
SRC_URI[x86_64_v2_rust-astral_async_http_range_reader+default-devel.sha256sum] = "3ae0334c174d90ba6a2e8bc9507ed2d0d66fae88aeb6b8bfa2ceacaa3472c0bb"

URI_x86_64_v2_rust-astral_async_http_range_reader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_http_range_reader-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_http_range_reader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_http_range_reader-devel}"
SRC_URI[x86_64_v2_rust-astral_async_http_range_reader-devel.sha256sum] = "e84e8a9238b826dd6875c459dd05c4310c2412b1421f32ae8051e09d125b5779"

URI_aarch64_rust-astral_async_http_range_reader+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_http_range_reader+default-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_http_range_reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_http_range_reader+default-devel}"
SRC_URI[aarch64_rust-astral_async_http_range_reader+default-devel.sha256sum] = "eccd42f22dc91174f5aa573b511afeffa31f0ddea20a95bf7f76ae44299b263f"

URI_aarch64_rust-astral_async_http_range_reader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_http_range_reader-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-astral_async_http_range_reader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_http_range_reader-devel}"
SRC_URI[aarch64_rust-astral_async_http_range_reader-devel.sha256sum] = "5b3f6fa9640df2c25432cb36325e4dd6807a96363a26843807d83a1c05f41955"

RDEPENDS:rust-astral_async_http_range_reader+default-devel = " \
 cargo \
 rust-astral_async_http_range_reader-devel \
 "
RDEPENDS:rust-astral_async_http_range_reader-devel = " \
 cargo \
 rust-astral-reqwest-middleware+default-devel \
 rust-bisection+default-devel \
 rust-futures+default-devel \
 rust-http-content-range+default-devel \
 rust-itertools0.13+default-devel \
 rust-memmap2+default-devel \
 rust-reqwest0.12+stream-devel \
 rust-reqwest0.12-devel \
 rust-thiserror1+default-devel \
 rust-tokio-devel \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-util+default-devel \
 rust-tracing+default-devel \
 "
