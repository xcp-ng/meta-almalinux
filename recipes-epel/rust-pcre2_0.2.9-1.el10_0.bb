# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pcre2"
PV = "0.2.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-pcre2+default-devel \
 rust-pcre2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pcre2-0.2.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0abe6e6991f836d01c9924537afdcc6c881b0fb5fae99c555add2fc5215862ea"

URI_x86_64_v2_rust-pcre2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcre2+default-devel-0.2.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcre2+default-devel}"
SRC_URI[x86_64_v2_rust-pcre2+default-devel.sha256sum] = "b899f282bf5903e0e127d04fe16e5c1322b0b2eba8b3127c62533d1ddd1cf458"

URI_x86_64_v2_rust-pcre2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcre2-devel-0.2.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcre2-devel}"
SRC_URI[x86_64_v2_rust-pcre2-devel.sha256sum] = "2e7be4335f9997d13fa9c10b421a3c563e5bcf13a597cbca5992455678e7abc7"

URI_aarch64_rust-pcre2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcre2+default-devel-0.2.9-1.el10_0.noarch.rpm;name=aarch64_rust-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcre2+default-devel}"
SRC_URI[aarch64_rust-pcre2+default-devel.sha256sum] = "770c72e6e152491047ccde0d83a461eda5f83d820dff98afdc956b158fe86056"

URI_aarch64_rust-pcre2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcre2-devel-0.2.9-1.el10_0.noarch.rpm;name=aarch64_rust-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcre2-devel}"
SRC_URI[aarch64_rust-pcre2-devel.sha256sum] = "f43db4749b2f2601a62c27a8d3511e6beb225c89202faab0b033a2ede0c95d88"

RDEPENDS:rust-pcre2+default-devel = " \
 cargo \
 rust-pcre2-devel \
 "
RDEPENDS:rust-pcre2-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-pcre2-sys+default-devel \
 "
