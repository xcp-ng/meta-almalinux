# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-erased-serde"
PV = "0.4.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-erased-serde+alloc-devel \
 rust-erased-serde+default-devel \
 rust-erased-serde+std-devel \
 rust-erased-serde+unstable-debug-devel \
 rust-erased-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-erased-serde-0.4.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcb26a1131c0059d25cd195370c4c16173d4215125d17411ec0932f4275c191d"

URI_x86_64_v2_rust-erased-serde+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+alloc-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+alloc-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+alloc-devel.sha256sum] = "b242f26dd5df94f774b1944866bac87d08275fadef2a2ca06dd27f2ac0daaf7a"

URI_x86_64_v2_rust-erased-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+default-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+default-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+default-devel.sha256sum] = "6a6f3f067d45b9d15bb2e811416208c35b1a21481ebac5dbf0387c9cb0fef3ec"

URI_x86_64_v2_rust-erased-serde+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+std-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+std-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+std-devel.sha256sum] = "635b54a4bc9d7a0ae1fb232717b685f3052f44c8fa0b90d599d486317ddaf393"

URI_x86_64_v2_rust-erased-serde+unstable-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+unstable-debug-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+unstable-debug-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+unstable-debug-devel.sha256sum] = "f9fe93e634fe2f65600f387ec0e541958bfff4a4813f92f4a1d979ae29ac45a2"

URI_x86_64_v2_rust-erased-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde-devel}"
SRC_URI[x86_64_v2_rust-erased-serde-devel.sha256sum] = "c611827aaa09f3b6ebe018ad9ff36de1fd420d64b6a4dcd1deb43b5ad1ab50d7"

URI_aarch64_rust-erased-serde+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+alloc-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-erased-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+alloc-devel}"
SRC_URI[aarch64_rust-erased-serde+alloc-devel.sha256sum] = "df91444f90be7007c91536eee0e419d2a0c71d8689968f68d139f7ad28f03178"

URI_aarch64_rust-erased-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+default-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-erased-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+default-devel}"
SRC_URI[aarch64_rust-erased-serde+default-devel.sha256sum] = "7cff11d0ef5862859dd524fa9e1a34512dc6c51e6c929afd94fac72522d7259e"

URI_aarch64_rust-erased-serde+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+std-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-erased-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+std-devel}"
SRC_URI[aarch64_rust-erased-serde+std-devel.sha256sum] = "210ec2cb755f5c3599e3debd59293778ba3549fa0cb3acffed26233e40ce980a"

URI_aarch64_rust-erased-serde+unstable-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+unstable-debug-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-erased-serde+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+unstable-debug-devel}"
SRC_URI[aarch64_rust-erased-serde+unstable-debug-devel.sha256sum] = "78afe755f9cec68819d085cec8875195ea12e9e6c26486fb824cbe3d7443a8f5"

URI_aarch64_rust-erased-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde-devel}"
SRC_URI[aarch64_rust-erased-serde-devel.sha256sum] = "adfbe5a7419a948ef57cdadf6512e55e283cbe293027d3fd62f5436e6837db21"

RDEPENDS:rust-erased-serde+alloc-devel = " \
 cargo \
 rust-erased-serde-devel \
 rust-serde_core+alloc-devel \
 "
RDEPENDS:rust-erased-serde+default-devel = " \
 cargo \
 rust-erased-serde+std-devel \
 rust-erased-serde-devel \
 "
RDEPENDS:rust-erased-serde+std-devel = " \
 cargo \
 rust-erased-serde+alloc-devel \
 rust-erased-serde-devel \
 rust-serde_core+std-devel \
 "
RDEPENDS:rust-erased-serde+unstable-debug-devel = " \
 cargo \
 rust-erased-serde-devel \
 "
RDEPENDS:rust-erased-serde-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core-devel \
 rust-typeid+default-devel \
 "
