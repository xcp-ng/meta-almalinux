# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-metrics-exporter-prometheus"
PV = "0.18.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-metrics-exporter-prometheus+_hyper-client-devel \
 rust-metrics-exporter-prometheus+_hyper-server-devel \
 rust-metrics-exporter-prometheus+_push-gateway-common-devel \
 rust-metrics-exporter-prometheus+async-runtime-devel \
 rust-metrics-exporter-prometheus+default-devel \
 rust-metrics-exporter-prometheus+http-body-util-devel \
 rust-metrics-exporter-prometheus+http-listener-devel \
 rust-metrics-exporter-prometheus+hyper-devel \
 rust-metrics-exporter-prometheus+hyper-rustls-devel \
 rust-metrics-exporter-prometheus+hyper-util-devel \
 rust-metrics-exporter-prometheus+ipnet-devel \
 rust-metrics-exporter-prometheus+mime-devel \
 rust-metrics-exporter-prometheus+prost-build-devel \
 rust-metrics-exporter-prometheus+prost-devel \
 rust-metrics-exporter-prometheus+prost-types-devel \
 rust-metrics-exporter-prometheus+push-gateway-devel \
 rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel \
 rust-metrics-exporter-prometheus+rustls-devel \
 rust-metrics-exporter-prometheus+tokio-devel \
 rust-metrics-exporter-prometheus+tracing-devel \
 rust-metrics-exporter-prometheus+uds-listener-devel \
 rust-metrics-exporter-prometheus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-metrics-exporter-prometheus-0.18.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "867ee0553c40b5b521b338c5424c02cd72b6851d6e133a0f58f110db81c3c652"

URI_x86_64_v2_rust-metrics-exporter-prometheus+_hyper-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+_hyper-client-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+_hyper-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+_hyper-client-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+_hyper-client-devel.sha256sum] = "7194812f6ab9d9f3aebf7f87cbe14acb30aa01948035684f3dd312f1785a22b5"

URI_x86_64_v2_rust-metrics-exporter-prometheus+_hyper-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+_hyper-server-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+_hyper-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+_hyper-server-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+_hyper-server-devel.sha256sum] = "308e705c0224736b9fccbf5c7290f041c76ba75293bdd6abe87fa4565416e061"

URI_x86_64_v2_rust-metrics-exporter-prometheus+_push-gateway-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+_push-gateway-common-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+_push-gateway-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+_push-gateway-common-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+_push-gateway-common-devel.sha256sum] = "f0f90ecd8c2a3c0ea81302e403b8f684b6895bd3fe486b84cac23b333681ef91"

URI_x86_64_v2_rust-metrics-exporter-prometheus+async-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+async-runtime-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+async-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+async-runtime-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+async-runtime-devel.sha256sum] = "4afc1ea9cb285db67fad464d0096b722449140b0bd59b6ca6c1edfad17a4965e"

URI_x86_64_v2_rust-metrics-exporter-prometheus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+default-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+default-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+default-devel.sha256sum] = "2bae0f7f3abba51a63c23444d72a9d98c526c65332ea1632f00b55816e299d35"

URI_x86_64_v2_rust-metrics-exporter-prometheus+http-body-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+http-body-util-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+http-body-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+http-body-util-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+http-body-util-devel.sha256sum] = "37e4f27aa7b7bacdba271e5af7fb5847fbf23c9f80aedb7ff949e984ee1015c3"

URI_x86_64_v2_rust-metrics-exporter-prometheus+http-listener-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+http-listener-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+http-listener-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+http-listener-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+http-listener-devel.sha256sum] = "925821b2c30e91f0f2426ab174fd7f20508beb31a87c7e70d81fac4810e3271d"

URI_x86_64_v2_rust-metrics-exporter-prometheus+hyper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+hyper-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+hyper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+hyper-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+hyper-devel.sha256sum] = "09bcb802432de89a72dd2b2e13e9d76151d00501797f8d20d04043008b838eb3"

URI_x86_64_v2_rust-metrics-exporter-prometheus+hyper-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+hyper-rustls-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+hyper-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+hyper-rustls-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+hyper-rustls-devel.sha256sum] = "2206e9519d4b1fb13096435c3c85915bd15c28121d1db47f61cd7ad1e6535ec9"

URI_x86_64_v2_rust-metrics-exporter-prometheus+hyper-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+hyper-util-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+hyper-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+hyper-util-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+hyper-util-devel.sha256sum] = "dba745e66499c2ac9df949d0884f1775520b2cb28846fd5bd30f5e95df7b5c60"

URI_x86_64_v2_rust-metrics-exporter-prometheus+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+ipnet-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+ipnet-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+ipnet-devel.sha256sum] = "4c3b41032e0a15a1c24e938c809eb18019cd6dd135cff80e697e6860d608e67e"

URI_x86_64_v2_rust-metrics-exporter-prometheus+mime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+mime-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+mime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+mime-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+mime-devel.sha256sum] = "3f7a392e37db5f8e61fa0c3acdc4ef853612583f1462a181eb5c542f1d60fe36"

URI_x86_64_v2_rust-metrics-exporter-prometheus+prost-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+prost-build-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+prost-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+prost-build-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+prost-build-devel.sha256sum] = "b3fec39a6a31a38bf28e3e3685ae04a288bc69bd067676c35b4a46bc5ebfaef4"

URI_x86_64_v2_rust-metrics-exporter-prometheus+prost-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+prost-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+prost-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+prost-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+prost-devel.sha256sum] = "4b67d5d709a3462289abd03bb8f532a679bac143d8f880c4aaf827cd2205ad34"

URI_x86_64_v2_rust-metrics-exporter-prometheus+prost-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+prost-types-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+prost-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+prost-types-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+prost-types-devel.sha256sum] = "74ec58e03d00d43a13a697517a10d04134f984c3af362a4f1b1ab7ce3b2213bd"

URI_x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+push-gateway-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-devel.sha256sum] = "880f8f4ccd8b6319b1cf19e59d23eac577ab8f259613a188d22f9a1ed4feb650"

URI_x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel.sha256sum] = "918b4d4fedabd75613db0d3eb77b14333839ce5a12f8ebb2f0617c92e6cbd9f7"

URI_x86_64_v2_rust-metrics-exporter-prometheus+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+rustls-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+rustls-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+rustls-devel.sha256sum] = "adfefd227679cbff79e92750818c240e26c5565070f94c2c1d13bb29b77a0165"

URI_x86_64_v2_rust-metrics-exporter-prometheus+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+tokio-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+tokio-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+tokio-devel.sha256sum] = "ad03491b01b9478efdd7425778b114a01e8c3b7503aacc65c4b42ffc5856559d"

URI_x86_64_v2_rust-metrics-exporter-prometheus+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+tracing-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+tracing-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+tracing-devel.sha256sum] = "06343f785d916d52352d5e9b56b08afa6f78efcb6e6082c8727474d696688217"

URI_x86_64_v2_rust-metrics-exporter-prometheus+uds-listener-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+uds-listener-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+uds-listener-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus+uds-listener-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+uds-listener-devel.sha256sum] = "c2a5578da2900f9598933645eb1d62c2b14d5c7586a2394e058adcd472745520"

URI_x86_64_v2_rust-metrics-exporter-prometheus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus-devel-0.18.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-metrics-exporter-prometheus-devel}"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus-devel.sha256sum] = "e8e45db5d609719781ef5f06ff1f9b272829b91c74ca5b21ed16afc136a52511"

URI_aarch64_rust-metrics-exporter-prometheus+_hyper-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+_hyper-client-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+_hyper-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+_hyper-client-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+_hyper-client-devel.sha256sum] = "cf2cfbadbbf098fd72da508aa9c327a141081bc0de6f38e1a8ec7e7e85a903d3"

URI_aarch64_rust-metrics-exporter-prometheus+_hyper-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+_hyper-server-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+_hyper-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+_hyper-server-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+_hyper-server-devel.sha256sum] = "6ca22acfa25a3c1acf37914b666fb0c19bba003f170d4fd208de73d071c26a27"

URI_aarch64_rust-metrics-exporter-prometheus+_push-gateway-common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+_push-gateway-common-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+_push-gateway-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+_push-gateway-common-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+_push-gateway-common-devel.sha256sum] = "60a97ead8812dc1eb8859d783e9bbdb88fc3e68cf30561c26518d6590c4e9ece"

URI_aarch64_rust-metrics-exporter-prometheus+async-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+async-runtime-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+async-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+async-runtime-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+async-runtime-devel.sha256sum] = "57f98e8df320591739ee359287b1acb7102d4d3ca4499b20d72ab7cafacf25a5"

URI_aarch64_rust-metrics-exporter-prometheus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+default-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+default-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+default-devel.sha256sum] = "10cd7f0d44509b4044ac190eacf5cc9ef9837619dcc684807e34b966270d9d37"

URI_aarch64_rust-metrics-exporter-prometheus+http-body-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+http-body-util-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+http-body-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+http-body-util-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+http-body-util-devel.sha256sum] = "98b2cb28816f6145d237f83194ddf5659be80b65bee013d7873ee47dabb760c1"

URI_aarch64_rust-metrics-exporter-prometheus+http-listener-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+http-listener-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+http-listener-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+http-listener-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+http-listener-devel.sha256sum] = "359ea915c57895544112947e069abd1251fe7c01702e80e4daa42845f8e3b988"

URI_aarch64_rust-metrics-exporter-prometheus+hyper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+hyper-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+hyper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+hyper-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+hyper-devel.sha256sum] = "e8c91699007e2043442ad816d5b82b0f71c76e641d65be58aceee136740ecbac"

URI_aarch64_rust-metrics-exporter-prometheus+hyper-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+hyper-rustls-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+hyper-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+hyper-rustls-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+hyper-rustls-devel.sha256sum] = "c4da2fe0b14abdcdc35ff640fdbe2f04044ba0be46a597bcbd4f68119b174832"

URI_aarch64_rust-metrics-exporter-prometheus+hyper-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+hyper-util-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+hyper-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+hyper-util-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+hyper-util-devel.sha256sum] = "8eb38f4138ae6b9a182a727dbe04707e068e7d83c6c102e27a98d6d1199e9a0f"

URI_aarch64_rust-metrics-exporter-prometheus+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+ipnet-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+ipnet-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+ipnet-devel.sha256sum] = "7563dc3e77b62558f6a7e5d460b4923d29932556c312c3de8d57303e8a8dd677"

URI_aarch64_rust-metrics-exporter-prometheus+mime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+mime-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+mime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+mime-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+mime-devel.sha256sum] = "f6c5b254ec19c6456789de7c80a6f84588cd6be7799c988d7d41a00161a2590c"

URI_aarch64_rust-metrics-exporter-prometheus+prost-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+prost-build-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+prost-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+prost-build-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+prost-build-devel.sha256sum] = "45666445a292c3a7ee6fe577328ab17a622f95061d46aeff131f07b2ad9fde07"

URI_aarch64_rust-metrics-exporter-prometheus+prost-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+prost-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+prost-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+prost-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+prost-devel.sha256sum] = "ff61d2b5ef59debdb5fa5465c684fef2b19df696ad8c42776d907e860caf26e5"

URI_aarch64_rust-metrics-exporter-prometheus+prost-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+prost-types-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+prost-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+prost-types-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+prost-types-devel.sha256sum] = "2670748367eb50d00547d85e19b8270457a0cb85dc9ca8e344183ce36f06ecd9"

URI_aarch64_rust-metrics-exporter-prometheus+push-gateway-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+push-gateway-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+push-gateway-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+push-gateway-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+push-gateway-devel.sha256sum] = "c587af3be75039efdbce69c7feb464909b9a1b6055b31e6c86a9e339132f5dd5"

URI_aarch64_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel.sha256sum] = "8d5c479496037c3260b8530553adb4fd6fdaf8593fb8668d9981a84adbd53e5b"

URI_aarch64_rust-metrics-exporter-prometheus+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+rustls-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+rustls-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+rustls-devel.sha256sum] = "e53bffb297908132dfcf6a5d3311eacc2072c896d28c462b47e7b2a7dc1bfd37"

URI_aarch64_rust-metrics-exporter-prometheus+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+tokio-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+tokio-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+tokio-devel.sha256sum] = "2c717f383ec5f757bb1b58646fba175800585fc316947764f342bd502c8e4e88"

URI_aarch64_rust-metrics-exporter-prometheus+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+tracing-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+tracing-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+tracing-devel.sha256sum] = "625acc7cf1f74f1ddfe4472c25e6dd9c5fa5e6f33671c5a1b75dfe2ac9e0ad98"

URI_aarch64_rust-metrics-exporter-prometheus+uds-listener-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+uds-listener-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+uds-listener-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus+uds-listener-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+uds-listener-devel.sha256sum] = "b84c7300414656789d02bab37369b433271eb3d8f32a00400af5066571571c0c"

URI_aarch64_rust-metrics-exporter-prometheus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus-devel-0.18.1-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-metrics-exporter-prometheus-devel}"
SRC_URI[aarch64_rust-metrics-exporter-prometheus-devel.sha256sum] = "8c5f05592fa801d1d687755d63c93bc7615514c286cff3ab4f64e80efb0e161e"

RDEPENDS:rust-metrics-exporter-prometheus+_hyper-client-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-metrics-exporter-prometheus+http-body-util-devel \
 rust-metrics-exporter-prometheus+hyper-rustls-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+_hyper-server-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-metrics-exporter-prometheus+http-body-util-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+_push-gateway-common-devel = " \
 cargo \
 rust-metrics-exporter-prometheus+_hyper-client-devel \
 rust-metrics-exporter-prometheus+async-runtime-devel \
 rust-metrics-exporter-prometheus+rustls-devel \
 rust-metrics-exporter-prometheus+tracing-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+async-runtime-devel = " \
 cargo \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-metrics-exporter-prometheus+tokio-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+default-devel = " \
 cargo \
 rust-metrics-exporter-prometheus+http-listener-devel \
 rust-metrics-exporter-prometheus+push-gateway-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+http-body-util-devel = " \
 cargo \
 rust-http-body-util-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+http-listener-devel = " \
 cargo \
 rust-metrics-exporter-prometheus+_hyper-server-devel \
 rust-metrics-exporter-prometheus+async-runtime-devel \
 rust-metrics-exporter-prometheus+ipnet-devel \
 rust-metrics-exporter-prometheus+tracing-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+hyper-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+hyper-rustls-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+rustls-native-certs-devel \
 rust-hyper-rustls-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+hyper-util-devel = " \
 cargo \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+ipnet-devel = " \
 cargo \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+mime-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-mime+default-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+prost-build-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-prost-build-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+prost-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-prost+derive-devel \
 rust-prost-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+prost-types-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-prost-types-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+push-gateway-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+rustls-native-certs-devel \
 rust-hyper-rustls-devel \
 rust-metrics-exporter-prometheus+_push-gateway-common-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel = " \
 cargo \
 rust-metrics-exporter-prometheus+_push-gateway-common-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+rustls-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+tokio-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+tracing-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+uds-listener-devel = " \
 cargo \
 rust-metrics-exporter-prometheus+http-listener-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus-devel = " \
 cargo \
 rust \
 rust-base64_0.22+std-devel \
 rust-base64_0.22-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-metrics+default-devel \
 rust-metrics-util+recency-devel \
 rust-metrics-util+registry-devel \
 rust-metrics-util+storage-devel \
 rust-metrics-util-devel \
 rust-quanta-devel \
 rust-thiserror-devel \
 "
