# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Spiffy"
PV = "0.46"
PR = "27.el10_0"
PACKAGES = " \
 perl-Spiffy \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Spiffy-0.46-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d0a0426a5a4783d9e22b8ca9bd0b1b47b0e7dcc61af689be2d4757cbb0b5fdd7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Spiffy-0.46-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Spiffy;unpack=0"
SRC_URI[x86_64_v2_perl-Spiffy.sha256sum] = "fa2d5c567db5a62fee880bce7afd2db33fc20a3b309f9451c871407cc2c524b0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Spiffy-0.46-27.el10_0.noarch.rpm;name=aarch64_perl-Spiffy;unpack=0"
SRC_URI[aarch64_perl-Spiffy.sha256sum] = "61179ba0ca6512c95c9146ceec0e87c07e90de420fc01287e6acc29aa3acab97"

RDEPENDS:perl-Spiffy = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Filter \
 perl-Scalar-List-Utils \
 perl-YAML \
 perl-libs \
 perl-overload \
 "
