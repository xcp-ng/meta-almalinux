# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lldpad"
PV = "1.1.1"
PR = "2.gitf1dd9eb.el10"
PACKAGES = " \
 lldpad \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lldpad-1.1.1-2.gitf1dd9eb.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "887ec057c1d2b4a236f62fe0bf8348c4c709001749b73dab3bb79d6e89dd96fb"

URI_x86_64_v2_lldpad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lldpad-1.1.1-2.gitf1dd9eb.el10.x86_64_v2.rpm;name=x86_64_v2_lldpad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldpad}"
SRC_URI[x86_64_v2_lldpad.sha256sum] = "727384252d07a092d8e41aba78cbdace03cfb606588b664cd4d57c7508d03cf2"

URI_aarch64_lldpad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lldpad-1.1.1-2.gitf1dd9eb.el10.aarch64.rpm;name=aarch64_lldpad;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldpad}"
SRC_URI[aarch64_lldpad.sha256sum] = "44f51d56cea286984a02120ab062708e1e7c80f925ef574f2901a7d8088d610b"

RDEPENDS:lldpad = " \
 bash \
 glibc \
 libconfig \
 libnl3 \
 readline \
 systemd \
 "
