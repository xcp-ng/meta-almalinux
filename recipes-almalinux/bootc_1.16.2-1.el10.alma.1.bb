# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bootc"
PV = "1.16.2"
PR = "1.el10.alma.1"
PACKAGES = " \
 bootc \
 system-reinstall-bootc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bootc-1.16.2-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb6d97ec1732899c1bc8c0a973c804a26d4ad3609c5fde7a5c535445a7247c91"

URI_x86_64_v2_bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bootc-1.16.2-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bootc}"
SRC_URI[x86_64_v2_bootc.sha256sum] = "75a586bb67bc898f84753905b65916897e9b566792318edb416722e2d796d1d1"

URI_x86_64_v2_system-reinstall-bootc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/system-reinstall-bootc-1.16.2-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_system-reinstall-bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_system-reinstall-bootc}"
SRC_URI[x86_64_v2_system-reinstall-bootc.sha256sum] = "50308d6ea54613b4ef81adf16b70cfd2ff2c66d03f594578ac0e1bdfe0063533"

URI_aarch64_bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bootc-1.16.2-1.el10.alma.1.aarch64.rpm;name=aarch64_bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bootc}"
SRC_URI[aarch64_bootc.sha256sum] = "3ba430aefe059bcfa61364d40a3357adb81c804da42cb0e87e28006e9af473f4"

URI_aarch64_system-reinstall-bootc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/system-reinstall-bootc-1.16.2-1.el10.alma.1.aarch64.rpm;name=aarch64_system-reinstall-bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_system-reinstall-bootc}"
SRC_URI[aarch64_system-reinstall-bootc.sha256sum] = "8a42e0cf1fcdf198ed63646022cdfd55ed27096c316b72b0c9717d0c4c501e51"

RDEPENDS:bootc = " \
 bash \
 composefs \
 glib2 \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 podman \
 skopeo \
 util-linux-core \
 virtual//usr/bin/chcon \
 zlib-ng-compat \
 "
RDEPENDS:system-reinstall-bootc = " \
 bash \
 glibc \
 libgcc \
 "
