# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ogr"
PV = "0.61.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-ogr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ogr-0.61.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29708fa1fc2084a0067b69aaf5ce0de1925d86f0a62a61b849edfb98c37d2e29"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-ogr: python3.12dist(gitpython)

URI_x86_64_v2_python3-ogr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ogr-0.61.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ogr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ogr}"
SRC_URI[x86_64_v2_python3-ogr.sha256sum] = "0319bddeb33bca8d405ecd59c03ffa8f8b0e3dfb2d8732f4f9610c099e719a69"

URI_aarch64_python3-ogr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ogr-0.61.2-1.el10_2.noarch.rpm;name=aarch64_python3-ogr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ogr}"
SRC_URI[aarch64_python3-ogr.sha256sum] = "c74f203dd630975cec02a3398bfc2ce030a7767714107c75caf312ac1d3710be"

RDEPENDS:python3-ogr:x86_64_v2 = " \
 python3 \
 python3-cryptography \
 python3-deprecated \
 python3-gitlab \
 python3-httpx \
 python3-pyforgejo \
 python3-pygithub \
 python3-pyyaml \
 python3-requests \
 python3-urllib3 \
"
RDEPENDS:python3-ogr:aarch64 = " \
 python3 \
 python3-GitPython \
 python3-cryptography \
 python3-deprecated \
 python3-gitlab \
 python3-httpx \
 python3-pyforgejo \
 python3-pygithub \
 python3-pyyaml \
 python3-requests \
 python3-urllib3 \
"
