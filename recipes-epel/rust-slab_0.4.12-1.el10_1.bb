# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slab"
PV = "0.4.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-slab+default-devel \
 rust-slab+serde-devel \
 rust-slab+std-devel \
 rust-slab-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slab-0.4.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a96f1fe1045c230726f0ede9c51d6a50df91f44b42f39ebe81a37f7b38dce36c"

URI_x86_64_v2_rust-slab+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab+default-devel-0.4.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slab+default-devel}"
SRC_URI[x86_64_v2_rust-slab+default-devel.sha256sum] = "9ed21217b6096aaf723d2722d660ed790f7d1b1c37b726455f7abdd366eee786"

URI_x86_64_v2_rust-slab+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab+serde-devel-0.4.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slab+serde-devel}"
SRC_URI[x86_64_v2_rust-slab+serde-devel.sha256sum] = "fada99f2f0ee939acf4bd2900badcf2b739ec4ec3087f9731b9e7f4abeef0e87"

URI_x86_64_v2_rust-slab+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab+std-devel-0.4.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slab+std-devel}"
SRC_URI[x86_64_v2_rust-slab+std-devel.sha256sum] = "3c4b932331e97378818776a5d3aec10742c426130c17192e2783541af64b15bd"

URI_x86_64_v2_rust-slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slab-devel-0.4.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slab-devel}"
SRC_URI[x86_64_v2_rust-slab-devel.sha256sum] = "211ee9c61ca913735d8f6fc4b8ad6582dcc4e864e78cae4f66b38484254ef3af"

URI_aarch64_rust-slab+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slab+default-devel-0.4.12-1.el10_1.noarch.rpm;name=aarch64_rust-slab+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slab+default-devel}"
SRC_URI[aarch64_rust-slab+default-devel.sha256sum] = "9458f8d6fc40979d28a749717688185e5e47cabaeb78b437bb8d342e6ee2235b"

URI_aarch64_rust-slab+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slab+serde-devel-0.4.12-1.el10_1.noarch.rpm;name=aarch64_rust-slab+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slab+serde-devel}"
SRC_URI[aarch64_rust-slab+serde-devel.sha256sum] = "53fb37927685fc8bc31888a5da5c76c1b12d7bc5f1887b2a7eb479d447ca41ed"

URI_aarch64_rust-slab+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slab+std-devel-0.4.12-1.el10_1.noarch.rpm;name=aarch64_rust-slab+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slab+std-devel}"
SRC_URI[aarch64_rust-slab+std-devel.sha256sum] = "82e508c08b0645bdeb0d5db392d1322c24da46adda631f6c5e10e02ecc681730"

URI_aarch64_rust-slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slab-devel-0.4.12-1.el10_1.noarch.rpm;name=aarch64_rust-slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slab-devel}"
SRC_URI[aarch64_rust-slab-devel.sha256sum] = "e1c79512c06a2d708869ee513e0a2c6c6b31dfc8c25067dc124bad11734e9b01"

RDEPENDS:rust-slab+default-devel = " \
 cargo \
 rust-slab+std-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-slab+serde-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-slab+std-devel = " \
 cargo \
 rust-slab-devel \
 "
RDEPENDS:rust-slab-devel = " \
 cargo \
 rust \
 "
