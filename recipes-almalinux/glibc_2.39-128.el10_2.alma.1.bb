# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glibc"
PV = "2.39"
PR = "128.el10_2.alma.1"
PACKAGES = " \
 glibc \
 glibc-all-langpacks \
 glibc-benchtests \
 glibc-common \
 glibc-devel \
 glibc-doc \
 glibc-gconv-extra \
 glibc-langpack-aa \
 glibc-langpack-af \
 glibc-langpack-agr \
 glibc-langpack-ak \
 glibc-langpack-am \
 glibc-langpack-an \
 glibc-langpack-anp \
 glibc-langpack-ar \
 glibc-langpack-as \
 glibc-langpack-ast \
 glibc-langpack-ayc \
 glibc-langpack-az \
 glibc-langpack-be \
 glibc-langpack-bem \
 glibc-langpack-ber \
 glibc-langpack-bg \
 glibc-langpack-bhb \
 glibc-langpack-bho \
 glibc-langpack-bi \
 glibc-langpack-bn \
 glibc-langpack-bo \
 glibc-langpack-br \
 glibc-langpack-brx \
 glibc-langpack-bs \
 glibc-langpack-byn \
 glibc-langpack-ca \
 glibc-langpack-ce \
 glibc-langpack-chr \
 glibc-langpack-ckb \
 glibc-langpack-cmn \
 glibc-langpack-crh \
 glibc-langpack-cs \
 glibc-langpack-csb \
 glibc-langpack-cv \
 glibc-langpack-cy \
 glibc-langpack-da \
 glibc-langpack-de \
 glibc-langpack-doi \
 glibc-langpack-dsb \
 glibc-langpack-dv \
 glibc-langpack-dz \
 glibc-langpack-el \
 glibc-langpack-en \
 glibc-langpack-eo \
 glibc-langpack-es \
 glibc-langpack-et \
 glibc-langpack-eu \
 glibc-langpack-fa \
 glibc-langpack-ff \
 glibc-langpack-fi \
 glibc-langpack-fil \
 glibc-langpack-fo \
 glibc-langpack-fr \
 glibc-langpack-fur \
 glibc-langpack-fy \
 glibc-langpack-ga \
 glibc-langpack-gbm \
 glibc-langpack-gd \
 glibc-langpack-gez \
 glibc-langpack-gl \
 glibc-langpack-gu \
 glibc-langpack-gv \
 glibc-langpack-ha \
 glibc-langpack-hak \
 glibc-langpack-he \
 glibc-langpack-hi \
 glibc-langpack-hif \
 glibc-langpack-hne \
 glibc-langpack-hr \
 glibc-langpack-hsb \
 glibc-langpack-ht \
 glibc-langpack-hu \
 glibc-langpack-hy \
 glibc-langpack-ia \
 glibc-langpack-id \
 glibc-langpack-ig \
 glibc-langpack-ik \
 glibc-langpack-is \
 glibc-langpack-it \
 glibc-langpack-iu \
 glibc-langpack-ja \
 glibc-langpack-ka \
 glibc-langpack-kab \
 glibc-langpack-kk \
 glibc-langpack-kl \
 glibc-langpack-km \
 glibc-langpack-kn \
 glibc-langpack-ko \
 glibc-langpack-kok \
 glibc-langpack-ks \
 glibc-langpack-ku \
 glibc-langpack-kv \
 glibc-langpack-kw \
 glibc-langpack-ky \
 glibc-langpack-lb \
 glibc-langpack-lg \
 glibc-langpack-li \
 glibc-langpack-lij \
 glibc-langpack-ln \
 glibc-langpack-lo \
 glibc-langpack-lt \
 glibc-langpack-lv \
 glibc-langpack-lzh \
 glibc-langpack-mag \
 glibc-langpack-mai \
 glibc-langpack-mfe \
 glibc-langpack-mg \
 glibc-langpack-mhr \
 glibc-langpack-mi \
 glibc-langpack-miq \
 glibc-langpack-mjw \
 glibc-langpack-mk \
 glibc-langpack-ml \
 glibc-langpack-mn \
 glibc-langpack-mni \
 glibc-langpack-mnw \
 glibc-langpack-mr \
 glibc-langpack-ms \
 glibc-langpack-mt \
 glibc-langpack-my \
 glibc-langpack-nan \
 glibc-langpack-nb \
 glibc-langpack-nds \
 glibc-langpack-ne \
 glibc-langpack-nhn \
 glibc-langpack-niu \
 glibc-langpack-nl \
 glibc-langpack-nn \
 glibc-langpack-nr \
 glibc-langpack-nso \
 glibc-langpack-oc \
 glibc-langpack-om \
 glibc-langpack-or \
 glibc-langpack-os \
 glibc-langpack-pa \
 glibc-langpack-pap \
 glibc-langpack-pl \
 glibc-langpack-ps \
 glibc-langpack-pt \
 glibc-langpack-quz \
 glibc-langpack-raj \
 glibc-langpack-rif \
 glibc-langpack-ro \
 glibc-langpack-ru \
 glibc-langpack-rw \
 glibc-langpack-sa \
 glibc-langpack-sah \
 glibc-langpack-sat \
 glibc-langpack-sc \
 glibc-langpack-sd \
 glibc-langpack-se \
 glibc-langpack-sgs \
 glibc-langpack-shn \
 glibc-langpack-shs \
 glibc-langpack-si \
 glibc-langpack-sid \
 glibc-langpack-sk \
 glibc-langpack-sl \
 glibc-langpack-sm \
 glibc-langpack-so \
 glibc-langpack-sq \
 glibc-langpack-sr \
 glibc-langpack-ss \
 glibc-langpack-ssy \
 glibc-langpack-st \
 glibc-langpack-su \
 glibc-langpack-sv \
 glibc-langpack-sw \
 glibc-langpack-syr \
 glibc-langpack-szl \
 glibc-langpack-ta \
 glibc-langpack-tcy \
 glibc-langpack-te \
 glibc-langpack-tg \
 glibc-langpack-th \
 glibc-langpack-the \
 glibc-langpack-ti \
 glibc-langpack-tig \
 glibc-langpack-tk \
 glibc-langpack-tl \
 glibc-langpack-tn \
 glibc-langpack-to \
 glibc-langpack-tok \
 glibc-langpack-tpi \
 glibc-langpack-tr \
 glibc-langpack-ts \
 glibc-langpack-tt \
 glibc-langpack-ug \
 glibc-langpack-uk \
 glibc-langpack-unm \
 glibc-langpack-ur \
 glibc-langpack-uz \
 glibc-langpack-ve \
 glibc-langpack-vi \
 glibc-langpack-wa \
 glibc-langpack-wae \
 glibc-langpack-wal \
 glibc-langpack-wo \
 glibc-langpack-xh \
 glibc-langpack-yi \
 glibc-langpack-yo \
 glibc-langpack-yue \
 glibc-langpack-yuw \
 glibc-langpack-zgh \
 glibc-langpack-zh \
 glibc-langpack-zu \
 glibc-locale-source \
 glibc-minimal-langpack \
 glibc-nss-devel \
 glibc-static \
 glibc-utils \
 libnsl \
 nss_db \
 nss_hesiod \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glibc-2.39-128.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d9a31679696e15d980f8235605f403b42cab29217dab8a4cf28069c8bbf24a3"

URI_x86_64_v2_glibc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc}"
SRC_URI[x86_64_v2_glibc.sha256sum] = "315c3a5ae33cdcbee53939443985a5c959ee9b400499c142c3acb962a7a29477"

URI_x86_64_v2_glibc-all-langpacks = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-all-langpacks-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-all-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-all-langpacks}"
SRC_URI[x86_64_v2_glibc-all-langpacks.sha256sum] = "e2b82dee0bab114784e8df515140f98e5fe9cdc71a9823bec176aae74a64b56a"
RPROVIDES:glibc-all-langpacks:x86_64_v2 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-benchtests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-benchtests-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-benchtests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-benchtests}"
SRC_URI[x86_64_v2_glibc-benchtests.sha256sum] = "e1cdc399fac2ff313e33dd060952c898debd882698892b2db681ec4457f67484"

URI_x86_64_v2_glibc-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-common-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-common}"
SRC_URI[x86_64_v2_glibc-common.sha256sum] = "05f415b401919ecaa9a574d7cef886351dcab657f5d7534404d0aac5b0e4440a"

URI_x86_64_v2_glibc-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-devel-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-devel}"
SRC_URI[x86_64_v2_glibc-devel.sha256sum] = "1abe4517ed42e88d24439570e3a0dceff0fec4e2eeed20adb7e6ae06b8c089ac"

URI_x86_64_v2_glibc-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-doc-2.39-128.el10_2.alma.1.noarch.rpm;name=x86_64_v2_glibc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-doc}"
SRC_URI[x86_64_v2_glibc-doc.sha256sum] = "ec6e77a457ba7f13faf9ac4994f0f83f6fa55864f6690c7cb0495903d28a82f2"

URI_x86_64_v2_glibc-gconv-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-gconv-extra-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-gconv-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-gconv-extra}"
SRC_URI[x86_64_v2_glibc-gconv-extra.sha256sum] = "8695e23c57c27f7aa3561fd765218d1f68fcf7b455cfcdd9757c18783abb0f1d"

URI_x86_64_v2_glibc-langpack-aa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-aa-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-aa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-aa}"
SRC_URI[x86_64_v2_glibc-langpack-aa.sha256sum] = "e7520e7525f72be764b1a233aaa3b48badeb3a22a7c239a476ce7c0bb4dc649d"
RPROVIDES:glibc-langpack-aa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-af = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-af-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-af;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-af}"
SRC_URI[x86_64_v2_glibc-langpack-af.sha256sum] = "25de9145da69d33339b52819cfcc708ad7f4de61859d1287164afdb768ad662b"
RPROVIDES:glibc-langpack-af:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-agr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-agr-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-agr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-agr}"
SRC_URI[x86_64_v2_glibc-langpack-agr.sha256sum] = "30433ea4bdb45ffc90300b81f141bd415661194356ee031b8cda9a1febd6533f"
RPROVIDES:glibc-langpack-agr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ak = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ak-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ak}"
SRC_URI[x86_64_v2_glibc-langpack-ak.sha256sum] = "3aeebcc4f526fb5baaba7590ab9baf8af7e7d1133c21c1a56d51253cbab03405"
RPROVIDES:glibc-langpack-ak:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-am = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-am-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-am;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-am}"
SRC_URI[x86_64_v2_glibc-langpack-am.sha256sum] = "cb135ae4048d780e864cd52553ce08d1bc70780004bae29edea80c1348bf0b42"
RPROVIDES:glibc-langpack-am:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-an = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-an-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-an;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-an}"
SRC_URI[x86_64_v2_glibc-langpack-an.sha256sum] = "47abd456ba2e4fef0be494f8a2e37383220722d82f3b2baa6993f8a0fd56e609"
RPROVIDES:glibc-langpack-an:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-anp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-anp-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-anp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-anp}"
SRC_URI[x86_64_v2_glibc-langpack-anp.sha256sum] = "34b017a4584528b8a807f35a893f17ffd1f5096a31a0a837f2ed7e1c00324335"
RPROVIDES:glibc-langpack-anp:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ar = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ar-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ar}"
SRC_URI[x86_64_v2_glibc-langpack-ar.sha256sum] = "0f0674cd6a43a17a4c6cb6a70962973acfd700e5f43183660544cd95c31839bb"
RPROVIDES:glibc-langpack-ar:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-as = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-as-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-as;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-as}"
SRC_URI[x86_64_v2_glibc-langpack-as.sha256sum] = "6cd8b5ec05b7b1894933bacf8cb30a07e5f8bd77255c8445417bacf303a53a99"
RPROVIDES:glibc-langpack-as:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ast = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ast-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ast}"
SRC_URI[x86_64_v2_glibc-langpack-ast.sha256sum] = "7e28cb951ec391882f851a096b4ecfe6806830224a291b508c8b1bfcb7b04ab7"
RPROVIDES:glibc-langpack-ast:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ayc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ayc-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ayc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ayc}"
SRC_URI[x86_64_v2_glibc-langpack-ayc.sha256sum] = "71fd673ec861a9337f67fd8b6e9173786eba31fc73ad21ea1dd1d568a59ebdb6"
RPROVIDES:glibc-langpack-ayc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-az = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-az-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-az;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-az}"
SRC_URI[x86_64_v2_glibc-langpack-az.sha256sum] = "65f1d44c38c9c9768cfcf51b82192d4ceda8a41d0f655061afd6c67090a55a8c"
RPROVIDES:glibc-langpack-az:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-be = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-be-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-be;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-be}"
SRC_URI[x86_64_v2_glibc-langpack-be.sha256sum] = "95e98989b287ac8ba8d428ed23da7ad176a5ebffa1b7c0e0f0fb7f2660ea2dcf"
RPROVIDES:glibc-langpack-be:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-bem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bem-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bem}"
SRC_URI[x86_64_v2_glibc-langpack-bem.sha256sum] = "910f4b3dc2970a0193ccdfd43fbef1aa8f6f939f773794cbd609ded5c5695b13"
RPROVIDES:glibc-langpack-bem:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ber = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ber-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ber}"
SRC_URI[x86_64_v2_glibc-langpack-ber.sha256sum] = "2ab399b245e0e20b701189dedcf7fe5c9b1e164e3a122ca73d8705b847d2d104"
RPROVIDES:glibc-langpack-ber:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-bg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bg-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bg}"
SRC_URI[x86_64_v2_glibc-langpack-bg.sha256sum] = "baa995f48556081e4f19f4c5c273f118ada68c9d056ff20190c28b7ae3b6ef34"
RPROVIDES:glibc-langpack-bg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-bhb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bhb-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bhb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bhb}"
SRC_URI[x86_64_v2_glibc-langpack-bhb.sha256sum] = "61a223413d28d6555b625b47deb870b746d12de130dea229ac5ac8ac3e118338"
RPROVIDES:glibc-langpack-bhb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-bho = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bho-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bho;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bho}"
SRC_URI[x86_64_v2_glibc-langpack-bho.sha256sum] = "a2daeaf705f76a0ab7f242b99a7b65f7b61607422c06ef7ed7bb03c4e73c8b4c"
RPROVIDES:glibc-langpack-bho:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-bi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bi-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bi}"
SRC_URI[x86_64_v2_glibc-langpack-bi.sha256sum] = "ea0cc78afc9656fb6fbb500af8eaf12d88af00b4a71f5b152a5e844aab5dfb3f"
RPROVIDES:glibc-langpack-bi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-bn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bn-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bn}"
SRC_URI[x86_64_v2_glibc-langpack-bn.sha256sum] = "99e5673fd8eb441686863257e0f9dea93af2fd2f2fb1180172d701ca16698265"
RPROVIDES:glibc-langpack-bn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-bo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bo-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bo}"
SRC_URI[x86_64_v2_glibc-langpack-bo.sha256sum] = "a868bf8060a7a9d5c2bcae6d87b407dd1b7f14dde5915c36476e350170f8fc7e"
RPROVIDES:glibc-langpack-bo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-br = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-br-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-br;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-br}"
SRC_URI[x86_64_v2_glibc-langpack-br.sha256sum] = "1023321818e073bf437bfd222c3b19c68041ac975fc757e8c06047ecbeff9af8"
RPROVIDES:glibc-langpack-br:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-brx = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-brx-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-brx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-brx}"
SRC_URI[x86_64_v2_glibc-langpack-brx.sha256sum] = "7419384993f05f86c97acda43fc6e67cd0f6e9fe602263a5804b235b2f628aba"
RPROVIDES:glibc-langpack-brx:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-bs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bs-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bs}"
SRC_URI[x86_64_v2_glibc-langpack-bs.sha256sum] = "7690f3106c5d40d1a06edfba7105dcd941facbc26c5a3ae540b7ff80b2b3e456"
RPROVIDES:glibc-langpack-bs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-byn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-byn-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-byn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-byn}"
SRC_URI[x86_64_v2_glibc-langpack-byn.sha256sum] = "99f1de52655f9da4a5afafb6b4f566b2c230b866fd858ee2076ba2f40ad864ff"
RPROVIDES:glibc-langpack-byn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ca = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ca-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ca}"
SRC_URI[x86_64_v2_glibc-langpack-ca.sha256sum] = "1edda945eb3cdaadcc511fa43a7f52b0290eef212772df31791e42ed8210883d"
RPROVIDES:glibc-langpack-ca:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ce = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ce-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ce}"
SRC_URI[x86_64_v2_glibc-langpack-ce.sha256sum] = "708b4d1dc4ebe20a028b90cdc049555b5fd6dc8130c5d30dbf1f03d4674cb412"
RPROVIDES:glibc-langpack-ce:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-chr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-chr-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-chr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-chr}"
SRC_URI[x86_64_v2_glibc-langpack-chr.sha256sum] = "d26e1c9337ea1a77b524141453ce37df0be3c0c35beaf1b799dc1969865e9c72"
RPROVIDES:glibc-langpack-chr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ckb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ckb-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ckb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ckb}"
SRC_URI[x86_64_v2_glibc-langpack-ckb.sha256sum] = "3a925906ee1a9f3aeb592cd1d4455b267fb356252c03cbf32364215790bf6c07"
RPROVIDES:glibc-langpack-ckb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-cmn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cmn-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cmn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cmn}"
SRC_URI[x86_64_v2_glibc-langpack-cmn.sha256sum] = "0bbc7b311869fbdd56ff7a1afc0db19ccb24bec7436d83d69806e94ed1c063bb"
RPROVIDES:glibc-langpack-cmn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-crh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-crh-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-crh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-crh}"
SRC_URI[x86_64_v2_glibc-langpack-crh.sha256sum] = "077d18f34911da988dd71d7cae85df38660c1182dbef0f5e80f144c17670ac54"
RPROVIDES:glibc-langpack-crh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-cs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cs-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cs}"
SRC_URI[x86_64_v2_glibc-langpack-cs.sha256sum] = "15f3a6af8142b2dfee3cb84d120c18b8d60afc08d51dea9733432336492b1390"
RPROVIDES:glibc-langpack-cs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-csb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-csb-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-csb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-csb}"
SRC_URI[x86_64_v2_glibc-langpack-csb.sha256sum] = "5882a5f0f2756b68bdcc64896093891e4335763a35a5e3bdd36efa91799953ff"
RPROVIDES:glibc-langpack-csb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-cv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cv-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cv}"
SRC_URI[x86_64_v2_glibc-langpack-cv.sha256sum] = "55587f1ba8eefe2a869726da11450486bdbe4660969c1a2c27d450c6e0bb34cd"
RPROVIDES:glibc-langpack-cv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-cy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cy-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cy}"
SRC_URI[x86_64_v2_glibc-langpack-cy.sha256sum] = "fcd04ace775d844f04b6c5e15322f712e7cd97b11e59d73b476ae6743d8c298b"
RPROVIDES:glibc-langpack-cy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-da = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-da-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-da;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-da}"
SRC_URI[x86_64_v2_glibc-langpack-da.sha256sum] = "7e753c160deef9ae8e1cb43f342bb4665f16f45639f62b5bb3181bbe5f1e431f"
RPROVIDES:glibc-langpack-da:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-de = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-de-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-de;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-de}"
SRC_URI[x86_64_v2_glibc-langpack-de.sha256sum] = "7f58a7045bc2838af0ba6dfe5ee7a9ce5cd8f0455b92705aa086187b5e9ff178"
RPROVIDES:glibc-langpack-de:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-doi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-doi-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-doi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-doi}"
SRC_URI[x86_64_v2_glibc-langpack-doi.sha256sum] = "7aa28c6a084423d504a0770a0de97b2c085bdee141e02a29093a4692b13c1e55"
RPROVIDES:glibc-langpack-doi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-dsb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dsb-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dsb}"
SRC_URI[x86_64_v2_glibc-langpack-dsb.sha256sum] = "5fa9af038cd2d365a36a2666813985902c91b478f6304bfe0f2ae1b0068ff5e0"
RPROVIDES:glibc-langpack-dsb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-dv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dv-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dv}"
SRC_URI[x86_64_v2_glibc-langpack-dv.sha256sum] = "48e7d5464d4b3c67973b0c38eb218bf8757fb3cc9cfef770c6503df37fed474a"
RPROVIDES:glibc-langpack-dv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-dz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dz-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dz}"
SRC_URI[x86_64_v2_glibc-langpack-dz.sha256sum] = "1fc0292e357dfd9a8cc7cd2129d95689f4a6c23b270f152c8880b326c1891fc9"
RPROVIDES:glibc-langpack-dz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-el = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-el-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-el;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-el}"
SRC_URI[x86_64_v2_glibc-langpack-el.sha256sum] = "1030304e64b35bdb5df2f7c590613487dd7c369448400dab04475fb9a9087ff1"
RPROVIDES:glibc-langpack-el:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-en = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-en-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-en;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-en}"
SRC_URI[x86_64_v2_glibc-langpack-en.sha256sum] = "29a9e41832f18d3d76a3cd0d607ca8b79e6945eb84e62d02fcb7d555ff9d9eab"
RPROVIDES:glibc-langpack-en:x86_64_v2 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-eo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eo-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-eo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-eo}"
SRC_URI[x86_64_v2_glibc-langpack-eo.sha256sum] = "d9a47ccb628c6fc1c2825e962a558b065b74ff8a6558582585e144a0e6afa513"
RPROVIDES:glibc-langpack-eo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-es = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-es-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-es;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-es}"
SRC_URI[x86_64_v2_glibc-langpack-es.sha256sum] = "2f0c55838bb9e975987e2805c18392746815a4808d36bee4d8fbfd49bd56cf93"
RPROVIDES:glibc-langpack-es:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-et = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-et-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-et;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-et}"
SRC_URI[x86_64_v2_glibc-langpack-et.sha256sum] = "851b22537f5f90e0f5e95d8ab525be4ba44c858e7ead290bcb411cbe10effd7c"
RPROVIDES:glibc-langpack-et:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-eu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eu-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-eu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-eu}"
SRC_URI[x86_64_v2_glibc-langpack-eu.sha256sum] = "0977764b0a4f39bd53ebcefb6e1595a4cab80ab60bf469bab4bcd28471c48f98"
RPROVIDES:glibc-langpack-eu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-fa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fa-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fa}"
SRC_URI[x86_64_v2_glibc-langpack-fa.sha256sum] = "aac00d1280b9422a93de57c6e227ee962d16d9637b1b320b4b23b1c0414167bc"
RPROVIDES:glibc-langpack-fa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ff = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ff-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ff}"
SRC_URI[x86_64_v2_glibc-langpack-ff.sha256sum] = "a567e6a2b3ae5aa3a60fee906a2964904e2a63f730f433c235fc76e62fac86af"
RPROVIDES:glibc-langpack-ff:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-fi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fi-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fi}"
SRC_URI[x86_64_v2_glibc-langpack-fi.sha256sum] = "53e70b079a360ab7a53edfb55b01495738dad1c2c529485fb694de628d93ba1d"
RPROVIDES:glibc-langpack-fi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-fil = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fil-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fil}"
SRC_URI[x86_64_v2_glibc-langpack-fil.sha256sum] = "8f7bdd866b5d1101d5160bf7a718f4cfb5d31440816299c97f57edb13a1ddb1a"
RPROVIDES:glibc-langpack-fil:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-fo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fo-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fo}"
SRC_URI[x86_64_v2_glibc-langpack-fo.sha256sum] = "7fd1992ecbaf55578fb08bd85c044915b46d16562da9a7c32861ebc6f99a7c2b"
RPROVIDES:glibc-langpack-fo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-fr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fr-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fr}"
SRC_URI[x86_64_v2_glibc-langpack-fr.sha256sum] = "cbbe96ad762dcbebf1c057c041b756570c0fb8d84dccc200258160985ea106ad"
RPROVIDES:glibc-langpack-fr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-fur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fur-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fur}"
SRC_URI[x86_64_v2_glibc-langpack-fur.sha256sum] = "e000e84f993187226b998efefa127d165bba2c67b5c6c09c69fea268de9472ca"
RPROVIDES:glibc-langpack-fur:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-fy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fy-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fy}"
SRC_URI[x86_64_v2_glibc-langpack-fy.sha256sum] = "c204c2f9be3d728ffc344f33b40030c0097f122f19d76f2e2b61cbc72ac1ff79"
RPROVIDES:glibc-langpack-fy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ga = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ga-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ga;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ga}"
SRC_URI[x86_64_v2_glibc-langpack-ga.sha256sum] = "af3227eae14ca1363970e776d202e6c8b07ab6b99a456028c3d1b3f25099601d"
RPROVIDES:glibc-langpack-ga:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-gbm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gbm-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gbm}"
SRC_URI[x86_64_v2_glibc-langpack-gbm.sha256sum] = "26471557c18f5ddc85cce96180d3f1e78934953daff3539e3d528ec6c67fef85"
RPROVIDES:glibc-langpack-gbm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-gd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gd-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gd}"
SRC_URI[x86_64_v2_glibc-langpack-gd.sha256sum] = "adc26698a022af4deddcc8caa5a3645b091f4ef5a0b68539a8962d9736a1d81f"
RPROVIDES:glibc-langpack-gd:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-gez = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gez-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gez;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gez}"
SRC_URI[x86_64_v2_glibc-langpack-gez.sha256sum] = "9761169d165337c150cc439bf7849dfbdc1b52153f62375be986592af2d982a7"
RPROVIDES:glibc-langpack-gez:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-gl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gl-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gl}"
SRC_URI[x86_64_v2_glibc-langpack-gl.sha256sum] = "a0a9b843ed74ad12069eb6537fdefc8c6e19f642d6db31e8fd2687dc3d61fb6d"
RPROVIDES:glibc-langpack-gl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-gu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gu-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gu}"
SRC_URI[x86_64_v2_glibc-langpack-gu.sha256sum] = "e8a23dbbc05371a9aa90a214eebfec45a61a7a03ed28bbf4bdb5120ecdd34ecd"
RPROVIDES:glibc-langpack-gu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-gv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gv-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gv}"
SRC_URI[x86_64_v2_glibc-langpack-gv.sha256sum] = "d542a9069acda8c0f7c2c9c9f2e5983a7b4844de3f6be275d50b7dafb3e7cd79"
RPROVIDES:glibc-langpack-gv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ha = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ha-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ha;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ha}"
SRC_URI[x86_64_v2_glibc-langpack-ha.sha256sum] = "7e3c402b3a63e4befda03ff169971c9651b135e90a3f33920fe9b678c6de15c0"
RPROVIDES:glibc-langpack-ha:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-hak = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hak-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hak}"
SRC_URI[x86_64_v2_glibc-langpack-hak.sha256sum] = "78acd89310abef9e61586aab74af8da6a094b1851e551f86031e0b5a3e06c924"
RPROVIDES:glibc-langpack-hak:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-he = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-he-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-he;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-he}"
SRC_URI[x86_64_v2_glibc-langpack-he.sha256sum] = "fe2000d3f47f9318a66464714c644efbe17592b83d8ebd9365f9ba368a3e3ad0"
RPROVIDES:glibc-langpack-he:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-hi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hi-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hi}"
SRC_URI[x86_64_v2_glibc-langpack-hi.sha256sum] = "51b98df58e7a0f4fd31671778019c4c1a4257337a0336250c1f754605942400f"
RPROVIDES:glibc-langpack-hi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-hif = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hif-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hif}"
SRC_URI[x86_64_v2_glibc-langpack-hif.sha256sum] = "f827862b0f2aa74f64d1401ee8d7629a72bf6825e5981646cceb0a3fc01c7298"
RPROVIDES:glibc-langpack-hif:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-hne = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hne-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hne;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hne}"
SRC_URI[x86_64_v2_glibc-langpack-hne.sha256sum] = "7e2d767105c565aeb63895f67169b0162337bbd5bec89f1e017f6cefef06c416"
RPROVIDES:glibc-langpack-hne:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-hr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hr-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hr}"
SRC_URI[x86_64_v2_glibc-langpack-hr.sha256sum] = "7df0b3747d0eb82e18cd4f02a378902718f32bce237de2a7fe3381156fd88bc2"
RPROVIDES:glibc-langpack-hr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-hsb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hsb-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hsb}"
SRC_URI[x86_64_v2_glibc-langpack-hsb.sha256sum] = "315c10b5031efb2cfce8bac4c1c5e93b5822557a439c4eba14ae3397792f59a1"
RPROVIDES:glibc-langpack-hsb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ht = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ht-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ht;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ht}"
SRC_URI[x86_64_v2_glibc-langpack-ht.sha256sum] = "c1167a4e8ad2fa7bbf55c534818b3df106b5a48cbebddc7981f20696771ccc0c"
RPROVIDES:glibc-langpack-ht:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-hu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hu-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hu}"
SRC_URI[x86_64_v2_glibc-langpack-hu.sha256sum] = "36b4280fcbd92656c9299a02a3b298dc3350a471765090222b3278ceba97e486"
RPROVIDES:glibc-langpack-hu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-hy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hy-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hy}"
SRC_URI[x86_64_v2_glibc-langpack-hy.sha256sum] = "7deb92fa1bff1467fc61758adf29a0b314e7bb354d567254ed88353bffd53734"
RPROVIDES:glibc-langpack-hy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ia = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ia-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ia}"
SRC_URI[x86_64_v2_glibc-langpack-ia.sha256sum] = "9c202ae5851f648eb8208cd550afccb65a9ed4153fe8a8a28042388efafec9bf"
RPROVIDES:glibc-langpack-ia:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-id = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-id-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-id;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-id}"
SRC_URI[x86_64_v2_glibc-langpack-id.sha256sum] = "466ef967b78141e51dd551f8e7bf36b1b0fe8d9ffce8fbc8ba9ac4ffcfad0eae"
RPROVIDES:glibc-langpack-id:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ig-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ig}"
SRC_URI[x86_64_v2_glibc-langpack-ig.sha256sum] = "aecdc2c90ee6e49a209875a18ba3dfee7827c00a33d5ea62cf8a7c9573f01eb6"
RPROVIDES:glibc-langpack-ig:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ik = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ik-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ik;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ik}"
SRC_URI[x86_64_v2_glibc-langpack-ik.sha256sum] = "954e66783b6a1c71d48fa8a8831377062f706d3abd4bc9291e902f43285c4186"
RPROVIDES:glibc-langpack-ik:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-is = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-is-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-is;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-is}"
SRC_URI[x86_64_v2_glibc-langpack-is.sha256sum] = "65ec1a06d1cca0eb4eb3938c14220706b03e5017e9460c7988a7ca500c83160b"
RPROVIDES:glibc-langpack-is:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-it = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-it-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-it;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-it}"
SRC_URI[x86_64_v2_glibc-langpack-it.sha256sum] = "c6f6b403a17f0d65321fe3a7d7f1c82628d55ce0d319c524912a54be5456ad57"
RPROVIDES:glibc-langpack-it:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-iu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-iu-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-iu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-iu}"
SRC_URI[x86_64_v2_glibc-langpack-iu.sha256sum] = "0b4381dd3a708a54159d056333406a7605038a7d9d0a6748ffee0afdfa211516"
RPROVIDES:glibc-langpack-iu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ja = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ja-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ja}"
SRC_URI[x86_64_v2_glibc-langpack-ja.sha256sum] = "3e9e884798bbfa5e894fda3d2d78d29e43d1aae34121745806510ee420f5a51d"
RPROVIDES:glibc-langpack-ja:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ka = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ka-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ka}"
SRC_URI[x86_64_v2_glibc-langpack-ka.sha256sum] = "af59889f140306438e76486c8310f912d476384861c87a95eee894b31eeed78c"
RPROVIDES:glibc-langpack-ka:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-kab = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kab-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kab}"
SRC_URI[x86_64_v2_glibc-langpack-kab.sha256sum] = "160260e4e5c2e7758f22cae751699db007dfc5a1657031dd8b04484816c52ea7"
RPROVIDES:glibc-langpack-kab:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-kk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kk-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kk}"
SRC_URI[x86_64_v2_glibc-langpack-kk.sha256sum] = "261b95f979d6b03840ecfe2727fabcf6f69f23fbf1493a1d40c507618baeb3d1"
RPROVIDES:glibc-langpack-kk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-kl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kl-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kl}"
SRC_URI[x86_64_v2_glibc-langpack-kl.sha256sum] = "6ae62c5aec943e72d04948e68747745226bec00a41bc587fb36b81472d446502"
RPROVIDES:glibc-langpack-kl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-km = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-km-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-km;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-km}"
SRC_URI[x86_64_v2_glibc-langpack-km.sha256sum] = "2335d303c5a1cc7c4904dcee84c4e8839bb9809f0a141ddd16f264932c083817"
RPROVIDES:glibc-langpack-km:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-kn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kn-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kn}"
SRC_URI[x86_64_v2_glibc-langpack-kn.sha256sum] = "914374605c1628cedcd99502267b2d77a172494b398060b39e0e4e2cd11fd7b6"
RPROVIDES:glibc-langpack-kn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ko = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ko-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ko}"
SRC_URI[x86_64_v2_glibc-langpack-ko.sha256sum] = "f06edaa0628f76cfb158a78b2e197d53d467f177c82f503d7e2c85d05e49d285"
RPROVIDES:glibc-langpack-ko:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-kok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kok-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kok}"
SRC_URI[x86_64_v2_glibc-langpack-kok.sha256sum] = "96e338e593247981d0dbf2f8bf557cfc9193a9155c8f7026fdebe43d5a9dce00"
RPROVIDES:glibc-langpack-kok:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ks = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ks-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ks}"
SRC_URI[x86_64_v2_glibc-langpack-ks.sha256sum] = "c2f243466e208bac18514e750c68581cb187e04065ecf590dfe58f03a7415949"
RPROVIDES:glibc-langpack-ks:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ku = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ku-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ku;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ku}"
SRC_URI[x86_64_v2_glibc-langpack-ku.sha256sum] = "b52e5c38c732eb6d8aee6f7ed76489fd3319aa2a49b934777698b4104f8f76f5"
RPROVIDES:glibc-langpack-ku:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-kv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kv-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kv}"
SRC_URI[x86_64_v2_glibc-langpack-kv.sha256sum] = "14a4bca3543ffe139276546ce89375d7c1a9778edfe9859a650c1bd87aecdece"
RPROVIDES:glibc-langpack-kv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-kw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kw-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kw}"
SRC_URI[x86_64_v2_glibc-langpack-kw.sha256sum] = "e0c6a4f8e4829d5b3bdc07b53ab7dee9a38d48eae327202a3ee434eae9c5e94a"
RPROVIDES:glibc-langpack-kw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ky = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ky-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ky;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ky}"
SRC_URI[x86_64_v2_glibc-langpack-ky.sha256sum] = "018132fc370dcad773ebb51d91b64b452906c56d56c9b07d46582bcec9a3d7f8"
RPROVIDES:glibc-langpack-ky:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-lb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lb-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lb}"
SRC_URI[x86_64_v2_glibc-langpack-lb.sha256sum] = "f48f655f9cb7766cc6fe4d87d30a164f29628f870575f718fc43989eb098759d"
RPROVIDES:glibc-langpack-lb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-lg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lg-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lg}"
SRC_URI[x86_64_v2_glibc-langpack-lg.sha256sum] = "f4509429801feb2644181e44bacec65a648d429cb368b04142c3c4fb0d82ed8f"
RPROVIDES:glibc-langpack-lg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-li = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-li-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-li;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-li}"
SRC_URI[x86_64_v2_glibc-langpack-li.sha256sum] = "22d56d9c9e4c59004195e1240bc6ea5779cc0a777a125b891f40b5eb90e39fa2"
RPROVIDES:glibc-langpack-li:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-lij = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lij-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lij;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lij}"
SRC_URI[x86_64_v2_glibc-langpack-lij.sha256sum] = "0cd32373427f3f18e77a8cf1111165b2d2cba864e68d2dbbf579dfc4c2451f30"
RPROVIDES:glibc-langpack-lij:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ln = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ln-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ln;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ln}"
SRC_URI[x86_64_v2_glibc-langpack-ln.sha256sum] = "1172ce8750a84ac6ae8f9c6ede893128ded268f92ada3a4bdeed053c67ff1fd9"
RPROVIDES:glibc-langpack-ln:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-lo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lo-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lo}"
SRC_URI[x86_64_v2_glibc-langpack-lo.sha256sum] = "80764cf299aae8ee1f84e38c8cbcbd60a03a5da1ac7419aa0cc6b9c511917417"
RPROVIDES:glibc-langpack-lo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-lt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lt-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lt}"
SRC_URI[x86_64_v2_glibc-langpack-lt.sha256sum] = "0a36c9d916242afde883002a6fc3012565b8161a76389c8f13b532875a81cd7b"
RPROVIDES:glibc-langpack-lt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-lv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lv-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lv}"
SRC_URI[x86_64_v2_glibc-langpack-lv.sha256sum] = "456bf1ac912525634fa9cffe768733949f795f88346e729fa87e1af5cc5f2f40"
RPROVIDES:glibc-langpack-lv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-lzh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lzh-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lzh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lzh}"
SRC_URI[x86_64_v2_glibc-langpack-lzh.sha256sum] = "897c52ef5dd10aa612edadb424ab32bdb601ec6b10460f93efe481ab38a3cee9"
RPROVIDES:glibc-langpack-lzh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mag = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mag-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mag}"
SRC_URI[x86_64_v2_glibc-langpack-mag.sha256sum] = "6f527e0c5e14f6f766fe1483186bdb21dbdd28585ddc4af53aa302740336f5a6"
RPROVIDES:glibc-langpack-mag:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mai = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mai-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mai}"
SRC_URI[x86_64_v2_glibc-langpack-mai.sha256sum] = "f8798c7f06529b097c7941f29b992980eff24ddcf22c81b70833ec5210ccef5e"
RPROVIDES:glibc-langpack-mai:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mfe = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mfe-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mfe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mfe}"
SRC_URI[x86_64_v2_glibc-langpack-mfe.sha256sum] = "a6ed3dcbf23fdf8b9a7fc4b10f9b66b549b3286f8d5c53a3c3a6a1d80c1da3b9"
RPROVIDES:glibc-langpack-mfe:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mg-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mg}"
SRC_URI[x86_64_v2_glibc-langpack-mg.sha256sum] = "0eb984070a3e69a01bc177138ec7860e5362ca79fafffbadc0a8d4fd57b8e728"
RPROVIDES:glibc-langpack-mg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mhr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mhr-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mhr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mhr}"
SRC_URI[x86_64_v2_glibc-langpack-mhr.sha256sum] = "c54824f315c91a5d8cf9e18d344b316a86df06f2d3f5d82ccf88e980e3445832"
RPROVIDES:glibc-langpack-mhr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mi-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mi}"
SRC_URI[x86_64_v2_glibc-langpack-mi.sha256sum] = "2dc7f4189c4605026cc709ab871578b0f51dec5c177bf2de3bb7c1ef6f535a54"
RPROVIDES:glibc-langpack-mi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-miq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-miq-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-miq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-miq}"
SRC_URI[x86_64_v2_glibc-langpack-miq.sha256sum] = "7f1cb927ca45084f35cb50b551aea4125a067d7ea622823716c9f45cd7b29ab8"
RPROVIDES:glibc-langpack-miq:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mjw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mjw-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mjw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mjw}"
SRC_URI[x86_64_v2_glibc-langpack-mjw.sha256sum] = "d772f717c9fd0cdf2666c0b5cb85753f653aafd1e7873c4d7ac181bade3d6aab"
RPROVIDES:glibc-langpack-mjw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mk-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mk}"
SRC_URI[x86_64_v2_glibc-langpack-mk.sha256sum] = "1d9d92f8400fc5c8f53fc3c77e3814102761664a4f6d25f7e5927ad387860a6a"
RPROVIDES:glibc-langpack-mk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ml = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ml-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ml}"
SRC_URI[x86_64_v2_glibc-langpack-ml.sha256sum] = "27dc07e22fd031777fa26e0479b8ec006292617cda5322bf7249046879e65379"
RPROVIDES:glibc-langpack-ml:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mn-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mn}"
SRC_URI[x86_64_v2_glibc-langpack-mn.sha256sum] = "e41038cbab216ce30afcafe90ef17bc9d615e266b45f310dda0380626c2a57bc"
RPROVIDES:glibc-langpack-mn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mni = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mni-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mni;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mni}"
SRC_URI[x86_64_v2_glibc-langpack-mni.sha256sum] = "de458c5f0aa55f89f8031646e587483131fff7543c809ae13014ee003c81eb53"
RPROVIDES:glibc-langpack-mni:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mnw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mnw-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mnw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mnw}"
SRC_URI[x86_64_v2_glibc-langpack-mnw.sha256sum] = "864a71d31196e9de57fbc521f5588fc912b217da9713c951a381d731273a1e2b"
RPROVIDES:glibc-langpack-mnw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mr-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mr}"
SRC_URI[x86_64_v2_glibc-langpack-mr.sha256sum] = "a9c2e177ccf35cc7bc63845eedf8d87479688648e0c230f34110a3ce8cab699c"
RPROVIDES:glibc-langpack-mr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ms = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ms-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ms}"
SRC_URI[x86_64_v2_glibc-langpack-ms.sha256sum] = "313630906c963d3e67b6dfd058ed296800aac33e20df0acd492b016a42c5161a"
RPROVIDES:glibc-langpack-ms:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-mt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mt-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mt}"
SRC_URI[x86_64_v2_glibc-langpack-mt.sha256sum] = "678ccbdba8d6e71dbaf0301effc7af16f2a9911e46c5cc2ba65f8dc6e561ff66"
RPROVIDES:glibc-langpack-mt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-my = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-my-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-my;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-my}"
SRC_URI[x86_64_v2_glibc-langpack-my.sha256sum] = "d5c77fb586d8f8ec7582e862555e4cad92990c313478320dd4c8d068f7f35ecc"
RPROVIDES:glibc-langpack-my:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-nan = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nan-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nan}"
SRC_URI[x86_64_v2_glibc-langpack-nan.sha256sum] = "11035e7d270688e1e94ed92af53ab580fe230391dd0e6b00ad4b11ac110f4bc7"
RPROVIDES:glibc-langpack-nan:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-nb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nb-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nb}"
SRC_URI[x86_64_v2_glibc-langpack-nb.sha256sum] = "ca66ba3f8ec92bcb85040e49e4e90a00776b0591cf51e38f84cc438fcd9369f5"
RPROVIDES:glibc-langpack-nb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-nds = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nds-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nds}"
SRC_URI[x86_64_v2_glibc-langpack-nds.sha256sum] = "4fff60c37318caf2b127a185118e164d9a2392bda8ee76fa62edee74d154d6e1"
RPROVIDES:glibc-langpack-nds:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ne = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ne-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ne;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ne}"
SRC_URI[x86_64_v2_glibc-langpack-ne.sha256sum] = "0d45e658fbb39fcdba47d2560770234b693365928eda8bdaaa338c35b36ff5ae"
RPROVIDES:glibc-langpack-ne:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-nhn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nhn-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nhn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nhn}"
SRC_URI[x86_64_v2_glibc-langpack-nhn.sha256sum] = "4c9ca2a9c8d9493807419769fd8d2ec9aace718b129e243c6be75f3e12b351d7"
RPROVIDES:glibc-langpack-nhn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-niu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-niu-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-niu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-niu}"
SRC_URI[x86_64_v2_glibc-langpack-niu.sha256sum] = "5192bdc5ceb69bbd25ec1d8c9d893eaabf4601e683cb86cae601491694649dad"
RPROVIDES:glibc-langpack-niu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-nl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nl-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nl}"
SRC_URI[x86_64_v2_glibc-langpack-nl.sha256sum] = "089d62e7efebf7d5fdae05c1d51d73f78ade1177302ee754eafb52c89934da8e"
RPROVIDES:glibc-langpack-nl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-nn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nn-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nn}"
SRC_URI[x86_64_v2_glibc-langpack-nn.sha256sum] = "cffa67f0ea8a8d70557d63d0113c7e2171e58d32784c3d2db2776595d24e8d8d"
RPROVIDES:glibc-langpack-nn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-nr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nr-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nr}"
SRC_URI[x86_64_v2_glibc-langpack-nr.sha256sum] = "e18862c8ad47acd691b9ff02e7b0d2e9c948c37bd74538bfc31d6815293bcdde"
RPROVIDES:glibc-langpack-nr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-nso = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nso-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nso}"
SRC_URI[x86_64_v2_glibc-langpack-nso.sha256sum] = "a6332bce8c58a00232212aecc492f66686f3d6ef7598c552aa492767a5c59f83"
RPROVIDES:glibc-langpack-nso:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-oc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-oc-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-oc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-oc}"
SRC_URI[x86_64_v2_glibc-langpack-oc.sha256sum] = "b0ccf36decdaef10d7758d334383208ad226550cd97e39c18d44f10854a3d0b7"
RPROVIDES:glibc-langpack-oc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-om = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-om-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-om;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-om}"
SRC_URI[x86_64_v2_glibc-langpack-om.sha256sum] = "8715f924ec24cd957fae1b7a3fe734d3dd345415ea3da73bb89d1e4c804e7bdc"
RPROVIDES:glibc-langpack-om:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-or = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-or-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-or;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-or}"
SRC_URI[x86_64_v2_glibc-langpack-or.sha256sum] = "561e65d99c0dca2e741fed16421ea52b1c256878cacb98c54f5daeeb5a07221a"
RPROVIDES:glibc-langpack-or:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-os = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-os-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-os;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-os}"
SRC_URI[x86_64_v2_glibc-langpack-os.sha256sum] = "1e21a36cf1cfed28a0669cc385c384f3c9d37841b7693424660dd2583e1ca46e"
RPROVIDES:glibc-langpack-os:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-pa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pa-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pa}"
SRC_URI[x86_64_v2_glibc-langpack-pa.sha256sum] = "3fe0a55b18f1279e8223dbcc8a662e12412dac112db5f953c1a5bc9679135ec9"
RPROVIDES:glibc-langpack-pa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-pap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pap-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pap}"
SRC_URI[x86_64_v2_glibc-langpack-pap.sha256sum] = "49a09ae95c2c2ab80d63abc8e5468c59a54b0ebf0db0bc2a08a2ba03792bd1b4"
RPROVIDES:glibc-langpack-pap:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-pl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pl-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pl}"
SRC_URI[x86_64_v2_glibc-langpack-pl.sha256sum] = "6d1d697702024a9916c6a6ab2db7a7b309581dd516180407da2be5de925a7666"
RPROVIDES:glibc-langpack-pl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ps = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ps-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ps}"
SRC_URI[x86_64_v2_glibc-langpack-ps.sha256sum] = "01cf83264c8331f0e20868dab3e00da4af13595d464ff153da7e86152aa3f5bd"
RPROVIDES:glibc-langpack-ps:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-pt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pt-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pt}"
SRC_URI[x86_64_v2_glibc-langpack-pt.sha256sum] = "d531641b9e10262425895c8bde6503dbe645311060a179387deba6e4b3efe72e"
RPROVIDES:glibc-langpack-pt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-quz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-quz-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-quz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-quz}"
SRC_URI[x86_64_v2_glibc-langpack-quz.sha256sum] = "3239aecbd157e0a33acd134443d6182278a16b01c1ff1972894cbba9abfe4b6c"
RPROVIDES:glibc-langpack-quz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-raj = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-raj-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-raj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-raj}"
SRC_URI[x86_64_v2_glibc-langpack-raj.sha256sum] = "18b1fb5da628ab5da48e1da796b591ffd8455efc2b57cd31ff6edeb2dfc29b5d"
RPROVIDES:glibc-langpack-raj:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-rif = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rif-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-rif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-rif}"
SRC_URI[x86_64_v2_glibc-langpack-rif.sha256sum] = "759aa88d4c4d22ea66bc03658e9a30bfaf2737e66e2abcdb632b29e433a186db"
RPROVIDES:glibc-langpack-rif:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ro = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ro-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ro}"
SRC_URI[x86_64_v2_glibc-langpack-ro.sha256sum] = "3b7c4e1d04b41f7c2b5bcb70667ea2200fe88e419487f43a28c345ab2c394257"
RPROVIDES:glibc-langpack-ro:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ru = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ru-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ru;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ru}"
SRC_URI[x86_64_v2_glibc-langpack-ru.sha256sum] = "8969793d508e33a59c610690146240069a7add16338dc6626f8b3070d735a5ca"
RPROVIDES:glibc-langpack-ru:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-rw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rw-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-rw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-rw}"
SRC_URI[x86_64_v2_glibc-langpack-rw.sha256sum] = "0c1a4f0b8d67b67e2dcb4141ba87999c3945e8cff0993ca6769bb3c3ff3aecda"
RPROVIDES:glibc-langpack-rw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sa-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sa}"
SRC_URI[x86_64_v2_glibc-langpack-sa.sha256sum] = "55ac8bf51634966f84c6bd075714b59c3128c3c95f7d34cb61273277925b775d"
RPROVIDES:glibc-langpack-sa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sah = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sah-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sah;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sah}"
SRC_URI[x86_64_v2_glibc-langpack-sah.sha256sum] = "28279390dcfe4754ea701d9c2af756e3635b1af8ffbe7f8adafd013ffee7b876"
RPROVIDES:glibc-langpack-sah:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sat-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sat}"
SRC_URI[x86_64_v2_glibc-langpack-sat.sha256sum] = "3dd3de970b527e0ebffa87d743ef06e093d99236672ab025ed6016d0f216f0ce"
RPROVIDES:glibc-langpack-sat:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sc-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sc}"
SRC_URI[x86_64_v2_glibc-langpack-sc.sha256sum] = "615a362f2775d49d0da3e66d198efeb669e9d12cb3f291fae890548081bfa1c4"
RPROVIDES:glibc-langpack-sc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sd-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sd}"
SRC_URI[x86_64_v2_glibc-langpack-sd.sha256sum] = "f98b4d62bc413b511994ac572d5824ccc5399a0677142dcc26ffa6569805e563"
RPROVIDES:glibc-langpack-sd:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-se = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-se-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-se;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-se}"
SRC_URI[x86_64_v2_glibc-langpack-se.sha256sum] = "27de8bce65d6783eba1e3827b18a368647353b034f68d48b5e5c5d44ef14e7be"
RPROVIDES:glibc-langpack-se:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sgs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sgs-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sgs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sgs}"
SRC_URI[x86_64_v2_glibc-langpack-sgs.sha256sum] = "3902274b45654251c211a386707d53e61fe3b3627da1ad20078c09d45dd88aaa"
RPROVIDES:glibc-langpack-sgs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-shn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shn-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-shn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-shn}"
SRC_URI[x86_64_v2_glibc-langpack-shn.sha256sum] = "bd1eefbc2557f69bc9fbbe61b2882d547ffd9446529bac29009a3422efdf37df"
RPROVIDES:glibc-langpack-shn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-shs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shs-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-shs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-shs}"
SRC_URI[x86_64_v2_glibc-langpack-shs.sha256sum] = "ff597569ce15e6d551deb8e079081bd23433cb09de6904daacb0db6f58319a87"
RPROVIDES:glibc-langpack-shs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-si = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-si-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-si;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-si}"
SRC_URI[x86_64_v2_glibc-langpack-si.sha256sum] = "5d86ec0052fc02b163ffef43fa48af1e02149bfc56f31657938510f87ce0eac7"
RPROVIDES:glibc-langpack-si:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sid-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sid}"
SRC_URI[x86_64_v2_glibc-langpack-sid.sha256sum] = "76315a6ed4bb046ef629bb1fafee983867658d82cdd5a47025bf910f193e7f69"
RPROVIDES:glibc-langpack-sid:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sk-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sk}"
SRC_URI[x86_64_v2_glibc-langpack-sk.sha256sum] = "24ed7155a9f9269b5530aa31c6dcfd37eea3af2fd5eb2f7514ea53f42b49fbd1"
RPROVIDES:glibc-langpack-sk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sl-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sl}"
SRC_URI[x86_64_v2_glibc-langpack-sl.sha256sum] = "edf87058f058f6c4906a4eb08747b1f03d3295c4e75daff34f92aa4ac29c89d0"
RPROVIDES:glibc-langpack-sl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sm-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sm}"
SRC_URI[x86_64_v2_glibc-langpack-sm.sha256sum] = "7f4a36ce9cb3c33415e63f91d6d907bd11fc6de78b5d4575ac8685c6a11e5307"
RPROVIDES:glibc-langpack-sm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-so = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-so-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-so;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-so}"
SRC_URI[x86_64_v2_glibc-langpack-so.sha256sum] = "f0784ba74ad3c91f6ea113c0fe79d0a17e5fd18c32f9be7abc9e33b33f6a6ccb"
RPROVIDES:glibc-langpack-so:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sq-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sq}"
SRC_URI[x86_64_v2_glibc-langpack-sq.sha256sum] = "1d3505e1b0ebf9ea0aa640718f6aefad3e4fa5b04e8e64dd34140c153aa4c65a"
RPROVIDES:glibc-langpack-sq:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sr-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sr}"
SRC_URI[x86_64_v2_glibc-langpack-sr.sha256sum] = "328220d61c7ef01012f50f1e29760cb3e17eba6e5b4bac5843a852e4792ce91f"
RPROVIDES:glibc-langpack-sr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ss-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ss}"
SRC_URI[x86_64_v2_glibc-langpack-ss.sha256sum] = "f5e52638fbf3531585b5ed440a13771a2249dde2c95490dbf6db3cd8b7756c30"
RPROVIDES:glibc-langpack-ss:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ssy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ssy-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ssy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ssy}"
SRC_URI[x86_64_v2_glibc-langpack-ssy.sha256sum] = "c0b5056b4cf90504ac5d71d3af4696b70329fd5acf6ee272a83e50273d493183"
RPROVIDES:glibc-langpack-ssy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-st = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-st-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-st;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-st}"
SRC_URI[x86_64_v2_glibc-langpack-st.sha256sum] = "89ab7493839ba80fea5e6e8dd34d13664ffc141d8af9cc067caa56545d367b69"
RPROVIDES:glibc-langpack-st:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-su = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-su-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-su;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-su}"
SRC_URI[x86_64_v2_glibc-langpack-su.sha256sum] = "3d1c265e516580a51c062afce244b3a8cd720a477ed201f493a3c7b501bfcb6a"
RPROVIDES:glibc-langpack-su:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sv-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sv}"
SRC_URI[x86_64_v2_glibc-langpack-sv.sha256sum] = "b2b272578ea6ca43aa49d1717263d61c104cd9c9b180428faf50af05564ee647"
RPROVIDES:glibc-langpack-sv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-sw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sw-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sw}"
SRC_URI[x86_64_v2_glibc-langpack-sw.sha256sum] = "ad534dd803193f00b551c94ff86a5cff402304f28d29b608f49d60af71f49179"
RPROVIDES:glibc-langpack-sw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-syr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-syr-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-syr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-syr}"
SRC_URI[x86_64_v2_glibc-langpack-syr.sha256sum] = "f2a89263b296bdd82a7c46d7bb146d595e7d5e538b2b576bacd781b011aae38d"
RPROVIDES:glibc-langpack-syr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-szl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-szl-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-szl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-szl}"
SRC_URI[x86_64_v2_glibc-langpack-szl.sha256sum] = "0c840a4ac018453b0bf7941fda7c8610e054766dd23350652bb17f969eb08fc3"
RPROVIDES:glibc-langpack-szl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ta = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ta-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ta}"
SRC_URI[x86_64_v2_glibc-langpack-ta.sha256sum] = "7233ed3585047c9691913d306e47492ac254f43ccbe53ff39d4349250b279930"
RPROVIDES:glibc-langpack-ta:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-tcy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tcy-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tcy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tcy}"
SRC_URI[x86_64_v2_glibc-langpack-tcy.sha256sum] = "00840aa0dddff0e37d8b16829155b3964f1d06ae1f0e450b5fcbed76095be740"
RPROVIDES:glibc-langpack-tcy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-te = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-te-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-te;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-te}"
SRC_URI[x86_64_v2_glibc-langpack-te.sha256sum] = "b8f5bb22c9851b7d648e0b4925ac9d1789c5a585e0c918c3e879241597dd910c"
RPROVIDES:glibc-langpack-te:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-tg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tg-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tg}"
SRC_URI[x86_64_v2_glibc-langpack-tg.sha256sum] = "f2635fc42ea6cd6d01b7b2eeff084887a76ff5ffc1de77d25f720cd404bcba3d"
RPROVIDES:glibc-langpack-tg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-th = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-th-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-th}"
SRC_URI[x86_64_v2_glibc-langpack-th.sha256sum] = "43fa2710515300c8da6b7dab6234f3e35c0502d2f60aaac03561afd91b5426dd"
RPROVIDES:glibc-langpack-th:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-the = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-the-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-the;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-the}"
SRC_URI[x86_64_v2_glibc-langpack-the.sha256sum] = "8d447b8a5a597abb0733d53c7f0eaef678ee6ae6c6c6e80112e30da434dff263"
RPROVIDES:glibc-langpack-the:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ti = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ti-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ti;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ti}"
SRC_URI[x86_64_v2_glibc-langpack-ti.sha256sum] = "74347ff99b07904b9d31e0c7364553fe6d8c6645b457ad9621479aaa7be2914c"
RPROVIDES:glibc-langpack-ti:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-tig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tig-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tig}"
SRC_URI[x86_64_v2_glibc-langpack-tig.sha256sum] = "3d12c4d339c653ee819eeaa9136b21c1e6b606b3de7407ae0427f1f9d0a57701"
RPROVIDES:glibc-langpack-tig:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-tk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tk-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tk}"
SRC_URI[x86_64_v2_glibc-langpack-tk.sha256sum] = "2491d01d7e8d81b57a74039559b4446b76381a79c7d0dce6919c038a2be64629"
RPROVIDES:glibc-langpack-tk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-tl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tl-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tl}"
SRC_URI[x86_64_v2_glibc-langpack-tl.sha256sum] = "a3628625de32a2f133b8bf0854a74e5c1d8fae6d834c45664a6c1076a65b5948"
RPROVIDES:glibc-langpack-tl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-tn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tn-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tn}"
SRC_URI[x86_64_v2_glibc-langpack-tn.sha256sum] = "223e1fbac89221a1205791c36690f28f1873d1b9133ad5e112a193257f10c102"
RPROVIDES:glibc-langpack-tn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-to = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-to-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-to;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-to}"
SRC_URI[x86_64_v2_glibc-langpack-to.sha256sum] = "117c76e978e8d0362aa13a9e879c271e6499c91f6b15d7a6c8bc452a0f05b27d"
RPROVIDES:glibc-langpack-to:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-tok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tok-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tok}"
SRC_URI[x86_64_v2_glibc-langpack-tok.sha256sum] = "af1b7ecf194699cf70a81c7c39ba4d02fb64953872fca42082c5f76656dd212b"
RPROVIDES:glibc-langpack-tok:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-tpi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tpi-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tpi}"
SRC_URI[x86_64_v2_glibc-langpack-tpi.sha256sum] = "5d71974cec7ee2e6051aec4ff2be35614854d1127d5f51007450be745526088a"
RPROVIDES:glibc-langpack-tpi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-tr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tr-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tr}"
SRC_URI[x86_64_v2_glibc-langpack-tr.sha256sum] = "8ea48ed027d5224b4221afe2b7a9e5e61520abdba26506774170668a5d82f01e"
RPROVIDES:glibc-langpack-tr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ts-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ts}"
SRC_URI[x86_64_v2_glibc-langpack-ts.sha256sum] = "eb8c38344d37c1d91774bf7c328b7874c75b3ee91842f1879e6a3340795fcff6"
RPROVIDES:glibc-langpack-ts:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-tt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tt-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tt}"
SRC_URI[x86_64_v2_glibc-langpack-tt.sha256sum] = "a570878091a6af139c173b8eecfb8805f3421b0b6fc42ea0d1fa61595ebb8dec"
RPROVIDES:glibc-langpack-tt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ug = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ug-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ug}"
SRC_URI[x86_64_v2_glibc-langpack-ug.sha256sum] = "e9d2cf588fa55330b676fdf0f7248f1945ce26669c3e4f9ed0e4e6381e987fa7"
RPROVIDES:glibc-langpack-ug:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-uk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uk-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-uk}"
SRC_URI[x86_64_v2_glibc-langpack-uk.sha256sum] = "9de888ce4c8236a4859dee88feb03802bc66f88e0a4dcfb7bf49fb1601318098"
RPROVIDES:glibc-langpack-uk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-unm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-unm-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-unm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-unm}"
SRC_URI[x86_64_v2_glibc-langpack-unm.sha256sum] = "36212d233d5ae42f5f1809eaf1ef5410d0cc7c123bb409ab5f1c3aba6b399388"
RPROVIDES:glibc-langpack-unm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ur-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ur}"
SRC_URI[x86_64_v2_glibc-langpack-ur.sha256sum] = "6a3f590f431defecb0b00b416733ffa1e83aaefe7aa1478856ec58eada3d7294"
RPROVIDES:glibc-langpack-ur:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-uz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uz-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-uz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-uz}"
SRC_URI[x86_64_v2_glibc-langpack-uz.sha256sum] = "0ea0bb9841860e532c7e323154f28e0d4b6ed17f446f0c01151b6f45d283ac37"
RPROVIDES:glibc-langpack-uz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-ve = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ve-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ve}"
SRC_URI[x86_64_v2_glibc-langpack-ve.sha256sum] = "92fa5e1ca094f321c7af984f60024f0ed467243f25514c5dfaefdd319e5c669c"
RPROVIDES:glibc-langpack-ve:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-vi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-vi-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-vi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-vi}"
SRC_URI[x86_64_v2_glibc-langpack-vi.sha256sum] = "6d8a99ea982eccba19b3a306656d0f8478460388c7179f8a83a83a80c7da0f13"
RPROVIDES:glibc-langpack-vi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-wa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wa-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wa}"
SRC_URI[x86_64_v2_glibc-langpack-wa.sha256sum] = "5216f1663abe71639b715abd5b497887f7dc6573980e93fc0e713fa6f8ab1cd2"
RPROVIDES:glibc-langpack-wa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-wae = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wae-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wae;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wae}"
SRC_URI[x86_64_v2_glibc-langpack-wae.sha256sum] = "086509f51d9b851886543fe19f6c472c848e9c792365506462ab26c318359ce6"
RPROVIDES:glibc-langpack-wae:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-wal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wal-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wal}"
SRC_URI[x86_64_v2_glibc-langpack-wal.sha256sum] = "4d9429f48981ffbcbf1ea121347552a8ed5ab7f590b8f2201bd6fe0dd8dc7375"
RPROVIDES:glibc-langpack-wal:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-wo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wo-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wo}"
SRC_URI[x86_64_v2_glibc-langpack-wo.sha256sum] = "d8f89ce157e9e18e2f8c44e22298cbc8c2fd77f03a5740c3b0078d6af9a4bb8b"
RPROVIDES:glibc-langpack-wo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-xh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-xh-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-xh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-xh}"
SRC_URI[x86_64_v2_glibc-langpack-xh.sha256sum] = "9f7386b69df4a5c1e5776d63c1d30ea07d59f8bcf8c5290107282c93b36be9c5"
RPROVIDES:glibc-langpack-xh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-yi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yi-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yi}"
SRC_URI[x86_64_v2_glibc-langpack-yi.sha256sum] = "4a8375283a77828ded92bf9a59801b75f2f90abfaf1403ba4996bb3722584856"
RPROVIDES:glibc-langpack-yi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-yo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yo-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yo}"
SRC_URI[x86_64_v2_glibc-langpack-yo.sha256sum] = "f19d950a833103c6c92968382a2b7008adff3da88068b1f17909d0aedc7a5510"
RPROVIDES:glibc-langpack-yo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-yue = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yue-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yue}"
SRC_URI[x86_64_v2_glibc-langpack-yue.sha256sum] = "5a55e1ee96fe492fcc45baf2efd321fd85bd9a48dcf5887a23aecd6c454cad15"
RPROVIDES:glibc-langpack-yue:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-yuw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yuw-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yuw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yuw}"
SRC_URI[x86_64_v2_glibc-langpack-yuw.sha256sum] = "6e97ede55c8c962c3e82314fb52a2b1f348dc5d1a2cd5afc6a033481e5911902"
RPROVIDES:glibc-langpack-yuw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-zgh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zgh-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zgh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zgh}"
SRC_URI[x86_64_v2_glibc-langpack-zgh.sha256sum] = "3f61065f54998ad17732ecb191f44cbdf6dab33f6a18c8a2bb0c9b8e8654d37a"
RPROVIDES:glibc-langpack-zgh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-zh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zh-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zh}"
SRC_URI[x86_64_v2_glibc-langpack-zh.sha256sum] = "af18f38d8f0a464ed116734650e49fdf459e60703eb784a6d34efc38d1b77893"
RPROVIDES:glibc-langpack-zh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-langpack-zu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zu-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zu}"
SRC_URI[x86_64_v2_glibc-langpack-zu.sha256sum] = "89fda92bedb14cf2070e34bf5dfe6d570488aa1ffd1fa991edafea9d2bf2d7ce"
RPROVIDES:glibc-langpack-zu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-locale-source = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-locale-source-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-locale-source;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-locale-source}"
SRC_URI[x86_64_v2_glibc-locale-source.sha256sum] = "f2f0a2f1c3b39e8fd33de62c1d5e2ecd4f63ef29cef257d38d4affdd90649739"

URI_x86_64_v2_glibc-minimal-langpack = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-minimal-langpack-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-minimal-langpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-minimal-langpack}"
SRC_URI[x86_64_v2_glibc-minimal-langpack.sha256sum] = "b98585a053e52ffb507a19340a548f8777cdbdbbc2dc765880a7267f75a362e8"
RPROVIDES:glibc-minimal-langpack:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_x86_64_v2_glibc-nss-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-nss-devel-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-nss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-nss-devel}"
SRC_URI[x86_64_v2_glibc-nss-devel.sha256sum] = "5b6349a8458f0dd7d9b1b9a8d2f7d4ec5e76a8a15171d7e03eddc21af2534117"

URI_x86_64_v2_glibc-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-static-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-static}"
SRC_URI[x86_64_v2_glibc-static.sha256sum] = "ff6520304f555210038cf7a2c89e88272bdf47713ddbf21737e4aa154fe8ebbf"

URI_x86_64_v2_glibc-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-utils-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-utils}"
SRC_URI[x86_64_v2_glibc-utils.sha256sum] = "808d1aa8826c6f226b11e0404bf23a7a6d5561341e8e8775c598321eecdb3516"

URI_x86_64_v2_libnsl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnsl-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libnsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnsl}"
SRC_URI[x86_64_v2_libnsl.sha256sum] = "9552e3d2c2e36d19e38bb2e23e57f7b1e6931bfcfb0469c226973c1fae5f4e5a"

URI_x86_64_v2_nss_db = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nss_db-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_nss_db;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss_db}"
SRC_URI[x86_64_v2_nss_db.sha256sum] = "fb359ff4af9682911222cd6614b347d71922b63bf7d10400694c4d2a3a1f0eb9"

URI_x86_64_v2_nss_hesiod = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nss_hesiod-2.39-128.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_nss_hesiod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss_hesiod}"
SRC_URI[x86_64_v2_nss_hesiod.sha256sum] = "ccda2431e9350aafdbb0f9f7bf5fccfd9f09e53fc77c13a4e6317a8c7b010c75"

URI_aarch64_glibc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc}"
SRC_URI[aarch64_glibc.sha256sum] = "5f14fed880bb2849349dbb6fc221d78cfb6a44068f8aa518c9e67a22264621e8"

URI_aarch64_glibc-all-langpacks = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-all-langpacks-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-all-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-all-langpacks}"
SRC_URI[aarch64_glibc-all-langpacks.sha256sum] = "d89ef8961ea68d107d917935393c4068d14de1a6690f1e2963a434bb8719455b"
RPROVIDES:glibc-all-langpacks:aarch64 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-benchtests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-benchtests-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-benchtests;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-benchtests}"
SRC_URI[aarch64_glibc-benchtests.sha256sum] = "573d9372e7c3ed1c87e1930251d94542e159127bded8c42720f9385ab875a703"

URI_aarch64_glibc-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-common-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-common}"
SRC_URI[aarch64_glibc-common.sha256sum] = "f88335f9130147b98264ebeca55156f0d4ab9a9a3f6517c8afedf645034f19b1"

URI_aarch64_glibc-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-devel-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-devel}"
SRC_URI[aarch64_glibc-devel.sha256sum] = "3fe14283fb02e3fc3a05638e79bde4570da697aff3cca353d99e38953bd4019f"

URI_aarch64_glibc-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-doc-2.39-128.el10_2.alma.1.noarch.rpm;name=aarch64_glibc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-doc}"
SRC_URI[aarch64_glibc-doc.sha256sum] = "ec6e77a457ba7f13faf9ac4994f0f83f6fa55864f6690c7cb0495903d28a82f2"

URI_aarch64_glibc-gconv-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-gconv-extra-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-gconv-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-gconv-extra}"
SRC_URI[aarch64_glibc-gconv-extra.sha256sum] = "cc5112f9adaee39873ba55c6be78396ee10743e780c84df3b0df6e8be590f5a3"

URI_aarch64_glibc-langpack-aa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-aa-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-aa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-aa}"
SRC_URI[aarch64_glibc-langpack-aa.sha256sum] = "9a076eedc94900abc6eab63854859a37060e57b9ebb7f33476d015e5c26e8d61"
RPROVIDES:glibc-langpack-aa:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-af = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-af-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-af;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-af}"
SRC_URI[aarch64_glibc-langpack-af.sha256sum] = "4d1ad8e6c1d8c7f90b0308b029f8c8b08f4714fb8ca676061cd67dc451b2ee5a"
RPROVIDES:glibc-langpack-af:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-agr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-agr-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-agr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-agr}"
SRC_URI[aarch64_glibc-langpack-agr.sha256sum] = "6ac03bf644c7e931547c32eb3a88375ce3d06fd89b6852dad1695db3e54e4403"
RPROVIDES:glibc-langpack-agr:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ak = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ak-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ak;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ak}"
SRC_URI[aarch64_glibc-langpack-ak.sha256sum] = "0519ee0400f0de496c15d1d5652e8fc550a116700890a34a40056d1e4c115894"
RPROVIDES:glibc-langpack-ak:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-am = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-am-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-am;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-am}"
SRC_URI[aarch64_glibc-langpack-am.sha256sum] = "2c2c7f6564a2732ca8dc5beb234c1a25f7786109de45a82336320bda1be3abe3"
RPROVIDES:glibc-langpack-am:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-an = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-an-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-an;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-an}"
SRC_URI[aarch64_glibc-langpack-an.sha256sum] = "f1a2535cdec9157313fba991d2f9124a86b32bcb78c7556dc6d01d588c775ea1"
RPROVIDES:glibc-langpack-an:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-anp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-anp-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-anp;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-anp}"
SRC_URI[aarch64_glibc-langpack-anp.sha256sum] = "15b6641c1f5f889e1bbf231d6203fd11b800010ea9136b723d376eb68d2acc8e"
RPROVIDES:glibc-langpack-anp:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ar = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ar-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ar;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ar}"
SRC_URI[aarch64_glibc-langpack-ar.sha256sum] = "2bcd97946c55af39590d99b1720a1fbd10492dab32f62b102ff7afe9c3e516bb"
RPROVIDES:glibc-langpack-ar:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-as = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-as-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-as;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-as}"
SRC_URI[aarch64_glibc-langpack-as.sha256sum] = "71e1e4c50299d522b2e161b32c3576a386017fd6077bbf1e1e098665d64e75cb"
RPROVIDES:glibc-langpack-as:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ast = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ast-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ast;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ast}"
SRC_URI[aarch64_glibc-langpack-ast.sha256sum] = "73293ff0c9e00fa96d22b3f1288afaff926ce1469fb158689f8b90d1600f7605"
RPROVIDES:glibc-langpack-ast:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ayc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ayc-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ayc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ayc}"
SRC_URI[aarch64_glibc-langpack-ayc.sha256sum] = "3f2c2534e832a909fd4726a87f9a3e210726f4563c2d709d8d8ae45488b17f9a"
RPROVIDES:glibc-langpack-ayc:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-az = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-az-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-az;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-az}"
SRC_URI[aarch64_glibc-langpack-az.sha256sum] = "64c799810151b9847be6438ccf28bc1f16f9dd6d205ae549103180b50d846915"
RPROVIDES:glibc-langpack-az:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-be = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-be-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-be;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-be}"
SRC_URI[aarch64_glibc-langpack-be.sha256sum] = "feb4af5690355689a4d503f1389112f04e972eee10cf8ca9f51aacd1a0d4b254"
RPROVIDES:glibc-langpack-be:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-bem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bem-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bem;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bem}"
SRC_URI[aarch64_glibc-langpack-bem.sha256sum] = "16f1637e24acb2a3bdf95a5c347d7657529e4f04d5a040109f3d939fd540ad4b"
RPROVIDES:glibc-langpack-bem:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ber = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ber-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ber;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ber}"
SRC_URI[aarch64_glibc-langpack-ber.sha256sum] = "43aafc2b132d06dfd54e3304c5187f248b8dbcf7a57464feb5903eb2207d1a34"
RPROVIDES:glibc-langpack-ber:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-bg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bg-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bg}"
SRC_URI[aarch64_glibc-langpack-bg.sha256sum] = "8f7b4f0309add863e354b71f8070ad77fee2b0daa5c0e3a88224a4eca32cf125"
RPROVIDES:glibc-langpack-bg:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-bhb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bhb-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bhb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bhb}"
SRC_URI[aarch64_glibc-langpack-bhb.sha256sum] = "4dc9692746102dfc3614f92609b26141455405da254de531ae1107a250e483d8"
RPROVIDES:glibc-langpack-bhb:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-bho = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bho-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bho;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bho}"
SRC_URI[aarch64_glibc-langpack-bho.sha256sum] = "6e6de21d9d71f0d2883215d31a310f2c781accef5f135e45b173244859d7589c"
RPROVIDES:glibc-langpack-bho:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-bi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bi-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bi}"
SRC_URI[aarch64_glibc-langpack-bi.sha256sum] = "db9ccf548db94412599b9427bddbac0cc581e6426207f2d3cec784d009c5fbe7"
RPROVIDES:glibc-langpack-bi:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-bn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bn-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bn}"
SRC_URI[aarch64_glibc-langpack-bn.sha256sum] = "1eb421b2e2a9109b2f4f94941b94305a4af9b34f7f4c21ef9da941fbc62ea2bc"
RPROVIDES:glibc-langpack-bn:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-bo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bo-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bo}"
SRC_URI[aarch64_glibc-langpack-bo.sha256sum] = "b95c52002ab6f69751b87fda578763ec925455352e943146d9410430f95e6273"
RPROVIDES:glibc-langpack-bo:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-br = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-br-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-br;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-br}"
SRC_URI[aarch64_glibc-langpack-br.sha256sum] = "7851dedd065ff5512ccd688c54487ede7ef0c76713d7f12e64ae6391a6f051f8"
RPROVIDES:glibc-langpack-br:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-brx = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-brx-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-brx;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-brx}"
SRC_URI[aarch64_glibc-langpack-brx.sha256sum] = "134fb83042d205c91e28f6344c56e53820442d3cdccf8fdcad079fca5bdc6415"
RPROVIDES:glibc-langpack-brx:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-bs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bs-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bs}"
SRC_URI[aarch64_glibc-langpack-bs.sha256sum] = "d59edc6c17515ec459cc8e5724580e7010e16649c130cc08c1cac7eca748ec58"
RPROVIDES:glibc-langpack-bs:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-byn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-byn-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-byn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-byn}"
SRC_URI[aarch64_glibc-langpack-byn.sha256sum] = "7c1f9bab299cae93c46876e6f299662461124f5c7997b1b508109fbebd749e9f"
RPROVIDES:glibc-langpack-byn:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ca = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ca-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ca;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ca}"
SRC_URI[aarch64_glibc-langpack-ca.sha256sum] = "80c384157166f0b411261e4b5646bbdc568565ae21dc020795b082dbbf8afc2e"
RPROVIDES:glibc-langpack-ca:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ce = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ce-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ce;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ce}"
SRC_URI[aarch64_glibc-langpack-ce.sha256sum] = "0c24bd4a115bc39b90e039bbc6ab3162712f4d139a5c17a86ddbd3ffbb8830e6"
RPROVIDES:glibc-langpack-ce:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-chr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-chr-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-chr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-chr}"
SRC_URI[aarch64_glibc-langpack-chr.sha256sum] = "17fa262949c37c1cc8b73598c4d092a3b55d71a5746c1199a7cf4cede0ce9144"
RPROVIDES:glibc-langpack-chr:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ckb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ckb-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ckb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ckb}"
SRC_URI[aarch64_glibc-langpack-ckb.sha256sum] = "622b8a506be163910f8d3b72aee015071fb7b65e8bd3207696432aa5cae8fb34"
RPROVIDES:glibc-langpack-ckb:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-cmn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cmn-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cmn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cmn}"
SRC_URI[aarch64_glibc-langpack-cmn.sha256sum] = "a989987fc34f1f9bb5af90fb9a66452466b76f0402ae40d6b8a91b0a5f49acc3"
RPROVIDES:glibc-langpack-cmn:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-crh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-crh-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-crh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-crh}"
SRC_URI[aarch64_glibc-langpack-crh.sha256sum] = "2cc51b60bd565c6b00aba5dda796ce295d3292874f9579113a8dd35543baa0c2"
RPROVIDES:glibc-langpack-crh:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-cs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cs-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cs}"
SRC_URI[aarch64_glibc-langpack-cs.sha256sum] = "06cec89eba7baf5e5eda34b22a79b9c338450e323664d47bf68c984e5ac4d967"
RPROVIDES:glibc-langpack-cs:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-csb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-csb-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-csb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-csb}"
SRC_URI[aarch64_glibc-langpack-csb.sha256sum] = "164de5537932e01b03e091254c058aa73d45f0680502695615ac3f194bee35a5"
RPROVIDES:glibc-langpack-csb:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-cv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cv-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cv}"
SRC_URI[aarch64_glibc-langpack-cv.sha256sum] = "a3a924de778196e802d8b89d48a4ac48a3ee374b72df197edd3a046186f58f86"
RPROVIDES:glibc-langpack-cv:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-cy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cy-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cy}"
SRC_URI[aarch64_glibc-langpack-cy.sha256sum] = "1d184be866ff7ca509acdb1f6ea968aa558a10b7cc511a62e130928bc9b239e5"
RPROVIDES:glibc-langpack-cy:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-da = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-da-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-da;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-da}"
SRC_URI[aarch64_glibc-langpack-da.sha256sum] = "3d7f14abef05197e17ebb5712f79e9b1b5cdec6f365b69d3dce87f78a21e8f70"
RPROVIDES:glibc-langpack-da:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-de = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-de-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-de;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-de}"
SRC_URI[aarch64_glibc-langpack-de.sha256sum] = "e0a878c808dd1d7a29c63759cd9c8fe89fdc548f4278cc9804eaed15bec38a8a"
RPROVIDES:glibc-langpack-de:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-doi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-doi-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-doi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-doi}"
SRC_URI[aarch64_glibc-langpack-doi.sha256sum] = "276e60fcb15d47fef63138b0b0c61a81ff3cb36b9dd7a2180fd05779205cc724"
RPROVIDES:glibc-langpack-doi:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-dsb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dsb-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dsb}"
SRC_URI[aarch64_glibc-langpack-dsb.sha256sum] = "106a17dc26e4de506faa857b27d8a67dce36e916143aec2d28fdcdb2787a4bcb"
RPROVIDES:glibc-langpack-dsb:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-dv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dv-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dv}"
SRC_URI[aarch64_glibc-langpack-dv.sha256sum] = "3b2aea94419b7da4264a314a3f81e8cecacb95630c56ea0f26997c35b65dabb1"
RPROVIDES:glibc-langpack-dv:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-dz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dz-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dz}"
SRC_URI[aarch64_glibc-langpack-dz.sha256sum] = "ed82245d30cdd52d9944037c4127a60af30a6ad0670eebbefc4c210cbd74db06"
RPROVIDES:glibc-langpack-dz:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-el = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-el-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-el;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-el}"
SRC_URI[aarch64_glibc-langpack-el.sha256sum] = "a3e59cef407ccb289312731bd76dc344168f17db13bd8e3b31aba28b63f49acd"
RPROVIDES:glibc-langpack-el:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-en = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-en-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-en;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-en}"
SRC_URI[aarch64_glibc-langpack-en.sha256sum] = "ab3af5b256bdfafe3e53634d7689794a63a3f6dff82e5ea7b50f607cfe431846"
RPROVIDES:glibc-langpack-en:aarch64 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-eo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-eo-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-eo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-eo}"
SRC_URI[aarch64_glibc-langpack-eo.sha256sum] = "40d0dfd06d00491e9881b6734a260239556ab5976c9fdc67236f855cbbfb1274"
RPROVIDES:glibc-langpack-eo:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-es = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-es-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-es;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-es}"
SRC_URI[aarch64_glibc-langpack-es.sha256sum] = "561309a808ebbcee56d608428592b1eb599f9f0f76f9a3029ff8bf6a05fe9a2c"
RPROVIDES:glibc-langpack-es:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-et = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-et-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-et;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-et}"
SRC_URI[aarch64_glibc-langpack-et.sha256sum] = "519ca03cdc5bf4a85ea20a5ee8c6bfc1ee5c19de56cc1045b9c8fe43dd2039e6"
RPROVIDES:glibc-langpack-et:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-eu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-eu-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-eu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-eu}"
SRC_URI[aarch64_glibc-langpack-eu.sha256sum] = "038db21ffe1e76288462fdda8990e888f365f441552e94d5d016343affe81755"
RPROVIDES:glibc-langpack-eu:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-fa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fa-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fa}"
SRC_URI[aarch64_glibc-langpack-fa.sha256sum] = "9068bfd4f68d32ac30e66335aec26a7fad0463a22f5437cafc035ca03e672731"
RPROVIDES:glibc-langpack-fa:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ff = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ff-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ff;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ff}"
SRC_URI[aarch64_glibc-langpack-ff.sha256sum] = "dcb0f3135f3dbc4cb10d5406fd622338eac453bf4ca79d96e439e7aa687de842"
RPROVIDES:glibc-langpack-ff:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-fi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fi-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fi}"
SRC_URI[aarch64_glibc-langpack-fi.sha256sum] = "6cf6199ef20ddb7305fcd9b56f570f2b0d7ab0dbd4c8da02d062f22b9ce2dc0e"
RPROVIDES:glibc-langpack-fi:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-fil = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fil-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fil;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fil}"
SRC_URI[aarch64_glibc-langpack-fil.sha256sum] = "69fde82be3d1230513c32367907527462cdf2797dbad135e0593376d187cf18a"
RPROVIDES:glibc-langpack-fil:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-fo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fo-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fo}"
SRC_URI[aarch64_glibc-langpack-fo.sha256sum] = "6c461617c768193a0e454599fd652e405f6a6c59a599159978ef3d670075c84b"
RPROVIDES:glibc-langpack-fo:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-fr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fr-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fr}"
SRC_URI[aarch64_glibc-langpack-fr.sha256sum] = "250da949610335bbf81d152d80d2fab8f38054129249a165d6183ea506fc5531"
RPROVIDES:glibc-langpack-fr:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-fur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fur-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fur;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fur}"
SRC_URI[aarch64_glibc-langpack-fur.sha256sum] = "b216187e23aabe77d09be07c3156ff0cb1ce0fdc3c5e2be7cfe5f8c0974f6081"
RPROVIDES:glibc-langpack-fur:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-fy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fy-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fy}"
SRC_URI[aarch64_glibc-langpack-fy.sha256sum] = "f7bc9ada28f40a0521edd6b33160c43378ec36d12aab5e4cae791139a53a20b4"
RPROVIDES:glibc-langpack-fy:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ga = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ga-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ga;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ga}"
SRC_URI[aarch64_glibc-langpack-ga.sha256sum] = "030bd3ee6d352cd52ef39399eb0a3b770cbebe437ad1d0d7fcb7e026925cf9d5"
RPROVIDES:glibc-langpack-ga:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-gbm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gbm-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gbm}"
SRC_URI[aarch64_glibc-langpack-gbm.sha256sum] = "756948b27a5e13ff573fb026918a2838c7365779a2d2c2ee1a8f813435464563"
RPROVIDES:glibc-langpack-gbm:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-gd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gd-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gd}"
SRC_URI[aarch64_glibc-langpack-gd.sha256sum] = "c0f9512d71d65891eee9693893f2e2a041befb206fadd73fea18a7bc3762fb69"
RPROVIDES:glibc-langpack-gd:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-gez = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gez-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gez;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gez}"
SRC_URI[aarch64_glibc-langpack-gez.sha256sum] = "7bf1546fb210e929202c4a7049fae6000e801e7f189b5b50c14cc440b00be928"
RPROVIDES:glibc-langpack-gez:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-gl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gl-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gl}"
SRC_URI[aarch64_glibc-langpack-gl.sha256sum] = "a97d3445fe76e460a932d694a9c1d2b4e565cfb9c457c202d4122c40725dafcc"
RPROVIDES:glibc-langpack-gl:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-gu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gu-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gu}"
SRC_URI[aarch64_glibc-langpack-gu.sha256sum] = "d1ea5cefd6981b36c180fde2f3697f6f8f45282e69b2b18b58985f23e664ad54"
RPROVIDES:glibc-langpack-gu:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-gv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gv-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gv}"
SRC_URI[aarch64_glibc-langpack-gv.sha256sum] = "9feb02cd1a2af36ec96d35f97df782afab72d7d1cd1393bb3726371cdd79a49f"
RPROVIDES:glibc-langpack-gv:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ha = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ha-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ha;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ha}"
SRC_URI[aarch64_glibc-langpack-ha.sha256sum] = "82d7c3dbcd821ed54a7d87f26617c23c3a0ebd970e4668f4662d0447888106a9"
RPROVIDES:glibc-langpack-ha:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-hak = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hak-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hak;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hak}"
SRC_URI[aarch64_glibc-langpack-hak.sha256sum] = "99cc45d484d2262b13428f2b02f45c739685d2c186a8a3f5c2ecf7d0cb829e3b"
RPROVIDES:glibc-langpack-hak:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-he = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-he-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-he;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-he}"
SRC_URI[aarch64_glibc-langpack-he.sha256sum] = "b0f359914e555eca1153796d1cdd805f0b24d231926d922c96476c19525ae2b8"
RPROVIDES:glibc-langpack-he:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-hi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hi-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hi}"
SRC_URI[aarch64_glibc-langpack-hi.sha256sum] = "b56246753bda753ed8487c7b5d59b7ed8c097f731bcb51fd83da4198e030ff2b"
RPROVIDES:glibc-langpack-hi:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-hif = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hif-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hif;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hif}"
SRC_URI[aarch64_glibc-langpack-hif.sha256sum] = "fdb675613742be7e4fab2e918a23fb20a0e9760881fce9eefb0093d35730e121"
RPROVIDES:glibc-langpack-hif:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-hne = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hne-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hne;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hne}"
SRC_URI[aarch64_glibc-langpack-hne.sha256sum] = "887f2eaad296f7836412e6b350a15c3e1e90c67f53e5c68402eada13ef983ff2"
RPROVIDES:glibc-langpack-hne:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-hr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hr-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hr}"
SRC_URI[aarch64_glibc-langpack-hr.sha256sum] = "d8159acffec8813d48eae63b0ceb08667952feb2a4d7760c0398b6858460303a"
RPROVIDES:glibc-langpack-hr:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-hsb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hsb-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hsb}"
SRC_URI[aarch64_glibc-langpack-hsb.sha256sum] = "9640cd3a6fdb5e455dce7a2f5885343cd4c736e12bf18d1db67834dae194b053"
RPROVIDES:glibc-langpack-hsb:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ht = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ht-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ht;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ht}"
SRC_URI[aarch64_glibc-langpack-ht.sha256sum] = "b747544be7000aa006d77a98683eb9ba982308a4eb40ffdffb076174a4336048"
RPROVIDES:glibc-langpack-ht:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-hu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hu-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hu}"
SRC_URI[aarch64_glibc-langpack-hu.sha256sum] = "2a1c71325fbacf9b576a24b590a983a3298d90c2f430013a21929d8b6f85e2b9"
RPROVIDES:glibc-langpack-hu:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-hy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hy-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hy}"
SRC_URI[aarch64_glibc-langpack-hy.sha256sum] = "b7d6401599d2d9c3ca01e51f22bc1c6200dfc4c4c5a37703a5e862cc22d18c75"
RPROVIDES:glibc-langpack-hy:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ia = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ia-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ia;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ia}"
SRC_URI[aarch64_glibc-langpack-ia.sha256sum] = "9eb8e434270918051cac2653ee511a69fd25735b3bdd0cbb184ee7a5dd30aae8"
RPROVIDES:glibc-langpack-ia:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-id = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-id-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-id;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-id}"
SRC_URI[aarch64_glibc-langpack-id.sha256sum] = "fc09588bf2210d99a26f8af2be5edf0ee04e8d73af6f7b88920c9b7068a1a5fc"
RPROVIDES:glibc-langpack-id:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ig-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ig;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ig}"
SRC_URI[aarch64_glibc-langpack-ig.sha256sum] = "ca4167f614c73ee71fb6a0ecd6124fd7b210598990863de6df48e8dd9a352cf3"
RPROVIDES:glibc-langpack-ig:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ik = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ik-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ik;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ik}"
SRC_URI[aarch64_glibc-langpack-ik.sha256sum] = "55fd219f7a3c9bfeb1a50db9162d7c8022bbca43c0e5640bf1d602f892492fd4"
RPROVIDES:glibc-langpack-ik:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-is = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-is-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-is;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-is}"
SRC_URI[aarch64_glibc-langpack-is.sha256sum] = "93c633463297c6a899479a4cfd8aa0ae1680c05eb00a9d8ec43aa3b0ba6fc8e2"
RPROVIDES:glibc-langpack-is:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-it = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-it-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-it;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-it}"
SRC_URI[aarch64_glibc-langpack-it.sha256sum] = "086b996d696a0b95050d69f10f5a1f5ff1e5a848fdf03a1e2c35a62a7c13b9fb"
RPROVIDES:glibc-langpack-it:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-iu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-iu-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-iu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-iu}"
SRC_URI[aarch64_glibc-langpack-iu.sha256sum] = "df1cd53d5666fa3fce400e626c2f777e28f92f0d86483f4899f4bd69f857d720"
RPROVIDES:glibc-langpack-iu:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ja = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ja-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ja;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ja}"
SRC_URI[aarch64_glibc-langpack-ja.sha256sum] = "cef35bfbc20f55eb3d425ab6ddda3af3bdc61f0fb1c66159c0f4b123ff7d9001"
RPROVIDES:glibc-langpack-ja:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ka = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ka-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ka;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ka}"
SRC_URI[aarch64_glibc-langpack-ka.sha256sum] = "ba3191cf272ec146548e35ae4c5622e6af519fc38b1b2b911ff36728f1bfaac6"
RPROVIDES:glibc-langpack-ka:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-kab = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kab-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kab;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kab}"
SRC_URI[aarch64_glibc-langpack-kab.sha256sum] = "5295c1fd2a794014b497b40b53a43182985c9436dee16ab4e018f42811b3dd88"
RPROVIDES:glibc-langpack-kab:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-kk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kk-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kk}"
SRC_URI[aarch64_glibc-langpack-kk.sha256sum] = "bef11cdce74eaa2b1ac0ccebb4eeff385ae8af1c2938a21902073bf74ae18bd8"
RPROVIDES:glibc-langpack-kk:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-kl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kl-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kl}"
SRC_URI[aarch64_glibc-langpack-kl.sha256sum] = "472b7aaaa8786d9951271fe983a1ba0f82934387b3fee4c499379ef2b79b186b"
RPROVIDES:glibc-langpack-kl:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-km = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-km-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-km;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-km}"
SRC_URI[aarch64_glibc-langpack-km.sha256sum] = "0223b3ca39bf69b5e46bc995ac9b54b63c53956ed62e6931a15b7132b91742e6"
RPROVIDES:glibc-langpack-km:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-kn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kn-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kn}"
SRC_URI[aarch64_glibc-langpack-kn.sha256sum] = "d0c91369ff40593e96ae1eaacb86c8b9db01cbb147bdbab1d4caab595dcd1912"
RPROVIDES:glibc-langpack-kn:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ko = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ko-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ko;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ko}"
SRC_URI[aarch64_glibc-langpack-ko.sha256sum] = "7b60298873ff5615e8cfb81ec080751570b26b3b3910f163c4a5c328fb576daf"
RPROVIDES:glibc-langpack-ko:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-kok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kok-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kok;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kok}"
SRC_URI[aarch64_glibc-langpack-kok.sha256sum] = "67bde3a950b9b76daf17896b9cd3084d3484c378ae35f7b16730bd8b38d0de4c"
RPROVIDES:glibc-langpack-kok:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ks = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ks-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ks;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ks}"
SRC_URI[aarch64_glibc-langpack-ks.sha256sum] = "8875462dadd423c8dcc6dac05b4cde4ceccf227384eec0f838ee601bf6590765"
RPROVIDES:glibc-langpack-ks:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ku = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ku-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ku;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ku}"
SRC_URI[aarch64_glibc-langpack-ku.sha256sum] = "5f83a199922b52541637a9399a1e56fff98153fec7e848f01b4fc22f85177bca"
RPROVIDES:glibc-langpack-ku:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-kv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kv-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kv}"
SRC_URI[aarch64_glibc-langpack-kv.sha256sum] = "ffaebc0a33d6ad39d5243e1238535187ceccb2a5b70cbba1fe1edc6220e9ff87"
RPROVIDES:glibc-langpack-kv:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-kw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kw-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kw}"
SRC_URI[aarch64_glibc-langpack-kw.sha256sum] = "8583834a480110c8f19c6084924e38364bbf42c219616d6527c20112b000db26"
RPROVIDES:glibc-langpack-kw:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ky = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ky-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ky;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ky}"
SRC_URI[aarch64_glibc-langpack-ky.sha256sum] = "a1b09d4db044b200bb95d7aa7e5a0aa2e4f6d54fc164f3ae56ef6c51f406a882"
RPROVIDES:glibc-langpack-ky:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-lb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lb-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lb}"
SRC_URI[aarch64_glibc-langpack-lb.sha256sum] = "8a551864c238835c14de00bba2b0c4b109566bfaff586c765ffcc80d52ec22d2"
RPROVIDES:glibc-langpack-lb:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-lg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lg-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lg}"
SRC_URI[aarch64_glibc-langpack-lg.sha256sum] = "76c824fbe9aaf9c3b4566dbd6d785688e2f6fb225651074779390d2186bab1c1"
RPROVIDES:glibc-langpack-lg:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-li = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-li-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-li;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-li}"
SRC_URI[aarch64_glibc-langpack-li.sha256sum] = "b1bcd644663cda162ff6d610d444b749154ac912841ed82f9328fca72ba984f1"
RPROVIDES:glibc-langpack-li:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-lij = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lij-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lij;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lij}"
SRC_URI[aarch64_glibc-langpack-lij.sha256sum] = "66bc384ba4de438d3b5d85392df9580f77854a28ae505b834fec510ae8c01e23"
RPROVIDES:glibc-langpack-lij:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ln = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ln-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ln;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ln}"
SRC_URI[aarch64_glibc-langpack-ln.sha256sum] = "38285380089771049936b152f02266093ea7fe241cc8f2e4f6c1e10d65e48b0f"
RPROVIDES:glibc-langpack-ln:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-lo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lo-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lo}"
SRC_URI[aarch64_glibc-langpack-lo.sha256sum] = "b18288c47126fe4c39cce075a3f1c88586ca5fa5a5e00a97c4285fc53493a8e0"
RPROVIDES:glibc-langpack-lo:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-lt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lt-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lt}"
SRC_URI[aarch64_glibc-langpack-lt.sha256sum] = "b578a4563c9df066ef0eaf7f64b4c428f8237473c8fc33f3a39591e0f89ed854"
RPROVIDES:glibc-langpack-lt:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-lv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lv-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lv}"
SRC_URI[aarch64_glibc-langpack-lv.sha256sum] = "61df2a5375c38e78ed61717686a257d1033183980d14d86e0531c983387c402c"
RPROVIDES:glibc-langpack-lv:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-lzh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lzh-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lzh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lzh}"
SRC_URI[aarch64_glibc-langpack-lzh.sha256sum] = "03afdae421827629d0ef9dea6d1de95d43c01e63bc669255b29c144468582834"
RPROVIDES:glibc-langpack-lzh:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mag = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mag-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mag;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mag}"
SRC_URI[aarch64_glibc-langpack-mag.sha256sum] = "d088413e9c4a32f824116685359d8aaf4cfea5db2d607a61de928729d201d7c1"
RPROVIDES:glibc-langpack-mag:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mai = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mai-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mai;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mai}"
SRC_URI[aarch64_glibc-langpack-mai.sha256sum] = "db6189a7cf437e24ae89349bafe55864c322115abd9d212ee1164b35415e0b15"
RPROVIDES:glibc-langpack-mai:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mfe = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mfe-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mfe;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mfe}"
SRC_URI[aarch64_glibc-langpack-mfe.sha256sum] = "756bb32556d186837ee2b012a0bc4cbb13f41b1e5f37f98ee512eb49b7327e89"
RPROVIDES:glibc-langpack-mfe:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mg-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mg}"
SRC_URI[aarch64_glibc-langpack-mg.sha256sum] = "b2705d4f0fae5659d5fc81381550f3a0954e6210a1dc0d7fdca032217e29339d"
RPROVIDES:glibc-langpack-mg:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mhr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mhr-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mhr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mhr}"
SRC_URI[aarch64_glibc-langpack-mhr.sha256sum] = "35d2bab6a0443090a112566e2fd2d40b17ae1d738a2dc8020b028153061eb755"
RPROVIDES:glibc-langpack-mhr:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mi-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mi}"
SRC_URI[aarch64_glibc-langpack-mi.sha256sum] = "98c2a8d546d32332487a6fe07c92a5dcb1bb31222afde2d181c50bc1cbb98876"
RPROVIDES:glibc-langpack-mi:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-miq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-miq-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-miq;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-miq}"
SRC_URI[aarch64_glibc-langpack-miq.sha256sum] = "7758fac75c0a5f606e91f2ed7af924ff713660d05bec9be1a07e0c0abb2943c4"
RPROVIDES:glibc-langpack-miq:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mjw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mjw-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mjw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mjw}"
SRC_URI[aarch64_glibc-langpack-mjw.sha256sum] = "5450f07fa6bb86bd061638f2106b9bfb0a9ec3e2a6cbbbcde78aa0c2c922d3ed"
RPROVIDES:glibc-langpack-mjw:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mk-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mk}"
SRC_URI[aarch64_glibc-langpack-mk.sha256sum] = "f27143b7d8909e0be4510427f4a9befde5b3e2e4fc6cc666758bd382c9074d78"
RPROVIDES:glibc-langpack-mk:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ml = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ml-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ml;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ml}"
SRC_URI[aarch64_glibc-langpack-ml.sha256sum] = "8022ddc26b1c03cfb2fccfd08306a9bc5e5f949e47deb79275c7f7c1ae40566c"
RPROVIDES:glibc-langpack-ml:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mn-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mn}"
SRC_URI[aarch64_glibc-langpack-mn.sha256sum] = "bc80fd2a831714a3b24bccb0100b07c65da18fe70849c69c4848c8f45715bf59"
RPROVIDES:glibc-langpack-mn:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mni = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mni-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mni;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mni}"
SRC_URI[aarch64_glibc-langpack-mni.sha256sum] = "c3e1ce2a72a25277b4000b280013a339cfbba627c67cb1a67b090a855786fa0f"
RPROVIDES:glibc-langpack-mni:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mnw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mnw-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mnw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mnw}"
SRC_URI[aarch64_glibc-langpack-mnw.sha256sum] = "55aa8055afb981eec83f92d7094ddc8ea6075c5ad4da4410fd4491525420cbdd"
RPROVIDES:glibc-langpack-mnw:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mr-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mr}"
SRC_URI[aarch64_glibc-langpack-mr.sha256sum] = "e06bfa08d51a8f3e18ec7d3e10795a4630e0c19d13725191070cfc34bd292cb0"
RPROVIDES:glibc-langpack-mr:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ms = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ms-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ms;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ms}"
SRC_URI[aarch64_glibc-langpack-ms.sha256sum] = "dd63067abf60f2cd2271d8a3c6886fe27ca6187152e3724a1767f7c83bd12e94"
RPROVIDES:glibc-langpack-ms:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-mt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mt-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mt}"
SRC_URI[aarch64_glibc-langpack-mt.sha256sum] = "004ee264ecde692820e30d7cbff558a34159fb5bea7f3924e0f3924f317ba7c8"
RPROVIDES:glibc-langpack-mt:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-my = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-my-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-my;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-my}"
SRC_URI[aarch64_glibc-langpack-my.sha256sum] = "3408b1419a6aa97a28ba5f95969766a66a17a3501fab8cf47a626af2b430f1eb"
RPROVIDES:glibc-langpack-my:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-nan = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nan-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nan;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nan}"
SRC_URI[aarch64_glibc-langpack-nan.sha256sum] = "dab3fd0c8200a67c61261c228608d7b71f0d0df7153c1bee64c13582bcb9cacf"
RPROVIDES:glibc-langpack-nan:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-nb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nb-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nb}"
SRC_URI[aarch64_glibc-langpack-nb.sha256sum] = "1f132d53960ad50e5becc010d9b3e951dde8cc4ef7cdbf9b6ee8fbdf5fe8c0b6"
RPROVIDES:glibc-langpack-nb:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-nds = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nds-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nds;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nds}"
SRC_URI[aarch64_glibc-langpack-nds.sha256sum] = "4c12a18716d18b001892a7b7c93f287881c57aab3be173695bb6ba40d1b0a862"
RPROVIDES:glibc-langpack-nds:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ne = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ne-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ne;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ne}"
SRC_URI[aarch64_glibc-langpack-ne.sha256sum] = "7edeeba7560b3b2df2f56191c08d145dad855f07f02d85438b9bd504f8ca9a29"
RPROVIDES:glibc-langpack-ne:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-nhn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nhn-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nhn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nhn}"
SRC_URI[aarch64_glibc-langpack-nhn.sha256sum] = "cdddc1fefb40df3c8114f4f146037a8f5fedd254abd100c48bca375acf7e2abf"
RPROVIDES:glibc-langpack-nhn:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-niu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-niu-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-niu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-niu}"
SRC_URI[aarch64_glibc-langpack-niu.sha256sum] = "87ae017cf973b372646692e3a78e6cb30acf3eb32c9cff1b3c0c7a9564c31906"
RPROVIDES:glibc-langpack-niu:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-nl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nl-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nl}"
SRC_URI[aarch64_glibc-langpack-nl.sha256sum] = "07dd0e4ab3046ff24812e66dfe1cf1526e21e5862cabb95b9b20fe61163f76a6"
RPROVIDES:glibc-langpack-nl:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-nn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nn-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nn}"
SRC_URI[aarch64_glibc-langpack-nn.sha256sum] = "4e64da8bf2c7ffd3a53f3e28a0de04b7b3f170600115b53513ce41866898d647"
RPROVIDES:glibc-langpack-nn:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-nr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nr-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nr}"
SRC_URI[aarch64_glibc-langpack-nr.sha256sum] = "d8cab5b2ebcdea0e0635694334920ed46c184f7ea79d3edd54b7021b191f3815"
RPROVIDES:glibc-langpack-nr:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-nso = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nso-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nso;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nso}"
SRC_URI[aarch64_glibc-langpack-nso.sha256sum] = "612c18cca63172bf49831379fe9094e2836f86ec9eaacf207a45406e631950f3"
RPROVIDES:glibc-langpack-nso:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-oc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-oc-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-oc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-oc}"
SRC_URI[aarch64_glibc-langpack-oc.sha256sum] = "c9b868d005fe26c1731a3f157a96353c792f24463c72c10cb4a0ca7d6f7790d4"
RPROVIDES:glibc-langpack-oc:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-om = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-om-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-om;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-om}"
SRC_URI[aarch64_glibc-langpack-om.sha256sum] = "577b6812a4e854eb4c482c917904faac34472df7dc4f1c2d59437b2b4de20553"
RPROVIDES:glibc-langpack-om:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-or = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-or-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-or;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-or}"
SRC_URI[aarch64_glibc-langpack-or.sha256sum] = "1571939469b1c2684452f32f75e55afc570eec0581f32cf2282e81834e1aee8c"
RPROVIDES:glibc-langpack-or:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-os = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-os-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-os;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-os}"
SRC_URI[aarch64_glibc-langpack-os.sha256sum] = "4e6eb84ed9f0f1a384f2990ff29aa870f5cf2f034fa0c8fd9f22ec9e67ac784d"
RPROVIDES:glibc-langpack-os:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-pa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pa-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pa}"
SRC_URI[aarch64_glibc-langpack-pa.sha256sum] = "c137a1580b8775559bbca7181fd39277276846a58a55c9bd3a7e92c8f81bd6c0"
RPROVIDES:glibc-langpack-pa:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-pap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pap-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pap;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pap}"
SRC_URI[aarch64_glibc-langpack-pap.sha256sum] = "3495e26b87e3fb2be16dc7f656f2f5c184f948056a9afef923244539f11bb433"
RPROVIDES:glibc-langpack-pap:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-pl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pl-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pl}"
SRC_URI[aarch64_glibc-langpack-pl.sha256sum] = "ba9879c2164f1229f64ae372c997650a9b3e1ad4935382f8df9ec5206883bce5"
RPROVIDES:glibc-langpack-pl:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ps = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ps-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ps;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ps}"
SRC_URI[aarch64_glibc-langpack-ps.sha256sum] = "473d4720305bac63e51cd07322792649ba7073bc385366babe94fb077dd062c2"
RPROVIDES:glibc-langpack-ps:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-pt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pt-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pt}"
SRC_URI[aarch64_glibc-langpack-pt.sha256sum] = "433e751ec2a10c69f3a1dc033f7fb8775389e3f1316e7ee62f4bd0784dfc95fc"
RPROVIDES:glibc-langpack-pt:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-quz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-quz-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-quz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-quz}"
SRC_URI[aarch64_glibc-langpack-quz.sha256sum] = "3fbad8912d8feef7839c25bb7478e7387358d6bc548b19ccadc3b1312410fdc0"
RPROVIDES:glibc-langpack-quz:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-raj = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-raj-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-raj;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-raj}"
SRC_URI[aarch64_glibc-langpack-raj.sha256sum] = "0b6e34999b637cffb720d2fef72b0dcabdcdb14139844c1a223779ae9ba8be42"
RPROVIDES:glibc-langpack-raj:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-rif = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-rif-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-rif;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-rif}"
SRC_URI[aarch64_glibc-langpack-rif.sha256sum] = "80978d9d0351c7953bb3dc1cdd0ebc5ff008db70bc8b29a5ab99fca6fe1fdbcb"
RPROVIDES:glibc-langpack-rif:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ro = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ro-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ro;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ro}"
SRC_URI[aarch64_glibc-langpack-ro.sha256sum] = "1bf040724878930ae4b2c641b94ddc41762484f45177af12a73a242fb39c8784"
RPROVIDES:glibc-langpack-ro:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ru = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ru-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ru;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ru}"
SRC_URI[aarch64_glibc-langpack-ru.sha256sum] = "7258203b0ee695279ea6e9bb2b4a5c8dbb7d0fd32e90a7f88e1b52946a434b12"
RPROVIDES:glibc-langpack-ru:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-rw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-rw-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-rw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-rw}"
SRC_URI[aarch64_glibc-langpack-rw.sha256sum] = "d3be933f7074f38bb21023b3d185b83ed3dcf5df5069ab12f2d2a1e56d1efdff"
RPROVIDES:glibc-langpack-rw:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sa-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sa}"
SRC_URI[aarch64_glibc-langpack-sa.sha256sum] = "6dc7e2aa5a0525fb1161e35923df685326bbe0552144a93919ea6dabca37e65f"
RPROVIDES:glibc-langpack-sa:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sah = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sah-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sah;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sah}"
SRC_URI[aarch64_glibc-langpack-sah.sha256sum] = "3161fece9ec5e666c7354b74d7b0759a70d8faebb40cd23d7ed24fb261b4d00b"
RPROVIDES:glibc-langpack-sah:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sat-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sat;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sat}"
SRC_URI[aarch64_glibc-langpack-sat.sha256sum] = "40b38b79257b4351e4f9d92b67b619f67a8c1283e05aa8f3c37c10d2a70672dd"
RPROVIDES:glibc-langpack-sat:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sc-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sc}"
SRC_URI[aarch64_glibc-langpack-sc.sha256sum] = "9ca456784e3df55eb2c1d46af3ae177fc6954883806b5c501c4dad3acd62faca"
RPROVIDES:glibc-langpack-sc:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sd-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sd;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sd}"
SRC_URI[aarch64_glibc-langpack-sd.sha256sum] = "c5f83ec15a22256afdeeaf83768a7b76ba832c87cad064e2cfe732a313d56471"
RPROVIDES:glibc-langpack-sd:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-se = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-se-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-se;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-se}"
SRC_URI[aarch64_glibc-langpack-se.sha256sum] = "461014e6483f30c79ae07709116d6b793084c4fcf8b255397c69f688fc154efb"
RPROVIDES:glibc-langpack-se:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sgs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sgs-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sgs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sgs}"
SRC_URI[aarch64_glibc-langpack-sgs.sha256sum] = "06298ef92a674ff34c01fb874e0836454717c2b1173a2ddeac737e05342c2058"
RPROVIDES:glibc-langpack-sgs:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-shn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-shn-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-shn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-shn}"
SRC_URI[aarch64_glibc-langpack-shn.sha256sum] = "ee57b68da15066a0aa850f5242e732894aea1004c015aa193eabad44df54cecc"
RPROVIDES:glibc-langpack-shn:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-shs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-shs-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-shs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-shs}"
SRC_URI[aarch64_glibc-langpack-shs.sha256sum] = "ca3efa5498dd2e2477a749ac9bcb60850841cee6ff0e756f7b645e581f472a42"
RPROVIDES:glibc-langpack-shs:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-si = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-si-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-si;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-si}"
SRC_URI[aarch64_glibc-langpack-si.sha256sum] = "f357c92b84699e53a02d20efcfadb32e01754e3678114423d71f1da4c6a4e7b1"
RPROVIDES:glibc-langpack-si:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sid-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sid;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sid}"
SRC_URI[aarch64_glibc-langpack-sid.sha256sum] = "b65a41f95325277aff016f44f18d72ead3bb06aa971ca71d862eaf0a0634845f"
RPROVIDES:glibc-langpack-sid:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sk-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sk}"
SRC_URI[aarch64_glibc-langpack-sk.sha256sum] = "d1ff4ea75faac1398fbe5848856d035836872c3c330cafe26aa03e8695637783"
RPROVIDES:glibc-langpack-sk:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sl-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sl}"
SRC_URI[aarch64_glibc-langpack-sl.sha256sum] = "9219934b49577c64357c520d83beb3db770dfe7724560790a18d4c6adbac2482"
RPROVIDES:glibc-langpack-sl:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sm-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sm}"
SRC_URI[aarch64_glibc-langpack-sm.sha256sum] = "c876fc6ebc20e6d9f1755a292f89e35a1903a8562a97e070f7dd062c421ca471"
RPROVIDES:glibc-langpack-sm:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-so = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-so-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-so;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-so}"
SRC_URI[aarch64_glibc-langpack-so.sha256sum] = "eca0f9a0eb29c082faa3411d298e3768d63812467ace2d1289178506143135ed"
RPROVIDES:glibc-langpack-so:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sq-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sq;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sq}"
SRC_URI[aarch64_glibc-langpack-sq.sha256sum] = "30f4ac3f811f255b528e005b52d0891ec91ef0f0152529b9208df553f884d054"
RPROVIDES:glibc-langpack-sq:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sr-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sr}"
SRC_URI[aarch64_glibc-langpack-sr.sha256sum] = "fa62034d10856fe32d90ac8f4cffc0f0c1b4fbceec987a2d3c2d4111c907ef03"
RPROVIDES:glibc-langpack-sr:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ss-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ss;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ss}"
SRC_URI[aarch64_glibc-langpack-ss.sha256sum] = "f02216e149c5dac56b61da0609b80e8af48d409f2af153617c4b8e38a911f3cb"
RPROVIDES:glibc-langpack-ss:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ssy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ssy-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ssy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ssy}"
SRC_URI[aarch64_glibc-langpack-ssy.sha256sum] = "c8a694b628e058d16a9d7144def1a14c15315f1db652e643c359d5290b6572be"
RPROVIDES:glibc-langpack-ssy:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-st = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-st-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-st;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-st}"
SRC_URI[aarch64_glibc-langpack-st.sha256sum] = "496748c2408687d6224ae581c6e29061e10df569c5f85e751d1ab71210156a99"
RPROVIDES:glibc-langpack-st:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-su = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-su-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-su;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-su}"
SRC_URI[aarch64_glibc-langpack-su.sha256sum] = "bbd12ff271921712dc5ea712efe91b76993bd927b21a4c9e26944007296615e0"
RPROVIDES:glibc-langpack-su:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sv-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sv}"
SRC_URI[aarch64_glibc-langpack-sv.sha256sum] = "575a061bde040c9f6676b1723ef6817076dfdc6d49d82f4ee204cde450bae29e"
RPROVIDES:glibc-langpack-sv:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-sw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sw-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sw}"
SRC_URI[aarch64_glibc-langpack-sw.sha256sum] = "a16d6f0d3a7dc3d99fbbe8961857a3bccc9253525d4f8dfee9df100b59987c6c"
RPROVIDES:glibc-langpack-sw:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-syr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-syr-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-syr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-syr}"
SRC_URI[aarch64_glibc-langpack-syr.sha256sum] = "f9849b21d1a374f86876a35c7bf0dce1cebbb41c3130660cd532890c849fe698"
RPROVIDES:glibc-langpack-syr:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-szl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-szl-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-szl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-szl}"
SRC_URI[aarch64_glibc-langpack-szl.sha256sum] = "797870772e15563096baf8f6247806f6fae5bbe3c3f38ab49ae9202c9151b8d5"
RPROVIDES:glibc-langpack-szl:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ta = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ta-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ta;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ta}"
SRC_URI[aarch64_glibc-langpack-ta.sha256sum] = "c8bc045f374f54c4a009d21cdaa8e4720cadc489d6bb8376a742a58109f49b08"
RPROVIDES:glibc-langpack-ta:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-tcy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tcy-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tcy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tcy}"
SRC_URI[aarch64_glibc-langpack-tcy.sha256sum] = "2ae38fbfc3817a0a745a654ab40d7b74e6830d15ba4ac817ebbcdf2b8ea4fcfe"
RPROVIDES:glibc-langpack-tcy:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-te = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-te-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-te;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-te}"
SRC_URI[aarch64_glibc-langpack-te.sha256sum] = "73d80390e847a7edbb0d955fcde9d1df25807aa2ebcdf6eaaf0934254e7757c4"
RPROVIDES:glibc-langpack-te:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-tg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tg-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tg}"
SRC_URI[aarch64_glibc-langpack-tg.sha256sum] = "69bc1514563a95fa1c158f03350ec6cd59d85bcf191e4999e87bc58be82ca2c8"
RPROVIDES:glibc-langpack-tg:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-th = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-th-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-th}"
SRC_URI[aarch64_glibc-langpack-th.sha256sum] = "7424121bb648bb91a7f77f74ef7e18445c72b94d81ee759ea085599c7d258c86"
RPROVIDES:glibc-langpack-th:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-the = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-the-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-the;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-the}"
SRC_URI[aarch64_glibc-langpack-the.sha256sum] = "0ca149999f40f08907fd5539279a73462c1aeca917cb37e84974abe4afeda967"
RPROVIDES:glibc-langpack-the:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ti = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ti-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ti;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ti}"
SRC_URI[aarch64_glibc-langpack-ti.sha256sum] = "e166f43454479a9b2d31785172bc75c1ff925a69da7b51d4584b605b08c49604"
RPROVIDES:glibc-langpack-ti:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-tig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tig-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tig;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tig}"
SRC_URI[aarch64_glibc-langpack-tig.sha256sum] = "881d49963ea545b23083c604dce3111e4782e930e8f2729410476b9e341084e1"
RPROVIDES:glibc-langpack-tig:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-tk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tk-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tk}"
SRC_URI[aarch64_glibc-langpack-tk.sha256sum] = "ad61d423fc316b199f8bfa47656d4b2c787715bee19c0d89a68495c314d5108d"
RPROVIDES:glibc-langpack-tk:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-tl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tl-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tl}"
SRC_URI[aarch64_glibc-langpack-tl.sha256sum] = "e7218a913daa476c2da71508366071982911ff761f606e639d9169a1537e30ee"
RPROVIDES:glibc-langpack-tl:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-tn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tn-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tn}"
SRC_URI[aarch64_glibc-langpack-tn.sha256sum] = "575af339dce0c6e43a7a3f617e056f9cc6505708b6cd3bab03168cd6894e1393"
RPROVIDES:glibc-langpack-tn:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-to = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-to-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-to;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-to}"
SRC_URI[aarch64_glibc-langpack-to.sha256sum] = "93940181bbfd9d40eed7b06fa919191041394e18ccc39af79e887e77111e0e5f"
RPROVIDES:glibc-langpack-to:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-tok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tok-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tok;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tok}"
SRC_URI[aarch64_glibc-langpack-tok.sha256sum] = "1f0ddf4d2e633751b8636a5c5542ca0d3c717f36f3b2312216de4fbddb48329b"
RPROVIDES:glibc-langpack-tok:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-tpi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tpi-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tpi}"
SRC_URI[aarch64_glibc-langpack-tpi.sha256sum] = "ac4f89c8a8c26574b548e5263140cf4fa6214b48317dfa1d1840448eb8ef596f"
RPROVIDES:glibc-langpack-tpi:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-tr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tr-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tr}"
SRC_URI[aarch64_glibc-langpack-tr.sha256sum] = "38bb95f94dcb341fd80b621bb58f50b231007cb6af20b815d96f2518e57e67cd"
RPROVIDES:glibc-langpack-tr:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ts-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ts;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ts}"
SRC_URI[aarch64_glibc-langpack-ts.sha256sum] = "4a46e7a3b6800ea34aa56e7faf6652866c5361955d5c026d6b668ddd7fbccfa4"
RPROVIDES:glibc-langpack-ts:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-tt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tt-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tt}"
SRC_URI[aarch64_glibc-langpack-tt.sha256sum] = "68e936dd8da6a4787eb4aaa6a8873f1b2ca4182484758de136905fdd78ab9c37"
RPROVIDES:glibc-langpack-tt:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ug-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ug;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ug}"
SRC_URI[aarch64_glibc-langpack-ug.sha256sum] = "85af8418d89946d9a18bdc580ca00e645b48fff697f3159fe4a8ee6a9e044673"
RPROVIDES:glibc-langpack-ug:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-uk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-uk-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-uk}"
SRC_URI[aarch64_glibc-langpack-uk.sha256sum] = "821efab838af9cf02beb3c97b67bcae70d1e00fd13c3b70da29966ab1cfa451e"
RPROVIDES:glibc-langpack-uk:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-unm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-unm-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-unm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-unm}"
SRC_URI[aarch64_glibc-langpack-unm.sha256sum] = "3522b7455a78761a1301d4349b38b52a46a627e0949eca0291cbbab510548ec8"
RPROVIDES:glibc-langpack-unm:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ur-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ur;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ur}"
SRC_URI[aarch64_glibc-langpack-ur.sha256sum] = "2b7d520e50cf1efecb87dec31b8e9358ff84a3faf8d186449ea65369de385261"
RPROVIDES:glibc-langpack-ur:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-uz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-uz-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-uz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-uz}"
SRC_URI[aarch64_glibc-langpack-uz.sha256sum] = "aed91740ae513fcf7d88d9658bf07e153554097bde6b2d63b3809d83d5d5a071"
RPROVIDES:glibc-langpack-uz:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-ve = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ve-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ve;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ve}"
SRC_URI[aarch64_glibc-langpack-ve.sha256sum] = "ce6fd6f73691d1fb51353874add6e7e69cbb8602784b274649ad0ff13fd691ba"
RPROVIDES:glibc-langpack-ve:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-vi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-vi-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-vi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-vi}"
SRC_URI[aarch64_glibc-langpack-vi.sha256sum] = "ecff862c49e197742badafe1428a9ec34c7e8f7ac6940e27925f04af52279519"
RPROVIDES:glibc-langpack-vi:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-wa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wa-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wa}"
SRC_URI[aarch64_glibc-langpack-wa.sha256sum] = "6ebd7a0361bf361d8f5a94db954ee27cacf1f90b715dfcec8355f9cb6c51acf8"
RPROVIDES:glibc-langpack-wa:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-wae = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wae-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wae;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wae}"
SRC_URI[aarch64_glibc-langpack-wae.sha256sum] = "676c7753e48517ffc5d055dfd437e878f71b42f74cb21136b9456d65d9e2a902"
RPROVIDES:glibc-langpack-wae:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-wal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wal-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wal;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wal}"
SRC_URI[aarch64_glibc-langpack-wal.sha256sum] = "7071de5e298c40182d973964c720375ddab740f664f21a428fdb9057b7e29d79"
RPROVIDES:glibc-langpack-wal:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-wo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wo-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wo}"
SRC_URI[aarch64_glibc-langpack-wo.sha256sum] = "2cdab521a3438afe6373044aa29f4b53b8d3bec9892dcd768a9938767978f817"
RPROVIDES:glibc-langpack-wo:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-xh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-xh-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-xh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-xh}"
SRC_URI[aarch64_glibc-langpack-xh.sha256sum] = "be70df9df8fbbae5179f9ac7fc507423f88024be20557b8cb1a45fb237be486e"
RPROVIDES:glibc-langpack-xh:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-yi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yi-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yi}"
SRC_URI[aarch64_glibc-langpack-yi.sha256sum] = "76ad46944bc0ed145954fd3aed60b3418a461399413001ccad8dc5b7005ed889"
RPROVIDES:glibc-langpack-yi:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-yo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yo-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yo}"
SRC_URI[aarch64_glibc-langpack-yo.sha256sum] = "53127757b03cae8b894fce65ebe3a421de5b0f42a1a61bcaef482b745ecdf184"
RPROVIDES:glibc-langpack-yo:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-yue = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yue-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yue;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yue}"
SRC_URI[aarch64_glibc-langpack-yue.sha256sum] = "dab6a470db5b4d7f0d8eea517d0bf1e5de86e86bb0346bbfc4b96d64e73b295e"
RPROVIDES:glibc-langpack-yue:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-yuw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yuw-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yuw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yuw}"
SRC_URI[aarch64_glibc-langpack-yuw.sha256sum] = "ea094bcf147cd32a69b87b08fde2af396eac69d334fc79580f132c2412ec78c6"
RPROVIDES:glibc-langpack-yuw:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-zgh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zgh-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zgh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zgh}"
SRC_URI[aarch64_glibc-langpack-zgh.sha256sum] = "6b17deab23ebb988a3b30f10bc684c76439b3ea62045615d47fe9c5cf19530d1"
RPROVIDES:glibc-langpack-zgh:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-zh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zh-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zh}"
SRC_URI[aarch64_glibc-langpack-zh.sha256sum] = "0418f5da22edd5e9b5035053530ddd191c7881cff7a576e668a1e08f15da730b"
RPROVIDES:glibc-langpack-zh:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-langpack-zu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zu-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zu}"
SRC_URI[aarch64_glibc-langpack-zu.sha256sum] = "211f407a27baf1bcd162226d650f577644a7c1235c0a3262df3ff35040c0ca54"
RPROVIDES:glibc-langpack-zu:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-locale-source = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-locale-source-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-locale-source;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-locale-source}"
SRC_URI[aarch64_glibc-locale-source.sha256sum] = "ea318a943248ad57581e74711b540ed4dcfec167b22f67e93ff7fc1e2a155ab7"

URI_aarch64_glibc-minimal-langpack = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-minimal-langpack-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-minimal-langpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-minimal-langpack}"
SRC_URI[aarch64_glibc-minimal-langpack.sha256sum] = "8d6fd4e2527d96b34bfc3270121f6e2a59452f6df6544773fe0565115a5c99f7"
RPROVIDES:glibc-minimal-langpack:aarch64 = "virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

URI_aarch64_glibc-nss-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-nss-devel-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-nss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-nss-devel}"
SRC_URI[aarch64_glibc-nss-devel.sha256sum] = "d3cba69db626f1bf109edf59ae01749da14bbc6117507f40b91b37dc78582682"

URI_aarch64_glibc-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-static-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-static}"
SRC_URI[aarch64_glibc-static.sha256sum] = "2cdbc97a466c0b67ebe43162d5103bbf0470c242e0a7e09b892a6b84ed29c2b1"

URI_aarch64_glibc-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-utils-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_glibc-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-utils}"
SRC_URI[aarch64_glibc-utils.sha256sum] = "a43b8d133a83b33dc23017e2e501bbdca4512b9f7c24713b7ff2b84d365dd419"

URI_aarch64_libnsl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnsl-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_libnsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnsl}"
SRC_URI[aarch64_libnsl.sha256sum] = "7ffce1adb8657ace887fa360b8b737f9872b8137acdae3d77d4b0c10b756b0ca"

URI_aarch64_nss_db = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nss_db-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_nss_db;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss_db}"
SRC_URI[aarch64_nss_db.sha256sum] = "155bacf7538a1eb4dc52c71607aeccefcd02c6fc075073011b80058900d836f6"

URI_aarch64_nss_hesiod = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nss_hesiod-2.39-128.el10_2.alma.1.aarch64.rpm;name=aarch64_nss_hesiod;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss_hesiod}"
SRC_URI[aarch64_nss_hesiod.sha256sum] = "268c5f4864840cd9c3518fd52a1f34d695243693959eac0b902c94eebdb417ae"

RDEPENDS:glibc = " \
 basesystem \
 glibc-common \
 glibc-gconv-extra \
 libgcc \
 virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1 \
 "
RDEPENDS:glibc-all-langpacks = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-benchtests = " \
 bash \
 glibc \
 python3 \
 "
RDEPENDS:glibc-common = " \
 bash \
 glibc \
 "
RDEPENDS:glibc-devel = " \
 glibc \
 kernel-headers \
 libxcrypt-devel \
 "
RDEPENDS:glibc-doc = " \
 glibc \
 "
RDEPENDS:glibc-gconv-extra = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-aa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-af = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-agr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ak = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-am = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-an = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-anp = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ar = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-as = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ast = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ayc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-az = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-be = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bem = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ber = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bhb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bho = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-br = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-brx = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-byn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ca = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ce = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-chr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ckb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cmn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-crh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-csb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-da = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-de = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-doi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dsb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-el = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-en = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-eo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-es = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-et = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-eu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ff = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fil = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fur = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ga = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gbm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gd = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gez = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ha = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hak = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-he = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hif = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hne = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hsb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ht = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ia = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-id = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ig = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ik = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-is = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-it = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-iu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ja = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ka = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kab = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-km = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ko = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kok = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ks = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ku = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ky = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-li = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lij = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ln = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lzh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mag = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mai = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mfe = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mhr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-miq = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mjw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ml = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mni = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mnw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ms = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-my = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nan = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nds = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ne = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nhn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-niu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nso = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-oc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-om = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-or = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-os = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pap = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ps = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-quz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-raj = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-rif = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ro = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ru = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-rw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sah = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sat = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sd = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-se = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sgs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-shn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-shs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-si = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sid = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-so = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sq = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ss = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ssy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-st = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-su = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-syr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-szl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ta = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tcy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-te = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-th = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-the = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ti = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tig = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-to = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tok = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tpi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ts = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ug = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-uk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-unm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ur = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-uz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ve = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-vi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wae = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wal = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-xh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yue = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yuw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zgh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-locale-source = " \
 glibc \
 glibc-common \
 gzip \
 "
RDEPENDS:glibc-minimal-langpack = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-nss-devel = " \
 glibc \
 nss_db \
 nss_hesiod \
 "
RDEPENDS:glibc-static = " \
 glibc-devel \
 libxcrypt-static \
 "
RDEPENDS:glibc-utils = " \
 bash \
 gd \
 glibc \
 libpng \
 perl-interpreter \
 zlib-ng-compat \
 "
RDEPENDS:libnsl = " \
 glibc \
 "
RDEPENDS:nss_db = " \
 glibc \
 libselinux \
 "
RDEPENDS:nss_hesiod = " \
 glibc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/glibc-langpack-en_or_glibc-all-langpacks rpm/virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"

PROVIDES:append:aarch64 = " rpm/virtual/glibc-langpack-en_or_glibc-all-langpacks rpm/virtual/glibc-langpack_eq_2.39-128.el10_2.alma.1"
