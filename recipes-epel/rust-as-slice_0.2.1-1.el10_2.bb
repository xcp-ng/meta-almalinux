# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-as-slice"
PV = "0.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-as-slice+default-devel \
 rust-as-slice-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-as-slice-0.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5f3ca4bdc7e2e023589fa0af92cbf0d7466c8f810a0a7165b0290ff2435acb5"

URI_x86_64_v2_rust-as-slice+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-as-slice+default-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-as-slice+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-as-slice+default-devel}"
SRC_URI[x86_64_v2_rust-as-slice+default-devel.sha256sum] = "9862a53a6709d62568b8d114396dced6c9ab892696d3ac12584691b95a3bd8a2"

URI_x86_64_v2_rust-as-slice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-as-slice-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-as-slice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-as-slice-devel}"
SRC_URI[x86_64_v2_rust-as-slice-devel.sha256sum] = "7e259c14c3a1a94815b2ebb00f365faeb26fe1efd79525613d9b4d32e7b0aa7f"

URI_aarch64_rust-as-slice+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-as-slice+default-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-as-slice+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-as-slice+default-devel}"
SRC_URI[aarch64_rust-as-slice+default-devel.sha256sum] = "41099f886831829b1f64cbd6b58e78fc00a694cc20bc0f3ec98a2545aca609ce"

URI_aarch64_rust-as-slice-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-as-slice-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-as-slice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-as-slice-devel}"
SRC_URI[aarch64_rust-as-slice-devel.sha256sum] = "34ce12ea37a35491bfc42d46b534b059b409646c1ba0b24c2d1a8ddb5f02fa70"

RDEPENDS:rust-as-slice+default-devel = " \
 cargo \
 rust-as-slice-devel \
 "
RDEPENDS:rust-as-slice-devel = " \
 cargo \
 rust-stable_deref_trait-devel \
 "
