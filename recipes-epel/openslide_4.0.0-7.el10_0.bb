# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openslide"
PV = "4.0.0"
PR = "7.el10_0"
PACKAGES = " \
 openslide \
 openslide-devel \
 openslide-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openslide-4.0.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b0e730009d3bd24c8a14e7c4eacd3d3a0c612895eb75ef83ac557b64a0e3a8e"

URI_x86_64_v2_openslide = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openslide-4.0.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openslide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openslide}"
SRC_URI[x86_64_v2_openslide.sha256sum] = "b167df741ff073b8d715e9b62230d9124a50c82f7a3097f58e9333e329ffb5db"

URI_x86_64_v2_openslide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openslide-devel-4.0.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openslide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openslide-devel}"
SRC_URI[x86_64_v2_openslide-devel.sha256sum] = "55baccbd8368669cf3150b2da640caed5343af08805182f822e44226b8e868dc"

URI_x86_64_v2_openslide-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openslide-tools-4.0.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openslide-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openslide-tools}"
SRC_URI[x86_64_v2_openslide-tools.sha256sum] = "0ca5e242ceb941a59134d77cec552b8c82438372db591c53cf20e4dd9f950801"

URI_aarch64_openslide = "${EPEL_MIRROR}/aarch64/Packages/o/openslide-4.0.0-7.el10_0.aarch64.rpm;name=aarch64_openslide;unpack=0"
SRC_URI:append = " ${URI_aarch64_openslide}"
SRC_URI[aarch64_openslide.sha256sum] = "db91b0a15a479f6395962b72a87d85bde1768e41f0038e9f75c7c9b5d7ed6799"

URI_aarch64_openslide-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openslide-devel-4.0.0-7.el10_0.aarch64.rpm;name=aarch64_openslide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openslide-devel}"
SRC_URI[aarch64_openslide-devel.sha256sum] = "2e4a449baa7701f0fa9d71e25fe42007f2b6602ee3633ad1922a73b8b3c89263"

URI_aarch64_openslide-tools = "${EPEL_MIRROR}/aarch64/Packages/o/openslide-tools-4.0.0-7.el10_0.aarch64.rpm;name=aarch64_openslide-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_openslide-tools}"
SRC_URI[aarch64_openslide-tools.sha256sum] = "185c561f30b79e21b56b5cf702282441e68218ed9e56316dedf55fa30d94de9a"

RDEPENDS:openslide = " \
 cairo \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules-extra \
 glib2 \
 glibc \
 libdicom \
 libgcc \
 libjpeg-turbo \
 libpng \
 libtiff \
 libxml2 \
 openjpeg2 \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:openslide-devel = " \
 cairo-devel \
 gdk-pixbuf2-devel \
 glib2-devel \
 libdicom-devel \
 libjpeg-turbo-devel \
 libpng-devel \
 libtiff-devel \
 libxml2-devel \
 openjpeg2-devel \
 openslide \
 pkgconf-pkg-config \
 sqlite-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:openslide-tools = " \
 glib2 \
 glibc \
 libgcc \
 libpng \
 openslide \
 "
