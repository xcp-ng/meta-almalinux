# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-ucm-asahi"
PV = "5"
PR = "4.el10_0"
PACKAGES = " \
 alsa-ucm-asahi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/alsa-ucm-asahi-5-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57923de12ce86a5358e76d062175e504f081d60fd144c13530b2844eebf370e4"

URI_x86_64_v2_alsa-ucm-asahi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alsa-ucm-asahi-5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_alsa-ucm-asahi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-ucm-asahi}"
SRC_URI[x86_64_v2_alsa-ucm-asahi.sha256sum] = "5518462c859cedefed1069223f8ae3276315b0f25d8c825a325a7693738e9849"

URI_aarch64_alsa-ucm-asahi = "${EPEL_MIRROR}/aarch64/Packages/a/alsa-ucm-asahi-5-4.el10_0.noarch.rpm;name=aarch64_alsa-ucm-asahi;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-ucm-asahi}"
SRC_URI[aarch64_alsa-ucm-asahi.sha256sum] = "fdec5259860a7900bc230322bfc35cca168cf363a961375c9ddf46ecba9df1c0"

RDEPENDS:alsa-ucm-asahi = " \
 alsa-ucm \
 "
