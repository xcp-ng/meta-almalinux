# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NLopt"
PV = "2.10.1"
PR = "4.el10_3"
PACKAGES = " \
 NLopt \
 NLopt-devel \
 NLopt-doc \
 guile-NLopt \
 octave-NLopt \
 python3-NLopt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/NLopt-2.10.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f258541249bb18b113d00442b9a173b3a51eeb6441a18c3f61508a0fca440436"

URI_x86_64_v2_NLopt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NLopt-2.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NLopt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NLopt}"
SRC_URI[x86_64_v2_NLopt.sha256sum] = "e634bb5b98fd238123c11b33b723ced2eff3b3b573f9feaaadc2702a3628337e"

URI_x86_64_v2_NLopt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NLopt-devel-2.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NLopt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NLopt-devel}"
SRC_URI[x86_64_v2_NLopt-devel.sha256sum] = "e1759aa93bee620048440d2928ffdd40d72eae1157c216fc0d98c7f8f801582d"

URI_x86_64_v2_NLopt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NLopt-doc-2.10.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_NLopt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NLopt-doc}"
SRC_URI[x86_64_v2_NLopt-doc.sha256sum] = "904cdc39df0aac3b57a4a9d14e1014e71ce4e4112c0d6d60c5b5d2c817d6ee8d"

URI_x86_64_v2_guile-NLopt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/guile-NLopt-2.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_guile-NLopt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guile-NLopt}"
SRC_URI[x86_64_v2_guile-NLopt.sha256sum] = "1fbb4582b99bd0b1860b909fe14c005c982d2ac52ad21f8e173ac8b43068a913"

URI_x86_64_v2_octave-NLopt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/octave-NLopt-2.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_octave-NLopt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_octave-NLopt}"
SRC_URI[x86_64_v2_octave-NLopt.sha256sum] = "054ac18c514749afa4da4f1b19ed12f41ac3410ba51f7e92c121344b3618afc6"

URI_x86_64_v2_python3-NLopt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-NLopt-2.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-NLopt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-NLopt}"
SRC_URI[x86_64_v2_python3-NLopt.sha256sum] = "e5177304c66ea2aedb7be3c04a2b77d42036a8109ae45137c791b500b5d4ceee"

URI_aarch64_NLopt = "${EPEL_MIRROR}/aarch64/Packages/n/NLopt-2.10.1-4.el10_3.aarch64.rpm;name=aarch64_NLopt;unpack=0"
SRC_URI:append = " ${URI_aarch64_NLopt}"
SRC_URI[aarch64_NLopt.sha256sum] = "74192dde81bced533c5fdece5e2223fea84059566179c3775300446b5994115f"

URI_aarch64_NLopt-devel = "${EPEL_MIRROR}/aarch64/Packages/n/NLopt-devel-2.10.1-4.el10_3.aarch64.rpm;name=aarch64_NLopt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_NLopt-devel}"
SRC_URI[aarch64_NLopt-devel.sha256sum] = "ecfe084bee207b10208c7752c84c8f8388f56eaa8f4a40223361c676b6f0cb32"

URI_aarch64_NLopt-doc = "${EPEL_MIRROR}/aarch64/Packages/n/NLopt-doc-2.10.1-4.el10_3.noarch.rpm;name=aarch64_NLopt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_NLopt-doc}"
SRC_URI[aarch64_NLopt-doc.sha256sum] = "7c04e7f1b6ead9581fcd598729b7da23161394d1b98c494594b1abcbafa39064"

URI_aarch64_guile-NLopt = "${EPEL_MIRROR}/aarch64/Packages/g/guile-NLopt-2.10.1-4.el10_3.aarch64.rpm;name=aarch64_guile-NLopt;unpack=0"
SRC_URI:append = " ${URI_aarch64_guile-NLopt}"
SRC_URI[aarch64_guile-NLopt.sha256sum] = "d5bd167de81f046fd370bd3cbfa0f4834f4bce2f51a504a8f47ea284da80d796"

URI_aarch64_octave-NLopt = "${EPEL_MIRROR}/aarch64/Packages/o/octave-NLopt-2.10.1-4.el10_3.aarch64.rpm;name=aarch64_octave-NLopt;unpack=0"
SRC_URI:append = " ${URI_aarch64_octave-NLopt}"
SRC_URI[aarch64_octave-NLopt.sha256sum] = "d4e8c68d31d17b90a646b34be3c455948937ac4e6faa32c922e5d6dbcbcfa94f"

URI_aarch64_python3-NLopt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-NLopt-2.10.1-4.el10_3.aarch64.rpm;name=aarch64_python3-NLopt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-NLopt}"
SRC_URI[aarch64_python3-NLopt.sha256sum] = "24448816235514edfc2d2281ef177e624bc2907610a68a212ff9a2666074c590"

RDEPENDS:NLopt = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:NLopt-devel = " \
 NLopt \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:NLopt-doc = " \
 "
RDEPENDS:guile-NLopt = " \
 NLopt \
 glibc \
 guile30 \
 libgcc \
 libstdc++ \
 "
RDEPENDS:octave-NLopt = " \
 NLopt \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 octave \
 "
RDEPENDS:python3-NLopt = " \
 NLopt \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
