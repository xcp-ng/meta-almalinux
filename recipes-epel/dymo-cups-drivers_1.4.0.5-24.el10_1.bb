# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dymo-cups-drivers"
PV = "1.4.0.5"
PR = "24.el10_1"
PACKAGES = " \
 dymo-cups-drivers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dymo-cups-drivers-1.4.0.5-24.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c941cf03e95cf33649d9a52f7962eec815a35ed82c2f1cfaa9f225c04575b6ab"

URI_x86_64_v2_dymo-cups-drivers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dymo-cups-drivers-1.4.0.5-24.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dymo-cups-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dymo-cups-drivers}"
SRC_URI[x86_64_v2_dymo-cups-drivers.sha256sum] = "2a1adf650a069ac674d57858bf02f67ef81eb59fc471ac8fe98d953b9f7199ec"

URI_aarch64_dymo-cups-drivers = "${EPEL_MIRROR}/aarch64/Packages/d/dymo-cups-drivers-1.4.0.5-24.el10_1.aarch64.rpm;name=aarch64_dymo-cups-drivers;unpack=0"
SRC_URI:append = " ${URI_aarch64_dymo-cups-drivers}"
SRC_URI[aarch64_dymo-cups-drivers.sha256sum] = "10181033b56efd88be3f7f93e6358f47cc6b2536fef0b595854aa30aa0b470af"

RDEPENDS:dymo-cups-drivers = " \
 cups \
 cups-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
