# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gmp"
PE = "1"
PV = "6.2.1"
PR = "12.el10"
PACKAGES = " \
 gmp \
 gmp-c++ \
 gmp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gmp-6.2.1-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ed6077d2efc407c84689b3927309cd665960a6d35d1e666a792337308e06d25"

URI_x86_64_v2_gmp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gmp-6.2.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_gmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmp}"
SRC_URI[x86_64_v2_gmp.sha256sum] = "81105d98e319cb61f1d350a6e3f46dd085d0ef3bffd0cd455d28b02383da854f"

URI_x86_64_v2_gmp-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gmp-c++-6.2.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_gmp-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmp-c++}"
SRC_URI[x86_64_v2_gmp-c++.sha256sum] = "a3c97fda4b8450dc9d779398959e9d7e857502c07c60ef107e263edaa905c035"

URI_x86_64_v2_gmp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gmp-devel-6.2.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_gmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmp-devel}"
SRC_URI[x86_64_v2_gmp-devel.sha256sum] = "f86a87bd8f4ba994bc2ab26428cb8367aa5259dd36d98ef804d6669719e46cdb"

URI_aarch64_gmp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gmp-6.2.1-12.el10.aarch64.rpm;name=aarch64_gmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmp}"
SRC_URI[aarch64_gmp.sha256sum] = "2637c58c1b716d2856c735ad85a61c1640e7e3a06d58e2bc102a480526823d56"

URI_aarch64_gmp-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gmp-c++-6.2.1-12.el10.aarch64.rpm;name=aarch64_gmp-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmp-c++}"
SRC_URI[aarch64_gmp-c++.sha256sum] = "849732c6980e98940a1356fee5dfd927cdf8b32e06914626015ae58222fb5256"

URI_aarch64_gmp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gmp-devel-6.2.1-12.el10.aarch64.rpm;name=aarch64_gmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmp-devel}"
SRC_URI[aarch64_gmp-devel.sha256sum] = "1bab791f2505a2bee95d31fee94ee9745349ab573beb2d7b6849a48e56f7559c"

RDEPENDS:gmp = " \
 glibc \
 "
RDEPENDS:gmp-c++ = " \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gmp-devel = " \
 gmp \
 gmp-c++ \
 gmp-devel \
 pkgconf-pkg-config \
 "
