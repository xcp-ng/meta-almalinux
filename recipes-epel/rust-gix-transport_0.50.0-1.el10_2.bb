# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-transport"
PV = "0.50.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-transport+async-client-devel \
 rust-gix-transport+async-std-devel \
 rust-gix-transport+async-trait-devel \
 rust-gix-transport+base64-devel \
 rust-gix-transport+blocking-client-devel \
 rust-gix-transport+curl-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+document-features-devel \
 rust-gix-transport+futures-io-devel \
 rust-gix-transport+futures-lite-devel \
 rust-gix-transport+gix-credentials-devel \
 rust-gix-transport+http-client-curl-devel \
 rust-gix-transport+http-client-devel \
 rust-gix-transport+http-client-insecure-credentials-devel \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport+http-client-reqwest-native-tls-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel \
 rust-gix-transport+pin-project-lite-devel \
 rust-gix-transport+reqwest-devel \
 rust-gix-transport+serde-devel \
 rust-gix-transport-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-transport-0.50.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6f580a893b6b85936e5230284fde4b135246bf5c7f91f6d30341875f5a10f23"

URI_x86_64_v2_rust-gix-transport+async-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-client-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-client-devel.sha256sum] = "fd571d2e025f27f0aed076b868b98c544c23e8cde5b93dd91ea45504db08e25d"

URI_x86_64_v2_rust-gix-transport+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-std-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-std-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-std-devel.sha256sum] = "3b66fa6d757207148d6afb6ab57dd12725fe33f73f869bd50b7f44505c30cd7c"

URI_x86_64_v2_rust-gix-transport+async-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-trait-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-trait-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-trait-devel.sha256sum] = "8be23b0c09ca6f675960f25aadf386e0cf63acefd3af86cdf45357040b11138d"

URI_x86_64_v2_rust-gix-transport+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+base64-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+base64-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+base64-devel.sha256sum] = "e64edc9607246343629cb027c63d6fe3cf10dfc5243324cbc4092f32a9e0beb2"

URI_x86_64_v2_rust-gix-transport+blocking-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+blocking-client-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+blocking-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+blocking-client-devel.sha256sum] = "da3d52ae0436c7826a0713993cf3545555c4e5641198de2f5d92e463655b565a"

URI_x86_64_v2_rust-gix-transport+curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+curl-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+curl-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+curl-devel.sha256sum] = "1a53d564cbdef78cf4b594c0b3679becfd49a6d22c31dbce06600a4218c64a2d"

URI_x86_64_v2_rust-gix-transport+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+default-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+default-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+default-devel.sha256sum] = "1ea6e53c32dcbc3d67ff964980e765d54464f6442a8f294dc68a6343d8f21a80"

URI_x86_64_v2_rust-gix-transport+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+document-features-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+document-features-devel.sha256sum] = "860ddeb0c5e0ded963606fedd3fc212dc7bba34bd3a5a0152703ac674b5f11bc"

URI_x86_64_v2_rust-gix-transport+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+futures-io-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+futures-io-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+futures-io-devel.sha256sum] = "c2e407730d33f1ad91befef396d6a04abeade90615d1276a43f5f94a491f87ca"

URI_x86_64_v2_rust-gix-transport+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+futures-lite-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+futures-lite-devel.sha256sum] = "63605e34164ea4176494704a0ffa2aab6215486c650969544573f7bcfdc302be"

URI_x86_64_v2_rust-gix-transport+gix-credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+gix-credentials-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+gix-credentials-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+gix-credentials-devel.sha256sum] = "9f5ad0513195bbe298b740d05a5a9ec862619ab170e1293db3c351dd9b95f511"

URI_x86_64_v2_rust-gix-transport+http-client-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-curl-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-curl-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-curl-devel.sha256sum] = "61c20c9bbf1680cd39ef50053ab15397bedd8ec1197010ef9b0606c73bbc5a04"

URI_x86_64_v2_rust-gix-transport+http-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-devel.sha256sum] = "5e85dc4b3a5ff939377d3cb0dfa185e6ab9c9186b8b93a9205624815ae58f401"

URI_x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-insecure-credentials-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel.sha256sum] = "e262f988ed9b2e1da8daa60328955a4facf8567d4963e91a2be601d5c4903014"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-devel.sha256sum] = "0abc3993bb60a894c91a15a50f9567d526cc1f8e2a7f0dea776268f489e26435"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-native-tls-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel.sha256sum] = "7076c83cd227f5278df7e0ae6ca9cdaac2c61581766739cb64a67b4120feae24"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-rust-tls-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel.sha256sum] = "c6a1aabc54a30e41ec8dda634e06e5651a1779a02b50fd7d1a39a10b1f662467"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel.sha256sum] = "ddb9a447f6afbc8f7af1e4db6c9b648a290d3b4e96a4fc93bca92a507c40b691"

URI_x86_64_v2_rust-gix-transport+pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+pin-project-lite-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+pin-project-lite-devel.sha256sum] = "c86dcfc37c6848c8d2f2f080bcd46f2d49235365879543e2fe81ae092f0a431e"

URI_x86_64_v2_rust-gix-transport+reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+reqwest-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+reqwest-devel.sha256sum] = "2fe6cdfa3fdf2415f38e28733b7f8169a6b42a4f62f9ba0543624c91d799ac80"

URI_x86_64_v2_rust-gix-transport+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+serde-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+serde-devel.sha256sum] = "abcc32356580f0df710f69352230fcd509d0199dd421791136bc7ed255e28714"

URI_x86_64_v2_rust-gix-transport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport-devel-0.50.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport-devel}"
SRC_URI[x86_64_v2_rust-gix-transport-devel.sha256sum] = "b7753a9e0be8d968f229628aabf35bdaccad1393ea2c5db48c9a174fcc755db2"

URI_aarch64_rust-gix-transport+async-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-client-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-client-devel}"
SRC_URI[aarch64_rust-gix-transport+async-client-devel.sha256sum] = "b8609d0c15ca782de9a372f6e8905e7ad59eeaa6f375b13b4ccb5396a83951cc"

URI_aarch64_rust-gix-transport+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-std-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-std-devel}"
SRC_URI[aarch64_rust-gix-transport+async-std-devel.sha256sum] = "dd5daea5c0d2635879c1616c3a538e3a7599a736d3e8aa0866f1a873db8f86ff"

URI_aarch64_rust-gix-transport+async-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-trait-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-trait-devel}"
SRC_URI[aarch64_rust-gix-transport+async-trait-devel.sha256sum] = "9eb503e97a9ec27c665925ef57b9aaf7e1e9a812e86aabfd1d3de97ed64a84a6"

URI_aarch64_rust-gix-transport+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+base64-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+base64-devel}"
SRC_URI[aarch64_rust-gix-transport+base64-devel.sha256sum] = "f71047fbb9ab3acc25b3eae82bdbf20084d6639a8bfd51c38142a891b1c73167"

URI_aarch64_rust-gix-transport+blocking-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+blocking-client-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+blocking-client-devel}"
SRC_URI[aarch64_rust-gix-transport+blocking-client-devel.sha256sum] = "37b1facacc0e6ffa04552526f9c182552a2fb860026c40a8d6f72a504b28b789"

URI_aarch64_rust-gix-transport+curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+curl-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+curl-devel}"
SRC_URI[aarch64_rust-gix-transport+curl-devel.sha256sum] = "1bf4cd91412a8a77b0d8e135cb9b984cd550d04a5b904d6c278ee89ae3164be8"

URI_aarch64_rust-gix-transport+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+default-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+default-devel}"
SRC_URI[aarch64_rust-gix-transport+default-devel.sha256sum] = "85a39e1719969cc287dbe060341206439766a0bd36b0a720227103948ce8b132"

URI_aarch64_rust-gix-transport+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+document-features-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+document-features-devel}"
SRC_URI[aarch64_rust-gix-transport+document-features-devel.sha256sum] = "c56dedce60ca6dad11369e3c891eeefe1bb9b07433b8dc68a817daeba059681d"

URI_aarch64_rust-gix-transport+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+futures-io-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+futures-io-devel}"
SRC_URI[aarch64_rust-gix-transport+futures-io-devel.sha256sum] = "c2e438bba4a31850a6043476a643a1fe2e1e201bac747dd6e26b4f2242cd0e17"

URI_aarch64_rust-gix-transport+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+futures-lite-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+futures-lite-devel}"
SRC_URI[aarch64_rust-gix-transport+futures-lite-devel.sha256sum] = "e3b04e82930de72098a65a0b9e020cb4fc2a4da574c073c9ad4dffaee7f93269"

URI_aarch64_rust-gix-transport+gix-credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+gix-credentials-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+gix-credentials-devel}"
SRC_URI[aarch64_rust-gix-transport+gix-credentials-devel.sha256sum] = "c507be749c85daf2ebc9cda96a4ad9ee8d85eb75c82e0550327da7f9fe14a9e6"

URI_aarch64_rust-gix-transport+http-client-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-curl-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+http-client-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-curl-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-curl-devel.sha256sum] = "4868e6cc27d4644a97adcf94e0b530f92fbc592884eb8b6bc0ea39e3fe8b32b8"

URI_aarch64_rust-gix-transport+http-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+http-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-devel.sha256sum] = "4c782d7eab07db7f2d27e195c53a5c0132d7b5a68629c319b4ebcf2a1713d068"

URI_aarch64_rust-gix-transport+http-client-insecure-credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-insecure-credentials-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+http-client-insecure-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-insecure-credentials-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-insecure-credentials-devel.sha256sum] = "2590cfd8d2f9ccc508527cb1a37a93857f4bfb9df7321ab4ff5985d55b62c47a"

URI_aarch64_rust-gix-transport+http-client-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-devel.sha256sum] = "54422c213bcff3e6e3c7fff1963d0163182ca201f2f05ee4a779da4f5c690d40"

URI_aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-native-tls-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel.sha256sum] = "a341b8ad0d84caf294afae56e071869f25b7c029012b3810a509817d95c619a5"

URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-rust-tls-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel.sha256sum] = "5462fe0497baa067f4f8877a9a94ec7b719a47519577e86eb2e34325a2621ec3"

URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel.sha256sum] = "d544886a33a47276aa75d9a2980fa74359e114fbfde87493fa0aff9a97709bb3"

URI_aarch64_rust-gix-transport+pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+pin-project-lite-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+pin-project-lite-devel}"
SRC_URI[aarch64_rust-gix-transport+pin-project-lite-devel.sha256sum] = "9fecbc17596799962869c727bc4752311ea18c6d948cce4d536dd7f6e63693be"

URI_aarch64_rust-gix-transport+reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+reqwest-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+reqwest-devel}"
SRC_URI[aarch64_rust-gix-transport+reqwest-devel.sha256sum] = "656157ec0c52a0c4f4a0eea3aafe2a73686f4a7a6e82f5d2093788530006e8e2"

URI_aarch64_rust-gix-transport+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+serde-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+serde-devel}"
SRC_URI[aarch64_rust-gix-transport+serde-devel.sha256sum] = "c94313ee11f2bb9b95b453a182285ff27f09672c824eeef789eba9d8c1d9572c"

URI_aarch64_rust-gix-transport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport-devel-0.50.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-transport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport-devel}"
SRC_URI[aarch64_rust-gix-transport-devel.sha256sum] = "de5b7167ea302358800ec39a51f6dc69e58913a54c9c735d5ec3a63ae25d70dc"

RDEPENDS:rust-gix-transport+async-client-devel = " \
 cargo \
 rust-gix-packetline+async-io-devel \
 rust-gix-transport+async-trait-devel \
 rust-gix-transport+futures-io-devel \
 rust-gix-transport+futures-lite-devel \
 rust-gix-transport+pin-project-lite-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+async-trait-devel = " \
 cargo \
 rust-async-trait+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+blocking-client-devel = " \
 cargo \
 rust-gix-packetline+blocking-io-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+curl-devel = " \
 cargo \
 rust-curl+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+default-devel = " \
 cargo \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+gix-credentials-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-curl-devel = " \
 cargo \
 rust-gix-transport+curl-devel \
 rust-gix-transport+http-client-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-devel = " \
 cargo \
 rust-gix-features+io-pipe-devel \
 rust-gix-transport+base64-devel \
 rust-gix-transport+blocking-client-devel \
 rust-gix-transport+gix-credentials-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-insecure-credentials-devel = " \
 cargo \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-devel = " \
 cargo \
 rust-gix-transport+http-client-devel \
 rust-gix-transport+reqwest-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-native-tls-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest0.12+blocking-devel \
 rust-reqwest0.12+charset-devel \
 rust-reqwest0.12+default-tls-devel \
 rust-reqwest0.12+http2-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-rust-tls-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest0.12+blocking-devel \
 rust-reqwest0.12+charset-devel \
 rust-reqwest0.12+http2-devel \
 rust-reqwest0.12+rustls-tls-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest0.12+blocking-devel \
 rust-reqwest0.12+charset-devel \
 rust-reqwest0.12+http2-devel \
 rust-reqwest0.12+rustls-tls-devel \
 rust-reqwest0.12+trust-dns-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-gix-transport+pin-project-lite-devel = " \
 cargo \
 rust-gix-transport-devel \
 rust-pin-project-lite+default-devel \
 "
RDEPENDS:rust-gix-transport+reqwest-devel = " \
 cargo \
 rust-gix-transport-devel \
 rust-reqwest0.12+blocking-devel \
 rust-reqwest0.12+charset-devel \
 rust-reqwest0.12+http2-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-gix-transport+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-transport-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-transport-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-command+default-devel \
 rust-gix-features+default-devel \
 rust-gix-packetline+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-sec+default-devel \
 rust-gix-url+default-devel \
 rust-thiserror+default-devel \
 "
