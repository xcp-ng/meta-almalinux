# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-kafka"
PV = "2.2.10"
PR = "1.el10_1"
PACKAGES = " \
 python-kafka-doc \
 python3-kafka \
 python3-kafka+lz4 \
 python3-kafka+snappy \
 python3-kafka+zstd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-kafka-2.2.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8599e3aaff040fca303eb46dee96b0429bf61fe314c8888fc7b92736900bcfe0"

URI_x86_64_v2_python-kafka-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-kafka-doc-2.2.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-kafka-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-kafka-doc}"
SRC_URI[x86_64_v2_python-kafka-doc.sha256sum] = "155f643d1a10d1df69bdf519a9df19cdd2472b48205a4a6b09487d0e45424a0f"

URI_x86_64_v2_python3-kafka = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kafka-2.2.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kafka}"
SRC_URI[x86_64_v2_python3-kafka.sha256sum] = "c197f77d45c072919ca560d708b313041b9b0533ab92c902094ec0eda0289f59"

URI_x86_64_v2_python3-kafka+lz4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kafka+lz4-2.2.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kafka+lz4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kafka+lz4}"
SRC_URI[x86_64_v2_python3-kafka+lz4.sha256sum] = "4c94d9c4a279d630a0cf1d52d07385178fb1a02667de0d15ac391bf2eb6aacb0"

URI_x86_64_v2_python3-kafka+snappy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kafka+snappy-2.2.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kafka+snappy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kafka+snappy}"
SRC_URI[x86_64_v2_python3-kafka+snappy.sha256sum] = "c1ff10957164fdae5233acec359fe4493f1fe1ced077d37b6a3671732d363d12"

URI_x86_64_v2_python3-kafka+zstd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kafka+zstd-2.2.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kafka+zstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kafka+zstd}"
SRC_URI[x86_64_v2_python3-kafka+zstd.sha256sum] = "9f91038f6ce7368aab31988708eff8025a1558f999ad60291f823c16db3343c7"

URI_aarch64_python-kafka-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-kafka-doc-2.2.10-1.el10_1.noarch.rpm;name=aarch64_python-kafka-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-kafka-doc}"
SRC_URI[aarch64_python-kafka-doc.sha256sum] = "7a399dbb7dd81b42b54d28f4f3251847560a74d654419eb4e824ee590e4c0720"

URI_aarch64_python3-kafka = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kafka-2.2.10-1.el10_1.noarch.rpm;name=aarch64_python3-kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kafka}"
SRC_URI[aarch64_python3-kafka.sha256sum] = "7e2710c679304b10d19f1126674aa8a016285c99a8b5c1aca4dc8f06b4713a0b"

URI_aarch64_python3-kafka+lz4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kafka+lz4-2.2.10-1.el10_1.noarch.rpm;name=aarch64_python3-kafka+lz4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kafka+lz4}"
SRC_URI[aarch64_python3-kafka+lz4.sha256sum] = "1298d6e7916a203ac9c1a5cbca8693ffc37e371000755b31b62bcbf622ee4474"

URI_aarch64_python3-kafka+snappy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kafka+snappy-2.2.10-1.el10_1.noarch.rpm;name=aarch64_python3-kafka+snappy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kafka+snappy}"
SRC_URI[aarch64_python3-kafka+snappy.sha256sum] = "51c35eb084357533b2e688126c6bc83821f3e94280bc48fa03025049fd78af15"

URI_aarch64_python3-kafka+zstd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kafka+zstd-2.2.10-1.el10_1.noarch.rpm;name=aarch64_python3-kafka+zstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kafka+zstd}"
SRC_URI[aarch64_python3-kafka+zstd.sha256sum] = "9ee499f7e73409138bdeae1e635d33a5dd6ab8f6f66bbd496a4854b88fe1393c"

RDEPENDS:python-kafka-doc = " \
 "
RDEPENDS:python3-kafka = " \
 python3 \
 "
RDEPENDS:python3-kafka+lz4 = " \
 python3 \
 python3-kafka \
 python3-lz4 \
 "
RDEPENDS:python3-kafka+snappy = " \
 python3 \
 python3-kafka \
 python3-snappy \
 "
RDEPENDS:python3-kafka+zstd = " \
 python3-kafka \
 python3-zstandard \
 "
