# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde-json-core"
PV = "0.6.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-serde-json-core+custom-error-messages-devel \
 rust-serde-json-core+default-devel \
 rust-serde-json-core+heapless-devel \
 rust-serde-json-core+std-devel \
 rust-serde-json-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde-json-core-0.6.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d185ba74c3f470b7dcd3977c2691f48941b768737648194e51e0fd5029effe3"

URI_x86_64_v2_rust-serde-json-core+custom-error-messages-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-json-core+custom-error-messages-devel-0.6.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-json-core+custom-error-messages-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-json-core+custom-error-messages-devel}"
SRC_URI[x86_64_v2_rust-serde-json-core+custom-error-messages-devel.sha256sum] = "c20034dca817247f25495b26c77264e475c0a0364de53e10c133deb6af8a843d"

URI_x86_64_v2_rust-serde-json-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-json-core+default-devel-0.6.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-json-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-json-core+default-devel}"
SRC_URI[x86_64_v2_rust-serde-json-core+default-devel.sha256sum] = "b4ff0b67a98dc93247f7acd4129572e50c19b8512d806094c25154878fc3431c"

URI_x86_64_v2_rust-serde-json-core+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-json-core+heapless-devel-0.6.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-json-core+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-json-core+heapless-devel}"
SRC_URI[x86_64_v2_rust-serde-json-core+heapless-devel.sha256sum] = "8f2f05fb223ac25456db35b9d8c07e30de8512e786db1a546621b92274650f15"

URI_x86_64_v2_rust-serde-json-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-json-core+std-devel-0.6.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-json-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-json-core+std-devel}"
SRC_URI[x86_64_v2_rust-serde-json-core+std-devel.sha256sum] = "2fb437091ba268fd470c7e5cb1828aa10213e258b42f4e4e662b68bfe7f4c216"

URI_x86_64_v2_rust-serde-json-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-json-core-devel-0.6.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-json-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-json-core-devel}"
SRC_URI[x86_64_v2_rust-serde-json-core-devel.sha256sum] = "518481d8f51d71aba348474455cff145f883fe3bfd3f091b8a2508363583d488"

URI_aarch64_rust-serde-json-core+custom-error-messages-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-json-core+custom-error-messages-devel-0.6.0-2.el10_2.noarch.rpm;name=aarch64_rust-serde-json-core+custom-error-messages-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-json-core+custom-error-messages-devel}"
SRC_URI[aarch64_rust-serde-json-core+custom-error-messages-devel.sha256sum] = "612410618c557665b977c7605dec1f02e5e47f3826ff9db723f931d0834b2b0b"

URI_aarch64_rust-serde-json-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-json-core+default-devel-0.6.0-2.el10_2.noarch.rpm;name=aarch64_rust-serde-json-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-json-core+default-devel}"
SRC_URI[aarch64_rust-serde-json-core+default-devel.sha256sum] = "522ccae8ba92bfaf6db488d4b95a1cea19db6f232dce87081813e2d364b1f93f"

URI_aarch64_rust-serde-json-core+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-json-core+heapless-devel-0.6.0-2.el10_2.noarch.rpm;name=aarch64_rust-serde-json-core+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-json-core+heapless-devel}"
SRC_URI[aarch64_rust-serde-json-core+heapless-devel.sha256sum] = "3e593eb8ee0d7a9f4a8329da3bcbafc17023b663f277af4e232fe1c857ff33c9"

URI_aarch64_rust-serde-json-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-json-core+std-devel-0.6.0-2.el10_2.noarch.rpm;name=aarch64_rust-serde-json-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-json-core+std-devel}"
SRC_URI[aarch64_rust-serde-json-core+std-devel.sha256sum] = "0068ff900e26caa4663321d626bf895c4076cf68f232ef566cf199857da7fb56"

URI_aarch64_rust-serde-json-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-json-core-devel-0.6.0-2.el10_2.noarch.rpm;name=aarch64_rust-serde-json-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-json-core-devel}"
SRC_URI[aarch64_rust-serde-json-core-devel.sha256sum] = "f1e632b1ac80494abbd7f73a659571aa35d58ddd412665eb63e2d93909b7b854"

RDEPENDS:rust-serde-json-core+custom-error-messages-devel = " \
 cargo \
 rust-serde-json-core+heapless-devel \
 rust-serde-json-core-devel \
 "
RDEPENDS:rust-serde-json-core+default-devel = " \
 cargo \
 rust-serde-json-core+heapless-devel \
 rust-serde-json-core-devel \
 "
RDEPENDS:rust-serde-json-core+heapless-devel = " \
 cargo \
 rust-heapless+default-devel \
 rust-heapless+serde-devel \
 rust-serde-json-core-devel \
 "
RDEPENDS:rust-serde-json-core+std-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde-json-core-devel \
 "
RDEPENDS:rust-serde-json-core-devel = " \
 cargo \
 rust \
 rust-ryu+default-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
