# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailimporter"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 mailimporter \
 mailimporter-akonadi \
 mailimporter-devel \
 mailimporter-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mailimporter-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff965c62160d522cb5f29f2b5a148736a8ea7869e13d56dfa25eee5b8e82fd76"

URI_x86_64_v2_mailimporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter}"
SRC_URI[x86_64_v2_mailimporter.sha256sum] = "33a6f6ad484268dd063c461919714a553c583b1da6306651700b2a1ca60ab146"

URI_x86_64_v2_mailimporter-akonadi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-akonadi-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter-akonadi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-akonadi}"
SRC_URI[x86_64_v2_mailimporter-akonadi.sha256sum] = "e520a602f09e3c76901e77a1d9f89f9d5df0ec7fb8024d58d1a3f1d090d238bd"

URI_x86_64_v2_mailimporter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-devel}"
SRC_URI[x86_64_v2_mailimporter-devel.sha256sum] = "d8ca57da13a9fb7f7ffade00bb8b06eb4f664e807690ebe22f352a7fffa7ba81"

URI_x86_64_v2_mailimporter-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mailimporter-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-doc}"
SRC_URI[x86_64_v2_mailimporter-doc.sha256sum] = "70c673807838405233bb2c6fdd8283b4433abcfc9995849c13db62b842cdd608"

URI_aarch64_mailimporter = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_mailimporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter}"
SRC_URI[aarch64_mailimporter.sha256sum] = "2f4442447b68e53378be21be930d0cc9ec2dab45de4c8c85ef96b773a265f640"

URI_aarch64_mailimporter-akonadi = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-akonadi-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_mailimporter-akonadi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-akonadi}"
SRC_URI[aarch64_mailimporter-akonadi.sha256sum] = "f51089c681ca8419f6414881b0c4c87fdc9df9923cb3e13a1bd72fec45558676"

URI_aarch64_mailimporter-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_mailimporter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-devel}"
SRC_URI[aarch64_mailimporter-devel.sha256sum] = "abe2c1d9849b4765cf14f9c25f2b642d44df672d6299e59ba6b013aaeec6f399"

URI_aarch64_mailimporter-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_mailimporter-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-doc}"
SRC_URI[aarch64_mailimporter-doc.sha256sum] = "08b9ed739711de85562e92ac833ad76267977ceac2d6e82a7db6006677eae6a1"

RDEPENDS:mailimporter = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-ki18n \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailimporter-akonadi = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kmime \
 libgcc \
 libstdc++ \
 mailimporter \
 qt6-qtbase \
 "
RDEPENDS:mailimporter-devel = " \
 cmake-filesystem \
 kf6-karchive-devel \
 mailimporter \
 mailimporter-akonadi \
 "
RDEPENDS:mailimporter-doc = " \
 "
