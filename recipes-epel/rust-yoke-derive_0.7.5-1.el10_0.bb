# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yoke-derive"
PV = "0.7.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-yoke-derive+default-devel \
 rust-yoke-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yoke-derive-0.7.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d87c1dc70d5c26eb111686246594356cafe5c61ea25369aa7a85ad4eb9244f0a"

URI_x86_64_v2_rust-yoke-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-derive+default-devel-0.7.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-derive+default-devel}"
SRC_URI[x86_64_v2_rust-yoke-derive+default-devel.sha256sum] = "ea16a17d875635186a7111825feca3e97572ff3c2ddf735372fe650504771382"

URI_x86_64_v2_rust-yoke-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-derive-devel-0.7.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-derive-devel}"
SRC_URI[x86_64_v2_rust-yoke-derive-devel.sha256sum] = "68582e27a146ccf4cc5b304f36f867324358efbe53294febcea700beb1aa0bbb"

URI_aarch64_rust-yoke-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-derive+default-devel-0.7.5-1.el10_0.noarch.rpm;name=aarch64_rust-yoke-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-derive+default-devel}"
SRC_URI[aarch64_rust-yoke-derive+default-devel.sha256sum] = "e5108e8f9ae8825da9fedf13b32f20f22bbdc5c0ef1398a7c210d42dd374daf6"

URI_aarch64_rust-yoke-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-derive-devel-0.7.5-1.el10_0.noarch.rpm;name=aarch64_rust-yoke-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-derive-devel}"
SRC_URI[aarch64_rust-yoke-derive-devel.sha256sum] = "20ce89c7bf1744a358c11601ff22c5650f5d5a2dc16c9b8b38b4960423fb31fa"

RDEPENDS:rust-yoke-derive+default-devel = " \
 cargo \
 rust-yoke-derive-devel \
 "
RDEPENDS:rust-yoke-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+fold-devel \
 rust-synstructure+default-devel \
 "
