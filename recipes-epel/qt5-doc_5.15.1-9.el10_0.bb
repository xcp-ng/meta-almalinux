# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-doc"
PV = "5.15.1"
PR = "9.el10_0"
PACKAGES = " \
 qt5-doc \
 qt5-qt3d-doc \
 qt5-qtbase-doc \
 qt5-qtcharts-doc \
 qt5-qtconnectivity-doc \
 qt5-qtdatavis3d-doc \
 qt5-qtdeclarative-doc \
 qt5-qtgamepad-doc \
 qt5-qtgraphicaleffects-doc \
 qt5-qtimageformats-doc \
 qt5-qtlocation-doc \
 qt5-qtmultimedia-doc \
 qt5-qtpurchasing-doc \
 qt5-qtquickcontrols-doc \
 qt5-qtquickcontrols2-doc \
 qt5-qtremoteobjects-doc \
 qt5-qtscript-doc \
 qt5-qtscxml-doc \
 qt5-qtsensors-doc \
 qt5-qtserialbus-doc \
 qt5-qtserialport-doc \
 qt5-qtspeech-doc \
 qt5-qtsvg-doc \
 qt5-qttools-doc \
 qt5-qtvirtualkeyboard-doc \
 qt5-qtwayland-doc \
 qt5-qtwebchannel-doc \
 qt5-qtwebsockets-doc \
 qt5-qtwebview-doc \
 qt5-qtx11extras-doc \
 qt5-qtxmlpatterns-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-doc-5.15.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcbcacc0616360f5be1178a168c601f2962c6e597e7ee7234b33d950ce5c3b9c"

URI_x86_64_v2_qt5-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-doc}"
SRC_URI[x86_64_v2_qt5-doc.sha256sum] = "1f5681c91bfa4184c5398326bb832093ff57f2a03cb0abc20df44265c9a59ec2"

URI_x86_64_v2_qt5-qt3d-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qt3d-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d-doc}"
SRC_URI[x86_64_v2_qt5-qt3d-doc.sha256sum] = "4c10ed02e70d3a973eb9dfe9cc3b6bfa9a9ea8752c99e986d4fc263fe27c83c4"

URI_x86_64_v2_qt5-qtbase-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtbase-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-doc}"
SRC_URI[x86_64_v2_qt5-qtbase-doc.sha256sum] = "869bb000d9127b2315dfb5256b5749b3a88a0de5e05e72254724e262d39fa18d"

URI_x86_64_v2_qt5-qtcharts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtcharts-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtcharts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtcharts-doc}"
SRC_URI[x86_64_v2_qt5-qtcharts-doc.sha256sum] = "3508765e1a4543e69da9469feb7d6adbe0890c20f99851eccee5c399267f1168"

URI_x86_64_v2_qt5-qtconnectivity-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtconnectivity-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity-doc}"
SRC_URI[x86_64_v2_qt5-qtconnectivity-doc.sha256sum] = "92e062730f11241a060e9a5297266fc20ebb4bfdc8340f472808665d7787d3aa"

URI_x86_64_v2_qt5-qtdatavis3d-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtdatavis3d-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d-doc}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d-doc.sha256sum] = "5334f39296282502a8240df4dadfae6319bee1f1c0a81f76371f4084d58eca98"

URI_x86_64_v2_qt5-qtdeclarative-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-doc}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-doc.sha256sum] = "cefffee193e6c8a109cc8b3bd7aa4baba05b9b00ae8b5083932f170e0c65cf7c"

URI_x86_64_v2_qt5-qtgamepad-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtgamepad-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad-doc}"
SRC_URI[x86_64_v2_qt5-qtgamepad-doc.sha256sum] = "7c82af79121537c79d1bd53e4a479609109c810ce3af41619bd8f6e39ba71aed"

URI_x86_64_v2_qt5-qtgraphicaleffects-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgraphicaleffects-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtgraphicaleffects-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgraphicaleffects-doc}"
SRC_URI[x86_64_v2_qt5-qtgraphicaleffects-doc.sha256sum] = "22968d74b7dae15f5961d8d0e0eb5c29081b3741711b5cdb2efb8068b0c77eab"

URI_x86_64_v2_qt5-qtimageformats-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtimageformats-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtimageformats-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtimageformats-doc}"
SRC_URI[x86_64_v2_qt5-qtimageformats-doc.sha256sum] = "fffb6f40e3b9f9f7d0998feb1f2223f48f6e9fe53a7fe4f7baed270eea3adf14"

URI_x86_64_v2_qt5-qtlocation-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtlocation-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation-doc}"
SRC_URI[x86_64_v2_qt5-qtlocation-doc.sha256sum] = "f1f2803be1d637a155fd625c56923e71f1c1454d695dcb9068d6ab275fe8425d"

URI_x86_64_v2_qt5-qtmultimedia-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtmultimedia-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtmultimedia-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtmultimedia-doc}"
SRC_URI[x86_64_v2_qt5-qtmultimedia-doc.sha256sum] = "154a53a07e0bebe52a83f97e6926ea67549c6743d56da5b69226b4cb50a1ff20"

URI_x86_64_v2_qt5-qtpurchasing-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtpurchasing-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtpurchasing-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtpurchasing-doc}"
SRC_URI[x86_64_v2_qt5-qtpurchasing-doc.sha256sum] = "cdac27c2259bde6556650f248a9a3c94c1987626aea7bc3ac03aeeca321032b0"

URI_x86_64_v2_qt5-qtquickcontrols-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtquickcontrols-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols-doc}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols-doc.sha256sum] = "549ad1a4416baab8c309b4b2824a5beaeefb035428bd79372e9d7cade96ab6c5"

URI_x86_64_v2_qt5-qtquickcontrols2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtquickcontrols2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2-doc}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2-doc.sha256sum] = "47c55066b7dfaddc35009fe2aa017204f4b14d1bd860fbffa441fa272b2e725f"

URI_x86_64_v2_qt5-qtremoteobjects-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtremoteobjects-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects-doc}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects-doc.sha256sum] = "c5797939dc5d0222a838ab402ff61dafb87a16efd2287c06f307bc38eb829eb3"

URI_x86_64_v2_qt5-qtscript-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscript-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtscript-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscript-doc}"
SRC_URI[x86_64_v2_qt5-qtscript-doc.sha256sum] = "eec5d8a5ae971027c32dae07c7ecd84b455f976d1b035aae58f04406510f7a44"

URI_x86_64_v2_qt5-qtscxml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscxml-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtscxml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscxml-doc}"
SRC_URI[x86_64_v2_qt5-qtscxml-doc.sha256sum] = "0413546233505f0ac6c548da47f8efb1a414a022b743d169c9e58462a5f0836b"

URI_x86_64_v2_qt5-qtsensors-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtsensors-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors-doc}"
SRC_URI[x86_64_v2_qt5-qtsensors-doc.sha256sum] = "1cf880cd9b4de9697958e0b0f2750b68c111434abdefe6e9b00a973499e8bb68"

URI_x86_64_v2_qt5-qtserialbus-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtserialbus-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus-doc}"
SRC_URI[x86_64_v2_qt5-qtserialbus-doc.sha256sum] = "544f497db38eb859a442635803ef51f2c7f503b97fd7ee3324b5f742fe6c6fc0"

URI_x86_64_v2_qt5-qtserialport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtserialport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport-doc}"
SRC_URI[x86_64_v2_qt5-qtserialport-doc.sha256sum] = "6f0cba1b6c769b4b98e5c14a33dee1e49b754eebee8b473a61a31570eb4c60eb"

URI_x86_64_v2_qt5-qtspeech-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtspeech-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtspeech-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtspeech-doc}"
SRC_URI[x86_64_v2_qt5-qtspeech-doc.sha256sum] = "4b52174ae25af1302aa11def392883692f3d13b3f5030877c18c83327067e227"

URI_x86_64_v2_qt5-qtsvg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsvg-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtsvg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsvg-doc}"
SRC_URI[x86_64_v2_qt5-qtsvg-doc.sha256sum] = "febadb4a6fe304bb8203162af3bed6cf01957245ffbaf7ef53916afa119ef36a"

URI_x86_64_v2_qt5-qttools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qttools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qttools-doc}"
SRC_URI[x86_64_v2_qt5-qttools-doc.sha256sum] = "f47d198e433fdd37e54d9298b29ace2154b9c0caa65ea3a8813cb16d2e555708"

URI_x86_64_v2_qt5-qtvirtualkeyboard-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard-doc}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard-doc.sha256sum] = "9e58c4788ec0e0bf83d42d17523d7a1097a8258028f28cbb570e2abb0b98cc82"

URI_x86_64_v2_qt5-qtwayland-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtwayland-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland-doc}"
SRC_URI[x86_64_v2_qt5-qtwayland-doc.sha256sum] = "78df1dd2302493306f702a262a21180f47319d519d5eb6b6778f3d52ea80ae67"

URI_x86_64_v2_qt5-qtwebchannel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebchannel-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtwebchannel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebchannel-doc}"
SRC_URI[x86_64_v2_qt5-qtwebchannel-doc.sha256sum] = "b8be9f77fc37c7add4f7abd1d79c1e14af78fbdcf60635c03399eccf65ce5af6"

URI_x86_64_v2_qt5-qtwebsockets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtwebsockets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets-doc}"
SRC_URI[x86_64_v2_qt5-qtwebsockets-doc.sha256sum] = "433019971e079a8ab4ea660079b67b602e30424344964c44064904142fc23e32"

URI_x86_64_v2_qt5-qtwebview-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebview-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtwebview-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebview-doc}"
SRC_URI[x86_64_v2_qt5-qtwebview-doc.sha256sum] = "041773d54cd42abade991b59d9864d27dc536bd1462710b3c921d2a9736dbfef"

URI_x86_64_v2_qt5-qtx11extras-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtx11extras-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtx11extras-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtx11extras-doc}"
SRC_URI[x86_64_v2_qt5-qtx11extras-doc.sha256sum] = "b9086ee2ae9a6eb9572421790d311e2f1c6d16eb53d1d38efc6b46737402ff53"

URI_x86_64_v2_qt5-qtxmlpatterns-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-doc-5.15.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtxmlpatterns-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns-doc}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns-doc.sha256sum] = "e26e6e7b5cb0de0710337c05cedc39c69375e72fd8a4fc182afc6a4626414db9"

URI_aarch64_qt5-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-doc}"
SRC_URI[aarch64_qt5-doc.sha256sum] = "6aa8e8f686f6217b20d6491681247d7deccd5e151d6ab368e6593dee0dadb0ef"

URI_aarch64_qt5-qt3d-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qt3d-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d-doc}"
SRC_URI[aarch64_qt5-qt3d-doc.sha256sum] = "3e9bf9648fddad07163b3d18922a803badda924797f05420ff043ac8a8badc30"

URI_aarch64_qt5-qtbase-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtbase-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-doc}"
SRC_URI[aarch64_qt5-qtbase-doc.sha256sum] = "abc812e47897ee8f07ddba98514e79ac111501ff381bc8d11ef8f66913fe3595"

URI_aarch64_qt5-qtcharts-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtcharts-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtcharts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtcharts-doc}"
SRC_URI[aarch64_qt5-qtcharts-doc.sha256sum] = "c8d383920843ee4fbfcc5882269d4432ede6d1a0334c69f22198ccb5b6b53589"

URI_aarch64_qt5-qtconnectivity-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtconnectivity-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity-doc}"
SRC_URI[aarch64_qt5-qtconnectivity-doc.sha256sum] = "2094ae2a550924e9aaa88a9716c482193d9a06b4562ec7232e23dbd81db940f0"

URI_aarch64_qt5-qtdatavis3d-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtdatavis3d-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d-doc}"
SRC_URI[aarch64_qt5-qtdatavis3d-doc.sha256sum] = "7ffbddb51e804f024e73f5dbf8f36b03dafee5aef12ec65ad37df07ddb65f0cd"

URI_aarch64_qt5-qtdeclarative-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-doc}"
SRC_URI[aarch64_qt5-qtdeclarative-doc.sha256sum] = "2ec68fd6c8697eb43d65e043fcc092782d5839cb5668df38d64667190f1821c0"

URI_aarch64_qt5-qtgamepad-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtgamepad-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad-doc}"
SRC_URI[aarch64_qt5-qtgamepad-doc.sha256sum] = "65ab8600f9a09734ce9fc8c01692481a6481bec677dd9ac8986b0da9b0b2de29"

URI_aarch64_qt5-qtgraphicaleffects-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgraphicaleffects-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtgraphicaleffects-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgraphicaleffects-doc}"
SRC_URI[aarch64_qt5-qtgraphicaleffects-doc.sha256sum] = "cad244a580c6c6dd1a72e50bc16021b3b08f8769fee62ee5800472ee03dfbc8c"

URI_aarch64_qt5-qtimageformats-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtimageformats-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtimageformats-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtimageformats-doc}"
SRC_URI[aarch64_qt5-qtimageformats-doc.sha256sum] = "13f7f053607c8e1e194d6730330e432fc5ee8fd29d034d9b4601fa295fc2ea94"

URI_aarch64_qt5-qtlocation-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtlocation-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation-doc}"
SRC_URI[aarch64_qt5-qtlocation-doc.sha256sum] = "addd462dd167c1e997a1c41926c91a870c0070b4c89c11a5720851ec47adeeb5"

URI_aarch64_qt5-qtmultimedia-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtmultimedia-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtmultimedia-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtmultimedia-doc}"
SRC_URI[aarch64_qt5-qtmultimedia-doc.sha256sum] = "3fd12d47d5586aba05bf768f64db74bdbb3b0f5d54e7e2b80d01857ea47e3700"

URI_aarch64_qt5-qtpurchasing-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtpurchasing-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtpurchasing-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtpurchasing-doc}"
SRC_URI[aarch64_qt5-qtpurchasing-doc.sha256sum] = "8030487d5d1419ed4f267b511e3ed03860fded64a60303aab66fd38eeef7ab7f"

URI_aarch64_qt5-qtquickcontrols-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtquickcontrols-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols-doc}"
SRC_URI[aarch64_qt5-qtquickcontrols-doc.sha256sum] = "877beae32bba16069409d04be8e78fd8413fb16a4f5ec5ef82580f1e7f1df4b1"

URI_aarch64_qt5-qtquickcontrols2-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtquickcontrols2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2-doc}"
SRC_URI[aarch64_qt5-qtquickcontrols2-doc.sha256sum] = "78ace3a7da242a85550e6b5a7b21ddc756cf2523a635211a7e4c7bc4eb8c5d16"

URI_aarch64_qt5-qtremoteobjects-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtremoteobjects-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects-doc}"
SRC_URI[aarch64_qt5-qtremoteobjects-doc.sha256sum] = "73129a500884ff930ac6fc4d92319d37046961f8ba40a044fb7ba11d00d0b9e4"

URI_aarch64_qt5-qtscript-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscript-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtscript-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscript-doc}"
SRC_URI[aarch64_qt5-qtscript-doc.sha256sum] = "38d7063ebd980bb8efca02c3075074878c9c49723292eea4f1e7c8280757a993"

URI_aarch64_qt5-qtscxml-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscxml-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtscxml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscxml-doc}"
SRC_URI[aarch64_qt5-qtscxml-doc.sha256sum] = "941ce314c07ac289a09525b63277c415d73d8e912115ba80c433aa463f228ce3"

URI_aarch64_qt5-qtsensors-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtsensors-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors-doc}"
SRC_URI[aarch64_qt5-qtsensors-doc.sha256sum] = "b4d169c286e67d7ab28651e7a82bea9678741e3e78f7f8612b24370d8eb563c4"

URI_aarch64_qt5-qtserialbus-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtserialbus-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus-doc}"
SRC_URI[aarch64_qt5-qtserialbus-doc.sha256sum] = "0eabe03e6b4ba156018788f8405e6a036a54dd91393544a6b4af17385bebbba5"

URI_aarch64_qt5-qtserialport-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtserialport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport-doc}"
SRC_URI[aarch64_qt5-qtserialport-doc.sha256sum] = "10fa7da5644f42294e74426af2e802defd1cb106d06404690e8d97eb9b05c2e5"

URI_aarch64_qt5-qtspeech-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtspeech-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtspeech-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtspeech-doc}"
SRC_URI[aarch64_qt5-qtspeech-doc.sha256sum] = "0ac318d044420dcf9b8e80c9832a932d1b23ddc958502f85a6220a90ff265a3a"

URI_aarch64_qt5-qtsvg-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsvg-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtsvg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsvg-doc}"
SRC_URI[aarch64_qt5-qtsvg-doc.sha256sum] = "97a17b4ce6f8bb7831a475acb5f16b0db63d93f7056865ad9b43e45b440c4fd7"

URI_aarch64_qt5-qttools-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qttools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qttools-doc}"
SRC_URI[aarch64_qt5-qttools-doc.sha256sum] = "4d48126ce59d864f312b9cb475d6e6c72a815799f663cf4acdc9fff040b4bf01"

URI_aarch64_qt5-qtvirtualkeyboard-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtvirtualkeyboard-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard-doc}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard-doc.sha256sum] = "0510d7db3271081e2ec52d90c1c4e59d74e8e6744f8bda4e7231a42ea36977bc"

URI_aarch64_qt5-qtwayland-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtwayland-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland-doc}"
SRC_URI[aarch64_qt5-qtwayland-doc.sha256sum] = "216a656fcaae21aae1bec793597a62fc42f4d9c376f067e8758e4caf15be5c33"

URI_aarch64_qt5-qtwebchannel-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebchannel-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtwebchannel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebchannel-doc}"
SRC_URI[aarch64_qt5-qtwebchannel-doc.sha256sum] = "81642824bc2a0b04caaf74f7804952aa069fc96d5d9fa36abcb90f1b0d8e442c"

URI_aarch64_qt5-qtwebsockets-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtwebsockets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets-doc}"
SRC_URI[aarch64_qt5-qtwebsockets-doc.sha256sum] = "5b9c56ddd486c3dc7422ffd742ddbb05e19033cea0bc75df8e4f6f1e08f4d2b7"

URI_aarch64_qt5-qtwebview-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebview-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtwebview-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebview-doc}"
SRC_URI[aarch64_qt5-qtwebview-doc.sha256sum] = "cc7df811cae3c55a639f01f76b9bf3d8ad837a7fa16f0bc1d8bdc295ff187dc4"

URI_aarch64_qt5-qtx11extras-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtx11extras-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtx11extras-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtx11extras-doc}"
SRC_URI[aarch64_qt5-qtx11extras-doc.sha256sum] = "f680088b4f3ce1a05bfb2c59e5f6611a3425e3fb7553309ef777797a88c4ece7"

URI_aarch64_qt5-qtxmlpatterns-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-doc-5.15.1-9.el10_0.noarch.rpm;name=aarch64_qt5-qtxmlpatterns-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns-doc}"
SRC_URI[aarch64_qt5-qtxmlpatterns-doc.sha256sum] = "6db0ee1b1f51c4a6072e3b24188452b70b25e6bb76270a8884b8dd51559c6f0f"

RDEPENDS:qt5-doc = " \
 qt5-qt3d-doc \
 qt5-qtbase-doc \
 qt5-qtcharts-doc \
 qt5-qtconnectivity-doc \
 qt5-qtdatavis3d-doc \
 qt5-qtdeclarative-doc \
 qt5-qtgamepad-doc \
 qt5-qtgraphicaleffects-doc \
 qt5-qtimageformats-doc \
 qt5-qtlocation-doc \
 qt5-qtmultimedia-doc \
 qt5-qtpurchasing-doc \
 qt5-qtquickcontrols-doc \
 qt5-qtquickcontrols2-doc \
 qt5-qtremoteobjects-doc \
 qt5-qtscript-doc \
 qt5-qtscxml-doc \
 qt5-qtsensors-doc \
 qt5-qtserialbus-doc \
 qt5-qtserialport-doc \
 qt5-qtspeech-doc \
 qt5-qtsvg-doc \
 qt5-qttools-doc \
 qt5-qtvirtualkeyboard-doc \
 qt5-qtwayland-doc \
 qt5-qtwebchannel-doc \
 qt5-qtwebsockets-doc \
 qt5-qtwebview-doc \
 qt5-qtx11extras-doc \
 qt5-qtxmlpatterns-doc \
 "
RDEPENDS:qt5-qt3d-doc = " \
 "
RDEPENDS:qt5-qtbase-doc = " \
 "
RDEPENDS:qt5-qtcharts-doc = " \
 "
RDEPENDS:qt5-qtconnectivity-doc = " \
 "
RDEPENDS:qt5-qtdatavis3d-doc = " \
 "
RDEPENDS:qt5-qtdeclarative-doc = " \
 "
RDEPENDS:qt5-qtgamepad-doc = " \
 "
RDEPENDS:qt5-qtgraphicaleffects-doc = " \
 "
RDEPENDS:qt5-qtimageformats-doc = " \
 "
RDEPENDS:qt5-qtlocation-doc = " \
 "
RDEPENDS:qt5-qtmultimedia-doc = " \
 "
RDEPENDS:qt5-qtpurchasing-doc = " \
 "
RDEPENDS:qt5-qtquickcontrols-doc = " \
 "
RDEPENDS:qt5-qtquickcontrols2-doc = " \
 "
RDEPENDS:qt5-qtremoteobjects-doc = " \
 "
RDEPENDS:qt5-qtscript-doc = " \
 "
RDEPENDS:qt5-qtscxml-doc = " \
 "
RDEPENDS:qt5-qtsensors-doc = " \
 "
RDEPENDS:qt5-qtserialbus-doc = " \
 "
RDEPENDS:qt5-qtserialport-doc = " \
 "
RDEPENDS:qt5-qtspeech-doc = " \
 "
RDEPENDS:qt5-qtsvg-doc = " \
 "
RDEPENDS:qt5-qttools-doc = " \
 "
RDEPENDS:qt5-qtvirtualkeyboard-doc = " \
 "
RDEPENDS:qt5-qtwayland-doc = " \
 "
RDEPENDS:qt5-qtwebchannel-doc = " \
 "
RDEPENDS:qt5-qtwebsockets-doc = " \
 "
RDEPENDS:qt5-qtwebview-doc = " \
 "
RDEPENDS:qt5-qtx11extras-doc = " \
 "
RDEPENDS:qt5-qtxmlpatterns-doc = " \
 "
