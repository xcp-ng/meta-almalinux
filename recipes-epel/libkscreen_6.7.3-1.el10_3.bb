# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkscreen"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 libkscreen \
 libkscreen-devel \
 libkscreen-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkscreen-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad0064508d3e61f3413d26d2e0f3e9e850ec461ec62e68d1f139d968dc893e68"

URI_x86_64_v2_libkscreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkscreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen}"
SRC_URI[x86_64_v2_libkscreen.sha256sum] = "f1ba6462989b9ec9ed4c8d599a1bc483614ea7831f56dc3d9f0b391cbb75a9b4"

URI_x86_64_v2_libkscreen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkscreen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen-devel}"
SRC_URI[x86_64_v2_libkscreen-devel.sha256sum] = "a847b2a2e226352c05c756b120eccb230616793e4fe14ed464121bd484185a15"

URI_x86_64_v2_libkscreen-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-doc-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkscreen-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen-doc}"
SRC_URI[x86_64_v2_libkscreen-doc.sha256sum] = "9423c56cddf4c1e0efd94853b3e49f0f43874d99e5a9141446a3d186e622ceac"

URI_aarch64_libkscreen = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_libkscreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen}"
SRC_URI[aarch64_libkscreen.sha256sum] = "5d51c0e96bbfd4a4cc3c0f02e91a6257c0c769ec4f01060fb2d1f84f94038bfb"

URI_aarch64_libkscreen-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_libkscreen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen-devel}"
SRC_URI[aarch64_libkscreen-devel.sha256sum] = "26e810360c7cce77b513bfdb7a5c8e0394be609fd770d9505f1a320b0b4243a5"

URI_aarch64_libkscreen-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-doc-6.7.3-1.el10_3.noarch.rpm;name=aarch64_libkscreen-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen-doc}"
SRC_URI[aarch64_libkscreen-doc.sha256sum] = "9376c29ed2a10c27d9440445381b22cc2e7e39b32d88f9300e36ae3b0ffd45f2"

RDEPENDS:libkscreen = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkscreen-devel = " \
 cmake-filesystem \
 libkscreen \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:libkscreen-doc = " \
 "
