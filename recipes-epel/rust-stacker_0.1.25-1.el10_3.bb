# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stacker"
PV = "0.1.25"
PR = "1.el10_3"
PACKAGES = " \
 rust-stacker+default-devel \
 rust-stacker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stacker-0.1.25-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fcfab57dbbeed54f435ea57d7d211227192028bba60c97e31ea895e63015bcc"

URI_x86_64_v2_rust-stacker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stacker+default-devel-0.1.25-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stacker+default-devel}"
SRC_URI[x86_64_v2_rust-stacker+default-devel.sha256sum] = "46c711ad2deca8d23dfb456e7c0c57b998f7c62f0947e4a9428e79c6113edaf1"

URI_x86_64_v2_rust-stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stacker-devel-0.1.25-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stacker-devel}"
SRC_URI[x86_64_v2_rust-stacker-devel.sha256sum] = "f60597921471a97fcfe697cc395150fdb9221dba9a9151cf3bc1d406ab924775"

URI_aarch64_rust-stacker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stacker+default-devel-0.1.25-1.el10_3.noarch.rpm;name=aarch64_rust-stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stacker+default-devel}"
SRC_URI[aarch64_rust-stacker+default-devel.sha256sum] = "c7d8d82a6c3c91e2d94f1ae82669e5e74d45351088e0f47b061135f4155b2fea"

URI_aarch64_rust-stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stacker-devel-0.1.25-1.el10_3.noarch.rpm;name=aarch64_rust-stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stacker-devel}"
SRC_URI[aarch64_rust-stacker-devel.sha256sum] = "06a11ca33e43f6d4a02d76311830130260ace862f917975ba9653ab25a27e1bc"

RDEPENDS:rust-stacker+default-devel = " \
 cargo \
 rust-stacker-devel \
 "
RDEPENDS:rust-stacker-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-psm+default-devel \
 "
