# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sereal-Encoder"
PV = "5.006"
PR = "1.el10_3"
PACKAGES = " \
 perl-Sereal-Encoder \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Sereal-Encoder-5.006-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "57dbc85c5ed1391266fda97768135d84baf8b695a974dbf16f1337a1ecd8c708"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sereal-Encoder-5.006-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sereal-Encoder;unpack=0"
SRC_URI[x86_64_v2_perl-Sereal-Encoder.sha256sum] = "c7df6cf06ace1e438cf38621121b52d55031ad0dffc8015b403b3ac5cd5606c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Sereal-Encoder-5.006-1.el10_3.aarch64.rpm;name=aarch64_perl-Sereal-Encoder;unpack=0"
SRC_URI[aarch64_perl-Sereal-Encoder.sha256sum] = "6db900e66b70ad89fc15fd5b10a8f5826a9d204a42c98ebd7b374b1611642ba7"

RDEPENDS:perl-Sereal-Encoder = " \
 csnappy \
 glibc \
 libzstd \
 miniz \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
