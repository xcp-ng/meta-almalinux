# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitmaps"
PV = "2.1.0"
PR = "15.el10_0"
PACKAGES = " \
 rust-bitmaps+default-devel \
 rust-bitmaps+std-devel \
 rust-bitmaps-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitmaps-2.1.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a673016790765978dfe9f152107846d08088f9c7cb822deccccead3c9e1abfba"

URI_x86_64_v2_rust-bitmaps+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitmaps+default-devel-2.1.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitmaps+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitmaps+default-devel}"
SRC_URI[x86_64_v2_rust-bitmaps+default-devel.sha256sum] = "d63aab9447718b77a850b6f5a4e84e0d134279c1f8762aead794e5433a1e5f29"

URI_x86_64_v2_rust-bitmaps+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitmaps+std-devel-2.1.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitmaps+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitmaps+std-devel}"
SRC_URI[x86_64_v2_rust-bitmaps+std-devel.sha256sum] = "6a76c4f2f3f10b27a1900895850d9854919890f5c4ff59b3eafb35ec53b149e7"

URI_x86_64_v2_rust-bitmaps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitmaps-devel-2.1.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitmaps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitmaps-devel}"
SRC_URI[x86_64_v2_rust-bitmaps-devel.sha256sum] = "64ec0fef3b8a45affd1108e0228ba81a94479c93ea2ec9c35ded499691753077"

URI_aarch64_rust-bitmaps+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitmaps+default-devel-2.1.0-15.el10_0.noarch.rpm;name=aarch64_rust-bitmaps+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitmaps+default-devel}"
SRC_URI[aarch64_rust-bitmaps+default-devel.sha256sum] = "874fbe8e876461dfc8410011bf0e5b227ae6c37a7234801a42c22afa44e4a508"

URI_aarch64_rust-bitmaps+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitmaps+std-devel-2.1.0-15.el10_0.noarch.rpm;name=aarch64_rust-bitmaps+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitmaps+std-devel}"
SRC_URI[aarch64_rust-bitmaps+std-devel.sha256sum] = "e3d37e8c69f589d5070fe9ca72bd1533874ab7b0e505ac1fb644fd92297c6ac9"

URI_aarch64_rust-bitmaps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitmaps-devel-2.1.0-15.el10_0.noarch.rpm;name=aarch64_rust-bitmaps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitmaps-devel}"
SRC_URI[aarch64_rust-bitmaps-devel.sha256sum] = "7de4c887f094781c9932aa1f70ef675c660319cb4d578040cf1899173cc377c6"

RDEPENDS:rust-bitmaps+default-devel = " \
 cargo \
 rust-bitmaps+std-devel \
 rust-bitmaps-devel \
 "
RDEPENDS:rust-bitmaps+std-devel = " \
 cargo \
 rust-bitmaps-devel \
 "
RDEPENDS:rust-bitmaps-devel = " \
 cargo \
 rust-typenum+default-devel \
 "
