# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-prometheus-client-model"
PV = "0.6.1"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-prometheus-client-model-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-prometheus-client-model-0.6.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eedefca93c15620d69f2a62b21ca4458868555bcb888ff7502f9d24e64cd43b6"

URI_x86_64_v2_golang-github-prometheus-client-model-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-prometheus-client-model-devel-0.6.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-prometheus-client-model-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-prometheus-client-model-devel}"
SRC_URI[x86_64_v2_golang-github-prometheus-client-model-devel.sha256sum] = "83b4bd39c348c931d27fc8b86e6fd21d0625585fc3f15a67809bc7797a5e3956"

URI_aarch64_golang-github-prometheus-client-model-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-prometheus-client-model-devel-0.6.1-2.el10_0.noarch.rpm;name=aarch64_golang-github-prometheus-client-model-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-prometheus-client-model-devel}"
SRC_URI[aarch64_golang-github-prometheus-client-model-devel.sha256sum] = "5708bf4837a04dc47a68376d5ab1f32c3d9a7075752ffbf4e44262d53450175f"

RDEPENDS:golang-github-prometheus-client-model-devel = " \
 go-filesystem \
 golang-google-protobuf-devel \
 "
