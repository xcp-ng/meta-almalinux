# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yasm"
PV = "1.3.0^20250625git121ab15"
PR = "1.el10_0"
PACKAGES = " \
 yasm \
 yasm-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/y/yasm-1.3.0^20250625git121ab15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52387a31a20bd40ee576321afcca76d76fb206c6c967c85d58f23a77a325b5db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yasm-1.3.0^20250625git121ab15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yasm;unpack=0"
SRC_URI[x86_64_v2_yasm.sha256sum] = "a48c6e96f14b8a2fded13274c39516428d2fabb72cb87e2817582cded5977c7f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yasm-devel-1.3.0^20250625git121ab15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yasm-devel;unpack=0"
SRC_URI[x86_64_v2_yasm-devel.sha256sum] = "6f5e4254ab2c3e40c04a310e3b3495a4cf43dfe86d881ac0d291f2ef83427006"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/yasm-1.3.0^20250625git121ab15-1.el10_0.aarch64.rpm;name=aarch64_yasm;unpack=0"
SRC_URI[aarch64_yasm.sha256sum] = "9a074fd333b14dd2066053b900bba164116825e57e8219eed26dcc6204c333d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/yasm-devel-1.3.0^20250625git121ab15-1.el10_0.aarch64.rpm;name=aarch64_yasm-devel;unpack=0"
SRC_URI[aarch64_yasm-devel.sha256sum] = "05ca2bf50ea333a9aa5bd5b1abfbbf45b5add60830330501bd5a889717a4e4b6"

RDEPENDS:yasm = " \
 glibc \
 "
RDEPENDS:yasm-devel = " \
 yasm \
 "
