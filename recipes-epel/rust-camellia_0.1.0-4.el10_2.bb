# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-camellia"
PV = "0.1.0"
PR = "4.el10_2"
PACKAGES = " \
 rust-camellia+default-devel \
 rust-camellia+zeroize-devel \
 rust-camellia-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-camellia-0.1.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b13c8fd894ea43c1c18e61c0fc8805cf7c08461c00efc2b7abaabcb733273fcc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camellia+default-devel-0.1.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camellia+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camellia+default-devel.sha256sum] = "1db0b49d8863df36508849d92a361fd887a98c43b60dd6a541c5552bd1b2accf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camellia+zeroize-devel-0.1.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camellia+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camellia+zeroize-devel.sha256sum] = "69f3d4284d785d77b836c3f7db1ed925349f2a47c1ccb8499cff80aeca4f0d29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camellia-devel-0.1.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camellia-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camellia-devel.sha256sum] = "aa8c2de3d404d4a5c75771afd069f98233a6afaa37ea565db38a501443841e7c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camellia+default-devel-0.1.0-4.el10_2.noarch.rpm;name=aarch64_rust-camellia+default-devel;unpack=0"
SRC_URI[aarch64_rust-camellia+default-devel.sha256sum] = "c9bb4e15923ca4c4792eb11e2442b74eab02ded99118ec67e8ec2a16a8caf46a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camellia+zeroize-devel-0.1.0-4.el10_2.noarch.rpm;name=aarch64_rust-camellia+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-camellia+zeroize-devel.sha256sum] = "107a9ff7a18d918ea2e54035efa5c24eaa5f3d38f908cacf6218648d94064c33"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camellia-devel-0.1.0-4.el10_2.noarch.rpm;name=aarch64_rust-camellia-devel;unpack=0"
SRC_URI[aarch64_rust-camellia-devel.sha256sum] = "701e54dc6ce58569607fad04363906f3c9342695a56c9f2d575a9628d98f6268"

RDEPENDS:rust-camellia+default-devel = " \
 cargo \
 rust-camellia-devel \
 "
RDEPENDS:rust-camellia+zeroize-devel = " \
 cargo \
 rust-camellia-devel \
 rust-cipher0.4+zeroize-devel \
 "
RDEPENDS:rust-camellia-devel = " \
 cargo \
 rust \
 rust-byteorder-devel \
 rust-cipher0.4+default-devel \
 "
