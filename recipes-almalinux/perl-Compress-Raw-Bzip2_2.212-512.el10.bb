# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Compress-Raw-Bzip2"
PV = "2.212"
PR = "512.el10"
PACKAGES = " \
 perl-Compress-Raw-Bzip2 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Compress-Raw-Bzip2-2.212-512.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2cfb5a7d35e403cf2e5a1b054c68110e903b1297ba4f0dc2e90e76f0320211b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Compress-Raw-Bzip2-2.212-512.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Compress-Raw-Bzip2;unpack=0"
SRC_URI[x86_64_v2_perl-Compress-Raw-Bzip2.sha256sum] = "b7c35fd8ec2957fd0c3d20b19ae8584fa3423258284173bb153b32f9ab99a947"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Compress-Raw-Bzip2-2.212-512.el10.aarch64.rpm;name=aarch64_perl-Compress-Raw-Bzip2;unpack=0"
SRC_URI[aarch64_perl-Compress-Raw-Bzip2.sha256sum] = "238aab7156df14aadcabcf46a7c199a3080341f8d8fa787f9855023b85662114"

RDEPENDS:perl-Compress-Raw-Bzip2 = " \
 bzip2-libs \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
