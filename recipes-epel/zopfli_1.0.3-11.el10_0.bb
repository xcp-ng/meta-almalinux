# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zopfli"
PV = "1.0.3"
PR = "11.el10_0"
PACKAGES = " \
 zopfli \
 zopfli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zopfli-1.0.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4869c6086df064435a131356de3f51d7b5d56ed5adde02a932893ec160131da7"

URI_x86_64_v2_zopfli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zopfli-1.0.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zopfli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zopfli}"
SRC_URI[x86_64_v2_zopfli.sha256sum] = "2c9e5b9e94ac0b91258b5534f175535edd0bf392de22fc56e6c7eccc45491539"

URI_x86_64_v2_zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zopfli-devel-1.0.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zopfli-devel}"
SRC_URI[x86_64_v2_zopfli-devel.sha256sum] = "54d9954737982f6747728478f55c9263bfad23b2b30c84843976bae8f69f8a81"

URI_aarch64_zopfli = "${EPEL_MIRROR}/aarch64/Packages/z/zopfli-1.0.3-11.el10_0.aarch64.rpm;name=aarch64_zopfli;unpack=0"
SRC_URI:append = " ${URI_aarch64_zopfli}"
SRC_URI[aarch64_zopfli.sha256sum] = "221297fb8cd4bb8748665e04dd6467d18fd7d83dc6f12c33fa28ed1f139d99ab"

URI_aarch64_zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zopfli-devel-1.0.3-11.el10_0.aarch64.rpm;name=aarch64_zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zopfli-devel}"
SRC_URI[aarch64_zopfli-devel.sha256sum] = "468f2462a28b241cfaa27afe1e825bb8f94535b5f0a44dfd0471802cd4dd8543"

RDEPENDS:zopfli = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:zopfli-devel = " \
 cmake-filesystem \
 zopfli \
 "
