# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "selinux-policy"
PV = "42.1.18"
PR = "4.el10_2.4"
PACKAGES = " \
 selinux-policy \
 selinux-policy-devel \
 selinux-policy-doc \
 selinux-policy-extra \
 selinux-policy-mls \
 selinux-policy-mls-extra \
 selinux-policy-sandbox \
 selinux-policy-targeted \
 selinux-policy-targeted-extra \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/selinux-policy-42.1.18-4.el10_2.4.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5ae454b1022536a80bf972171239f854829a6bcf7f1a2ff9e14324c91193d5fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-42.1.18-4.el10_2.4.noarch.rpm;name=x86_64_v2_selinux-policy;unpack=0"
SRC_URI[x86_64_v2_selinux-policy.sha256sum] = "704421fb936b81fe323cd448c2ea60d86af48ebae4a0f8fab2e6c26da88f2466"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/selinux-policy-devel-42.1.18-4.el10_2.4.noarch.rpm;name=x86_64_v2_selinux-policy-devel;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-devel.sha256sum] = "36936c92ebd1c9488e3748e705260e5939ca2f5803116579e1a22d3c2ed9916d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-doc-42.1.18-4.el10_2.4.noarch.rpm;name=x86_64_v2_selinux-policy-doc;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-doc.sha256sum] = "ea67a7130aad84281f87407acec4e833789a3ad92293fdd68b1475e2de036f19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-extra-42.1.18-4.el10_2.4.noarch.rpm;name=x86_64_v2_selinux-policy-extra;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-extra.sha256sum] = "242f4598aed750a1289b6abbe1e1e7dbd376a842e2946239fc4c0e5265ba2481"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-mls-42.1.18-4.el10_2.4.noarch.rpm;name=x86_64_v2_selinux-policy-mls;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-mls.sha256sum] = "d4c660a4788af1724694de53df6aeae7a527a105112973f6eba99495ac0e5505"
RPROVIDES:selinux-policy-mls:append:x86_64_v2 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.18-4.el10_2.4 virtual/selinux-policy-any_ge_42.1.13 virtual/selinux-policy-any_ge_42.1.18 virtual/selinux-policy-any_ge_42.1.9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-mls-extra-42.1.18-4.el10_2.4.noarch.rpm;name=x86_64_v2_selinux-policy-mls-extra;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-mls-extra.sha256sum] = "75ae6dbb14695b0591c7cf1f72b06703830a4701de410c65799c9b78bc5bf631"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-sandbox-42.1.18-4.el10_2.4.noarch.rpm;name=x86_64_v2_selinux-policy-sandbox;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-sandbox.sha256sum] = "5e5b359c8c511501bd38225b25a0fe747e6d5bdc7a857a7c8cc85296a0ad06ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-targeted-42.1.18-4.el10_2.4.noarch.rpm;name=x86_64_v2_selinux-policy-targeted;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-targeted.sha256sum] = "55c9c5f2d7ed432a99e688ea7331b74dabb8411b476826c7594014ecc9d7f4f4"
RPROVIDES:selinux-policy-targeted:append:x86_64_v2 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.18-4.el10_2.4 virtual/selinux-policy-any_ge_42.1.13 virtual/selinux-policy-any_ge_42.1.18 virtual/selinux-policy-any_ge_42.1.9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/selinux-policy-targeted-extra-42.1.18-4.el10_2.4.noarch.rpm;name=x86_64_v2_selinux-policy-targeted-extra;unpack=0"
SRC_URI[x86_64_v2_selinux-policy-targeted-extra.sha256sum] = "a054f4597a36abf2aee816a4a4fa01ac086928af5c3f0964f6d3889ffa43bf53"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-42.1.18-4.el10_2.4.noarch.rpm;name=aarch64_selinux-policy;unpack=0"
SRC_URI[aarch64_selinux-policy.sha256sum] = "704421fb936b81fe323cd448c2ea60d86af48ebae4a0f8fab2e6c26da88f2466"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/selinux-policy-devel-42.1.18-4.el10_2.4.noarch.rpm;name=aarch64_selinux-policy-devel;unpack=0"
SRC_URI[aarch64_selinux-policy-devel.sha256sum] = "36936c92ebd1c9488e3748e705260e5939ca2f5803116579e1a22d3c2ed9916d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-doc-42.1.18-4.el10_2.4.noarch.rpm;name=aarch64_selinux-policy-doc;unpack=0"
SRC_URI[aarch64_selinux-policy-doc.sha256sum] = "ea67a7130aad84281f87407acec4e833789a3ad92293fdd68b1475e2de036f19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-extra-42.1.18-4.el10_2.4.noarch.rpm;name=aarch64_selinux-policy-extra;unpack=0"
SRC_URI[aarch64_selinux-policy-extra.sha256sum] = "242f4598aed750a1289b6abbe1e1e7dbd376a842e2946239fc4c0e5265ba2481"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-mls-42.1.18-4.el10_2.4.noarch.rpm;name=aarch64_selinux-policy-mls;unpack=0"
SRC_URI[aarch64_selinux-policy-mls.sha256sum] = "d4c660a4788af1724694de53df6aeae7a527a105112973f6eba99495ac0e5505"
RPROVIDES:selinux-policy-mls:append:aarch64 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.18-4.el10_2.4 virtual/selinux-policy-any_ge_42.1.12 virtual/selinux-policy-any_ge_42.1.18 virtual/selinux-policy-any_ge_42.1.9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-mls-extra-42.1.18-4.el10_2.4.noarch.rpm;name=aarch64_selinux-policy-mls-extra;unpack=0"
SRC_URI[aarch64_selinux-policy-mls-extra.sha256sum] = "75ae6dbb14695b0591c7cf1f72b06703830a4701de410c65799c9b78bc5bf631"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-sandbox-42.1.18-4.el10_2.4.noarch.rpm;name=aarch64_selinux-policy-sandbox;unpack=0"
SRC_URI[aarch64_selinux-policy-sandbox.sha256sum] = "5e5b359c8c511501bd38225b25a0fe747e6d5bdc7a857a7c8cc85296a0ad06ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-targeted-42.1.18-4.el10_2.4.noarch.rpm;name=aarch64_selinux-policy-targeted;unpack=0"
SRC_URI[aarch64_selinux-policy-targeted.sha256sum] = "55c9c5f2d7ed432a99e688ea7331b74dabb8411b476826c7594014ecc9d7f4f4"
RPROVIDES:selinux-policy-targeted:append:aarch64 = " virtual/selinux-policy-any virtual/selinux-policy-any_eq_42.1.18-4.el10_2.4 virtual/selinux-policy-any_ge_42.1.12 virtual/selinux-policy-any_ge_42.1.18 virtual/selinux-policy-any_ge_42.1.9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/selinux-policy-targeted-extra-42.1.18-4.el10_2.4.noarch.rpm;name=aarch64_selinux-policy-targeted-extra;unpack=0"
SRC_URI[aarch64_selinux-policy-targeted-extra.sha256sum] = "a054f4597a36abf2aee816a4a4fa01ac086928af5c3f0964f6d3889ffa43bf53"

RDEPENDS:selinux-policy = " \
 bash \
 gawk \
 policycoreutils \
 rpm-plugin-selinux \
 virtual//usr/bin/sha512sum \
 virtual/selinux-policy-any_eq_42.1.18-4.el10_2.4 \
 "
RDEPENDS:selinux-policy-devel = " \
 bash \
 checkpolicy \
 m4 \
 make \
 policycoreutils-devel \
 selinux-policy \
 "
RDEPENDS:selinux-policy-doc = " \
 selinux-policy \
 "
RDEPENDS:selinux-policy-extra = " \
 selinux-policy-mls-extra \
 selinux-policy-targeted-extra \
 "
RDEPENDS:selinux-policy-mls = " \
 bash \
 mcstrans \
 policycoreutils \
 policycoreutils-newrole \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-mls-extra = " \
 bash \
 selinux-policy-mls \
 "
RDEPENDS:selinux-policy-sandbox = " \
 bash \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:selinux-policy-targeted = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-targeted-extra = " \
 bash \
 selinux-policy-targeted \
 "
