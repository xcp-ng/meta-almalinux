# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distribution-gpg-keys"
PV = "1.114"
PR = "1.el10_0"
PACKAGES = " \
 distribution-gpg-keys \
 distribution-gpg-keys-copr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/distribution-gpg-keys-1.114-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a18ba3ea042f9346e8817bea83b15f829307b17451c57e23d44081857bbf86e9"

URI_x86_64_v2_distribution-gpg-keys = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-1.114-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distribution-gpg-keys}"
SRC_URI[x86_64_v2_distribution-gpg-keys.sha256sum] = "caee2ee301686424c8913376c58e04cc628b78588fc989ec40299f52466f0cd0"

URI_x86_64_v2_distribution-gpg-keys-copr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-copr-1.114-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys-copr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distribution-gpg-keys-copr}"
SRC_URI[x86_64_v2_distribution-gpg-keys-copr.sha256sum] = "d8ac9588cc39774115df28a33c7c17e8ebd31ea8bb543f7ad5a804107cfa4ce3"

URI_aarch64_distribution-gpg-keys = "${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-1.114-1.el10_0.noarch.rpm;name=aarch64_distribution-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_aarch64_distribution-gpg-keys}"
SRC_URI[aarch64_distribution-gpg-keys.sha256sum] = "f273f6822578f38a7c3f8520194a4773f2636222d3d1094d212ab24213d3eaac"

URI_aarch64_distribution-gpg-keys-copr = "${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-copr-1.114-1.el10_0.noarch.rpm;name=aarch64_distribution-gpg-keys-copr;unpack=0"
SRC_URI:append = " ${URI_aarch64_distribution-gpg-keys-copr}"
SRC_URI[aarch64_distribution-gpg-keys-copr.sha256sum] = "7a96a464b67dac3666313cacffaa7f1aaae28074a3530ce1a8d93f1595056e15"

RDEPENDS:distribution-gpg-keys = " \
 "
RDEPENDS:distribution-gpg-keys-copr = " \
 "
