# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "micropipenv"
PV = "1.6.0"
PR = "9.el10"
PACKAGES = " \
 micropipenv \
 micropipenv+toml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/micropipenv-1.6.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d4a3da237f5e2e4d4f05bfd62dcbb863c625f4b546707030f2a716719c46f93"

URI_x86_64_v2_micropipenv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/micropipenv-1.6.0-9.el10.noarch.rpm;name=x86_64_v2_micropipenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_micropipenv}"
SRC_URI[x86_64_v2_micropipenv.sha256sum] = "f758953feff048ca692622b91008076e10b28ef0dd4da165d898a6bd9d6bc55e"

URI_x86_64_v2_micropipenv+toml = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/micropipenv+toml-1.6.0-9.el10.noarch.rpm;name=x86_64_v2_micropipenv+toml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_micropipenv+toml}"
SRC_URI[x86_64_v2_micropipenv+toml.sha256sum] = "9bbdf3889d93e6609dc7b2af32fb0885a99d0eda5e387e014b05724feab6a18e"

URI_aarch64_micropipenv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/micropipenv-1.6.0-9.el10.noarch.rpm;name=aarch64_micropipenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_micropipenv}"
SRC_URI[aarch64_micropipenv.sha256sum] = "f758953feff048ca692622b91008076e10b28ef0dd4da165d898a6bd9d6bc55e"

URI_aarch64_micropipenv+toml = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/micropipenv+toml-1.6.0-9.el10.noarch.rpm;name=aarch64_micropipenv+toml;unpack=0"
SRC_URI:append = " ${URI_aarch64_micropipenv+toml}"
SRC_URI[aarch64_micropipenv+toml.sha256sum] = "9bbdf3889d93e6609dc7b2af32fb0885a99d0eda5e387e014b05724feab6a18e"

RDEPENDS:micropipenv = " \
 python3 \
 python3-pip \
 "
RDEPENDS:micropipenv+toml = " \
 micropipenv \
 python3 \
 "
