# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openjph"
PV = "0.21.5"
PR = "1.el10_0"
PACKAGES = " \
 libopenjph \
 libopenjph-devel \
 openjph \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openjph-0.21.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8aff3562289d0d1e35b7e354ea1eeb14968b6d09a10338e940dc51d02961fc5"

URI_x86_64_v2_libopenjph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenjph-0.21.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenjph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenjph}"
SRC_URI[x86_64_v2_libopenjph.sha256sum] = "4bd21868e658bd1788ff46af1fbf1a3bb234a8eaa00f509da070598d079b123d"

URI_x86_64_v2_libopenjph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopenjph-devel-0.21.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopenjph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenjph-devel}"
SRC_URI[x86_64_v2_libopenjph-devel.sha256sum] = "c2bb160d147d04b5891361379f6cb4c05fc5afd2e2058bfc3e661edae002c622"

URI_x86_64_v2_openjph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openjph-0.21.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openjph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openjph}"
SRC_URI[x86_64_v2_openjph.sha256sum] = "cf3db231d9bd4d952e3294b8c73841448c45069d581ada6a5185c3aa8997139a"

URI_aarch64_libopenjph = "${EPEL_MIRROR}/aarch64/Packages/l/libopenjph-0.21.5-1.el10_0.aarch64.rpm;name=aarch64_libopenjph;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenjph}"
SRC_URI[aarch64_libopenjph.sha256sum] = "6ac7307c732ad6972d2b1ef901a2d5cd460923119f410d2d3ab560c0849ed7c4"

URI_aarch64_libopenjph-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopenjph-devel-0.21.5-1.el10_0.aarch64.rpm;name=aarch64_libopenjph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenjph-devel}"
SRC_URI[aarch64_libopenjph-devel.sha256sum] = "69031a4f281a9de27836acdd548a3215029f405a87051d333ca20069ca79bedc"

URI_aarch64_openjph = "${EPEL_MIRROR}/aarch64/Packages/o/openjph-0.21.5-1.el10_0.aarch64.rpm;name=aarch64_openjph;unpack=0"
SRC_URI:append = " ${URI_aarch64_openjph}"
SRC_URI[aarch64_openjph.sha256sum] = "288094dfaac27ce8e8df1b450741b8fe07cbe158341e902d3533ed4ac60da863"

RDEPENDS:libopenjph = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libopenjph-devel = " \
 cmake-filesystem \
 libjpeg-turbo-devel \
 libopenjph \
 pkgconf-pkg-config \
 "
RDEPENDS:openjph = " \
 glibc \
 libgcc \
 libopenjph \
 libstdc++ \
 libtiff \
 "
