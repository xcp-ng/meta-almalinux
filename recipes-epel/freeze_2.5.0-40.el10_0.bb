# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeze"
PV = "2.5.0"
PR = "40.el10_0"
PACKAGES = " \
 freeze \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/freeze-2.5.0-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5ab83e272036aaa8e77c6607f3741adc9acd03f8bac28ab90f1253b2b9efb906"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freeze-2.5.0-40.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freeze;unpack=0"
SRC_URI[x86_64_v2_freeze.sha256sum] = "1d93b9c06dd0a7c3185cc1ffa12bbf708b3fffe8c3bb48314e36df7dac6df87e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/freeze-2.5.0-40.el10_0.aarch64.rpm;name=aarch64_freeze;unpack=0"
SRC_URI[aarch64_freeze.sha256sum] = "48f0e808e3fb426c69a894e3e113beb12848f10dde4cca245433e5edb71fe0b2"

RDEPENDS:freeze = " \
 glibc \
 "
