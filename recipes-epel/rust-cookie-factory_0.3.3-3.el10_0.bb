# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cookie-factory"
PV = "0.3.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-cookie-factory+async-devel \
 rust-cookie-factory+default-devel \
 rust-cookie-factory+futures-devel \
 rust-cookie-factory+std-devel \
 rust-cookie-factory-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cookie-factory-0.3.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c269f293d4f16a6219aed6e9d4912eafe423b663651d9e9fa5a24a4acad66474"

URI_x86_64_v2_rust-cookie-factory+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-factory+async-devel-0.3.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-factory+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-factory+async-devel}"
SRC_URI[x86_64_v2_rust-cookie-factory+async-devel.sha256sum] = "8fb9199b0dd9381c49164790811160bdc2e3e19d162622c35f1361550c2b6c00"

URI_x86_64_v2_rust-cookie-factory+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-factory+default-devel-0.3.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-factory+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-factory+default-devel}"
SRC_URI[x86_64_v2_rust-cookie-factory+default-devel.sha256sum] = "cca920822436150fec208d7142efc468933d7da0389ced5c0a97f1b5f0d265c1"

URI_x86_64_v2_rust-cookie-factory+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-factory+futures-devel-0.3.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-factory+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-factory+futures-devel}"
SRC_URI[x86_64_v2_rust-cookie-factory+futures-devel.sha256sum] = "21896ee480367b5069e38eaf7a2cebc26f82e2876b491612a80ee84297f88d4f"

URI_x86_64_v2_rust-cookie-factory+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-factory+std-devel-0.3.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-factory+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-factory+std-devel}"
SRC_URI[x86_64_v2_rust-cookie-factory+std-devel.sha256sum] = "3c8f742bf3f7c0624bd0f38fa64f90da6ea6b2922144a5189f18a0ff01e0d0a0"

URI_x86_64_v2_rust-cookie-factory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-factory-devel-0.3.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-factory-devel}"
SRC_URI[x86_64_v2_rust-cookie-factory-devel.sha256sum] = "bb9cf27215cd104abead25043ad3e379112021060e2413bfcff2327d67df4496"

URI_aarch64_rust-cookie-factory+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-factory+async-devel-0.3.3-3.el10_0.noarch.rpm;name=aarch64_rust-cookie-factory+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-factory+async-devel}"
SRC_URI[aarch64_rust-cookie-factory+async-devel.sha256sum] = "cb06be281c7b6c10c38922b10771276e664145d02cc6d2ce1c43fda4238510d9"

URI_aarch64_rust-cookie-factory+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-factory+default-devel-0.3.3-3.el10_0.noarch.rpm;name=aarch64_rust-cookie-factory+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-factory+default-devel}"
SRC_URI[aarch64_rust-cookie-factory+default-devel.sha256sum] = "b120a3ca7610694fe713df41f6962dd264b0787902bfd9cc8094de12defd227e"

URI_aarch64_rust-cookie-factory+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-factory+futures-devel-0.3.3-3.el10_0.noarch.rpm;name=aarch64_rust-cookie-factory+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-factory+futures-devel}"
SRC_URI[aarch64_rust-cookie-factory+futures-devel.sha256sum] = "2014cb732d66e93078a12480933f89e2b83ca56978de475593cc13f76b5a45d8"

URI_aarch64_rust-cookie-factory+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-factory+std-devel-0.3.3-3.el10_0.noarch.rpm;name=aarch64_rust-cookie-factory+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-factory+std-devel}"
SRC_URI[aarch64_rust-cookie-factory+std-devel.sha256sum] = "a4673da521eedb4061e9d7d5eaa2b3675b9fed199f2d010d32f1389bfce1350c"

URI_aarch64_rust-cookie-factory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-factory-devel-0.3.3-3.el10_0.noarch.rpm;name=aarch64_rust-cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-factory-devel}"
SRC_URI[aarch64_rust-cookie-factory-devel.sha256sum] = "21bb16dd6c952a033e7ba4f6419ce84b0c0d44f112e35b11e23781e4f2303b70"

RDEPENDS:rust-cookie-factory+async-devel = " \
 cargo \
 rust-cookie-factory+futures-devel \
 rust-cookie-factory-devel \
 "
RDEPENDS:rust-cookie-factory+default-devel = " \
 cargo \
 rust-cookie-factory+async-devel \
 rust-cookie-factory+std-devel \
 rust-cookie-factory-devel \
 "
RDEPENDS:rust-cookie-factory+futures-devel = " \
 cargo \
 rust-cookie-factory-devel \
 rust-futures+default-devel \
 "
RDEPENDS:rust-cookie-factory+std-devel = " \
 cargo \
 rust-cookie-factory-devel \
 "
RDEPENDS:rust-cookie-factory-devel = " \
 cargo \
 "
