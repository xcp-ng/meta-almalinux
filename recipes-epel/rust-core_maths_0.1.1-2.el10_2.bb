# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-core_maths"
PV = "0.1.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-core_maths+default-devel \
 rust-core_maths-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-core_maths-0.1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1775c35c436f8d803a56c21e326dc261635240838381d2492d2baccca24d72cd"

URI_x86_64_v2_rust-core_maths+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-core_maths+default-devel-0.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-core_maths+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-core_maths+default-devel}"
SRC_URI[x86_64_v2_rust-core_maths+default-devel.sha256sum] = "ad443c088a7621d568711c0ee22a542e4da165f206311e8fc0b94fb8a23b3b3e"

URI_x86_64_v2_rust-core_maths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-core_maths-devel-0.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-core_maths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-core_maths-devel}"
SRC_URI[x86_64_v2_rust-core_maths-devel.sha256sum] = "3c45967ed07610d3548674db7e43e8117ec023d741662bbdfdbc96cf8fc38730"

URI_aarch64_rust-core_maths+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-core_maths+default-devel-0.1.1-2.el10_2.noarch.rpm;name=aarch64_rust-core_maths+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-core_maths+default-devel}"
SRC_URI[aarch64_rust-core_maths+default-devel.sha256sum] = "5abd84b037afa4840d7c79cf3d9e1b20c3d7d828eeb84f208b29b97728a3c854"

URI_aarch64_rust-core_maths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-core_maths-devel-0.1.1-2.el10_2.noarch.rpm;name=aarch64_rust-core_maths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-core_maths-devel}"
SRC_URI[aarch64_rust-core_maths-devel.sha256sum] = "63d42e8476ea36733bd2f354d8f05d03e6da05be90aa24ba693dffb39473ecc1"

RDEPENDS:rust-core_maths+default-devel = " \
 cargo \
 rust-core_maths-devel \
 "
RDEPENDS:rust-core_maths-devel = " \
 cargo \
 rust-libm+default-devel \
 "
