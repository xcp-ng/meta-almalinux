# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kunifiedpush"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kunifiedpush \
 kunifiedpush-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kunifiedpush-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18678f5e91bf874b7a9aeb2c96daee7c48564f095156eca97ea881f055940c47"

URI_x86_64_v2_kunifiedpush = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kunifiedpush-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kunifiedpush;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kunifiedpush}"
SRC_URI[x86_64_v2_kunifiedpush.sha256sum] = "ab78565e7940982cb6cb6fbd26edf522e1def8a2bfe085e4715ec863b03f4e25"

URI_x86_64_v2_kunifiedpush-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kunifiedpush-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kunifiedpush-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kunifiedpush-devel}"
SRC_URI[x86_64_v2_kunifiedpush-devel.sha256sum] = "28aac10cb1b519ce47f51fb4b34f5f1acdc69f7f863a1db0efcd0244833b7e0d"

URI_aarch64_kunifiedpush = "${EPEL_MIRROR}/aarch64/Packages/k/kunifiedpush-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kunifiedpush;unpack=0"
SRC_URI:append = " ${URI_aarch64_kunifiedpush}"
SRC_URI[aarch64_kunifiedpush.sha256sum] = "0b841eeff7a0067b470ca827c3ff7b285273d1b5f763387bdca438ce26dafb95"

URI_aarch64_kunifiedpush-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kunifiedpush-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kunifiedpush-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kunifiedpush-devel}"
SRC_URI[aarch64_kunifiedpush-devel.sha256sum] = "9b04a5e26c9d8bfbc116c9df2d076eff9718cc00cdb2ee9fa30c1ec6a6c9d701"

RDEPENDS:kunifiedpush = " \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:kunifiedpush-devel = " \
 cmake-filesystem \
 kunifiedpush \
 "
