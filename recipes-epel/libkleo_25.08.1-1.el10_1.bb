# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkleo"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libkleo \
 libkleo-devel \
 libkleo-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkleo-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c8687321910438838267e8988394df81824b8cfccc0ca40be2f1750b28e66af"

URI_x86_64_v2_libkleo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkleo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo}"
SRC_URI[x86_64_v2_libkleo.sha256sum] = "b8bc46e6148ddbd52321895e9053c9c818d9e0fe8718c989532d9ed815ad5225"

URI_x86_64_v2_libkleo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkleo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo-devel}"
SRC_URI[x86_64_v2_libkleo-devel.sha256sum] = "7b29e0897f4af83db171601b0202fd60a686dd392d33ef68e37895c8609257f2"

URI_x86_64_v2_libkleo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libkleo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo-doc}"
SRC_URI[x86_64_v2_libkleo-doc.sha256sum] = "c41955c0f42efdb137d014feb4a9bc0e3fe0e43a075fa5752b5f874b20ba818d"

URI_aarch64_libkleo = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkleo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo}"
SRC_URI[aarch64_libkleo.sha256sum] = "74fcf45e1d2c0fb5bd1098aaac93be94f2223a2c5f4351048a0eb819139a84eb"

URI_aarch64_libkleo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkleo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo-devel}"
SRC_URI[aarch64_libkleo-devel.sha256sum] = "7bfd5f02bbbe7ef70b78312349b222413512c0b47bcf1b3cdb4976194831a61f"

URI_aarch64_libkleo-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_libkleo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo-doc}"
SRC_URI[aarch64_libkleo-doc.sha256sum] = "4af2849f613ce744a0ab058b97cc0eee8bd2d2281697806be6ae86c9ef197ae9"

RDEPENDS:libkleo = " \
 glibc \
 gpgmepp \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 libgcc \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkleo-devel = " \
 cmake-filesystem \
 gpgmepp-devel \
 libkleo \
 qgpgme-qt6-devel \
 "
RDEPENDS:libkleo-doc = " \
 "
