# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dist-git-client"
PV = "1.3"
PR = "1.el10_1"
PACKAGES = " \
 dist-git-client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dist-git-client-1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26839edac423a87312cc43d128ea2bb9e5a1afe9f151b1ce19f04b2b137469c4"

URI_x86_64_v2_dist-git-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dist-git-client-1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dist-git-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dist-git-client}"
SRC_URI[x86_64_v2_dist-git-client.sha256sum] = "dcc724cc5ab0f474a6ca0acd007e2eb42f5485d7df77b0f319e1944ac677b46a"

URI_aarch64_dist-git-client = "${EPEL_MIRROR}/aarch64/Packages/d/dist-git-client-1.3-1.el10_1.noarch.rpm;name=aarch64_dist-git-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_dist-git-client}"
SRC_URI[aarch64_dist-git-client.sha256sum] = "eb2a102485bbdb9d83eef89464d20ee5edd1015fd4d78e4e7b8a09f49ba99f74"

RDEPENDS:dist-git-client = " \
 curl \
 git-core \
 python3 \
 python3-rpmautospec \
 "
