# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "7zip"
PV = "26.02"
PR = "1.el10_2"
PACKAGES = " \
 7zip \
 7zip-reduced \
 7zip-standalone \
 7zip-standalone-all \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/7/7zip-26.02-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bac1de5d823f42b7d1043b20d250faeff6e501b436ea0705054c2a34dba63824"

URI_x86_64_v2_7zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-26.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip}"
SRC_URI[x86_64_v2_7zip.sha256sum] = "64727c7d37189de193f7204b7f49899914522fa1ba3f5d9d2d299f828f2f4ddb"

URI_x86_64_v2_7zip-reduced = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-reduced-26.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-reduced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-reduced}"
SRC_URI[x86_64_v2_7zip-reduced.sha256sum] = "673b5bbd58fdcaf4ec5294c00cef21c49901a6704b47d98f5d53f59c3270465e"

URI_x86_64_v2_7zip-standalone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-standalone-26.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-standalone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-standalone}"
SRC_URI[x86_64_v2_7zip-standalone.sha256sum] = "230d17aeb775aa0d0e719086d9526486e9f99e47263ae5d539b0988145822018"

URI_x86_64_v2_7zip-standalone-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-standalone-all-26.02-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-standalone-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-standalone-all}"
SRC_URI[x86_64_v2_7zip-standalone-all.sha256sum] = "31d48e8b74e9eb3cbf6c24af0d24d5a5c0d1235743946f734a08cd5679982365"

URI_aarch64_7zip = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-26.02-1.el10_2.aarch64.rpm;name=aarch64_7zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip}"
SRC_URI[aarch64_7zip.sha256sum] = "c251e29209d46545c46312e783ab7ff04e14b193460e2cbe071ec5e823c3dd9a"

URI_aarch64_7zip-reduced = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-reduced-26.02-1.el10_2.aarch64.rpm;name=aarch64_7zip-reduced;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-reduced}"
SRC_URI[aarch64_7zip-reduced.sha256sum] = "89928be9791dddeda75d1c18c924f1cc24f835d5460258e55f9b7a3a71be4b53"

URI_aarch64_7zip-standalone = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-standalone-26.02-1.el10_2.aarch64.rpm;name=aarch64_7zip-standalone;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-standalone}"
SRC_URI[aarch64_7zip-standalone.sha256sum] = "48f4120c51a04925794cf54ec9bc6b008d71a67897ffb3008fe1f1b3e68ad604"

URI_aarch64_7zip-standalone-all = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-standalone-all-26.02-1.el10_2.aarch64.rpm;name=aarch64_7zip-standalone-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-standalone-all}"
SRC_URI[aarch64_7zip-standalone-all.sha256sum] = "ab2bb5456ca79363d111b2c474a530608e175448202e1cd7274106edd1f11af8"

RDEPENDS:7zip = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-reduced = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-standalone = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-standalone-all = " \
 glibc \
 libgcc \
 libstdc++ \
 "
