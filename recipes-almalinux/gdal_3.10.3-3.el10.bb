# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdal"
PV = "3.10.3"
PR = "3.el10"
PACKAGES = " \
 gdal \
 gdal-devel \
 gdal-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdal-3.10.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22035f0c09318b9e295a7f3312ac525bdd53b697a6117da8eab6c8343f0e6f0b"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gdal-libs: libgeos_c.so.1()(64bit)

URI_x86_64_v2_gdal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdal-3.10.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_gdal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal}"
SRC_URI[x86_64_v2_gdal.sha256sum] = "c568217af46eac71f8bdbcaa4f1a0551b2f703aa6db35dce8ac4bac6d2730bc5"

URI_x86_64_v2_gdal-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdal-devel-3.10.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_gdal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal-devel}"
SRC_URI[x86_64_v2_gdal-devel.sha256sum] = "3ad8fa9773c416e47b4831f97c005163f4656d2ab565fb7a3ae7b45155c52369"

URI_x86_64_v2_gdal-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdal-libs-3.10.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_gdal-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal-libs}"
SRC_URI[x86_64_v2_gdal-libs.sha256sum] = "a524b223fe403e9e050904a104c63fce5ba8ee7d1c9385050c4b7438da2edc7e"

URI_aarch64_gdal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdal-3.10.3-3.el10.aarch64.rpm;name=aarch64_gdal;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal}"
SRC_URI[aarch64_gdal.sha256sum] = "5b4e459c8c9bd0e072526d69058bc8a3cf4ee5f5836c8df65d743bd8df6989d8"

URI_aarch64_gdal-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdal-devel-3.10.3-3.el10.aarch64.rpm;name=aarch64_gdal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal-devel}"
SRC_URI[aarch64_gdal-devel.sha256sum] = "d7896b9d98076fd1ab520d288f888624d68c3f678ffecf8f0fca9dc376153632"

URI_aarch64_gdal-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdal-libs-3.10.3-3.el10.aarch64.rpm;name=aarch64_gdal-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal-libs}"
SRC_URI[aarch64_gdal-libs.sha256sum] = "843664dd713e506b28eebf6efe7bf2caece18e5baa692860ea7cf8cb90b79caf"

RDEPENDS:gdal = " \
 gdal-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gdal-devel = " \
 bash \
 cmake-filesystem \
 gdal-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gdal-libs:x86_64_v2 = " \
 expat \
 glibc \
 json-c \
 libarchive \
 libgcc \
 libstdc++ \
 libzstd \
 openssl-libs \
 proj \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdal-libs:aarch64 = " \
 expat \
 geos \
 glibc \
 json-c \
 libarchive \
 libgcc \
 libstdc++ \
 libzstd \
 openssl-libs \
 proj \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
