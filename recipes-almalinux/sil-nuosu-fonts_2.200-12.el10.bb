# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sil-nuosu-fonts"
PV = "2.200"
PR = "12.el10"
PACKAGES = " \
 sil-nuosu-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/sil-nuosu-fonts-2.200-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fcf39eb170174470e67a842e8beacf2f0f9b67cc460ff2749202089e83b9cd3"

URI_x86_64_v2_sil-nuosu-fonts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sil-nuosu-fonts-2.200-12.el10.noarch.rpm;name=x86_64_v2_sil-nuosu-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sil-nuosu-fonts}"
SRC_URI[x86_64_v2_sil-nuosu-fonts.sha256sum] = "e53205b3de6832e83cdb1b56a740fd9c6af3dcc7311d2d094ecac9810bdfd1f7"

URI_aarch64_sil-nuosu-fonts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sil-nuosu-fonts-2.200-12.el10.noarch.rpm;name=aarch64_sil-nuosu-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_sil-nuosu-fonts}"
SRC_URI[aarch64_sil-nuosu-fonts.sha256sum] = "e53205b3de6832e83cdb1b56a740fd9c6af3dcc7311d2d094ecac9810bdfd1f7"

RDEPENDS:sil-nuosu-fonts = " \
 fonts-filesystem \
 "
