# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-frozenlist"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-frozenlist \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-frozenlist-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c1251c0ecb048dcb506bf2c65e3b60622de5155fa77c1af63b15807d84c5613"

URI_x86_64_v2_python3-frozenlist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-frozenlist-1.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-frozenlist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-frozenlist}"
SRC_URI[x86_64_v2_python3-frozenlist.sha256sum] = "df6c74e6ba68bde51cbaede7922d3b823a36ac192ab94aeeb794e105300ce7ef"

URI_aarch64_python3-frozenlist = "${EPEL_MIRROR}/aarch64/Packages/p/python3-frozenlist-1.5.0-1.el10_0.aarch64.rpm;name=aarch64_python3-frozenlist;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-frozenlist}"
SRC_URI[aarch64_python3-frozenlist.sha256sum] = "923c74b53508b526cf8c2aceba16f434cae08d5c186bf596e7e0153e99878092"

RDEPENDS:python3-frozenlist = " \
 glibc \
 python3 \
 "
