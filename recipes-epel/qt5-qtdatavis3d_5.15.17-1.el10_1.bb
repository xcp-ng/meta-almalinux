# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtdatavis3d"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtdatavis3d \
 qt5-qtdatavis3d-devel \
 qt5-qtdatavis3d-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtdatavis3d-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "deb295665b037a67f0d1015f913136bf3edaa86c9ab3c36a3efb54d16ee5ea48"

URI_x86_64_v2_qt5-qtdatavis3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdatavis3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d.sha256sum] = "9ce1f916a19292c60a18b3dcfc3ce0d8668a263cf23aade6e7bcc06e12594a30"

URI_x86_64_v2_qt5-qtdatavis3d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdatavis3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d-devel}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d-devel.sha256sum] = "67f73011e2d0ca3c39f09c5e581d50bdecadf3c4a492e3b02abae038fb412a79"

URI_x86_64_v2_qt5-qtdatavis3d-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdatavis3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d-examples}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d-examples.sha256sum] = "c284922e3dbf394f7bb988c08800ad7e639facb8806d9a69856eef8087c6fa97"

URI_aarch64_qt5-qtdatavis3d = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtdatavis3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d}"
SRC_URI[aarch64_qt5-qtdatavis3d.sha256sum] = "77e847b89b250ec43dd82ab80e62c07e9119fd2e3ab65471501d485efa0e5328"

URI_aarch64_qt5-qtdatavis3d-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtdatavis3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d-devel}"
SRC_URI[aarch64_qt5-qtdatavis3d-devel.sha256sum] = "d3959ca5964345fbcb61443bde2679e3814e35126124d020d10e9596f1651c9d"

URI_aarch64_qt5-qtdatavis3d-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtdatavis3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d-examples}"
SRC_URI[aarch64_qt5-qtdatavis3d-examples.sha256sum] = "780ece328956144c62a02ad57faf535648906cff71ca20fb7e38c5cb9fd89e2a"

RDEPENDS:qt5-qtdatavis3d = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtdatavis3d-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdatavis3d \
 qt5-qtdeclarative-devel \
 "
RDEPENDS:qt5-qtdatavis3d-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdatavis3d \
 qt5-qtdeclarative \
 "
