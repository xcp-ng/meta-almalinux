# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "texlive"
PE = "13"
PV = "20240311"
PR = "6.el10"
PACKAGES = " \
 texlive \
 texlive-acronym \
 texlive-adjustbox \
 texlive-ae \
 texlive-algorithms \
 texlive-alphalph \
 texlive-amscls \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-anyfontsize \
 texlive-anysize \
 texlive-appendix \
 texlive-arphic \
 texlive-atbegshi \
 texlive-attachfile \
 texlive-attachfile2 \
 texlive-atveryend \
 texlive-auxhook \
 texlive-avantgar \
 texlive-awesomebox \
 texlive-babel \
 texlive-babel-english \
 texlive-babelbib \
 texlive-base \
 texlive-beamer \
 texlive-bera \
 texlive-beton \
 texlive-bibtex \
 texlive-bibtopic \
 texlive-bidi \
 texlive-bigfoot \
 texlive-bigintcalc \
 texlive-bitset \
 texlive-bookman \
 texlive-bookmark \
 texlive-booktabs \
 texlive-breakurl \
 texlive-breqn \
 texlive-capt-of \
 texlive-caption \
 texlive-carlisle \
 texlive-catchfile \
 texlive-changebar \
 texlive-changepage \
 texlive-charter \
 texlive-chngcntr \
 texlive-cite \
 texlive-classpack \
 texlive-cm \
 texlive-cm-lgc \
 texlive-cm-super \
 texlive-cmap \
 texlive-cmextra \
 texlive-cns \
 texlive-collectbox \
 texlive-collection-basic \
 texlive-collection-fontsrecommended \
 texlive-collection-htmlxml \
 texlive-collection-latex \
 texlive-collection-latexrecommended \
 texlive-collection-xetex \
 texlive-colorprofiles \
 texlive-colortbl \
 texlive-context \
 texlive-count1to \
 texlive-courier \
 texlive-crop \
 texlive-csquotes \
 texlive-ctable \
 texlive-ctablestack \
 texlive-currfile \
 texlive-datetime \
 texlive-dehyph \
 texlive-dvipdfmx \
 texlive-dvipng \
 texlive-dvips \
 texlive-dvisvgm \
 texlive-ec \
 texlive-eepic \
 texlive-enctex \
 texlive-enumitem \
 texlive-environ \
 texlive-epsf \
 texlive-epstopdf \
 texlive-epstopdf-pkg \
 texlive-eqparbox \
 texlive-eso-pic \
 texlive-etex \
 texlive-etex-pkg \
 texlive-etexcmds \
 texlive-etoc \
 texlive-etoolbox \
 texlive-euenc \
 texlive-euler \
 texlive-euro \
 texlive-eurosym \
 texlive-everysel \
 texlive-everyshi \
 texlive-extsizes \
 texlive-fancybox \
 texlive-fancyhdr \
 texlive-fancyref \
 texlive-fancyvrb \
 texlive-filecontents \
 texlive-filehook \
 texlive-finstrut \
 texlive-firstaid \
 texlive-fix2col \
 texlive-fixlatvian \
 texlive-float \
 texlive-fmtcount \
 texlive-fncychap \
 texlive-fontawesome \
 texlive-fontbook \
 texlive-fonts-tlwg \
 texlive-fontspec \
 texlive-fontware \
 texlive-fontwrap \
 texlive-footmisc \
 texlive-footnotehyper \
 texlive-fp \
 texlive-fpl \
 texlive-framed \
 texlive-garuda-c90 \
 texlive-geometry \
 texlive-gettitlestring \
 texlive-glyphlist \
 texlive-gnu-freefont \
 texlive-graphics \
 texlive-graphics-cfg \
 texlive-graphics-def \
 texlive-grfext \
 texlive-grffile \
 texlive-gsftopk \
 texlive-hanging \
 texlive-helvetic \
 texlive-hobsub \
 texlive-hologo \
 texlive-hopatch \
 texlive-hycolor \
 texlive-hypcap \
 texlive-hypdoc \
 texlive-hyperref \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-hyphenat \
 texlive-hyphenex \
 texlive-ifmtarg \
 texlive-ifoddpage \
 texlive-ifplatform \
 texlive-iftex \
 texlive-import \
 texlive-index \
 texlive-infwarerr \
 texlive-intcalc \
 texlive-jadetex \
 texlive-jknapltx \
 texlive-kastrup \
 texlive-kerkis \
 texlive-knuth-lib \
 texlive-knuth-local \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-kvdefinekeys \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-l3backend \
 texlive-l3experimental \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-lastpage \
 texlive-latex \
 texlive-latex-fonts \
 texlive-latex2man \
 texlive-latexbug \
 texlive-latexconfig \
 texlive-letltxmacro \
 texlive-lettrine \
 texlive-lib \
 texlive-lib-devel \
 texlive-linegoal \
 texlive-lineno \
 texlive-listings \
 texlive-listofitems \
 texlive-lm \
 texlive-lm-math \
 texlive-ltabptch \
 texlive-ltxcmds \
 texlive-ltxmisc \
 texlive-lua-alt-getopt \
 texlive-lua-uni-algos \
 texlive-luahbtex \
 texlive-lualatex-math \
 texlive-lualibs \
 texlive-luaotfload \
 texlive-luatex \
 texlive-luatex85 \
 texlive-luatexbase \
 texlive-lwarp \
 texlive-makecmds \
 texlive-makeindex \
 texlive-manfnt-font \
 texlive-marginnote \
 texlive-marvosym \
 texlive-mathpazo \
 texlive-mathspec \
 texlive-mathtools \
 texlive-mdwtools \
 texlive-memoir \
 texlive-metafont \
 texlive-metalogo \
 texlive-metapost \
 texlive-mflogo \
 texlive-mflogo-font \
 texlive-mfnfss \
 texlive-mfware \
 texlive-microtype \
 texlive-minitoc \
 texlive-mnsymbol \
 texlive-modes \
 texlive-mparhack \
 texlive-mptopdf \
 texlive-multido \
 texlive-multirow \
 texlive-multitoc \
 texlive-natbib \
 texlive-ncctools \
 texlive-ncntrsbk \
 texlive-needspace \
 texlive-newfloat \
 texlive-newunicodechar \
 texlive-norasi-c90 \
 texlive-notoccite \
 texlive-ntgclass \
 texlive-oberdiek \
 texlive-overpic \
 texlive-palatino \
 texlive-paralist \
 texlive-parallel \
 texlive-parskip \
 texlive-passivetex \
 texlive-pdfcol \
 texlive-pdfcolfoot \
 texlive-pdfcolmk \
 texlive-pdfescape \
 texlive-pdflscape \
 texlive-pdfmanagement-testphase \
 texlive-pdfpages \
 texlive-pdftex \
 texlive-pdftexcmds \
 texlive-pgf \
 texlive-philokalia \
 texlive-placeins \
 texlive-plain \
 texlive-polyglossia \
 texlive-powerdot \
 texlive-preprint \
 texlive-psfrag \
 texlive-pslatex \
 texlive-psnfss \
 texlive-pspicture \
 texlive-pst-3d \
 texlive-pst-arrow \
 texlive-pst-blur \
 texlive-pst-coil \
 texlive-pst-eps \
 texlive-pst-fill \
 texlive-pst-grad \
 texlive-pst-math \
 texlive-pst-node \
 texlive-pst-plot \
 texlive-pst-slpe \
 texlive-pst-text \
 texlive-pst-tools \
 texlive-pst-tree \
 texlive-pstricks \
 texlive-pstricks-add \
 texlive-ptext \
 texlive-pxfonts \
 texlive-qstest \
 texlive-ragged2e \
 texlive-rcs \
 texlive-realscripts \
 texlive-refcount \
 texlive-relsize \
 texlive-rerunfilecheck \
 texlive-rsfs \
 texlive-sansmath \
 texlive-sansmathaccent \
 texlive-sauerj \
 texlive-scheme-basic \
 texlive-section \
 texlive-sectsty \
 texlive-seminar \
 texlive-sepnum \
 texlive-setspace \
 texlive-sfmath \
 texlive-showexpl \
 texlive-soul \
 texlive-stackengine \
 texlive-stmaryrd \
 texlive-stringenc \
 texlive-subfig \
 texlive-subfigure \
 texlive-svn-prov \
 texlive-symbol \
 texlive-t2 \
 texlive-tabu \
 texlive-tabulary \
 texlive-tex \
 texlive-tex-gyre \
 texlive-tex-gyre-math \
 texlive-tex-ini-files \
 texlive-tex4ht \
 texlive-texlive-common-doc \
 texlive-texlive-en \
 texlive-texlive-msg-translations \
 texlive-texlive-scripts \
 texlive-texlive-scripts-extra \
 texlive-texlive.infra \
 texlive-textcase \
 texlive-textpos \
 texlive-threeparttable \
 texlive-thumbpdf \
 texlive-times \
 texlive-tipa \
 texlive-titlesec \
 texlive-titling \
 texlive-tocloft \
 texlive-tools \
 texlive-translator \
 texlive-trimspaces \
 texlive-txfonts \
 texlive-type1cm \
 texlive-typehtml \
 texlive-ucharcat \
 texlive-ucharclasses \
 texlive-ucs \
 texlive-uhc \
 texlive-ulem \
 texlive-underscore \
 texlive-unicode-data \
 texlive-unicode-math \
 texlive-uniquecounter \
 texlive-unisugar \
 texlive-upquote \
 texlive-url \
 texlive-utopia \
 texlive-varwidth \
 texlive-wadalab \
 texlive-was \
 texlive-wasy \
 texlive-wasy-type1 \
 texlive-wasysym \
 texlive-wrapfig \
 texlive-xcolor \
 texlive-xecolor \
 texlive-xecyr \
 texlive-xeindex \
 texlive-xepersian \
 texlive-xesearch \
 texlive-xetex \
 texlive-xetex-itrans \
 texlive-xetex-pstricks \
 texlive-xetexconfig \
 texlive-xetexfontinfo \
 texlive-xfrac \
 texlive-xifthen \
 texlive-xkeyval \
 texlive-xltxtra \
 texlive-xmltex \
 texlive-xpatch \
 texlive-xstring \
 texlive-xtab \
 texlive-xunicode \
 texlive-zapfchan \
 texlive-zapfding \
 texlive-zref \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/texlive-20240311-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc11136704c59ce5bf645e6f8a4d3558ecb52919ca663583fe135f6ed8c19d1b"

URI_x86_64_v2_texlive = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive}"
SRC_URI[x86_64_v2_texlive.sha256sum] = "46baedf95e65d4fc6dabdbfdd333b15279050019b143d6f840d3304ef60472cc"

URI_x86_64_v2_texlive-acronym = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-acronym-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-acronym;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-acronym}"
SRC_URI[x86_64_v2_texlive-acronym.sha256sum] = "8ebfe009fc3ee905809b42382a7f3a9642b47db7f1360d62765d75c76745b9a0"

URI_x86_64_v2_texlive-adjustbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-adjustbox-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-adjustbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-adjustbox}"
SRC_URI[x86_64_v2_texlive-adjustbox.sha256sum] = "050ef80bec4e63aed5aa36779ed607f9b24660664be97c573cb5730b7b2b3863"

URI_x86_64_v2_texlive-ae = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ae-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ae;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ae}"
SRC_URI[x86_64_v2_texlive-ae.sha256sum] = "448937bf45289972e3f920da4d5c14003348ce074c5ef1d923ed0d743b35a7f9"

URI_x86_64_v2_texlive-algorithms = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-algorithms-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-algorithms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-algorithms}"
SRC_URI[x86_64_v2_texlive-algorithms.sha256sum] = "ba8d182c052fc2baf6af369c9b7c0cf098d4a9f451e9a0feb2b57be41d3bdd00"

URI_x86_64_v2_texlive-alphalph = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-alphalph-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-alphalph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-alphalph}"
SRC_URI[x86_64_v2_texlive-alphalph.sha256sum] = "c93a570fcf2b97ca72634f1b163e1d0778b8a36634e099d387f11ec90eb4e17f"

URI_x86_64_v2_texlive-amscls = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-amscls-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-amscls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-amscls}"
SRC_URI[x86_64_v2_texlive-amscls.sha256sum] = "8fb0beb912449c54901ef8a4a81bdaa46b750ede0c8f846dcb62753bd613ca4e"

URI_x86_64_v2_texlive-amsfonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-amsfonts-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-amsfonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-amsfonts}"
SRC_URI[x86_64_v2_texlive-amsfonts.sha256sum] = "9dc5bfd237ae6ba1241c1cfa0c026550681b2e0d4b4fc2b9e8ad78d4baac32df"

URI_x86_64_v2_texlive-amsmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-amsmath-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-amsmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-amsmath}"
SRC_URI[x86_64_v2_texlive-amsmath.sha256sum] = "000e53b4859706852b926824082a77c106b6cc4a84c0250f823fe3045d2a0be4"

URI_x86_64_v2_texlive-anyfontsize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-anyfontsize-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-anyfontsize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-anyfontsize}"
SRC_URI[x86_64_v2_texlive-anyfontsize.sha256sum] = "33b3308469d94392bf6e7eb0c65d599c424f9d2b32ee3cfe34ced0ed2a310c5a"

URI_x86_64_v2_texlive-anysize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-anysize-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-anysize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-anysize}"
SRC_URI[x86_64_v2_texlive-anysize.sha256sum] = "7db26b44fc4611f170a1a0abe301f79afac6994c96456c72652b06ef7742c62e"

URI_x86_64_v2_texlive-appendix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-appendix-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-appendix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-appendix}"
SRC_URI[x86_64_v2_texlive-appendix.sha256sum] = "0f7925e876fbd1a0cbbefda5f030cdd118eae88fcec4c388c564f53d37e7a248"

URI_x86_64_v2_texlive-arphic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-arphic-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-arphic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-arphic}"
SRC_URI[x86_64_v2_texlive-arphic.sha256sum] = "878839326bea628a8f2bd3a1232352019baea2240d1ea5d0232f8c32b397339e"

URI_x86_64_v2_texlive-atbegshi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-atbegshi-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-atbegshi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-atbegshi}"
SRC_URI[x86_64_v2_texlive-atbegshi.sha256sum] = "4fe9c3a5ff637debf1b7edfa9c3278c79c53803321725433ecaa062118157ad9"

URI_x86_64_v2_texlive-attachfile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-attachfile-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-attachfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-attachfile}"
SRC_URI[x86_64_v2_texlive-attachfile.sha256sum] = "dc73176f36b7fef5fef390eefda5ddaeed93b25caf6917b1cc114f2841fea9a2"

URI_x86_64_v2_texlive-attachfile2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-attachfile2-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-attachfile2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-attachfile2}"
SRC_URI[x86_64_v2_texlive-attachfile2.sha256sum] = "ae12a00f770d1c92e59a7f1ed9d42e9474baf023bf5f2f964002f65869e638e3"

URI_x86_64_v2_texlive-atveryend = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-atveryend-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-atveryend;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-atveryend}"
SRC_URI[x86_64_v2_texlive-atveryend.sha256sum] = "df3ce6b65df6b55b93a232f814f8322a267e3f1d56e82ed28a102280bffa1036"

URI_x86_64_v2_texlive-auxhook = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-auxhook-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-auxhook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-auxhook}"
SRC_URI[x86_64_v2_texlive-auxhook.sha256sum] = "0c3418addb6d360923e35c30869898e04974bfed3abdcfe6d7046f45c0b3800a"

URI_x86_64_v2_texlive-avantgar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-avantgar-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-avantgar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-avantgar}"
SRC_URI[x86_64_v2_texlive-avantgar.sha256sum] = "c0b47b566fe13e5dfcb4e26c2d7c5ff6b1dd52092ae0f5dd434ce60e67bf028a"

URI_x86_64_v2_texlive-awesomebox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-awesomebox-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-awesomebox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-awesomebox}"
SRC_URI[x86_64_v2_texlive-awesomebox.sha256sum] = "716ffb722231afdced27c7333c38db1a1396d9f35dd682571c1a11ad00504b88"

URI_x86_64_v2_texlive-babel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-babel-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-babel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel}"
SRC_URI[x86_64_v2_texlive-babel.sha256sum] = "41ff045ad6a3ee07f350797092d66c7bae728d0d0815407fa593eda743ddd58f"

URI_x86_64_v2_texlive-babel-english = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-babel-english-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-babel-english;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel-english}"
SRC_URI[x86_64_v2_texlive-babel-english.sha256sum] = "18fac7cdc1b9f6f9b504becbfa9525d7b1532e5127a7a538e46d4ad142c420f9"

URI_x86_64_v2_texlive-babelbib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-babelbib-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-babelbib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babelbib}"
SRC_URI[x86_64_v2_texlive-babelbib.sha256sum] = "0a0958788fcf260c8b82e8e2dbd3df4e399d27029107b91299a6a49e8c588597"

URI_x86_64_v2_texlive-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-base-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-base}"
SRC_URI[x86_64_v2_texlive-base.sha256sum] = "1aa59f6fad1e2325a70f52351cf3e811077b7ff1159ed2ad0d0475f316c37e87"

URI_x86_64_v2_texlive-beamer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-beamer-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-beamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-beamer}"
SRC_URI[x86_64_v2_texlive-beamer.sha256sum] = "1051a30ece8f34b38b620f74a85a9e3758829d6f86737d3c394ef99e992373cc"

URI_x86_64_v2_texlive-bera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bera-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-bera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bera}"
SRC_URI[x86_64_v2_texlive-bera.sha256sum] = "0a2030890563cd7882e73787b17b36246248d48996bbf96e879f56510c3766f2"

URI_x86_64_v2_texlive-beton = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-beton-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-beton;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-beton}"
SRC_URI[x86_64_v2_texlive-beton.sha256sum] = "63464d6cf2863e1c8170e52302221f764955beaa9450baa12e38f3a4916be8be"

URI_x86_64_v2_texlive-bibtex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bibtex-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-bibtex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bibtex}"
SRC_URI[x86_64_v2_texlive-bibtex.sha256sum] = "af79a25571bca88c93ced5ba97ac10c7672be1748f60a2c219cf80dd8bf331e9"

URI_x86_64_v2_texlive-bibtopic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bibtopic-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-bibtopic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bibtopic}"
SRC_URI[x86_64_v2_texlive-bibtopic.sha256sum] = "d9ed124f905d848309f483a43ed0d2d85c0089953ad9a9bdbf655703723b8f7c"

URI_x86_64_v2_texlive-bidi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bidi-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-bidi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bidi}"
SRC_URI[x86_64_v2_texlive-bidi.sha256sum] = "31b4ba01e61b8b176fa2234eb0ceb031b6b177a29b549c8bb067c3a782c6be36"

URI_x86_64_v2_texlive-bigfoot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bigfoot-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-bigfoot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bigfoot}"
SRC_URI[x86_64_v2_texlive-bigfoot.sha256sum] = "1b17b239f8385a5e0827c08a04d1b9c25837971af0a8acb7133da7f61d64c063"

URI_x86_64_v2_texlive-bigintcalc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bigintcalc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-bigintcalc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bigintcalc}"
SRC_URI[x86_64_v2_texlive-bigintcalc.sha256sum] = "b08aae1d238f8f5eca3e3218a7a6793e9f267bd586c55308c5a0d33304c5bd2b"

URI_x86_64_v2_texlive-bitset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bitset-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-bitset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bitset}"
SRC_URI[x86_64_v2_texlive-bitset.sha256sum] = "e71e3a3eba576cf8ed23938ad561e37edf3f744a97510d935bc6294f4855ec69"

URI_x86_64_v2_texlive-bookman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bookman-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-bookman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bookman}"
SRC_URI[x86_64_v2_texlive-bookman.sha256sum] = "168af1aacb5f0008e8abd26dc7e43911d3a628bb25970d66defba0c489d7aa51"

URI_x86_64_v2_texlive-bookmark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bookmark-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-bookmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bookmark}"
SRC_URI[x86_64_v2_texlive-bookmark.sha256sum] = "a45e7f0c4632a72904b58b1a193ee1668c61d558bdb908ff7b72dfc50d7a2916"

URI_x86_64_v2_texlive-booktabs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-booktabs-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-booktabs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-booktabs}"
SRC_URI[x86_64_v2_texlive-booktabs.sha256sum] = "293b991f6b70f1e216a286ce1ed6a4087ea3feb0da215fccb83bda30f97ac062"

URI_x86_64_v2_texlive-breakurl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-breakurl-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-breakurl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-breakurl}"
SRC_URI[x86_64_v2_texlive-breakurl.sha256sum] = "f26c94e13b509ebc43c69a9ad72c2fe3dfe2c9aca86ecf2244fca7789edd8cad"

URI_x86_64_v2_texlive-breqn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-breqn-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-breqn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-breqn}"
SRC_URI[x86_64_v2_texlive-breqn.sha256sum] = "f5e45aa80fa94e558be01dd38e12ced9f47089e2d3625315b5a8ee1bfdd12688"

URI_x86_64_v2_texlive-capt-of = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-capt-of-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-capt-of;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-capt-of}"
SRC_URI[x86_64_v2_texlive-capt-of.sha256sum] = "6857ada40ecd81e0a499517759107be4760728339ecad42582b8a41c985344b7"

URI_x86_64_v2_texlive-caption = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-caption-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-caption;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-caption}"
SRC_URI[x86_64_v2_texlive-caption.sha256sum] = "3c6237e82ecad54e748def980011280f69caae152c33aafd4a297f0f27923e41"

URI_x86_64_v2_texlive-carlisle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-carlisle-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-carlisle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-carlisle}"
SRC_URI[x86_64_v2_texlive-carlisle.sha256sum] = "b642c7f596102fdd03b25cdf05e427d1ba256d7fb73a709918b4e14e56c4498c"

URI_x86_64_v2_texlive-catchfile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-catchfile-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-catchfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-catchfile}"
SRC_URI[x86_64_v2_texlive-catchfile.sha256sum] = "c8fda800688aae42ad40848fe20aa2a267ff1e9702ca7743c6342e9c48f24956"

URI_x86_64_v2_texlive-changebar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-changebar-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-changebar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-changebar}"
SRC_URI[x86_64_v2_texlive-changebar.sha256sum] = "c2502d7e0d46f72120dc9558cf3b377888948cb3325e12cc232c8f5a4f4767d2"

URI_x86_64_v2_texlive-changepage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-changepage-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-changepage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-changepage}"
SRC_URI[x86_64_v2_texlive-changepage.sha256sum] = "02c5aa90cfd17f8de9f97b786cfd3b80b6e984354078c9ce57115dd88a8347be"

URI_x86_64_v2_texlive-charter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-charter-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-charter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-charter}"
SRC_URI[x86_64_v2_texlive-charter.sha256sum] = "2919d5ed46b2128ee6f8e38970ed5a7b730933044d2ade141610a863e3b078d2"

URI_x86_64_v2_texlive-chngcntr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-chngcntr-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-chngcntr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chngcntr}"
SRC_URI[x86_64_v2_texlive-chngcntr.sha256sum] = "7cb75153984eb2615666706067f7e6e45f9e45eace3b2f00737a8a333f5a6510"

URI_x86_64_v2_texlive-cite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cite-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-cite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cite}"
SRC_URI[x86_64_v2_texlive-cite.sha256sum] = "9ede9d057e6410224c291e856e8fb6a214b6261d43481f1dcd05822e34d47ff8"

URI_x86_64_v2_texlive-classpack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-classpack-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-classpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-classpack}"
SRC_URI[x86_64_v2_texlive-classpack.sha256sum] = "ef89a3e544e664f18846b65f1684239bbffd8fa77ff8671061854e000ece03ff"

URI_x86_64_v2_texlive-cm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cm-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-cm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cm}"
SRC_URI[x86_64_v2_texlive-cm.sha256sum] = "b5a8db3342577f21f3c4f99db7da197bdb0e663b5a43c8cf5a8ed65c3699ac9f"

URI_x86_64_v2_texlive-cm-lgc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cm-lgc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-cm-lgc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cm-lgc}"
SRC_URI[x86_64_v2_texlive-cm-lgc.sha256sum] = "83d2ba83d31471852ee7329444c8ca57509409c9982e1cf37e24865970277dd9"

URI_x86_64_v2_texlive-cm-super = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cm-super-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-cm-super;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cm-super}"
SRC_URI[x86_64_v2_texlive-cm-super.sha256sum] = "873bd034eeb8ea275f189224b5d2d6a027e6f3155feb1782abfa30eb256c1231"

URI_x86_64_v2_texlive-cmap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cmap-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-cmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cmap}"
SRC_URI[x86_64_v2_texlive-cmap.sha256sum] = "1b12f6f7e5285e271c32d1635d4fa9410b1cd8ae753191cb213a1af1d55b882a"

URI_x86_64_v2_texlive-cmextra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cmextra-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-cmextra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cmextra}"
SRC_URI[x86_64_v2_texlive-cmextra.sha256sum] = "9a26fa286a469354fa502dfd61289522f6b49c1c23b79c3295a722c9cb9b093a"

URI_x86_64_v2_texlive-cns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cns-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-cns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cns}"
SRC_URI[x86_64_v2_texlive-cns.sha256sum] = "4f9c693d5f90f7d7658e4e39f07f484a69fc6559ff87ea461a30fd06ad6e786a"

URI_x86_64_v2_texlive-collectbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collectbox-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-collectbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collectbox}"
SRC_URI[x86_64_v2_texlive-collectbox.sha256sum] = "76f3f6b1276df181543939b59de938da50555b32af3a56f0a22ef24fb26923fa"

URI_x86_64_v2_texlive-collection-basic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-basic-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-collection-basic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-basic}"
SRC_URI[x86_64_v2_texlive-collection-basic.sha256sum] = "7b80ad661df231f2362e58ea5a760dd442c28181cbb87c420b650c118f82c620"

URI_x86_64_v2_texlive-collection-fontsrecommended = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-fontsrecommended-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-collection-fontsrecommended;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-fontsrecommended}"
SRC_URI[x86_64_v2_texlive-collection-fontsrecommended.sha256sum] = "d6936a72fac979f0808c7c5744defcdaef9c3034d3360fcad266950a3aa9a42c"

URI_x86_64_v2_texlive-collection-htmlxml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-htmlxml-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-collection-htmlxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-htmlxml}"
SRC_URI[x86_64_v2_texlive-collection-htmlxml.sha256sum] = "9f47bad0c100a3565e59984ddb504c4753555ae551866d368ab47a49effd6eb5"

URI_x86_64_v2_texlive-collection-latex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-latex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-collection-latex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-latex}"
SRC_URI[x86_64_v2_texlive-collection-latex.sha256sum] = "c66be8884ddd627328200bc765e4c13a94c250ad382974b995d09e6e5993393a"

URI_x86_64_v2_texlive-collection-latexrecommended = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-latexrecommended-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-collection-latexrecommended;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-latexrecommended}"
SRC_URI[x86_64_v2_texlive-collection-latexrecommended.sha256sum] = "47028f87c999e2e45a46f178de683c2f6f2e3eb67d6d3464e3464a86c5295ebe"
RPROVIDES:texlive-collection-latexrecommended:append:x86_64_v2 = " virtual/texlive-latex"

URI_x86_64_v2_texlive-collection-xetex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-xetex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-collection-xetex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-xetex}"
SRC_URI[x86_64_v2_texlive-collection-xetex.sha256sum] = "c7d0d5aa59eecf1c3e824e3fb5019c63256fe5fc03293dd93f671447fb5e05ea"

URI_x86_64_v2_texlive-colorprofiles = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-colorprofiles-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-colorprofiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-colorprofiles}"
SRC_URI[x86_64_v2_texlive-colorprofiles.sha256sum] = "9f81ab3242480704b165bc0ed6da44b2a9f53b773b34449b9d94990c03af146e"

URI_x86_64_v2_texlive-colortbl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-colortbl-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-colortbl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-colortbl}"
SRC_URI[x86_64_v2_texlive-colortbl.sha256sum] = "a2b8ce0ac4276ecb695eb21bdb9dc427541416c06fbefa00c8b5a2cdaf7f1db7"

URI_x86_64_v2_texlive-context = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-context-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-context;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-context}"
SRC_URI[x86_64_v2_texlive-context.sha256sum] = "1efb0b3de50685ef4722ac01a07718c59ffd78323df5c0581471e92c3e86f3b5"

URI_x86_64_v2_texlive-count1to = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-count1to-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-count1to;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-count1to}"
SRC_URI[x86_64_v2_texlive-count1to.sha256sum] = "526347aef96c973c4c09e18ae8d9e4baf42425b05fe82788d66a67b870ddc7a7"

URI_x86_64_v2_texlive-courier = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-courier-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-courier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-courier}"
SRC_URI[x86_64_v2_texlive-courier.sha256sum] = "3d94866d426971b3cb4f25ac8071e012313a5030e1cdeacb3af6c0add963ef24"

URI_x86_64_v2_texlive-crop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-crop-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-crop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-crop}"
SRC_URI[x86_64_v2_texlive-crop.sha256sum] = "33a474af6ce6444fa3d68fc2bc3d1c5b3f5947a63f67468e4b9fb67a18dda1ef"

URI_x86_64_v2_texlive-csquotes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-csquotes-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-csquotes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-csquotes}"
SRC_URI[x86_64_v2_texlive-csquotes.sha256sum] = "6bcb42246c76c203f9482ca78de4a6b921a9bd6bd3baf01dd7c8058dc3d7b6c4"

URI_x86_64_v2_texlive-ctable = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ctable-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ctable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctable}"
SRC_URI[x86_64_v2_texlive-ctable.sha256sum] = "a6e9a5cd623ebe9fc5726f4f34c37d1dfa41ee5fb7a8e1a80c1271743241cc55"

URI_x86_64_v2_texlive-ctablestack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ctablestack-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ctablestack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctablestack}"
SRC_URI[x86_64_v2_texlive-ctablestack.sha256sum] = "c31864812a791c97fa88a9e1102481f1b7080b3316c5fef3e140c94b4be3ad31"

URI_x86_64_v2_texlive-currfile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-currfile-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-currfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-currfile}"
SRC_URI[x86_64_v2_texlive-currfile.sha256sum] = "7029609375105a05df5ee7a6509671c1e4f9779f4ad9137723759fc81ef6f6a2"

URI_x86_64_v2_texlive-datetime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-datetime-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-datetime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-datetime}"
SRC_URI[x86_64_v2_texlive-datetime.sha256sum] = "07641c073b3d34087f912c885b8447e7a37b8461f19e656f1681dcd9e542f0a8"

URI_x86_64_v2_texlive-dehyph = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-dehyph-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-dehyph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-dehyph}"
SRC_URI[x86_64_v2_texlive-dehyph.sha256sum] = "49b5195ff178ad52c298f2559bc019d13ab96f3e6c0addb4465d03bf280e2b6e"

URI_x86_64_v2_texlive-dvipdfmx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-dvipdfmx-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-dvipdfmx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-dvipdfmx}"
SRC_URI[x86_64_v2_texlive-dvipdfmx.sha256sum] = "fd6224ccddd8b46888ee170d23819058d7190c32506a85d52a7d39b504491a5e"

URI_x86_64_v2_texlive-dvipng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-dvipng-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-dvipng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-dvipng}"
SRC_URI[x86_64_v2_texlive-dvipng.sha256sum] = "982d2ffd2414f7ddb6cad3f1beff0ac4578297c6fe56b4ec854f70b890bf9919"

URI_x86_64_v2_texlive-dvips = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-dvips-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-dvips;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-dvips}"
SRC_URI[x86_64_v2_texlive-dvips.sha256sum] = "0c7de96648f10df7ab3223dbd117d5a47328ec626faf80048e617943ddcae29f"

URI_x86_64_v2_texlive-dvisvgm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-dvisvgm-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-dvisvgm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-dvisvgm}"
SRC_URI[x86_64_v2_texlive-dvisvgm.sha256sum] = "8a4fda06362e61a2063d0d45eadae2f18f224e3f55e586e4db245655051ab8bf"

URI_x86_64_v2_texlive-ec = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ec-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ec}"
SRC_URI[x86_64_v2_texlive-ec.sha256sum] = "ede4197ec1b9f2402b6808f308702b99496bb11b06328ebe5e9a447fa50987f4"

URI_x86_64_v2_texlive-eepic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-eepic-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-eepic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-eepic}"
SRC_URI[x86_64_v2_texlive-eepic.sha256sum] = "785cb2079afadc7ab58a10001051ae7fe8392842da2035ab58e76107828d0c41"

URI_x86_64_v2_texlive-enctex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-enctex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-enctex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-enctex}"
SRC_URI[x86_64_v2_texlive-enctex.sha256sum] = "76258ed78db73a0d50064dfd03dca77119f4e6b3ea4ef5bf70bee6e6beb08dbb"

URI_x86_64_v2_texlive-enumitem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-enumitem-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-enumitem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-enumitem}"
SRC_URI[x86_64_v2_texlive-enumitem.sha256sum] = "7f1d1b8f8bf81d09e3d34df45c4d773e875493c59b8c6c2b55f97555db2f3ce5"

URI_x86_64_v2_texlive-environ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-environ-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-environ;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-environ}"
SRC_URI[x86_64_v2_texlive-environ.sha256sum] = "a3cf6db69efe126eb93397cc9a501b00f8acdeb8193f0e26776f857b4c719992"

URI_x86_64_v2_texlive-epsf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-epsf-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-epsf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-epsf}"
SRC_URI[x86_64_v2_texlive-epsf.sha256sum] = "a64561dff8b04d1dd7a2954952761f68b6f8dcf7f3565a64e26f797f452feda4"

URI_x86_64_v2_texlive-epstopdf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-epstopdf-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-epstopdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-epstopdf}"
SRC_URI[x86_64_v2_texlive-epstopdf.sha256sum] = "53fd92707119f3ad95a93da4a257af98fd20e3ae2e82688965a4b078ece1f8d8"

URI_x86_64_v2_texlive-epstopdf-pkg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-epstopdf-pkg-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-epstopdf-pkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-epstopdf-pkg}"
SRC_URI[x86_64_v2_texlive-epstopdf-pkg.sha256sum] = "08fd08cd29ca15c5b54bca1643db101209f6f06d21a4507e23bce1901e3c857d"

URI_x86_64_v2_texlive-eqparbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-eqparbox-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-eqparbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-eqparbox}"
SRC_URI[x86_64_v2_texlive-eqparbox.sha256sum] = "093b7d7f754bf981fa521c6a325fca0c1639f990855648e8712e3fcf608617ad"

URI_x86_64_v2_texlive-eso-pic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-eso-pic-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-eso-pic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-eso-pic}"
SRC_URI[x86_64_v2_texlive-eso-pic.sha256sum] = "c220264b03012a7da04362b5fde450f33204bbc762fe2c151795c0ccf67d7efc"

URI_x86_64_v2_texlive-etex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-etex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-etex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-etex}"
SRC_URI[x86_64_v2_texlive-etex.sha256sum] = "60b2cff3e1dc933c4f90a47492d5e5d9828d521bde97814f7c608a572b5a7d7d"

URI_x86_64_v2_texlive-etex-pkg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-etex-pkg-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-etex-pkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-etex-pkg}"
SRC_URI[x86_64_v2_texlive-etex-pkg.sha256sum] = "ef2e95b92689c7ce5904e30e032244677129ac2eabf0de8ff46bf0726552bc11"

URI_x86_64_v2_texlive-etexcmds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-etexcmds-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-etexcmds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-etexcmds}"
SRC_URI[x86_64_v2_texlive-etexcmds.sha256sum] = "b19d9ae6ae5c82dd2f3c3e4fad85c9fa1a6ea560692d947bbe2ec9e4f6bb775e"

URI_x86_64_v2_texlive-etoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-etoc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-etoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-etoc}"
SRC_URI[x86_64_v2_texlive-etoc.sha256sum] = "7b114be5bbd95084273b30e0980c006eb2c546105904146d57ee58f08db18e8e"

URI_x86_64_v2_texlive-etoolbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-etoolbox-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-etoolbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-etoolbox}"
SRC_URI[x86_64_v2_texlive-etoolbox.sha256sum] = "0f375cbcadc0756d45d3f452d5d5480a36fe7b873a08b29a0b23878a740ef708"

URI_x86_64_v2_texlive-euenc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-euenc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-euenc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-euenc}"
SRC_URI[x86_64_v2_texlive-euenc.sha256sum] = "5415d4482f7a0f108bb0fd85348437b331e7fa39783518267199aa76dd22318a"

URI_x86_64_v2_texlive-euler = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-euler-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-euler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-euler}"
SRC_URI[x86_64_v2_texlive-euler.sha256sum] = "bd4bd5f45e4d470bb5666e471a2818a5f54a755cd4d05fdc5a6e8fa77a81dcde"

URI_x86_64_v2_texlive-euro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-euro-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-euro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-euro}"
SRC_URI[x86_64_v2_texlive-euro.sha256sum] = "d710f38070428c81ef5a9dce39986620b3e3d1de05b236fa2d7ecc123380ff96"

URI_x86_64_v2_texlive-eurosym = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-eurosym-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-eurosym;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-eurosym}"
SRC_URI[x86_64_v2_texlive-eurosym.sha256sum] = "d2a90dc4e55e942f1daeac197ee8583b4c66402775d2428b4bacee5aefb7b7fd"

URI_x86_64_v2_texlive-everysel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-everysel-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-everysel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-everysel}"
SRC_URI[x86_64_v2_texlive-everysel.sha256sum] = "4b002fab710c49734afc999fcb5352b64b7b7a68c2b74fd488bdbbf57739b757"

URI_x86_64_v2_texlive-everyshi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-everyshi-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-everyshi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-everyshi}"
SRC_URI[x86_64_v2_texlive-everyshi.sha256sum] = "8ec04cb30b46746c7bccab63b121004c7c34a8819be020142f5c7f529eb724e4"

URI_x86_64_v2_texlive-extsizes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-extsizes-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-extsizes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-extsizes}"
SRC_URI[x86_64_v2_texlive-extsizes.sha256sum] = "1f7a72440a13808d61ba24cd3997b7140c60a85648e3a16afdab5b4c281a5935"

URI_x86_64_v2_texlive-fancybox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fancybox-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fancybox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fancybox}"
SRC_URI[x86_64_v2_texlive-fancybox.sha256sum] = "6397dc7e7f3c390f82e5d33f7d1cd87c87b3b5ef989acdf9c87020ff08a6aa89"

URI_x86_64_v2_texlive-fancyhdr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fancyhdr-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fancyhdr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fancyhdr}"
SRC_URI[x86_64_v2_texlive-fancyhdr.sha256sum] = "652231176eb36e94cde6ff52f5182322d8cd9f33290a7a6edd1be785318622ab"

URI_x86_64_v2_texlive-fancyref = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fancyref-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fancyref;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fancyref}"
SRC_URI[x86_64_v2_texlive-fancyref.sha256sum] = "33b3090d2fef6f00346c5cc0657c79cc6bff00829a53f2e02be36be87a4d9fa2"

URI_x86_64_v2_texlive-fancyvrb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fancyvrb-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fancyvrb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fancyvrb}"
SRC_URI[x86_64_v2_texlive-fancyvrb.sha256sum] = "a098780f3f5a5617ef20fe91f790628a3a213cb3d97b1a79d6869c043f2c4db2"

URI_x86_64_v2_texlive-filecontents = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-filecontents-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-filecontents;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-filecontents}"
SRC_URI[x86_64_v2_texlive-filecontents.sha256sum] = "22840e6a1292c358ae68e509abd406cada26d520500c2ed134bd370379ca58a8"

URI_x86_64_v2_texlive-filehook = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-filehook-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-filehook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-filehook}"
SRC_URI[x86_64_v2_texlive-filehook.sha256sum] = "b1e251017051616a3cb85224f56ca6d43f29b46e523fa5ecc9c321de853940cb"

URI_x86_64_v2_texlive-finstrut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-finstrut-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-finstrut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-finstrut}"
SRC_URI[x86_64_v2_texlive-finstrut.sha256sum] = "1e8f5ef6a8c90637f3ea0e5ee20206fd41a814b73f2b3fadb930f2eee8910ac5"

URI_x86_64_v2_texlive-firstaid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-firstaid-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-firstaid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-firstaid}"
SRC_URI[x86_64_v2_texlive-firstaid.sha256sum] = "31f5a95dbaec4daccb2268330e27553ac08776a3924b242fce10e5b8a21cf3c9"

URI_x86_64_v2_texlive-fix2col = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fix2col-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fix2col;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fix2col}"
SRC_URI[x86_64_v2_texlive-fix2col.sha256sum] = "17f672f6ca8e64288ab873a3f803bba539b6ca8f952ec142c52a38eba026b472"

URI_x86_64_v2_texlive-fixlatvian = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fixlatvian-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fixlatvian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fixlatvian}"
SRC_URI[x86_64_v2_texlive-fixlatvian.sha256sum] = "5d2b3020de2ee33bcfc93158f1479c5750b7d422d7a928b9082ed86d7e2c5ac2"

URI_x86_64_v2_texlive-float = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-float-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-float;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-float}"
SRC_URI[x86_64_v2_texlive-float.sha256sum] = "1133a7eef34afe7859bf319a0bb8ead38befe04d08c51c9a738e3ab90c8c3096"

URI_x86_64_v2_texlive-fmtcount = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fmtcount-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fmtcount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fmtcount}"
SRC_URI[x86_64_v2_texlive-fmtcount.sha256sum] = "2f2e486352cf8feddc038d834775aa09df6a8f263caf529c03425f35afceca97"

URI_x86_64_v2_texlive-fncychap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fncychap-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fncychap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fncychap}"
SRC_URI[x86_64_v2_texlive-fncychap.sha256sum] = "82b469184f8bd8b59d98d1ee798c93e204037961ef5bb50443824320a2c114bf"

URI_x86_64_v2_texlive-fontawesome = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fontawesome-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fontawesome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontawesome}"
SRC_URI[x86_64_v2_texlive-fontawesome.sha256sum] = "09488d70ec1bbdb873c98a6acc4e8632f81553d221c5fe4e1d34a61ada34b387"

URI_x86_64_v2_texlive-fontbook = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fontbook-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fontbook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontbook}"
SRC_URI[x86_64_v2_texlive-fontbook.sha256sum] = "02b00ad11ef6a2b02d141b3a116b1e81f9dd62358227de44b5a09c7d5806513a"

URI_x86_64_v2_texlive-fonts-tlwg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fonts-tlwg-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fonts-tlwg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fonts-tlwg}"
SRC_URI[x86_64_v2_texlive-fonts-tlwg.sha256sum] = "564d59f5dcb04b3a6926f83fb722ed06bec7405662a52699c499718cd739abc3"

URI_x86_64_v2_texlive-fontspec = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fontspec-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fontspec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontspec}"
SRC_URI[x86_64_v2_texlive-fontspec.sha256sum] = "b7d0f670f1c40b6a0760cfc7f002edd30b526707a6dbb8c06d8076f1ff6ea431"

URI_x86_64_v2_texlive-fontware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fontware-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-fontware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontware}"
SRC_URI[x86_64_v2_texlive-fontware.sha256sum] = "e539ee8233281fb5c1f537470f74767cd5c63b93f3caa917f2ea6205b451aad3"

URI_x86_64_v2_texlive-fontwrap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fontwrap-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fontwrap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontwrap}"
SRC_URI[x86_64_v2_texlive-fontwrap.sha256sum] = "813df9ca1a5b0aab70b2d719e9f011028704fa72cb6fbcf96bc09af31bb326ed"

URI_x86_64_v2_texlive-footmisc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-footmisc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-footmisc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-footmisc}"
SRC_URI[x86_64_v2_texlive-footmisc.sha256sum] = "69dc1c7285850b0fef37b5848617dd8958e1759c5460ea9df7a18b48b1d384bc"

URI_x86_64_v2_texlive-footnotehyper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-footnotehyper-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-footnotehyper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-footnotehyper}"
SRC_URI[x86_64_v2_texlive-footnotehyper.sha256sum] = "cf25052d51f3805a8fb664d7ed1ff67df92baa590f0a1ee966f888d2ecfd6870"

URI_x86_64_v2_texlive-fp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fp-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fp}"
SRC_URI[x86_64_v2_texlive-fp.sha256sum] = "d1682e024ea41e3b1f7eb2515a74b273e5c4b69861aed2ea51bb65c8320f9c24"

URI_x86_64_v2_texlive-fpl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fpl-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-fpl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fpl}"
SRC_URI[x86_64_v2_texlive-fpl.sha256sum] = "b4b2e15275dd75438534334d3fa2c98da2abd31e9cde35e136071b8cc060f86c"

URI_x86_64_v2_texlive-framed = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-framed-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-framed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-framed}"
SRC_URI[x86_64_v2_texlive-framed.sha256sum] = "68a73bdefd07ce2b893c7828dae84b92da4bf27456960f84b24d7f02e8302982"

URI_x86_64_v2_texlive-garuda-c90 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-garuda-c90-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-garuda-c90;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-garuda-c90}"
SRC_URI[x86_64_v2_texlive-garuda-c90.sha256sum] = "6fe6cb01ad8cfb3a8feab7257ceb1ea1df1b26f1de70d7cd246af82661135dd8"

URI_x86_64_v2_texlive-geometry = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-geometry-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-geometry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-geometry}"
SRC_URI[x86_64_v2_texlive-geometry.sha256sum] = "410c1847a81daa380d1664e4f5a6a10d6aa1b356ef4a7190dea59687b1705867"

URI_x86_64_v2_texlive-gettitlestring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-gettitlestring-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-gettitlestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-gettitlestring}"
SRC_URI[x86_64_v2_texlive-gettitlestring.sha256sum] = "df1f5f31f9824dcff850bf62a31fac2d998a57b250fd59e0e37fff2bc37b2dd0"

URI_x86_64_v2_texlive-glyphlist = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-glyphlist-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-glyphlist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glyphlist}"
SRC_URI[x86_64_v2_texlive-glyphlist.sha256sum] = "0b61b5bf100cced075e6a312dd1bedbf8a671c36d74f79753ab1c016519654e9"

URI_x86_64_v2_texlive-gnu-freefont = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/texlive-gnu-freefont-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-gnu-freefont;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-gnu-freefont}"
SRC_URI[x86_64_v2_texlive-gnu-freefont.sha256sum] = "86a5b55e20a5eff47edcc6cf05fecf475e0f2aa9acfea123724054f96c07071c"

URI_x86_64_v2_texlive-graphics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-graphics-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-graphics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-graphics}"
SRC_URI[x86_64_v2_texlive-graphics.sha256sum] = "ec4a5489684bac3768d808590b341cc46a2f60609ffd43ae072c7b83a22ee663"

URI_x86_64_v2_texlive-graphics-cfg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-graphics-cfg-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-graphics-cfg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-graphics-cfg}"
SRC_URI[x86_64_v2_texlive-graphics-cfg.sha256sum] = "2ba8cbe6edce6a9c93164c9ab3a72aff63ccd66affab04958f9ebcc6ed4e08bd"

URI_x86_64_v2_texlive-graphics-def = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-graphics-def-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-graphics-def;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-graphics-def}"
SRC_URI[x86_64_v2_texlive-graphics-def.sha256sum] = "345b5c43de3c77b20793fd9b313c42c4c3b9f77116348ce7aeb041e123f3e756"

URI_x86_64_v2_texlive-grfext = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-grfext-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-grfext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-grfext}"
SRC_URI[x86_64_v2_texlive-grfext.sha256sum] = "14e9d285e13c5f82186d681e4c862a2981bdba834222d0e85ccee5ab3738b546"

URI_x86_64_v2_texlive-grffile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-grffile-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-grffile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-grffile}"
SRC_URI[x86_64_v2_texlive-grffile.sha256sum] = "930dbdc1dfbe2d8c469ade8e2531916b7737b97738a20ba55a6af6804d71463d"

URI_x86_64_v2_texlive-gsftopk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-gsftopk-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-gsftopk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-gsftopk}"
SRC_URI[x86_64_v2_texlive-gsftopk.sha256sum] = "2d8162896285a86dfca7b310e0b87fa0a2b58f3f0e5900fee0434457aadafb2f"

URI_x86_64_v2_texlive-hanging = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hanging-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hanging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hanging}"
SRC_URI[x86_64_v2_texlive-hanging.sha256sum] = "b1bfb6819626c5dfb35a10b1e9ee71cf1ef5adfffa3c64025bebb03f7657296d"

URI_x86_64_v2_texlive-helvetic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-helvetic-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-helvetic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-helvetic}"
SRC_URI[x86_64_v2_texlive-helvetic.sha256sum] = "0b7968261c4f26af23318aec2dc93de89e499f57a1fdcd29815442ddd8767282"

URI_x86_64_v2_texlive-hobsub = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hobsub-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hobsub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hobsub}"
SRC_URI[x86_64_v2_texlive-hobsub.sha256sum] = "e0336e46093ce5e3329e46a74020069970c4e4f43ebaf63a9e4e4c0f5ea81112"

URI_x86_64_v2_texlive-hologo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hologo-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hologo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hologo}"
SRC_URI[x86_64_v2_texlive-hologo.sha256sum] = "93d047cf0dc0681c339e9814093c739e959ac3e513c70b9e7a3c6d5851b1ed83"

URI_x86_64_v2_texlive-hopatch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hopatch-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hopatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hopatch}"
SRC_URI[x86_64_v2_texlive-hopatch.sha256sum] = "daf3becaa2d8da58b1fbf4c682a6358f592fed37eb29f004f7e1b9a324082028"

URI_x86_64_v2_texlive-hycolor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hycolor-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hycolor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hycolor}"
SRC_URI[x86_64_v2_texlive-hycolor.sha256sum] = "c330e74b21e4cd4f648ea43536d10c6e154d2fe9e324ea0fc767ed783456dfc9"

URI_x86_64_v2_texlive-hypcap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hypcap-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hypcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hypcap}"
SRC_URI[x86_64_v2_texlive-hypcap.sha256sum] = "8137e25d64285242f5758bbda2d319a8f69b60d827596d2d6186bb862b485cfa"

URI_x86_64_v2_texlive-hypdoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hypdoc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hypdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hypdoc}"
SRC_URI[x86_64_v2_texlive-hypdoc.sha256sum] = "c209a690a2c3b28af06f6f82dbaa3c2b2a83a87b44374ebb8329dd35094ae8d1"

URI_x86_64_v2_texlive-hyperref = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hyperref-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hyperref;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyperref}"
SRC_URI[x86_64_v2_texlive-hyperref.sha256sum] = "6735a664b72db7c3298cd6ef15b0c19e0c51f2ea9cbdfc844cf3dc81c27eb190"

URI_x86_64_v2_texlive-hyph-utf8 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hyph-utf8-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hyph-utf8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyph-utf8}"
SRC_URI[x86_64_v2_texlive-hyph-utf8.sha256sum] = "9794a180018ec35022869b853f9cae21062c5bf4275c3a659c7ddaa83143d5db"

URI_x86_64_v2_texlive-hyphen-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hyphen-base-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hyphen-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyphen-base}"
SRC_URI[x86_64_v2_texlive-hyphen-base.sha256sum] = "b5a454a75041f5dcf148f982a47d80e61ece196e8c447bc0978ef178ef235457"

URI_x86_64_v2_texlive-hyphenat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hyphenat-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hyphenat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyphenat}"
SRC_URI[x86_64_v2_texlive-hyphenat.sha256sum] = "a746206e0ff95b5af04df4c8d63194f183997e8c42edbc41cc516ba2a2654d11"

URI_x86_64_v2_texlive-hyphenex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hyphenex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-hyphenex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyphenex}"
SRC_URI[x86_64_v2_texlive-hyphenex.sha256sum] = "f0bfa96740fb55186e8531dda7574cfbf5fb452bd48c016f94a0dc98807925ce"

URI_x86_64_v2_texlive-ifmtarg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ifmtarg-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ifmtarg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ifmtarg}"
SRC_URI[x86_64_v2_texlive-ifmtarg.sha256sum] = "25fb8260d4591ede2ddd1004b1ce88b26f845567deb606d9a89d21af13dea7e1"

URI_x86_64_v2_texlive-ifoddpage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ifoddpage-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ifoddpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ifoddpage}"
SRC_URI[x86_64_v2_texlive-ifoddpage.sha256sum] = "3d9283f8bd9ad361b7fa599f335f33b312f78bd8191fd5699f464009031bf542"

URI_x86_64_v2_texlive-ifplatform = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ifplatform-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ifplatform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ifplatform}"
SRC_URI[x86_64_v2_texlive-ifplatform.sha256sum] = "28f733a8174665781981d85062669200cd3b8ea30a372f2e58fdcdfe62517542"

URI_x86_64_v2_texlive-iftex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-iftex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-iftex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-iftex}"
SRC_URI[x86_64_v2_texlive-iftex.sha256sum] = "7b6bb8f38a019559345afe8b21146f336defb6b3527fcf1af8c8dbd574920d67"

URI_x86_64_v2_texlive-import = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-import-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-import;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-import}"
SRC_URI[x86_64_v2_texlive-import.sha256sum] = "35eedd23d1e8c157f40a5b3703165b347f3cb889bf6230dd674abe76d68eca8b"

URI_x86_64_v2_texlive-index = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-index-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-index}"
SRC_URI[x86_64_v2_texlive-index.sha256sum] = "0de27ff6c09af51b1a1aac5bfe4456c6c3095d0f335cce1652cead6086015319"

URI_x86_64_v2_texlive-infwarerr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-infwarerr-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-infwarerr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-infwarerr}"
SRC_URI[x86_64_v2_texlive-infwarerr.sha256sum] = "c7995e906c968ba217a18cd527cc9525cd2c6373badd40eb49e21db4fe8c7569"

URI_x86_64_v2_texlive-intcalc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-intcalc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-intcalc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-intcalc}"
SRC_URI[x86_64_v2_texlive-intcalc.sha256sum] = "70c9cf07a0386aaf0fe53469c9dc0729e721feda7661e76833aa892190b9a04e"

URI_x86_64_v2_texlive-jadetex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-jadetex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-jadetex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-jadetex}"
SRC_URI[x86_64_v2_texlive-jadetex.sha256sum] = "79149cafe1aea68a2d62eb99fe68a795b92bd5ab87328ebb0e6d5a12f01a186e"

URI_x86_64_v2_texlive-jknapltx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-jknapltx-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-jknapltx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-jknapltx}"
SRC_URI[x86_64_v2_texlive-jknapltx.sha256sum] = "d3bf00b6d605ddd6f20141ae6bdf8b2c87e8a787582ebf4a048b2c13c9ca06cf"

URI_x86_64_v2_texlive-kastrup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kastrup-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-kastrup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kastrup}"
SRC_URI[x86_64_v2_texlive-kastrup.sha256sum] = "c934653c5573b70b8893d9d9a5cafd1e0550cdea135b63e1908132d42837a221"

URI_x86_64_v2_texlive-kerkis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kerkis-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-kerkis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kerkis}"
SRC_URI[x86_64_v2_texlive-kerkis.sha256sum] = "14fcf15d08fff01562c99ed73eea202086d35ac0bbebfdcafc38ec5df996dddb"

URI_x86_64_v2_texlive-knuth-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-knuth-lib-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-knuth-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-knuth-lib}"
SRC_URI[x86_64_v2_texlive-knuth-lib.sha256sum] = "802f92ece8e88b852b1e14ab3dbae5696420303122502c95bf85ab53e0918cf4"

URI_x86_64_v2_texlive-knuth-local = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-knuth-local-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-knuth-local;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-knuth-local}"
SRC_URI[x86_64_v2_texlive-knuth-local.sha256sum] = "fa5ae7b52e7dc20126ae4c2915f0bb483e4c6b7c302d35fde64767a2db082714"

URI_x86_64_v2_texlive-koma-script = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-koma-script-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-koma-script;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-koma-script}"
SRC_URI[x86_64_v2_texlive-koma-script.sha256sum] = "ce096d7829992ed04bb4b6f745c1114810c96d02d9eadd776c0ca1c44e4326e6"

URI_x86_64_v2_texlive-kpathsea = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kpathsea-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-kpathsea;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kpathsea}"
SRC_URI[x86_64_v2_texlive-kpathsea.sha256sum] = "b89a7e82292488f93d539b8fbef0bc40833bd6981ed49d409c4b1a7e4ad11e70"

URI_x86_64_v2_texlive-kvdefinekeys = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kvdefinekeys-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-kvdefinekeys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kvdefinekeys}"
SRC_URI[x86_64_v2_texlive-kvdefinekeys.sha256sum] = "d11aee3f00acfdfe93357fbdaa83c13fa1d74053edc2393f759ac0ba1e57862f"

URI_x86_64_v2_texlive-kvoptions = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kvoptions-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-kvoptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kvoptions}"
SRC_URI[x86_64_v2_texlive-kvoptions.sha256sum] = "6d897439b5aedeaf1289186c082c67fb4eed0ea804e2fa23fe64c293c4c8f40e"

URI_x86_64_v2_texlive-kvsetkeys = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kvsetkeys-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-kvsetkeys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kvsetkeys}"
SRC_URI[x86_64_v2_texlive-kvsetkeys.sha256sum] = "f9e53e1c1c129e160b3e2f33dfc615a3109a52df64068f6d13e2f7049be4a22f"

URI_x86_64_v2_texlive-l3backend = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-l3backend-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-l3backend;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-l3backend}"
SRC_URI[x86_64_v2_texlive-l3backend.sha256sum] = "c80a4b490da01a6c086be0d02bddabbe9a44f4de8e10fccf8c0f707f60022521"

URI_x86_64_v2_texlive-l3experimental = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-l3experimental-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-l3experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-l3experimental}"
SRC_URI[x86_64_v2_texlive-l3experimental.sha256sum] = "a408a27aadf3dba403cf8bd8520a8aa7abdaeb3fcc26406d45999599f28c111d"

URI_x86_64_v2_texlive-l3kernel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-l3kernel-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-l3kernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-l3kernel}"
SRC_URI[x86_64_v2_texlive-l3kernel.sha256sum] = "429c8afda0240d1c16cd8fa4f0b8cb66c659cb7b22966ecda2ad0be17af8c725"

URI_x86_64_v2_texlive-l3packages = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-l3packages-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-l3packages;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-l3packages}"
SRC_URI[x86_64_v2_texlive-l3packages.sha256sum] = "bb91ffc69d003542afdf0395752eb5e4bb40582f123ee20f1b9be891ad17abbe"

URI_x86_64_v2_texlive-lastpage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lastpage-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-lastpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lastpage}"
SRC_URI[x86_64_v2_texlive-lastpage.sha256sum] = "fd1b8f3fd8d386783689bb444385291e43b2a8f6d2eb48e7b81960d3f6acac55"

URI_x86_64_v2_texlive-latex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-latex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-latex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex}"
SRC_URI[x86_64_v2_texlive-latex.sha256sum] = "a463504942d7afe874247573cae24c4a9500d099b4c3fe34b2f422ca646dad4c"
RPROVIDES:texlive-latex:append:x86_64_v2 = " virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_ virtual/texlive-latex"

URI_x86_64_v2_texlive-latex-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-latex-fonts-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-latex-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex-fonts}"
SRC_URI[x86_64_v2_texlive-latex-fonts.sha256sum] = "c956e5756398df793f5a761f27ae25bccd109a28a0d4dc1c9e8b5831e350281f"

URI_x86_64_v2_texlive-latex2man = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-latex2man-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-latex2man;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex2man}"
SRC_URI[x86_64_v2_texlive-latex2man.sha256sum] = "0eb0ab627050c0f44dd8abdf5ace4eca1236eeaf2bd03c7459e36b00f5c46e94"

URI_x86_64_v2_texlive-latexbug = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-latexbug-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-latexbug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latexbug}"
SRC_URI[x86_64_v2_texlive-latexbug.sha256sum] = "27c00c69f68270e70cb447e096996eeacedb1d49834e5c5c5ccdd9bfc3ab9522"

URI_x86_64_v2_texlive-latexconfig = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-latexconfig-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-latexconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latexconfig}"
SRC_URI[x86_64_v2_texlive-latexconfig.sha256sum] = "d3088136fd669c7162a9ef3a3e54842d607bd424d7eb7b39c06af2e6071f4edb"

URI_x86_64_v2_texlive-letltxmacro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-letltxmacro-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-letltxmacro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-letltxmacro}"
SRC_URI[x86_64_v2_texlive-letltxmacro.sha256sum] = "08d50f4fb413fb8a6d4ba2d8807cdb704f947d50f8df52badfaab6ddbf219b40"

URI_x86_64_v2_texlive-lettrine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lettrine-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-lettrine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lettrine}"
SRC_URI[x86_64_v2_texlive-lettrine.sha256sum] = "fbc5a9bcb4401363b227d12f53c34e48caa97d9c83b4bf2a2e90acc37e5bf4cd"

URI_x86_64_v2_texlive-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lib-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lib}"
SRC_URI[x86_64_v2_texlive-lib.sha256sum] = "ded3855db19b4f26dc964f1a3936b06925701fa16fe776ca7d636dbf3cb95c06"

URI_x86_64_v2_texlive-lib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/texlive-lib-devel-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-lib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lib-devel}"
SRC_URI[x86_64_v2_texlive-lib-devel.sha256sum] = "75ea4b8bb96bc0fb9422d4e8550deb5607c3ee944affd8e8a12a60a3c8654e96"

URI_x86_64_v2_texlive-linegoal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-linegoal-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-linegoal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-linegoal}"
SRC_URI[x86_64_v2_texlive-linegoal.sha256sum] = "ff0fa91cf992fab9cb765687ab0e8ea1a8100b40e73d365521ad626d52aa24a5"

URI_x86_64_v2_texlive-lineno = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lineno-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-lineno;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lineno}"
SRC_URI[x86_64_v2_texlive-lineno.sha256sum] = "847b1214306bf9a12376816fb6f1087b24bde8013be20120e1a4d9af987cab5c"

URI_x86_64_v2_texlive-listings = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-listings-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-listings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-listings}"
SRC_URI[x86_64_v2_texlive-listings.sha256sum] = "5db64f123427d23848ea6c4cf69724f5efa8ecf729758c9c69e72ede20838482"

URI_x86_64_v2_texlive-listofitems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-listofitems-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-listofitems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-listofitems}"
SRC_URI[x86_64_v2_texlive-listofitems.sha256sum] = "74d9224b08b2a3d57c621b0c76ceb6218721a83fb2bf47c1136cf52ff9b81be2"

URI_x86_64_v2_texlive-lm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lm-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-lm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lm}"
SRC_URI[x86_64_v2_texlive-lm.sha256sum] = "870d37c634dabb82020062dedec56bff418ba0ff304982c5533ea1adc6539fa7"

URI_x86_64_v2_texlive-lm-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lm-math-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-lm-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lm-math}"
SRC_URI[x86_64_v2_texlive-lm-math.sha256sum] = "9a6836fc0d1398a3c83f08f0f94dcaa270c47bb6611ae5f6f71214018fe464c8"

URI_x86_64_v2_texlive-ltabptch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ltabptch-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ltabptch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ltabptch}"
SRC_URI[x86_64_v2_texlive-ltabptch.sha256sum] = "18757d34b6eba9f14e4ef2030149bce36a87f34f28968ddc7ddab4f51e5f619f"

URI_x86_64_v2_texlive-ltxcmds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ltxcmds-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ltxcmds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ltxcmds}"
SRC_URI[x86_64_v2_texlive-ltxcmds.sha256sum] = "d89ae7253ef2157870421edd5315876a305fb81e4b9b30eedaa579be7898f800"

URI_x86_64_v2_texlive-ltxmisc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ltxmisc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ltxmisc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ltxmisc}"
SRC_URI[x86_64_v2_texlive-ltxmisc.sha256sum] = "044f16dad4052a6d07b5b42e71c2435302809f2575a352c721db938c072cf84c"

URI_x86_64_v2_texlive-lua-alt-getopt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lua-alt-getopt-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-lua-alt-getopt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lua-alt-getopt}"
SRC_URI[x86_64_v2_texlive-lua-alt-getopt.sha256sum] = "4fb6f1101924010b4808f86f5c9b47f89ec8d9d7c2ff9bf2ab0504afa8cafe10"

URI_x86_64_v2_texlive-lua-uni-algos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lua-uni-algos-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-lua-uni-algos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lua-uni-algos}"
SRC_URI[x86_64_v2_texlive-lua-uni-algos.sha256sum] = "f259f0841946fb4b935603e711f15ad8c1e179105cdd3aaa9aa2ebf407a544d0"

URI_x86_64_v2_texlive-luahbtex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-luahbtex-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-luahbtex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luahbtex}"
SRC_URI[x86_64_v2_texlive-luahbtex.sha256sum] = "4a9841618f3e6261b148ee4877c4dee8179da15c4ec2b9e5c067450757f6d572"

URI_x86_64_v2_texlive-lualatex-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lualatex-math-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-lualatex-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lualatex-math}"
SRC_URI[x86_64_v2_texlive-lualatex-math.sha256sum] = "d83022e6241054eafd5ee02f340a4957da15937101784ea473af65f9ea4399c8"

URI_x86_64_v2_texlive-lualibs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lualibs-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-lualibs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lualibs}"
SRC_URI[x86_64_v2_texlive-lualibs.sha256sum] = "e2a2d5708f33880c34d692510a6e86929a4e57fbdd6b12f570af486f858daea4"

URI_x86_64_v2_texlive-luaotfload = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-luaotfload-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-luaotfload;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luaotfload}"
SRC_URI[x86_64_v2_texlive-luaotfload.sha256sum] = "37a85f96ca94f90cb74c216b3b767d21c567ced9ff05bc24501f2fd39fcebc9f"

URI_x86_64_v2_texlive-luatex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-luatex-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-luatex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luatex}"
SRC_URI[x86_64_v2_texlive-luatex.sha256sum] = "b57acfca26c08afb3cee3879121cb84b643d9fafd42e79b7958fd48ee1411bf0"

URI_x86_64_v2_texlive-luatex85 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-luatex85-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-luatex85;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luatex85}"
SRC_URI[x86_64_v2_texlive-luatex85.sha256sum] = "ebdc1cd8e63eeef456cefeaa6c9a4f8398ae98237eba37010c65f72736c40b4d"

URI_x86_64_v2_texlive-luatexbase = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-luatexbase-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-luatexbase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luatexbase}"
SRC_URI[x86_64_v2_texlive-luatexbase.sha256sum] = "7e7a20a1335817cffdc69f91f9023fa74bd9c238d94ef3d87fec0e68b119e944"

URI_x86_64_v2_texlive-lwarp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lwarp-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-lwarp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lwarp}"
SRC_URI[x86_64_v2_texlive-lwarp.sha256sum] = "c035115151353c752431808c16d6800242f84b177f0d966cac217b6062a3f4ec"

URI_x86_64_v2_texlive-makecmds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-makecmds-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-makecmds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-makecmds}"
SRC_URI[x86_64_v2_texlive-makecmds.sha256sum] = "491d07fda42ca73f24dde21d4b12f34e1ecce134fca26329d00ec27ca3acefeb"

URI_x86_64_v2_texlive-makeindex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-makeindex-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-makeindex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-makeindex}"
SRC_URI[x86_64_v2_texlive-makeindex.sha256sum] = "c62f2c9015f4c69566083b0a98c89ddd309cbb59d3c728a03a9c7828aef0b2d0"

URI_x86_64_v2_texlive-manfnt-font = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-manfnt-font-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-manfnt-font;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-manfnt-font}"
SRC_URI[x86_64_v2_texlive-manfnt-font.sha256sum] = "9cec5bcb7cf06278a2eb0d3c1ada61f7b78292a7da1c5f6ad5e3f28958bdc547"

URI_x86_64_v2_texlive-marginnote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-marginnote-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-marginnote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-marginnote}"
SRC_URI[x86_64_v2_texlive-marginnote.sha256sum] = "c4fdd82885a218939ac1a95fa711e61749d907362f191220a9c151f44e724b2b"

URI_x86_64_v2_texlive-marvosym = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-marvosym-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-marvosym;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-marvosym}"
SRC_URI[x86_64_v2_texlive-marvosym.sha256sum] = "078bc7b64a9a3b0b87edcdd3638e8c5ed452fadaa0f845cd5624ac696f8d33d7"

URI_x86_64_v2_texlive-mathpazo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mathpazo-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-mathpazo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mathpazo}"
SRC_URI[x86_64_v2_texlive-mathpazo.sha256sum] = "115b2120f6f4fdd4c2a018c123848b67031eaa782388e8d5d27efe3979293175"

URI_x86_64_v2_texlive-mathspec = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mathspec-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-mathspec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mathspec}"
SRC_URI[x86_64_v2_texlive-mathspec.sha256sum] = "d12563ef1f8be490df25d75a553be08bec71a88d794daf71914cb5ed2331d64f"

URI_x86_64_v2_texlive-mathtools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mathtools-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-mathtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mathtools}"
SRC_URI[x86_64_v2_texlive-mathtools.sha256sum] = "4be2776d66c339ee7d1198ee8b9ef71ac0a10c85c2d4e3f1704cae3df7851b8c"

URI_x86_64_v2_texlive-mdwtools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mdwtools-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-mdwtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mdwtools}"
SRC_URI[x86_64_v2_texlive-mdwtools.sha256sum] = "28d8a857e825c8ea7031a9cf641752a80ee323b3f7cc681b4cd7c64d76a7699a"

URI_x86_64_v2_texlive-memoir = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-memoir-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-memoir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-memoir}"
SRC_URI[x86_64_v2_texlive-memoir.sha256sum] = "15223364fe278176dd67ec9ff604e6a0ea060e7c424a70be6e2a2ac9f0427e88"

URI_x86_64_v2_texlive-metafont = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-metafont-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-metafont;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-metafont}"
SRC_URI[x86_64_v2_texlive-metafont.sha256sum] = "9fed63b33ba52eaf8ea90f273e8630102c6ca56203e2d7d81b7e66ffc8d39796"

URI_x86_64_v2_texlive-metalogo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-metalogo-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-metalogo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-metalogo}"
SRC_URI[x86_64_v2_texlive-metalogo.sha256sum] = "8efc7ea8af63eafaf11f691ffe06ffb8a005a3d4a19f50a0f2ea70e9ee4d40af"

URI_x86_64_v2_texlive-metapost = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-metapost-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-metapost;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-metapost}"
SRC_URI[x86_64_v2_texlive-metapost.sha256sum] = "e7a931edeccff6b47cb61d7a042c35c320d01364119ae5727c0e6d8e1dec412d"

URI_x86_64_v2_texlive-mflogo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mflogo-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-mflogo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mflogo}"
SRC_URI[x86_64_v2_texlive-mflogo.sha256sum] = "cbdfd878c8f3b3ef4b63548114ba0a862a9dc1842f018d548223ca900dbe6e11"

URI_x86_64_v2_texlive-mflogo-font = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mflogo-font-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-mflogo-font;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mflogo-font}"
SRC_URI[x86_64_v2_texlive-mflogo-font.sha256sum] = "b9e1d6f6a34897ef76094a79201bf6c5eddfcb71e0caae54e23a177b2615b9ea"

URI_x86_64_v2_texlive-mfnfss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mfnfss-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-mfnfss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mfnfss}"
SRC_URI[x86_64_v2_texlive-mfnfss.sha256sum] = "130c4044a96ef88759dcb4e5e2323682120852f82e25dc4a888fb40272010d92"

URI_x86_64_v2_texlive-mfware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mfware-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-mfware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mfware}"
SRC_URI[x86_64_v2_texlive-mfware.sha256sum] = "7f6a0c2227d1b35cf3f44b75a708be1fed4a98591c8684a5da9d34f8ded2d02a"

URI_x86_64_v2_texlive-microtype = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-microtype-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-microtype;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-microtype}"
SRC_URI[x86_64_v2_texlive-microtype.sha256sum] = "8031a0a3568539b1c8aba69b68cd1089a5c37c51a8acaa8d688ba898a6770c62"

URI_x86_64_v2_texlive-minitoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-minitoc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-minitoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-minitoc}"
SRC_URI[x86_64_v2_texlive-minitoc.sha256sum] = "f5043f59eb717d72c7af353180c2a94dfa363d4baf087293b6ba940842e112cc"

URI_x86_64_v2_texlive-mnsymbol = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mnsymbol-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-mnsymbol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mnsymbol}"
SRC_URI[x86_64_v2_texlive-mnsymbol.sha256sum] = "b14f13a8b7e9c1c7ae8de31d0b6c677ed9bfd4d91d55b8dda4bdbedf4769f683"

URI_x86_64_v2_texlive-modes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-modes-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-modes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-modes}"
SRC_URI[x86_64_v2_texlive-modes.sha256sum] = "4418dc9e04558a355851cf1ec52d2a30a165ddedf6967caf2fb1c2ac195c746d"

URI_x86_64_v2_texlive-mparhack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mparhack-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-mparhack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mparhack}"
SRC_URI[x86_64_v2_texlive-mparhack.sha256sum] = "7b9a819c9119ea302dfc44cf9e839e062ff121015f6e1b269abcead4868da4aa"

URI_x86_64_v2_texlive-mptopdf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mptopdf-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-mptopdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mptopdf}"
SRC_URI[x86_64_v2_texlive-mptopdf.sha256sum] = "ec7accf5f4f4d36ddd23a313656bd5b8af31fb199afd5cc50c89d82236b872d7"

URI_x86_64_v2_texlive-multido = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-multido-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-multido;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-multido}"
SRC_URI[x86_64_v2_texlive-multido.sha256sum] = "a3e14ac997a1d378ef977d99667bf9542934056b581e449865f431f05c1a3d67"

URI_x86_64_v2_texlive-multirow = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-multirow-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-multirow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-multirow}"
SRC_URI[x86_64_v2_texlive-multirow.sha256sum] = "f7273ef1874d2ad0658339d7770b8ef91b1dbfbbb5191a4b2f9955a5d690a01f"

URI_x86_64_v2_texlive-multitoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-multitoc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-multitoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-multitoc}"
SRC_URI[x86_64_v2_texlive-multitoc.sha256sum] = "f47ffd1665ec47b2b6c218cf851b4c85dc720d3df52fcc03a53e7aff1944a588"

URI_x86_64_v2_texlive-natbib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-natbib-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-natbib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-natbib}"
SRC_URI[x86_64_v2_texlive-natbib.sha256sum] = "da51fcbc61ad8871d446522661b2647df0ca2b93b5d4512981e79be906291051"

URI_x86_64_v2_texlive-ncctools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ncctools-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ncctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ncctools}"
SRC_URI[x86_64_v2_texlive-ncctools.sha256sum] = "1f860592d1796afcc34bee0e3c4e7c9cd7fbd5dad83d53266df08de312cdc908"

URI_x86_64_v2_texlive-ncntrsbk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ncntrsbk-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ncntrsbk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ncntrsbk}"
SRC_URI[x86_64_v2_texlive-ncntrsbk.sha256sum] = "6251576f9368a7563aad9da161e5f1d6389cc0d974e9cbc9d05cc4af24f77e62"

URI_x86_64_v2_texlive-needspace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-needspace-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-needspace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-needspace}"
SRC_URI[x86_64_v2_texlive-needspace.sha256sum] = "a4682c25896fcbb371c56c78365ccd8aa280e79effd5323883eb91a4e651f912"

URI_x86_64_v2_texlive-newfloat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-newfloat-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-newfloat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-newfloat}"
SRC_URI[x86_64_v2_texlive-newfloat.sha256sum] = "1504537a82467927678ced0c0e859a699d712a95b4600dfb7afde1d0af7bbbb1"

URI_x86_64_v2_texlive-newunicodechar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-newunicodechar-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-newunicodechar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-newunicodechar}"
SRC_URI[x86_64_v2_texlive-newunicodechar.sha256sum] = "cf1949ec476bf8f2934c5ed6db14ee7010c53a5d12bd22a87b97ba6a0e94e637"

URI_x86_64_v2_texlive-norasi-c90 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-norasi-c90-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-norasi-c90;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-norasi-c90}"
SRC_URI[x86_64_v2_texlive-norasi-c90.sha256sum] = "8f058965dce5a913d3ac36d25b3344233d5acf9ce26efe7e56ed5fac199c51c3"

URI_x86_64_v2_texlive-notoccite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-notoccite-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-notoccite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-notoccite}"
SRC_URI[x86_64_v2_texlive-notoccite.sha256sum] = "3ae343008dc1ac2de9742625cbd8635d62f557ea6cd58ee63e1a59b2712c9480"

URI_x86_64_v2_texlive-ntgclass = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ntgclass-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ntgclass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ntgclass}"
SRC_URI[x86_64_v2_texlive-ntgclass.sha256sum] = "dcd8de656d6be698858bb1d92f9933a3e6590fd09059efa9eb016b02fb43e912"

URI_x86_64_v2_texlive-oberdiek = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-oberdiek-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-oberdiek;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-oberdiek}"
SRC_URI[x86_64_v2_texlive-oberdiek.sha256sum] = "4669c32a90e8515ca3a55685bdfd87e7bc3688392b0b2a22de8e25ece6cd2d07"

URI_x86_64_v2_texlive-overpic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-overpic-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-overpic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-overpic}"
SRC_URI[x86_64_v2_texlive-overpic.sha256sum] = "6afc155d6b0569a71c8cf047dca6f999b818142e72f9772681e99dcdf3a54795"

URI_x86_64_v2_texlive-palatino = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-palatino-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-palatino;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-palatino}"
SRC_URI[x86_64_v2_texlive-palatino.sha256sum] = "1043000116fd5af45278b7204eba7f6b4e3e44d96e7fc80e198c16c790e2920a"

URI_x86_64_v2_texlive-paralist = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-paralist-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-paralist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-paralist}"
SRC_URI[x86_64_v2_texlive-paralist.sha256sum] = "3ae6ca32c4c581d3ea2adb0f3b429244c20a509798b25fd676daf638f04858e3"

URI_x86_64_v2_texlive-parallel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-parallel-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-parallel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-parallel}"
SRC_URI[x86_64_v2_texlive-parallel.sha256sum] = "3ad9eef2fa82fcf12e51f4a7dc3e2c1b75f7b8007c67fb8e429929a6477ed5e1"

URI_x86_64_v2_texlive-parskip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-parskip-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-parskip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-parskip}"
SRC_URI[x86_64_v2_texlive-parskip.sha256sum] = "ad057883cf28ca7f334690bc3e91a16f7964c3ce7915b4687fa9c44ca854580f"

URI_x86_64_v2_texlive-passivetex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-passivetex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-passivetex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-passivetex}"
SRC_URI[x86_64_v2_texlive-passivetex.sha256sum] = "1068ea61ed7e8a7317e5c100a6016261cd0df91bdcd7858365497b3ac534e031"

URI_x86_64_v2_texlive-pdfcol = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfcol-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pdfcol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfcol}"
SRC_URI[x86_64_v2_texlive-pdfcol.sha256sum] = "dfe4c5b0c3e5bb182e6b0e4d4e0e7d40afc36bccab13bebcfe178712c3b8a8fc"

URI_x86_64_v2_texlive-pdfcolfoot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfcolfoot-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pdfcolfoot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfcolfoot}"
SRC_URI[x86_64_v2_texlive-pdfcolfoot.sha256sum] = "3971f8a891fbc91735b54c7ea44ffd86d09bd663ef5370bec233bd96dee1ee2a"

URI_x86_64_v2_texlive-pdfcolmk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfcolmk-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pdfcolmk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfcolmk}"
SRC_URI[x86_64_v2_texlive-pdfcolmk.sha256sum] = "ee6a4d241edf9555b09b0b602f261416720e4964d565cbb33f18581e7bbb9eff"

URI_x86_64_v2_texlive-pdfescape = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfescape-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pdfescape;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfescape}"
SRC_URI[x86_64_v2_texlive-pdfescape.sha256sum] = "55688d02facaa9cf6f4c07092a6fd427715e1b77ba4e3eba26aa5b7c65cd0a9b"

URI_x86_64_v2_texlive-pdflscape = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdflscape-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pdflscape;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdflscape}"
SRC_URI[x86_64_v2_texlive-pdflscape.sha256sum] = "315c87a8df3eae1482b4b82068bb08c758ee759dfe3a4f5065be96abdd656b71"

URI_x86_64_v2_texlive-pdfmanagement-testphase = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfmanagement-testphase-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pdfmanagement-testphase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfmanagement-testphase}"
SRC_URI[x86_64_v2_texlive-pdfmanagement-testphase.sha256sum] = "7422f1121ada16fcc037680b844f22bce7d5a74fce0f467a8894e4a262e7bd62"

URI_x86_64_v2_texlive-pdfpages = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfpages-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pdfpages;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfpages}"
SRC_URI[x86_64_v2_texlive-pdfpages.sha256sum] = "24b64b1776f43c1d30789e120d3737b66793c498641aabf744ab49d2650914db"

URI_x86_64_v2_texlive-pdftex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdftex-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-pdftex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdftex}"
SRC_URI[x86_64_v2_texlive-pdftex.sha256sum] = "9f152198e150e6c3dcafa5e0f22cc56d4e18e10f166ba3481f907de2524e0a83"

URI_x86_64_v2_texlive-pdftexcmds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdftexcmds-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pdftexcmds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdftexcmds}"
SRC_URI[x86_64_v2_texlive-pdftexcmds.sha256sum] = "b108e09f93ae42aa27eef17110ed236d420d5e71bfe025d7688608c45408ce59"

URI_x86_64_v2_texlive-pgf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pgf-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pgf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pgf}"
SRC_URI[x86_64_v2_texlive-pgf.sha256sum] = "2a963c70cf2e1648e43ab37068847a9b43aff66e0b3dd82041fd14e254bd6ed7"

URI_x86_64_v2_texlive-philokalia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-philokalia-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-philokalia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-philokalia}"
SRC_URI[x86_64_v2_texlive-philokalia.sha256sum] = "a12b0cfb225676af7b7adb96c0dd6af3eca33c1f0bfdd70837cd343b878a0981"

URI_x86_64_v2_texlive-placeins = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-placeins-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-placeins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-placeins}"
SRC_URI[x86_64_v2_texlive-placeins.sha256sum] = "c88da1b2d7e321d13f7822085a25098f29c50a384792489ca0ae4475691d2ab4"

URI_x86_64_v2_texlive-plain = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-plain-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-plain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-plain}"
SRC_URI[x86_64_v2_texlive-plain.sha256sum] = "17d99b9e0821f701556b2d62642624ec50e3dee44e8b543767c33c8e1d437362"

URI_x86_64_v2_texlive-polyglossia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-polyglossia-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-polyglossia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-polyglossia}"
SRC_URI[x86_64_v2_texlive-polyglossia.sha256sum] = "878086d830fd66800eb70e738048a823cb4e2458ac1abb6048a527d967503233"

URI_x86_64_v2_texlive-powerdot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-powerdot-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-powerdot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-powerdot}"
SRC_URI[x86_64_v2_texlive-powerdot.sha256sum] = "59eaf25da2702bce4dcb734daa815c346c0dde474cdcd74b219ee340917ee530"

URI_x86_64_v2_texlive-preprint = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-preprint-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-preprint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-preprint}"
SRC_URI[x86_64_v2_texlive-preprint.sha256sum] = "e0f8c1eb0b595683dbf3776218850ff3c83b7ac44511d6d446c922b89f184fb8"

URI_x86_64_v2_texlive-psfrag = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-psfrag-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-psfrag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-psfrag}"
SRC_URI[x86_64_v2_texlive-psfrag.sha256sum] = "d1ea2a7d96f5db9b13cebc06c2cce52545d0dacdab574d9255844b27d0c53671"

URI_x86_64_v2_texlive-pslatex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pslatex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pslatex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pslatex}"
SRC_URI[x86_64_v2_texlive-pslatex.sha256sum] = "142f19aa4bb22f2e7e1f3cc35e5c450a1ea99d2f2db7edd4596bc432ad52d670"

URI_x86_64_v2_texlive-psnfss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-psnfss-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-psnfss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-psnfss}"
SRC_URI[x86_64_v2_texlive-psnfss.sha256sum] = "d10837e1e574330699b490438a37bf2b4df781cb75a4a5a58361f5155025c8c7"

URI_x86_64_v2_texlive-pspicture = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pspicture-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pspicture;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pspicture}"
SRC_URI[x86_64_v2_texlive-pspicture.sha256sum] = "8ab4d439b459e252ac9a70d1c9d87591ec2f53129789f5c3cbe8d216b0e7ecbe"

URI_x86_64_v2_texlive-pst-3d = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-3d-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-3d}"
SRC_URI[x86_64_v2_texlive-pst-3d.sha256sum] = "efac7c1f4911f82cfcaf8af5f9d0cf93115ae8130d511b3c9f263bda2e0df622"

URI_x86_64_v2_texlive-pst-arrow = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-arrow-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-arrow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-arrow}"
SRC_URI[x86_64_v2_texlive-pst-arrow.sha256sum] = "1c985bfbfbe7a73b0edd94ea84fc7c19cb16164478a8f32e2dead0db3421b663"

URI_x86_64_v2_texlive-pst-blur = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-blur-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-blur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-blur}"
SRC_URI[x86_64_v2_texlive-pst-blur.sha256sum] = "f36bf6ecb5689270d916536171b260f73de9b1a1d427c27c23cc6923caf4a7bc"

URI_x86_64_v2_texlive-pst-coil = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-coil-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-coil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-coil}"
SRC_URI[x86_64_v2_texlive-pst-coil.sha256sum] = "267015b1412f6662a96000ce6385e57cbdb1012ea16247bb3d872fd1c4dafd90"

URI_x86_64_v2_texlive-pst-eps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-eps-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-eps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-eps}"
SRC_URI[x86_64_v2_texlive-pst-eps.sha256sum] = "8a830840ff11690118dd4524fbcb7b9b073b344f3bf471bae2be1d8807996c16"

URI_x86_64_v2_texlive-pst-fill = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-fill-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-fill;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-fill}"
SRC_URI[x86_64_v2_texlive-pst-fill.sha256sum] = "96dc7a756e8834a6afbc1d8a7918c1fdc73a7ac46e20be1ab62687ad66d4fc40"

URI_x86_64_v2_texlive-pst-grad = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-grad-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-grad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-grad}"
SRC_URI[x86_64_v2_texlive-pst-grad.sha256sum] = "c1e4ac5c00244a7339ede6b3af0b0b0e1631f0961bc3fb7b65fbe7ff9704d534"

URI_x86_64_v2_texlive-pst-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-math-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-math}"
SRC_URI[x86_64_v2_texlive-pst-math.sha256sum] = "9c173ec926580063a1d78c81de3add5baee30f2f304a4fed6abd485c4710be1c"

URI_x86_64_v2_texlive-pst-node = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-node-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-node;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-node}"
SRC_URI[x86_64_v2_texlive-pst-node.sha256sum] = "119ab3c28982638c47db4c70816cdfc6fbe1e5ed940f475a2cf6320d772894d2"

URI_x86_64_v2_texlive-pst-plot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-plot-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-plot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-plot}"
SRC_URI[x86_64_v2_texlive-pst-plot.sha256sum] = "20e09a14e2fa2fcb8db313f471f2218ee2ae97151509dc66a2945e6ddcdb0451"

URI_x86_64_v2_texlive-pst-slpe = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-slpe-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-slpe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-slpe}"
SRC_URI[x86_64_v2_texlive-pst-slpe.sha256sum] = "ba682149cee935ffd676df9e6f086123f4c4e4e6d7744181017ab9215b9dd599"

URI_x86_64_v2_texlive-pst-text = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-text-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-text}"
SRC_URI[x86_64_v2_texlive-pst-text.sha256sum] = "a0f4f0432d09b53275329216fdfeb6534216eb496183ca8891ff23520a85d4a1"

URI_x86_64_v2_texlive-pst-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-tools-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-tools}"
SRC_URI[x86_64_v2_texlive-pst-tools.sha256sum] = "9f80e4a8587530ad6471bd2c0de7614bd3bf4f8a83a36917abfe5026ae2cdfe4"

URI_x86_64_v2_texlive-pst-tree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-tree-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pst-tree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-tree}"
SRC_URI[x86_64_v2_texlive-pst-tree.sha256sum] = "dfbf53f0a3d5550210e014aa3c5883f9828ef28db880db1caf7892e316fed449"

URI_x86_64_v2_texlive-pstricks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pstricks-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pstricks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pstricks}"
SRC_URI[x86_64_v2_texlive-pstricks.sha256sum] = "aff55ebb65afd55ab64c606063ea5e7b565a8b21ed189300651d4969ec308710"

URI_x86_64_v2_texlive-pstricks-add = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pstricks-add-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pstricks-add;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pstricks-add}"
SRC_URI[x86_64_v2_texlive-pstricks-add.sha256sum] = "8527c2d3188501330928d5799714a9fa7bd6665a7ced118c87b4c9066e42db74"

URI_x86_64_v2_texlive-ptext = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ptext-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ptext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptext}"
SRC_URI[x86_64_v2_texlive-ptext.sha256sum] = "03ec72f59f89c83b86ac9ce286c7465445499c554a2b1df4bf5156fffe41075a"

URI_x86_64_v2_texlive-pxfonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pxfonts-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-pxfonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pxfonts}"
SRC_URI[x86_64_v2_texlive-pxfonts.sha256sum] = "28bdd60ee035061e6a882a1ad823bae4cab70b71f9495519164c5c7dee0c97cc"

URI_x86_64_v2_texlive-qstest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-qstest-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-qstest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-qstest}"
SRC_URI[x86_64_v2_texlive-qstest.sha256sum] = "3661c41e9750061c30e533ac706811b00d62d7c08394be1108886e29437cc242"

URI_x86_64_v2_texlive-ragged2e = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ragged2e-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ragged2e;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ragged2e}"
SRC_URI[x86_64_v2_texlive-ragged2e.sha256sum] = "da2688c1a2f78d3294b568c97ca79ee7fba93101f44cfbeef09d8cda6984f2a3"

URI_x86_64_v2_texlive-rcs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-rcs-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-rcs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-rcs}"
SRC_URI[x86_64_v2_texlive-rcs.sha256sum] = "0845c9d6c9a7090f7a7cfe973c6b49119446ffa6b347ff29028060399c545ae3"

URI_x86_64_v2_texlive-realscripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-realscripts-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-realscripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-realscripts}"
SRC_URI[x86_64_v2_texlive-realscripts.sha256sum] = "87d1c1b60f3af3f48b7a1f1df032c1bff91b66c7fe90357242e20f3625651ccf"

URI_x86_64_v2_texlive-refcount = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-refcount-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-refcount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-refcount}"
SRC_URI[x86_64_v2_texlive-refcount.sha256sum] = "a3b5bd7aefe5870e20d056d705ca139550f25902caf22160c02227a9c651fb70"

URI_x86_64_v2_texlive-relsize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-relsize-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-relsize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-relsize}"
SRC_URI[x86_64_v2_texlive-relsize.sha256sum] = "6ce2ac2f7dc69e2f6223d1975b9b2e6c5eb840eb7387a937af946b5186fa7aec"

URI_x86_64_v2_texlive-rerunfilecheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-rerunfilecheck-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-rerunfilecheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-rerunfilecheck}"
SRC_URI[x86_64_v2_texlive-rerunfilecheck.sha256sum] = "1a939772aa802ca2fc79fe6c18d46d80885f4a3ccea35c22e899f2253adbb995"

URI_x86_64_v2_texlive-rsfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-rsfs-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-rsfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-rsfs}"
SRC_URI[x86_64_v2_texlive-rsfs.sha256sum] = "534fffff5e5cba0a0b09fbaebc48bc01b373ef33cfe425519f0183721131f3d0"

URI_x86_64_v2_texlive-sansmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sansmath-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-sansmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sansmath}"
SRC_URI[x86_64_v2_texlive-sansmath.sha256sum] = "08283f85a678d569796d52cfb96f860170de03b80cc86e6a28eb57f9a9b87932"

URI_x86_64_v2_texlive-sansmathaccent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sansmathaccent-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-sansmathaccent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sansmathaccent}"
SRC_URI[x86_64_v2_texlive-sansmathaccent.sha256sum] = "2c309ff48d5b6c331418f999bb947b18ecd3a1b95f8b0af617de7e548b07cdd2"

URI_x86_64_v2_texlive-sauerj = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sauerj-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-sauerj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sauerj}"
SRC_URI[x86_64_v2_texlive-sauerj.sha256sum] = "0dee151aa4648617cee1c986a6a7856088e8763ed7cb1a2504ed1c240083ea71"

URI_x86_64_v2_texlive-scheme-basic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-scheme-basic-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-scheme-basic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-scheme-basic}"
SRC_URI[x86_64_v2_texlive-scheme-basic.sha256sum] = "7cb43973ec7e17e2f4fd1f5a5df221ed23c23f1d43be68ddce34e9f69eb4862e"

URI_x86_64_v2_texlive-section = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-section-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-section;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-section}"
SRC_URI[x86_64_v2_texlive-section.sha256sum] = "00f1e314b0060c903f28ff80f69eadbaf755c23a9df51e562f70a06492f17da8"

URI_x86_64_v2_texlive-sectsty = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sectsty-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-sectsty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sectsty}"
SRC_URI[x86_64_v2_texlive-sectsty.sha256sum] = "4892147c37adbb06efebae4776844a74b2c2738b526a4bd1dc6c0b6db28719eb"

URI_x86_64_v2_texlive-seminar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-seminar-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-seminar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-seminar}"
SRC_URI[x86_64_v2_texlive-seminar.sha256sum] = "4184740d93d1a8f017d66e12b2ab4783dd70b87302dcbaf2183cb8bd9c29eb8d"

URI_x86_64_v2_texlive-sepnum = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sepnum-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-sepnum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sepnum}"
SRC_URI[x86_64_v2_texlive-sepnum.sha256sum] = "8ae7b27a310e943c4e32b3ed51148af1217b263c97b9e3e127e52ad8e23e92cf"

URI_x86_64_v2_texlive-setspace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-setspace-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-setspace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-setspace}"
SRC_URI[x86_64_v2_texlive-setspace.sha256sum] = "3c10e16e21bed84a7803ee46a79b80617a743a19a7c202e08af8b299ef5f702a"

URI_x86_64_v2_texlive-sfmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sfmath-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-sfmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sfmath}"
SRC_URI[x86_64_v2_texlive-sfmath.sha256sum] = "6553311a2eee5f21127f40e52feca5da18e394515771e7741a993efc63110093"

URI_x86_64_v2_texlive-showexpl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-showexpl-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-showexpl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-showexpl}"
SRC_URI[x86_64_v2_texlive-showexpl.sha256sum] = "491c1866d4b0ef9c0aca2943d0afdb1ca24dde8257a31858b3b31fe84264518e"

URI_x86_64_v2_texlive-soul = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-soul-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-soul;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-soul}"
SRC_URI[x86_64_v2_texlive-soul.sha256sum] = "47d703c5a949adabcabd0dc1e3ff6fef61c9a4b6ff7293d94c7e181ad799eec5"

URI_x86_64_v2_texlive-stackengine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-stackengine-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-stackengine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-stackengine}"
SRC_URI[x86_64_v2_texlive-stackengine.sha256sum] = "c23ea31b76538f456d5abab1c818e3881493af0e96c0af5ee92111dde67811a0"

URI_x86_64_v2_texlive-stmaryrd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-stmaryrd-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-stmaryrd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-stmaryrd}"
SRC_URI[x86_64_v2_texlive-stmaryrd.sha256sum] = "ccfed540249465ffa89699bd24cb4368d4c531313767279ee28ae1930653784e"

URI_x86_64_v2_texlive-stringenc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-stringenc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-stringenc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-stringenc}"
SRC_URI[x86_64_v2_texlive-stringenc.sha256sum] = "f7af7fc98f76993aad383347652050912b8b7f7c701ef1e0d5106ed0899dadff"

URI_x86_64_v2_texlive-subfig = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-subfig-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-subfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-subfig}"
SRC_URI[x86_64_v2_texlive-subfig.sha256sum] = "6a92670a22d86a4ae0d58696d55b12eba88fadb7d770ba1de554745d07b9183f"

URI_x86_64_v2_texlive-subfigure = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-subfigure-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-subfigure;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-subfigure}"
SRC_URI[x86_64_v2_texlive-subfigure.sha256sum] = "9ba539b29bffb9e076f52f838cb88a876def656eeb065cca46d32a064aaa385e"

URI_x86_64_v2_texlive-svn-prov = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-svn-prov-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-svn-prov;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-svn-prov}"
SRC_URI[x86_64_v2_texlive-svn-prov.sha256sum] = "fbf4c8f8c751e9382507180807e9136fb600bd5473eeda22c2a396f001772db1"

URI_x86_64_v2_texlive-symbol = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-symbol-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-symbol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-symbol}"
SRC_URI[x86_64_v2_texlive-symbol.sha256sum] = "462cdcfa00e4399cff2c39179124a1ea13aebbe6bf2b0116223d9a98ea6ab213"

URI_x86_64_v2_texlive-t2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-t2-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-t2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-t2}"
SRC_URI[x86_64_v2_texlive-t2.sha256sum] = "bbfd737544f9067434ef308f6de40ec28f6c797848debee03c2ea06b08289f6a"

URI_x86_64_v2_texlive-tabu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tabu-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-tabu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tabu}"
SRC_URI[x86_64_v2_texlive-tabu.sha256sum] = "5c2f6cebbfad62c218feac42937f4a9ced2214d34b20ff1cb6742596896784aa"

URI_x86_64_v2_texlive-tabulary = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tabulary-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-tabulary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tabulary}"
SRC_URI[x86_64_v2_texlive-tabulary.sha256sum] = "a3b8c25b09b443338d08c97e243a489aca02b198698018ba0607db739b228fb7"

URI_x86_64_v2_texlive-tex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tex-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-tex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tex}"
SRC_URI[x86_64_v2_texlive-tex.sha256sum] = "dd658306d7b0f32d58226297081ca4217c02b9cb63a87fa6b36662d0a6c3eb35"

URI_x86_64_v2_texlive-tex-gyre = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tex-gyre-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-tex-gyre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tex-gyre}"
SRC_URI[x86_64_v2_texlive-tex-gyre.sha256sum] = "9477722053646030e21371854dd81dd891d8ef2d8d325d71d187c9349526d00b"

URI_x86_64_v2_texlive-tex-gyre-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tex-gyre-math-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-tex-gyre-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tex-gyre-math}"
SRC_URI[x86_64_v2_texlive-tex-gyre-math.sha256sum] = "5ec8584e24053305e5e5e119dfd396765de5526c7df024cb302b8e9f6b20c013"

URI_x86_64_v2_texlive-tex-ini-files = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tex-ini-files-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-tex-ini-files;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tex-ini-files}"
SRC_URI[x86_64_v2_texlive-tex-ini-files.sha256sum] = "fe197c833a773a1e52ca6c625999238d2583f6faa3f0b0f6bbe24c8bde1fdab1"

URI_x86_64_v2_texlive-tex4ht = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tex4ht-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-tex4ht;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tex4ht}"
SRC_URI[x86_64_v2_texlive-tex4ht.sha256sum] = "8c9a8c307f1fedab420038e2d8bbe37e904850b872c8a8064730ae590b81c2c7"

URI_x86_64_v2_texlive-texlive-common-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive-common-doc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-texlive-common-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive-common-doc}"
SRC_URI[x86_64_v2_texlive-texlive-common-doc.sha256sum] = "8f5594caf4b732b24fd825b851ad960270ad45c411f29f10963a9e1de93b7123"

URI_x86_64_v2_texlive-texlive-en = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive-en-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-texlive-en;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive-en}"
SRC_URI[x86_64_v2_texlive-texlive-en.sha256sum] = "2c1881bbe5c7ddcabe7dfa4108c18e143cd4229c4d9cd4da20529ea2eab6ea82"

URI_x86_64_v2_texlive-texlive-msg-translations = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive-msg-translations-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-texlive-msg-translations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive-msg-translations}"
SRC_URI[x86_64_v2_texlive-texlive-msg-translations.sha256sum] = "69f01cfb30a9c0bb51967c3beb2e6e119d97ee4036be17f46774d1b385127e90"

URI_x86_64_v2_texlive-texlive-scripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive-scripts-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-texlive-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive-scripts}"
SRC_URI[x86_64_v2_texlive-texlive-scripts.sha256sum] = "47008a42465488d481cf440e5518cc0763de2a788ce58a2e05e5ab5bc7d17b8d"

URI_x86_64_v2_texlive-texlive-scripts-extra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive-scripts-extra-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-texlive-scripts-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive-scripts-extra}"
SRC_URI[x86_64_v2_texlive-texlive-scripts-extra.sha256sum] = "4c4a42eaa607c8a3eee96ae6abd9f482d0ea80502a4366279c45f10528cd5b8e"

URI_x86_64_v2_texlive-texlive.infra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive.infra-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-texlive.infra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive.infra}"
SRC_URI[x86_64_v2_texlive-texlive.infra.sha256sum] = "d2d0ad3d87954fb35aa4136d2d5f02c59416e414b1d760273ef4901659b48092"

URI_x86_64_v2_texlive-textcase = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-textcase-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-textcase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-textcase}"
SRC_URI[x86_64_v2_texlive-textcase.sha256sum] = "a8589fc5649923dc42f488cc0a12d8420a98dfc9abd82790076453951de0f107"

URI_x86_64_v2_texlive-textpos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-textpos-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-textpos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-textpos}"
SRC_URI[x86_64_v2_texlive-textpos.sha256sum] = "6ed267cb379e611a9315d4b05f26d3e84a597d4c880743ac6d0708f09bc425f4"

URI_x86_64_v2_texlive-threeparttable = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-threeparttable-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-threeparttable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-threeparttable}"
SRC_URI[x86_64_v2_texlive-threeparttable.sha256sum] = "79ccb1fc7ea156e0aae04aa824674f4f0320aa93d5d1ba3afa360c36f93f286a"

URI_x86_64_v2_texlive-thumbpdf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-thumbpdf-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-thumbpdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-thumbpdf}"
SRC_URI[x86_64_v2_texlive-thumbpdf.sha256sum] = "8f5322e45629481367f5f077e4d8ad6f1924b6e35f07b9d02a5782c0fa3579d4"

URI_x86_64_v2_texlive-times = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-times-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-times;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-times}"
SRC_URI[x86_64_v2_texlive-times.sha256sum] = "c998d0d28a39aded84916dd0abd11ebf8bc5df57333e8479675036fae5ce9b83"

URI_x86_64_v2_texlive-tipa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tipa-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-tipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tipa}"
SRC_URI[x86_64_v2_texlive-tipa.sha256sum] = "0d398e0eefb856a633b90b48c1e68f5fd1267307ecef521c6d0455f56473f920"

URI_x86_64_v2_texlive-titlesec = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-titlesec-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-titlesec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-titlesec}"
SRC_URI[x86_64_v2_texlive-titlesec.sha256sum] = "da6573fffc12935cd74b9cf465dd422bd8925a42ab608f2f71147565839c447e"

URI_x86_64_v2_texlive-titling = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-titling-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-titling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-titling}"
SRC_URI[x86_64_v2_texlive-titling.sha256sum] = "498abc15ad57f1a50c00498ca25b93ccb8ff053d60671688d3d3246a2965a6d9"

URI_x86_64_v2_texlive-tocloft = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tocloft-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-tocloft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tocloft}"
SRC_URI[x86_64_v2_texlive-tocloft.sha256sum] = "f40b4b64e9cf47717b5fa616bae8f745a7a369dbfb1f51ad47f16c02b4bde4b0"

URI_x86_64_v2_texlive-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tools-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tools}"
SRC_URI[x86_64_v2_texlive-tools.sha256sum] = "c7c2eea487d65fdfc1fbb3a8e7ad3f97a1a34d79f6380438cdfba055d2e3c475"

URI_x86_64_v2_texlive-translator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-translator-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-translator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-translator}"
SRC_URI[x86_64_v2_texlive-translator.sha256sum] = "feb68bcc9cddc9becde221920762c0986f863a034812d433a192148773dc42ff"

URI_x86_64_v2_texlive-trimspaces = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-trimspaces-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-trimspaces;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-trimspaces}"
SRC_URI[x86_64_v2_texlive-trimspaces.sha256sum] = "ec0e6bd400e5d7c6d3542440984756c7bab669cf41633ae30346af7f4370d697"

URI_x86_64_v2_texlive-txfonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-txfonts-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-txfonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-txfonts}"
SRC_URI[x86_64_v2_texlive-txfonts.sha256sum] = "b8a28f5fec69945f6ec15b8d399e7d8b47e15dc3cbc9cc96daa2a8b0eb234d7c"

URI_x86_64_v2_texlive-type1cm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-type1cm-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-type1cm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-type1cm}"
SRC_URI[x86_64_v2_texlive-type1cm.sha256sum] = "96773f276fb1e7285382ea36fcc4e88a82b0b8f81c8a7f84d57e84749e56e237"

URI_x86_64_v2_texlive-typehtml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-typehtml-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-typehtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-typehtml}"
SRC_URI[x86_64_v2_texlive-typehtml.sha256sum] = "aa4949317fdf900360ac175d7c649999dd2f623db3be23a637f3659f352feab3"

URI_x86_64_v2_texlive-ucharcat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ucharcat-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ucharcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ucharcat}"
SRC_URI[x86_64_v2_texlive-ucharcat.sha256sum] = "ad54b94fa23b0f7966542e072466e219a6aef74b9fc95afc5aa4aef558227a19"

URI_x86_64_v2_texlive-ucharclasses = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ucharclasses-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ucharclasses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ucharclasses}"
SRC_URI[x86_64_v2_texlive-ucharclasses.sha256sum] = "cb272b35fa21ec04d1c095695fb916da9fc05f30e4598bb541e1e257a2a1a2d0"

URI_x86_64_v2_texlive-ucs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ucs-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ucs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ucs}"
SRC_URI[x86_64_v2_texlive-ucs.sha256sum] = "686387a5d6d63add465b955117818f9be23ba022329ec3686aac17410ea7c8ac"

URI_x86_64_v2_texlive-uhc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-uhc-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-uhc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uhc}"
SRC_URI[x86_64_v2_texlive-uhc.sha256sum] = "907aa8902573f451790e48f29e3a8f4992900c7e738260e12a8511a963602b9f"

URI_x86_64_v2_texlive-ulem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ulem-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-ulem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ulem}"
SRC_URI[x86_64_v2_texlive-ulem.sha256sum] = "09dc20f3c6a9b6fe167ddb9070a212717e7bf0afc3af5cd7d38827586c1c69b5"

URI_x86_64_v2_texlive-underscore = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-underscore-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-underscore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-underscore}"
SRC_URI[x86_64_v2_texlive-underscore.sha256sum] = "92c90bafe1a5d5122db0085c70de880f9f742b98955b0d1380edb544e07eace1"

URI_x86_64_v2_texlive-unicode-data = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-unicode-data-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-unicode-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-unicode-data}"
SRC_URI[x86_64_v2_texlive-unicode-data.sha256sum] = "2f4cfe0404f81cd34acbbecf80f1c439acf9ce03de7ddd76fc9a1db55004d2df"

URI_x86_64_v2_texlive-unicode-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-unicode-math-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-unicode-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-unicode-math}"
SRC_URI[x86_64_v2_texlive-unicode-math.sha256sum] = "a97f3acefcf20e55432ebecaaf075ff55f68d7da21c0c995bafc53fba65ca246"

URI_x86_64_v2_texlive-uniquecounter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-uniquecounter-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-uniquecounter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uniquecounter}"
SRC_URI[x86_64_v2_texlive-uniquecounter.sha256sum] = "25ac8cc440a5218370f12526cd8d9aaf48d0417c5afd1466c410aef7dc1c231e"

URI_x86_64_v2_texlive-unisugar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-unisugar-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-unisugar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-unisugar}"
SRC_URI[x86_64_v2_texlive-unisugar.sha256sum] = "c36473c164a16069b4b3531d706dcc4ff2f42317e485c2ea34b68b77c82d752e"

URI_x86_64_v2_texlive-upquote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-upquote-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-upquote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-upquote}"
SRC_URI[x86_64_v2_texlive-upquote.sha256sum] = "e961a1f925ee1175b557d4a87666a2e04dfbb5e3d9d99540cd003cc675d0d595"

URI_x86_64_v2_texlive-url = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-url-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-url;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-url}"
SRC_URI[x86_64_v2_texlive-url.sha256sum] = "76479c34e7c405bb03960719dc4cafb1cc53f1a9363a33155fe9f57e6142eb98"

URI_x86_64_v2_texlive-utopia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-utopia-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-utopia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-utopia}"
SRC_URI[x86_64_v2_texlive-utopia.sha256sum] = "72d41fec45217ab1cba71552298ec4fa7a05d4ed9d37e6240d12bad0e8dbbf04"

URI_x86_64_v2_texlive-varwidth = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-varwidth-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-varwidth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-varwidth}"
SRC_URI[x86_64_v2_texlive-varwidth.sha256sum] = "b61e56625b11644a0bd9b41d4b3cdd86703e298e88070b7af8a73dba14689df6"

URI_x86_64_v2_texlive-wadalab = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-wadalab-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-wadalab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-wadalab}"
SRC_URI[x86_64_v2_texlive-wadalab.sha256sum] = "d3f648dbd83842ba9a09fdc5ab34060d75984a2ab5c870745d730a7ff288b76e"

URI_x86_64_v2_texlive-was = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-was-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-was;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-was}"
SRC_URI[x86_64_v2_texlive-was.sha256sum] = "28765f7b1eb4eea284a484d641c4c61ebfd6b6bc42b30d5158821ec6ee592810"

URI_x86_64_v2_texlive-wasy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-wasy-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-wasy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-wasy}"
SRC_URI[x86_64_v2_texlive-wasy.sha256sum] = "e5cf1fc9c604cad9cc33e3f21c5eddd479419c383c61efc8b5f7d35d2a5f1767"

URI_x86_64_v2_texlive-wasy-type1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-wasy-type1-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-wasy-type1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-wasy-type1}"
SRC_URI[x86_64_v2_texlive-wasy-type1.sha256sum] = "18333b06115981355ba90798814e8c61b3b065ec6b1684452be78ba03a429e15"

URI_x86_64_v2_texlive-wasysym = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-wasysym-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-wasysym;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-wasysym}"
SRC_URI[x86_64_v2_texlive-wasysym.sha256sum] = "f616fdb95d8376a384679e126a77074e04cd0cd5b1faa52ead32057c54d714e2"

URI_x86_64_v2_texlive-wrapfig = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-wrapfig-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-wrapfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-wrapfig}"
SRC_URI[x86_64_v2_texlive-wrapfig.sha256sum] = "d44f2bb170f03794bbb78bb98d2e51acfb2a2ba41afe352b120caa0e6c813d56"

URI_x86_64_v2_texlive-xcolor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xcolor-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xcolor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xcolor}"
SRC_URI[x86_64_v2_texlive-xcolor.sha256sum] = "0716c198a759790a84bab8e1ed32a9248fe1d09244d84c848ffda6d7944f347b"

URI_x86_64_v2_texlive-xecolor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xecolor-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xecolor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xecolor}"
SRC_URI[x86_64_v2_texlive-xecolor.sha256sum] = "00fc9cf59105133861f60c3891ab810966c93164712e603de20809aff8345cd5"

URI_x86_64_v2_texlive-xecyr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xecyr-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xecyr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xecyr}"
SRC_URI[x86_64_v2_texlive-xecyr.sha256sum] = "2ddabc8e6d4964fcb3bb201cf8d6f80554c5753f31fb174ea171815aa5456aa6"

URI_x86_64_v2_texlive-xeindex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xeindex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xeindex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xeindex}"
SRC_URI[x86_64_v2_texlive-xeindex.sha256sum] = "303ec55d1cf0672db7ff54c701b88f01bb67ded32b397117bd6aaf4717260ceb"

URI_x86_64_v2_texlive-xepersian = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xepersian-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xepersian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xepersian}"
SRC_URI[x86_64_v2_texlive-xepersian.sha256sum] = "371e1e3c8196f820c4af39b512f9191195cbdc3edf26aba55e7a2a6ece5019c2"

URI_x86_64_v2_texlive-xesearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xesearch-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xesearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xesearch}"
SRC_URI[x86_64_v2_texlive-xesearch.sha256sum] = "d5ffcd5fa1bcc9ee12cf34126d99ddbbb5394a732a28a937f8642241cf65e1c7"

URI_x86_64_v2_texlive-xetex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xetex-20240311-6.el10.x86_64_v2.rpm;name=x86_64_v2_texlive-xetex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xetex}"
SRC_URI[x86_64_v2_texlive-xetex.sha256sum] = "c28314e4ef07b14354a4aaf7af00868c2e1822ad5cdccc8dd86ef65691bc24b9"

URI_x86_64_v2_texlive-xetex-itrans = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xetex-itrans-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xetex-itrans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xetex-itrans}"
SRC_URI[x86_64_v2_texlive-xetex-itrans.sha256sum] = "68f82005c91c958d9bbf006643c66e0d91c42d8f63d9e32c97709fed745f550d"

URI_x86_64_v2_texlive-xetex-pstricks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xetex-pstricks-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xetex-pstricks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xetex-pstricks}"
SRC_URI[x86_64_v2_texlive-xetex-pstricks.sha256sum] = "822b13c650e0d6303ddda5ddefb5f9dd4d125bcb57fd8627c826dce9bdaa7dea"

URI_x86_64_v2_texlive-xetexconfig = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xetexconfig-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xetexconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xetexconfig}"
SRC_URI[x86_64_v2_texlive-xetexconfig.sha256sum] = "072d0b4ce773f44d9c2e7397ff9d99fb50282c5b2fcfbe5b2af078326c416c8d"

URI_x86_64_v2_texlive-xetexfontinfo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xetexfontinfo-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xetexfontinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xetexfontinfo}"
SRC_URI[x86_64_v2_texlive-xetexfontinfo.sha256sum] = "d4d9afd56325bd54225b7980bb2cfb64cf98f841f2eac57df3302d016978c07f"

URI_x86_64_v2_texlive-xfrac = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xfrac-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xfrac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xfrac}"
SRC_URI[x86_64_v2_texlive-xfrac.sha256sum] = "c8740829e27a5120ec556092fd8ba0ede523c6188b1ebc190fbddc75382533f9"

URI_x86_64_v2_texlive-xifthen = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xifthen-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xifthen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xifthen}"
SRC_URI[x86_64_v2_texlive-xifthen.sha256sum] = "724d6b18154cbf0bdce87647e49748aeac271b47d541f3a4327fe5b1c082a64c"

URI_x86_64_v2_texlive-xkeyval = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xkeyval-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xkeyval;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xkeyval}"
SRC_URI[x86_64_v2_texlive-xkeyval.sha256sum] = "2204fe2dcfe8aad8b790ca4a7456bb01a582436108b5d4f9dce101a7b7ae6e29"

URI_x86_64_v2_texlive-xltxtra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xltxtra-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xltxtra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xltxtra}"
SRC_URI[x86_64_v2_texlive-xltxtra.sha256sum] = "64e484df7726e2d779515f67e6b0cc45c41ca0971125fa755de4dbc6edae168d"

URI_x86_64_v2_texlive-xmltex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xmltex-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xmltex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xmltex}"
SRC_URI[x86_64_v2_texlive-xmltex.sha256sum] = "ef3b9c3649ec7abfcf46096876e068ea45da17f2b8c9476f8c54f062bbef5e01"

URI_x86_64_v2_texlive-xpatch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xpatch-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xpatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xpatch}"
SRC_URI[x86_64_v2_texlive-xpatch.sha256sum] = "9b24932987901a82c54659ff050a46036e3a89d6a0f435ce19dc66187449b419"

URI_x86_64_v2_texlive-xstring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xstring-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xstring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xstring}"
SRC_URI[x86_64_v2_texlive-xstring.sha256sum] = "154f936a07b8cdeecb554e099b96b0f3cdf11230d8443c48fd41d9c58e4cf091"

URI_x86_64_v2_texlive-xtab = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xtab-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xtab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xtab}"
SRC_URI[x86_64_v2_texlive-xtab.sha256sum] = "dfccf1d73357635f3673328adda2e9a11bb656ee446a36ef3f2d34d7e602637b"

URI_x86_64_v2_texlive-xunicode = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xunicode-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-xunicode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xunicode}"
SRC_URI[x86_64_v2_texlive-xunicode.sha256sum] = "e8175e59ac471ec808a62f8474516741ae23519a4840b13338d3c86cafe3b90e"

URI_x86_64_v2_texlive-zapfchan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-zapfchan-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-zapfchan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zapfchan}"
SRC_URI[x86_64_v2_texlive-zapfchan.sha256sum] = "9c87a4ff8c1a2f0c15f2db323f5c5f019b504625f226f56d6a697a4b610b3293"

URI_x86_64_v2_texlive-zapfding = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-zapfding-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-zapfding;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zapfding}"
SRC_URI[x86_64_v2_texlive-zapfding.sha256sum] = "3dfbeef3adb0ad11633cf41b9c2f1f017f4aeb12fbf51c5b1ead585f6f664747"

URI_x86_64_v2_texlive-zref = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-zref-20240311-6.el10.noarch.rpm;name=x86_64_v2_texlive-zref;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zref}"
SRC_URI[x86_64_v2_texlive-zref.sha256sum] = "895ec361386b9d93411a3df565dd4efbfeb8f33a0c7b668e7647d7fb2d572c8e"

URI_aarch64_texlive = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-20240311-6.el10.aarch64.rpm;name=aarch64_texlive;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive}"
SRC_URI[aarch64_texlive.sha256sum] = "8d4216af9bcec69bbc495eb8675330bfee112a3879acc3b0d9f274106b8eb495"

URI_aarch64_texlive-acronym = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-acronym-20240311-6.el10.noarch.rpm;name=aarch64_texlive-acronym;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-acronym}"
SRC_URI[aarch64_texlive-acronym.sha256sum] = "8ebfe009fc3ee905809b42382a7f3a9642b47db7f1360d62765d75c76745b9a0"

URI_aarch64_texlive-adjustbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-adjustbox-20240311-6.el10.noarch.rpm;name=aarch64_texlive-adjustbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-adjustbox}"
SRC_URI[aarch64_texlive-adjustbox.sha256sum] = "050ef80bec4e63aed5aa36779ed607f9b24660664be97c573cb5730b7b2b3863"

URI_aarch64_texlive-ae = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ae-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ae;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ae}"
SRC_URI[aarch64_texlive-ae.sha256sum] = "448937bf45289972e3f920da4d5c14003348ce074c5ef1d923ed0d743b35a7f9"

URI_aarch64_texlive-algorithms = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-algorithms-20240311-6.el10.noarch.rpm;name=aarch64_texlive-algorithms;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-algorithms}"
SRC_URI[aarch64_texlive-algorithms.sha256sum] = "ba8d182c052fc2baf6af369c9b7c0cf098d4a9f451e9a0feb2b57be41d3bdd00"

URI_aarch64_texlive-alphalph = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-alphalph-20240311-6.el10.noarch.rpm;name=aarch64_texlive-alphalph;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-alphalph}"
SRC_URI[aarch64_texlive-alphalph.sha256sum] = "c93a570fcf2b97ca72634f1b163e1d0778b8a36634e099d387f11ec90eb4e17f"

URI_aarch64_texlive-amscls = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-amscls-20240311-6.el10.noarch.rpm;name=aarch64_texlive-amscls;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-amscls}"
SRC_URI[aarch64_texlive-amscls.sha256sum] = "8fb0beb912449c54901ef8a4a81bdaa46b750ede0c8f846dcb62753bd613ca4e"

URI_aarch64_texlive-amsfonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-amsfonts-20240311-6.el10.noarch.rpm;name=aarch64_texlive-amsfonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-amsfonts}"
SRC_URI[aarch64_texlive-amsfonts.sha256sum] = "9dc5bfd237ae6ba1241c1cfa0c026550681b2e0d4b4fc2b9e8ad78d4baac32df"

URI_aarch64_texlive-amsmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-amsmath-20240311-6.el10.noarch.rpm;name=aarch64_texlive-amsmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-amsmath}"
SRC_URI[aarch64_texlive-amsmath.sha256sum] = "000e53b4859706852b926824082a77c106b6cc4a84c0250f823fe3045d2a0be4"

URI_aarch64_texlive-anyfontsize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-anyfontsize-20240311-6.el10.noarch.rpm;name=aarch64_texlive-anyfontsize;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-anyfontsize}"
SRC_URI[aarch64_texlive-anyfontsize.sha256sum] = "33b3308469d94392bf6e7eb0c65d599c424f9d2b32ee3cfe34ced0ed2a310c5a"

URI_aarch64_texlive-anysize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-anysize-20240311-6.el10.noarch.rpm;name=aarch64_texlive-anysize;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-anysize}"
SRC_URI[aarch64_texlive-anysize.sha256sum] = "7db26b44fc4611f170a1a0abe301f79afac6994c96456c72652b06ef7742c62e"

URI_aarch64_texlive-appendix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-appendix-20240311-6.el10.noarch.rpm;name=aarch64_texlive-appendix;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-appendix}"
SRC_URI[aarch64_texlive-appendix.sha256sum] = "0f7925e876fbd1a0cbbefda5f030cdd118eae88fcec4c388c564f53d37e7a248"

URI_aarch64_texlive-arphic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-arphic-20240311-6.el10.noarch.rpm;name=aarch64_texlive-arphic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-arphic}"
SRC_URI[aarch64_texlive-arphic.sha256sum] = "878839326bea628a8f2bd3a1232352019baea2240d1ea5d0232f8c32b397339e"

URI_aarch64_texlive-atbegshi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-atbegshi-20240311-6.el10.noarch.rpm;name=aarch64_texlive-atbegshi;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-atbegshi}"
SRC_URI[aarch64_texlive-atbegshi.sha256sum] = "4fe9c3a5ff637debf1b7edfa9c3278c79c53803321725433ecaa062118157ad9"

URI_aarch64_texlive-attachfile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-attachfile-20240311-6.el10.noarch.rpm;name=aarch64_texlive-attachfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-attachfile}"
SRC_URI[aarch64_texlive-attachfile.sha256sum] = "dc73176f36b7fef5fef390eefda5ddaeed93b25caf6917b1cc114f2841fea9a2"

URI_aarch64_texlive-attachfile2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-attachfile2-20240311-6.el10.noarch.rpm;name=aarch64_texlive-attachfile2;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-attachfile2}"
SRC_URI[aarch64_texlive-attachfile2.sha256sum] = "ae12a00f770d1c92e59a7f1ed9d42e9474baf023bf5f2f964002f65869e638e3"

URI_aarch64_texlive-atveryend = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-atveryend-20240311-6.el10.noarch.rpm;name=aarch64_texlive-atveryend;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-atveryend}"
SRC_URI[aarch64_texlive-atveryend.sha256sum] = "df3ce6b65df6b55b93a232f814f8322a267e3f1d56e82ed28a102280bffa1036"

URI_aarch64_texlive-auxhook = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-auxhook-20240311-6.el10.noarch.rpm;name=aarch64_texlive-auxhook;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-auxhook}"
SRC_URI[aarch64_texlive-auxhook.sha256sum] = "0c3418addb6d360923e35c30869898e04974bfed3abdcfe6d7046f45c0b3800a"

URI_aarch64_texlive-avantgar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-avantgar-20240311-6.el10.noarch.rpm;name=aarch64_texlive-avantgar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-avantgar}"
SRC_URI[aarch64_texlive-avantgar.sha256sum] = "c0b47b566fe13e5dfcb4e26c2d7c5ff6b1dd52092ae0f5dd434ce60e67bf028a"

URI_aarch64_texlive-awesomebox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-awesomebox-20240311-6.el10.noarch.rpm;name=aarch64_texlive-awesomebox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-awesomebox}"
SRC_URI[aarch64_texlive-awesomebox.sha256sum] = "716ffb722231afdced27c7333c38db1a1396d9f35dd682571c1a11ad00504b88"

URI_aarch64_texlive-babel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-babel-20240311-6.el10.noarch.rpm;name=aarch64_texlive-babel;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel}"
SRC_URI[aarch64_texlive-babel.sha256sum] = "41ff045ad6a3ee07f350797092d66c7bae728d0d0815407fa593eda743ddd58f"

URI_aarch64_texlive-babel-english = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-babel-english-20240311-6.el10.noarch.rpm;name=aarch64_texlive-babel-english;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel-english}"
SRC_URI[aarch64_texlive-babel-english.sha256sum] = "18fac7cdc1b9f6f9b504becbfa9525d7b1532e5127a7a538e46d4ad142c420f9"

URI_aarch64_texlive-babelbib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-babelbib-20240311-6.el10.noarch.rpm;name=aarch64_texlive-babelbib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babelbib}"
SRC_URI[aarch64_texlive-babelbib.sha256sum] = "0a0958788fcf260c8b82e8e2dbd3df4e399d27029107b91299a6a49e8c588597"

URI_aarch64_texlive-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-base-20240311-6.el10.noarch.rpm;name=aarch64_texlive-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-base}"
SRC_URI[aarch64_texlive-base.sha256sum] = "1aa59f6fad1e2325a70f52351cf3e811077b7ff1159ed2ad0d0475f316c37e87"

URI_aarch64_texlive-beamer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-beamer-20240311-6.el10.noarch.rpm;name=aarch64_texlive-beamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-beamer}"
SRC_URI[aarch64_texlive-beamer.sha256sum] = "1051a30ece8f34b38b620f74a85a9e3758829d6f86737d3c394ef99e992373cc"

URI_aarch64_texlive-bera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bera-20240311-6.el10.noarch.rpm;name=aarch64_texlive-bera;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bera}"
SRC_URI[aarch64_texlive-bera.sha256sum] = "0a2030890563cd7882e73787b17b36246248d48996bbf96e879f56510c3766f2"

URI_aarch64_texlive-beton = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-beton-20240311-6.el10.noarch.rpm;name=aarch64_texlive-beton;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-beton}"
SRC_URI[aarch64_texlive-beton.sha256sum] = "63464d6cf2863e1c8170e52302221f764955beaa9450baa12e38f3a4916be8be"

URI_aarch64_texlive-bibtex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bibtex-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-bibtex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bibtex}"
SRC_URI[aarch64_texlive-bibtex.sha256sum] = "fdde354faaede37e1597f2fffcb4f089e30a4ef6cfc7ed95abe0e563d0cf8cdb"

URI_aarch64_texlive-bibtopic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bibtopic-20240311-6.el10.noarch.rpm;name=aarch64_texlive-bibtopic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bibtopic}"
SRC_URI[aarch64_texlive-bibtopic.sha256sum] = "d9ed124f905d848309f483a43ed0d2d85c0089953ad9a9bdbf655703723b8f7c"

URI_aarch64_texlive-bidi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bidi-20240311-6.el10.noarch.rpm;name=aarch64_texlive-bidi;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bidi}"
SRC_URI[aarch64_texlive-bidi.sha256sum] = "31b4ba01e61b8b176fa2234eb0ceb031b6b177a29b549c8bb067c3a782c6be36"

URI_aarch64_texlive-bigfoot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bigfoot-20240311-6.el10.noarch.rpm;name=aarch64_texlive-bigfoot;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bigfoot}"
SRC_URI[aarch64_texlive-bigfoot.sha256sum] = "1b17b239f8385a5e0827c08a04d1b9c25837971af0a8acb7133da7f61d64c063"

URI_aarch64_texlive-bigintcalc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bigintcalc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-bigintcalc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bigintcalc}"
SRC_URI[aarch64_texlive-bigintcalc.sha256sum] = "b08aae1d238f8f5eca3e3218a7a6793e9f267bd586c55308c5a0d33304c5bd2b"

URI_aarch64_texlive-bitset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bitset-20240311-6.el10.noarch.rpm;name=aarch64_texlive-bitset;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bitset}"
SRC_URI[aarch64_texlive-bitset.sha256sum] = "e71e3a3eba576cf8ed23938ad561e37edf3f744a97510d935bc6294f4855ec69"

URI_aarch64_texlive-bookman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bookman-20240311-6.el10.noarch.rpm;name=aarch64_texlive-bookman;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bookman}"
SRC_URI[aarch64_texlive-bookman.sha256sum] = "168af1aacb5f0008e8abd26dc7e43911d3a628bb25970d66defba0c489d7aa51"

URI_aarch64_texlive-bookmark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bookmark-20240311-6.el10.noarch.rpm;name=aarch64_texlive-bookmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bookmark}"
SRC_URI[aarch64_texlive-bookmark.sha256sum] = "a45e7f0c4632a72904b58b1a193ee1668c61d558bdb908ff7b72dfc50d7a2916"

URI_aarch64_texlive-booktabs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-booktabs-20240311-6.el10.noarch.rpm;name=aarch64_texlive-booktabs;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-booktabs}"
SRC_URI[aarch64_texlive-booktabs.sha256sum] = "293b991f6b70f1e216a286ce1ed6a4087ea3feb0da215fccb83bda30f97ac062"

URI_aarch64_texlive-breakurl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-breakurl-20240311-6.el10.noarch.rpm;name=aarch64_texlive-breakurl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-breakurl}"
SRC_URI[aarch64_texlive-breakurl.sha256sum] = "f26c94e13b509ebc43c69a9ad72c2fe3dfe2c9aca86ecf2244fca7789edd8cad"

URI_aarch64_texlive-breqn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-breqn-20240311-6.el10.noarch.rpm;name=aarch64_texlive-breqn;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-breqn}"
SRC_URI[aarch64_texlive-breqn.sha256sum] = "f5e45aa80fa94e558be01dd38e12ced9f47089e2d3625315b5a8ee1bfdd12688"

URI_aarch64_texlive-capt-of = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-capt-of-20240311-6.el10.noarch.rpm;name=aarch64_texlive-capt-of;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-capt-of}"
SRC_URI[aarch64_texlive-capt-of.sha256sum] = "6857ada40ecd81e0a499517759107be4760728339ecad42582b8a41c985344b7"

URI_aarch64_texlive-caption = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-caption-20240311-6.el10.noarch.rpm;name=aarch64_texlive-caption;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-caption}"
SRC_URI[aarch64_texlive-caption.sha256sum] = "3c6237e82ecad54e748def980011280f69caae152c33aafd4a297f0f27923e41"

URI_aarch64_texlive-carlisle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-carlisle-20240311-6.el10.noarch.rpm;name=aarch64_texlive-carlisle;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-carlisle}"
SRC_URI[aarch64_texlive-carlisle.sha256sum] = "b642c7f596102fdd03b25cdf05e427d1ba256d7fb73a709918b4e14e56c4498c"

URI_aarch64_texlive-catchfile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-catchfile-20240311-6.el10.noarch.rpm;name=aarch64_texlive-catchfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-catchfile}"
SRC_URI[aarch64_texlive-catchfile.sha256sum] = "c8fda800688aae42ad40848fe20aa2a267ff1e9702ca7743c6342e9c48f24956"

URI_aarch64_texlive-changebar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-changebar-20240311-6.el10.noarch.rpm;name=aarch64_texlive-changebar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-changebar}"
SRC_URI[aarch64_texlive-changebar.sha256sum] = "c2502d7e0d46f72120dc9558cf3b377888948cb3325e12cc232c8f5a4f4767d2"

URI_aarch64_texlive-changepage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-changepage-20240311-6.el10.noarch.rpm;name=aarch64_texlive-changepage;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-changepage}"
SRC_URI[aarch64_texlive-changepage.sha256sum] = "02c5aa90cfd17f8de9f97b786cfd3b80b6e984354078c9ce57115dd88a8347be"

URI_aarch64_texlive-charter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-charter-20240311-6.el10.noarch.rpm;name=aarch64_texlive-charter;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-charter}"
SRC_URI[aarch64_texlive-charter.sha256sum] = "2919d5ed46b2128ee6f8e38970ed5a7b730933044d2ade141610a863e3b078d2"

URI_aarch64_texlive-chngcntr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-chngcntr-20240311-6.el10.noarch.rpm;name=aarch64_texlive-chngcntr;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chngcntr}"
SRC_URI[aarch64_texlive-chngcntr.sha256sum] = "7cb75153984eb2615666706067f7e6e45f9e45eace3b2f00737a8a333f5a6510"

URI_aarch64_texlive-cite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cite-20240311-6.el10.noarch.rpm;name=aarch64_texlive-cite;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cite}"
SRC_URI[aarch64_texlive-cite.sha256sum] = "9ede9d057e6410224c291e856e8fb6a214b6261d43481f1dcd05822e34d47ff8"

URI_aarch64_texlive-classpack = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-classpack-20240311-6.el10.noarch.rpm;name=aarch64_texlive-classpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-classpack}"
SRC_URI[aarch64_texlive-classpack.sha256sum] = "ef89a3e544e664f18846b65f1684239bbffd8fa77ff8671061854e000ece03ff"

URI_aarch64_texlive-cm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cm-20240311-6.el10.noarch.rpm;name=aarch64_texlive-cm;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cm}"
SRC_URI[aarch64_texlive-cm.sha256sum] = "b5a8db3342577f21f3c4f99db7da197bdb0e663b5a43c8cf5a8ed65c3699ac9f"

URI_aarch64_texlive-cm-lgc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cm-lgc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-cm-lgc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cm-lgc}"
SRC_URI[aarch64_texlive-cm-lgc.sha256sum] = "83d2ba83d31471852ee7329444c8ca57509409c9982e1cf37e24865970277dd9"

URI_aarch64_texlive-cm-super = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cm-super-20240311-6.el10.noarch.rpm;name=aarch64_texlive-cm-super;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cm-super}"
SRC_URI[aarch64_texlive-cm-super.sha256sum] = "873bd034eeb8ea275f189224b5d2d6a027e6f3155feb1782abfa30eb256c1231"

URI_aarch64_texlive-cmap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cmap-20240311-6.el10.noarch.rpm;name=aarch64_texlive-cmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cmap}"
SRC_URI[aarch64_texlive-cmap.sha256sum] = "1b12f6f7e5285e271c32d1635d4fa9410b1cd8ae753191cb213a1af1d55b882a"

URI_aarch64_texlive-cmextra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cmextra-20240311-6.el10.noarch.rpm;name=aarch64_texlive-cmextra;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cmextra}"
SRC_URI[aarch64_texlive-cmextra.sha256sum] = "9a26fa286a469354fa502dfd61289522f6b49c1c23b79c3295a722c9cb9b093a"

URI_aarch64_texlive-cns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cns-20240311-6.el10.noarch.rpm;name=aarch64_texlive-cns;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cns}"
SRC_URI[aarch64_texlive-cns.sha256sum] = "4f9c693d5f90f7d7658e4e39f07f484a69fc6559ff87ea461a30fd06ad6e786a"

URI_aarch64_texlive-collectbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collectbox-20240311-6.el10.noarch.rpm;name=aarch64_texlive-collectbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collectbox}"
SRC_URI[aarch64_texlive-collectbox.sha256sum] = "76f3f6b1276df181543939b59de938da50555b32af3a56f0a22ef24fb26923fa"

URI_aarch64_texlive-collection-basic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-basic-20240311-6.el10.noarch.rpm;name=aarch64_texlive-collection-basic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-basic}"
SRC_URI[aarch64_texlive-collection-basic.sha256sum] = "7b80ad661df231f2362e58ea5a760dd442c28181cbb87c420b650c118f82c620"

URI_aarch64_texlive-collection-fontsrecommended = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-fontsrecommended-20240311-6.el10.noarch.rpm;name=aarch64_texlive-collection-fontsrecommended;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-fontsrecommended}"
SRC_URI[aarch64_texlive-collection-fontsrecommended.sha256sum] = "d6936a72fac979f0808c7c5744defcdaef9c3034d3360fcad266950a3aa9a42c"

URI_aarch64_texlive-collection-htmlxml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-htmlxml-20240311-6.el10.noarch.rpm;name=aarch64_texlive-collection-htmlxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-htmlxml}"
SRC_URI[aarch64_texlive-collection-htmlxml.sha256sum] = "9f47bad0c100a3565e59984ddb504c4753555ae551866d368ab47a49effd6eb5"

URI_aarch64_texlive-collection-latex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-latex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-collection-latex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-latex}"
SRC_URI[aarch64_texlive-collection-latex.sha256sum] = "c66be8884ddd627328200bc765e4c13a94c250ad382974b995d09e6e5993393a"

URI_aarch64_texlive-collection-latexrecommended = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-latexrecommended-20240311-6.el10.noarch.rpm;name=aarch64_texlive-collection-latexrecommended;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-latexrecommended}"
SRC_URI[aarch64_texlive-collection-latexrecommended.sha256sum] = "47028f87c999e2e45a46f178de683c2f6f2e3eb67d6d3464e3464a86c5295ebe"
RPROVIDES:texlive-collection-latexrecommended:append:aarch64 = " virtual/texlive-latex"

URI_aarch64_texlive-collection-xetex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-xetex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-collection-xetex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-xetex}"
SRC_URI[aarch64_texlive-collection-xetex.sha256sum] = "c7d0d5aa59eecf1c3e824e3fb5019c63256fe5fc03293dd93f671447fb5e05ea"

URI_aarch64_texlive-colorprofiles = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-colorprofiles-20240311-6.el10.noarch.rpm;name=aarch64_texlive-colorprofiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-colorprofiles}"
SRC_URI[aarch64_texlive-colorprofiles.sha256sum] = "9f81ab3242480704b165bc0ed6da44b2a9f53b773b34449b9d94990c03af146e"

URI_aarch64_texlive-colortbl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-colortbl-20240311-6.el10.noarch.rpm;name=aarch64_texlive-colortbl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-colortbl}"
SRC_URI[aarch64_texlive-colortbl.sha256sum] = "a2b8ce0ac4276ecb695eb21bdb9dc427541416c06fbefa00c8b5a2cdaf7f1db7"

URI_aarch64_texlive-context = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-context-20240311-6.el10.noarch.rpm;name=aarch64_texlive-context;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-context}"
SRC_URI[aarch64_texlive-context.sha256sum] = "1efb0b3de50685ef4722ac01a07718c59ffd78323df5c0581471e92c3e86f3b5"

URI_aarch64_texlive-count1to = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-count1to-20240311-6.el10.noarch.rpm;name=aarch64_texlive-count1to;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-count1to}"
SRC_URI[aarch64_texlive-count1to.sha256sum] = "526347aef96c973c4c09e18ae8d9e4baf42425b05fe82788d66a67b870ddc7a7"

URI_aarch64_texlive-courier = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-courier-20240311-6.el10.noarch.rpm;name=aarch64_texlive-courier;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-courier}"
SRC_URI[aarch64_texlive-courier.sha256sum] = "3d94866d426971b3cb4f25ac8071e012313a5030e1cdeacb3af6c0add963ef24"

URI_aarch64_texlive-crop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-crop-20240311-6.el10.noarch.rpm;name=aarch64_texlive-crop;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-crop}"
SRC_URI[aarch64_texlive-crop.sha256sum] = "33a474af6ce6444fa3d68fc2bc3d1c5b3f5947a63f67468e4b9fb67a18dda1ef"

URI_aarch64_texlive-csquotes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-csquotes-20240311-6.el10.noarch.rpm;name=aarch64_texlive-csquotes;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-csquotes}"
SRC_URI[aarch64_texlive-csquotes.sha256sum] = "6bcb42246c76c203f9482ca78de4a6b921a9bd6bd3baf01dd7c8058dc3d7b6c4"

URI_aarch64_texlive-ctable = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ctable-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ctable;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctable}"
SRC_URI[aarch64_texlive-ctable.sha256sum] = "a6e9a5cd623ebe9fc5726f4f34c37d1dfa41ee5fb7a8e1a80c1271743241cc55"

URI_aarch64_texlive-ctablestack = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ctablestack-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ctablestack;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctablestack}"
SRC_URI[aarch64_texlive-ctablestack.sha256sum] = "c31864812a791c97fa88a9e1102481f1b7080b3316c5fef3e140c94b4be3ad31"

URI_aarch64_texlive-currfile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-currfile-20240311-6.el10.noarch.rpm;name=aarch64_texlive-currfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-currfile}"
SRC_URI[aarch64_texlive-currfile.sha256sum] = "7029609375105a05df5ee7a6509671c1e4f9779f4ad9137723759fc81ef6f6a2"

URI_aarch64_texlive-datetime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-datetime-20240311-6.el10.noarch.rpm;name=aarch64_texlive-datetime;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-datetime}"
SRC_URI[aarch64_texlive-datetime.sha256sum] = "07641c073b3d34087f912c885b8447e7a37b8461f19e656f1681dcd9e542f0a8"

URI_aarch64_texlive-dehyph = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-dehyph-20240311-6.el10.noarch.rpm;name=aarch64_texlive-dehyph;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-dehyph}"
SRC_URI[aarch64_texlive-dehyph.sha256sum] = "49b5195ff178ad52c298f2559bc019d13ab96f3e6c0addb4465d03bf280e2b6e"

URI_aarch64_texlive-dvipdfmx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-dvipdfmx-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-dvipdfmx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-dvipdfmx}"
SRC_URI[aarch64_texlive-dvipdfmx.sha256sum] = "31e6be0023df740cbb1a5f29d15c40a796c7e7882b7b0ae34bafdfb241d54548"

URI_aarch64_texlive-dvipng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-dvipng-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-dvipng;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-dvipng}"
SRC_URI[aarch64_texlive-dvipng.sha256sum] = "956a02c5c86f86245e21bc92f152b64608a491d18f0c70c9b1ab298ec4d458c3"

URI_aarch64_texlive-dvips = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-dvips-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-dvips;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-dvips}"
SRC_URI[aarch64_texlive-dvips.sha256sum] = "59ac5396c6be1e52f7839db0d6b3eeeece37ad90990069d2e8e069c561df8d1b"

URI_aarch64_texlive-dvisvgm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-dvisvgm-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-dvisvgm;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-dvisvgm}"
SRC_URI[aarch64_texlive-dvisvgm.sha256sum] = "ce66385e42ff2e1d4809cdfd47a47124a4e270bde32e67ae77febf521254f1c3"

URI_aarch64_texlive-ec = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ec-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ec;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ec}"
SRC_URI[aarch64_texlive-ec.sha256sum] = "ede4197ec1b9f2402b6808f308702b99496bb11b06328ebe5e9a447fa50987f4"

URI_aarch64_texlive-eepic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-eepic-20240311-6.el10.noarch.rpm;name=aarch64_texlive-eepic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-eepic}"
SRC_URI[aarch64_texlive-eepic.sha256sum] = "785cb2079afadc7ab58a10001051ae7fe8392842da2035ab58e76107828d0c41"

URI_aarch64_texlive-enctex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-enctex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-enctex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-enctex}"
SRC_URI[aarch64_texlive-enctex.sha256sum] = "76258ed78db73a0d50064dfd03dca77119f4e6b3ea4ef5bf70bee6e6beb08dbb"

URI_aarch64_texlive-enumitem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-enumitem-20240311-6.el10.noarch.rpm;name=aarch64_texlive-enumitem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-enumitem}"
SRC_URI[aarch64_texlive-enumitem.sha256sum] = "7f1d1b8f8bf81d09e3d34df45c4d773e875493c59b8c6c2b55f97555db2f3ce5"

URI_aarch64_texlive-environ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-environ-20240311-6.el10.noarch.rpm;name=aarch64_texlive-environ;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-environ}"
SRC_URI[aarch64_texlive-environ.sha256sum] = "a3cf6db69efe126eb93397cc9a501b00f8acdeb8193f0e26776f857b4c719992"

URI_aarch64_texlive-epsf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-epsf-20240311-6.el10.noarch.rpm;name=aarch64_texlive-epsf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-epsf}"
SRC_URI[aarch64_texlive-epsf.sha256sum] = "a64561dff8b04d1dd7a2954952761f68b6f8dcf7f3565a64e26f797f452feda4"

URI_aarch64_texlive-epstopdf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-epstopdf-20240311-6.el10.noarch.rpm;name=aarch64_texlive-epstopdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-epstopdf}"
SRC_URI[aarch64_texlive-epstopdf.sha256sum] = "53fd92707119f3ad95a93da4a257af98fd20e3ae2e82688965a4b078ece1f8d8"

URI_aarch64_texlive-epstopdf-pkg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-epstopdf-pkg-20240311-6.el10.noarch.rpm;name=aarch64_texlive-epstopdf-pkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-epstopdf-pkg}"
SRC_URI[aarch64_texlive-epstopdf-pkg.sha256sum] = "08fd08cd29ca15c5b54bca1643db101209f6f06d21a4507e23bce1901e3c857d"

URI_aarch64_texlive-eqparbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-eqparbox-20240311-6.el10.noarch.rpm;name=aarch64_texlive-eqparbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-eqparbox}"
SRC_URI[aarch64_texlive-eqparbox.sha256sum] = "093b7d7f754bf981fa521c6a325fca0c1639f990855648e8712e3fcf608617ad"

URI_aarch64_texlive-eso-pic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-eso-pic-20240311-6.el10.noarch.rpm;name=aarch64_texlive-eso-pic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-eso-pic}"
SRC_URI[aarch64_texlive-eso-pic.sha256sum] = "c220264b03012a7da04362b5fde450f33204bbc762fe2c151795c0ccf67d7efc"

URI_aarch64_texlive-etex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-etex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-etex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-etex}"
SRC_URI[aarch64_texlive-etex.sha256sum] = "60b2cff3e1dc933c4f90a47492d5e5d9828d521bde97814f7c608a572b5a7d7d"

URI_aarch64_texlive-etex-pkg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-etex-pkg-20240311-6.el10.noarch.rpm;name=aarch64_texlive-etex-pkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-etex-pkg}"
SRC_URI[aarch64_texlive-etex-pkg.sha256sum] = "ef2e95b92689c7ce5904e30e032244677129ac2eabf0de8ff46bf0726552bc11"

URI_aarch64_texlive-etexcmds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-etexcmds-20240311-6.el10.noarch.rpm;name=aarch64_texlive-etexcmds;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-etexcmds}"
SRC_URI[aarch64_texlive-etexcmds.sha256sum] = "b19d9ae6ae5c82dd2f3c3e4fad85c9fa1a6ea560692d947bbe2ec9e4f6bb775e"

URI_aarch64_texlive-etoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-etoc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-etoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-etoc}"
SRC_URI[aarch64_texlive-etoc.sha256sum] = "7b114be5bbd95084273b30e0980c006eb2c546105904146d57ee58f08db18e8e"

URI_aarch64_texlive-etoolbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-etoolbox-20240311-6.el10.noarch.rpm;name=aarch64_texlive-etoolbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-etoolbox}"
SRC_URI[aarch64_texlive-etoolbox.sha256sum] = "0f375cbcadc0756d45d3f452d5d5480a36fe7b873a08b29a0b23878a740ef708"

URI_aarch64_texlive-euenc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-euenc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-euenc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-euenc}"
SRC_URI[aarch64_texlive-euenc.sha256sum] = "5415d4482f7a0f108bb0fd85348437b331e7fa39783518267199aa76dd22318a"

URI_aarch64_texlive-euler = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-euler-20240311-6.el10.noarch.rpm;name=aarch64_texlive-euler;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-euler}"
SRC_URI[aarch64_texlive-euler.sha256sum] = "bd4bd5f45e4d470bb5666e471a2818a5f54a755cd4d05fdc5a6e8fa77a81dcde"

URI_aarch64_texlive-euro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-euro-20240311-6.el10.noarch.rpm;name=aarch64_texlive-euro;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-euro}"
SRC_URI[aarch64_texlive-euro.sha256sum] = "d710f38070428c81ef5a9dce39986620b3e3d1de05b236fa2d7ecc123380ff96"

URI_aarch64_texlive-eurosym = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-eurosym-20240311-6.el10.noarch.rpm;name=aarch64_texlive-eurosym;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-eurosym}"
SRC_URI[aarch64_texlive-eurosym.sha256sum] = "d2a90dc4e55e942f1daeac197ee8583b4c66402775d2428b4bacee5aefb7b7fd"

URI_aarch64_texlive-everysel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-everysel-20240311-6.el10.noarch.rpm;name=aarch64_texlive-everysel;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-everysel}"
SRC_URI[aarch64_texlive-everysel.sha256sum] = "4b002fab710c49734afc999fcb5352b64b7b7a68c2b74fd488bdbbf57739b757"

URI_aarch64_texlive-everyshi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-everyshi-20240311-6.el10.noarch.rpm;name=aarch64_texlive-everyshi;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-everyshi}"
SRC_URI[aarch64_texlive-everyshi.sha256sum] = "8ec04cb30b46746c7bccab63b121004c7c34a8819be020142f5c7f529eb724e4"

URI_aarch64_texlive-extsizes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-extsizes-20240311-6.el10.noarch.rpm;name=aarch64_texlive-extsizes;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-extsizes}"
SRC_URI[aarch64_texlive-extsizes.sha256sum] = "1f7a72440a13808d61ba24cd3997b7140c60a85648e3a16afdab5b4c281a5935"

URI_aarch64_texlive-fancybox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fancybox-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fancybox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fancybox}"
SRC_URI[aarch64_texlive-fancybox.sha256sum] = "6397dc7e7f3c390f82e5d33f7d1cd87c87b3b5ef989acdf9c87020ff08a6aa89"

URI_aarch64_texlive-fancyhdr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fancyhdr-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fancyhdr;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fancyhdr}"
SRC_URI[aarch64_texlive-fancyhdr.sha256sum] = "652231176eb36e94cde6ff52f5182322d8cd9f33290a7a6edd1be785318622ab"

URI_aarch64_texlive-fancyref = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fancyref-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fancyref;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fancyref}"
SRC_URI[aarch64_texlive-fancyref.sha256sum] = "33b3090d2fef6f00346c5cc0657c79cc6bff00829a53f2e02be36be87a4d9fa2"

URI_aarch64_texlive-fancyvrb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fancyvrb-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fancyvrb;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fancyvrb}"
SRC_URI[aarch64_texlive-fancyvrb.sha256sum] = "a098780f3f5a5617ef20fe91f790628a3a213cb3d97b1a79d6869c043f2c4db2"

URI_aarch64_texlive-filecontents = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-filecontents-20240311-6.el10.noarch.rpm;name=aarch64_texlive-filecontents;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-filecontents}"
SRC_URI[aarch64_texlive-filecontents.sha256sum] = "22840e6a1292c358ae68e509abd406cada26d520500c2ed134bd370379ca58a8"

URI_aarch64_texlive-filehook = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-filehook-20240311-6.el10.noarch.rpm;name=aarch64_texlive-filehook;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-filehook}"
SRC_URI[aarch64_texlive-filehook.sha256sum] = "b1e251017051616a3cb85224f56ca6d43f29b46e523fa5ecc9c321de853940cb"

URI_aarch64_texlive-finstrut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-finstrut-20240311-6.el10.noarch.rpm;name=aarch64_texlive-finstrut;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-finstrut}"
SRC_URI[aarch64_texlive-finstrut.sha256sum] = "1e8f5ef6a8c90637f3ea0e5ee20206fd41a814b73f2b3fadb930f2eee8910ac5"

URI_aarch64_texlive-firstaid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-firstaid-20240311-6.el10.noarch.rpm;name=aarch64_texlive-firstaid;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-firstaid}"
SRC_URI[aarch64_texlive-firstaid.sha256sum] = "31f5a95dbaec4daccb2268330e27553ac08776a3924b242fce10e5b8a21cf3c9"

URI_aarch64_texlive-fix2col = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fix2col-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fix2col;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fix2col}"
SRC_URI[aarch64_texlive-fix2col.sha256sum] = "17f672f6ca8e64288ab873a3f803bba539b6ca8f952ec142c52a38eba026b472"

URI_aarch64_texlive-fixlatvian = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fixlatvian-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fixlatvian;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fixlatvian}"
SRC_URI[aarch64_texlive-fixlatvian.sha256sum] = "5d2b3020de2ee33bcfc93158f1479c5750b7d422d7a928b9082ed86d7e2c5ac2"

URI_aarch64_texlive-float = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-float-20240311-6.el10.noarch.rpm;name=aarch64_texlive-float;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-float}"
SRC_URI[aarch64_texlive-float.sha256sum] = "1133a7eef34afe7859bf319a0bb8ead38befe04d08c51c9a738e3ab90c8c3096"

URI_aarch64_texlive-fmtcount = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fmtcount-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fmtcount;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fmtcount}"
SRC_URI[aarch64_texlive-fmtcount.sha256sum] = "2f2e486352cf8feddc038d834775aa09df6a8f263caf529c03425f35afceca97"

URI_aarch64_texlive-fncychap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fncychap-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fncychap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fncychap}"
SRC_URI[aarch64_texlive-fncychap.sha256sum] = "82b469184f8bd8b59d98d1ee798c93e204037961ef5bb50443824320a2c114bf"

URI_aarch64_texlive-fontawesome = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fontawesome-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fontawesome;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontawesome}"
SRC_URI[aarch64_texlive-fontawesome.sha256sum] = "09488d70ec1bbdb873c98a6acc4e8632f81553d221c5fe4e1d34a61ada34b387"

URI_aarch64_texlive-fontbook = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fontbook-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fontbook;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontbook}"
SRC_URI[aarch64_texlive-fontbook.sha256sum] = "02b00ad11ef6a2b02d141b3a116b1e81f9dd62358227de44b5a09c7d5806513a"

URI_aarch64_texlive-fonts-tlwg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fonts-tlwg-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fonts-tlwg;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fonts-tlwg}"
SRC_URI[aarch64_texlive-fonts-tlwg.sha256sum] = "564d59f5dcb04b3a6926f83fb722ed06bec7405662a52699c499718cd739abc3"

URI_aarch64_texlive-fontspec = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fontspec-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fontspec;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontspec}"
SRC_URI[aarch64_texlive-fontspec.sha256sum] = "b7d0f670f1c40b6a0760cfc7f002edd30b526707a6dbb8c06d8076f1ff6ea431"

URI_aarch64_texlive-fontware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fontware-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-fontware;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontware}"
SRC_URI[aarch64_texlive-fontware.sha256sum] = "7bf8818858b06f7eea0f5fcdb5488cd5b792f648262c7283f9d25ad794bfcb70"

URI_aarch64_texlive-fontwrap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fontwrap-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fontwrap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontwrap}"
SRC_URI[aarch64_texlive-fontwrap.sha256sum] = "813df9ca1a5b0aab70b2d719e9f011028704fa72cb6fbcf96bc09af31bb326ed"

URI_aarch64_texlive-footmisc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-footmisc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-footmisc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-footmisc}"
SRC_URI[aarch64_texlive-footmisc.sha256sum] = "69dc1c7285850b0fef37b5848617dd8958e1759c5460ea9df7a18b48b1d384bc"

URI_aarch64_texlive-footnotehyper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-footnotehyper-20240311-6.el10.noarch.rpm;name=aarch64_texlive-footnotehyper;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-footnotehyper}"
SRC_URI[aarch64_texlive-footnotehyper.sha256sum] = "cf25052d51f3805a8fb664d7ed1ff67df92baa590f0a1ee966f888d2ecfd6870"

URI_aarch64_texlive-fp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fp-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fp;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fp}"
SRC_URI[aarch64_texlive-fp.sha256sum] = "d1682e024ea41e3b1f7eb2515a74b273e5c4b69861aed2ea51bb65c8320f9c24"

URI_aarch64_texlive-fpl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fpl-20240311-6.el10.noarch.rpm;name=aarch64_texlive-fpl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fpl}"
SRC_URI[aarch64_texlive-fpl.sha256sum] = "b4b2e15275dd75438534334d3fa2c98da2abd31e9cde35e136071b8cc060f86c"

URI_aarch64_texlive-framed = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-framed-20240311-6.el10.noarch.rpm;name=aarch64_texlive-framed;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-framed}"
SRC_URI[aarch64_texlive-framed.sha256sum] = "68a73bdefd07ce2b893c7828dae84b92da4bf27456960f84b24d7f02e8302982"

URI_aarch64_texlive-garuda-c90 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-garuda-c90-20240311-6.el10.noarch.rpm;name=aarch64_texlive-garuda-c90;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-garuda-c90}"
SRC_URI[aarch64_texlive-garuda-c90.sha256sum] = "6fe6cb01ad8cfb3a8feab7257ceb1ea1df1b26f1de70d7cd246af82661135dd8"

URI_aarch64_texlive-geometry = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-geometry-20240311-6.el10.noarch.rpm;name=aarch64_texlive-geometry;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-geometry}"
SRC_URI[aarch64_texlive-geometry.sha256sum] = "410c1847a81daa380d1664e4f5a6a10d6aa1b356ef4a7190dea59687b1705867"

URI_aarch64_texlive-gettitlestring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-gettitlestring-20240311-6.el10.noarch.rpm;name=aarch64_texlive-gettitlestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-gettitlestring}"
SRC_URI[aarch64_texlive-gettitlestring.sha256sum] = "df1f5f31f9824dcff850bf62a31fac2d998a57b250fd59e0e37fff2bc37b2dd0"

URI_aarch64_texlive-glyphlist = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-glyphlist-20240311-6.el10.noarch.rpm;name=aarch64_texlive-glyphlist;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glyphlist}"
SRC_URI[aarch64_texlive-glyphlist.sha256sum] = "0b61b5bf100cced075e6a312dd1bedbf8a671c36d74f79753ab1c016519654e9"

URI_aarch64_texlive-gnu-freefont = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/texlive-gnu-freefont-20240311-6.el10.noarch.rpm;name=aarch64_texlive-gnu-freefont;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-gnu-freefont}"
SRC_URI[aarch64_texlive-gnu-freefont.sha256sum] = "86a5b55e20a5eff47edcc6cf05fecf475e0f2aa9acfea123724054f96c07071c"

URI_aarch64_texlive-graphics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-graphics-20240311-6.el10.noarch.rpm;name=aarch64_texlive-graphics;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-graphics}"
SRC_URI[aarch64_texlive-graphics.sha256sum] = "ec4a5489684bac3768d808590b341cc46a2f60609ffd43ae072c7b83a22ee663"

URI_aarch64_texlive-graphics-cfg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-graphics-cfg-20240311-6.el10.noarch.rpm;name=aarch64_texlive-graphics-cfg;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-graphics-cfg}"
SRC_URI[aarch64_texlive-graphics-cfg.sha256sum] = "2ba8cbe6edce6a9c93164c9ab3a72aff63ccd66affab04958f9ebcc6ed4e08bd"

URI_aarch64_texlive-graphics-def = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-graphics-def-20240311-6.el10.noarch.rpm;name=aarch64_texlive-graphics-def;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-graphics-def}"
SRC_URI[aarch64_texlive-graphics-def.sha256sum] = "345b5c43de3c77b20793fd9b313c42c4c3b9f77116348ce7aeb041e123f3e756"

URI_aarch64_texlive-grfext = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-grfext-20240311-6.el10.noarch.rpm;name=aarch64_texlive-grfext;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-grfext}"
SRC_URI[aarch64_texlive-grfext.sha256sum] = "14e9d285e13c5f82186d681e4c862a2981bdba834222d0e85ccee5ab3738b546"

URI_aarch64_texlive-grffile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-grffile-20240311-6.el10.noarch.rpm;name=aarch64_texlive-grffile;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-grffile}"
SRC_URI[aarch64_texlive-grffile.sha256sum] = "930dbdc1dfbe2d8c469ade8e2531916b7737b97738a20ba55a6af6804d71463d"

URI_aarch64_texlive-gsftopk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-gsftopk-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-gsftopk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-gsftopk}"
SRC_URI[aarch64_texlive-gsftopk.sha256sum] = "100614500f899ff905cd1b58796c3131e8d779388af25b142bc2f3f5ee2c89a8"

URI_aarch64_texlive-hanging = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hanging-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hanging;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hanging}"
SRC_URI[aarch64_texlive-hanging.sha256sum] = "b1bfb6819626c5dfb35a10b1e9ee71cf1ef5adfffa3c64025bebb03f7657296d"

URI_aarch64_texlive-helvetic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-helvetic-20240311-6.el10.noarch.rpm;name=aarch64_texlive-helvetic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-helvetic}"
SRC_URI[aarch64_texlive-helvetic.sha256sum] = "0b7968261c4f26af23318aec2dc93de89e499f57a1fdcd29815442ddd8767282"

URI_aarch64_texlive-hobsub = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hobsub-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hobsub;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hobsub}"
SRC_URI[aarch64_texlive-hobsub.sha256sum] = "e0336e46093ce5e3329e46a74020069970c4e4f43ebaf63a9e4e4c0f5ea81112"

URI_aarch64_texlive-hologo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hologo-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hologo;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hologo}"
SRC_URI[aarch64_texlive-hologo.sha256sum] = "93d047cf0dc0681c339e9814093c739e959ac3e513c70b9e7a3c6d5851b1ed83"

URI_aarch64_texlive-hopatch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hopatch-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hopatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hopatch}"
SRC_URI[aarch64_texlive-hopatch.sha256sum] = "daf3becaa2d8da58b1fbf4c682a6358f592fed37eb29f004f7e1b9a324082028"

URI_aarch64_texlive-hycolor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hycolor-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hycolor;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hycolor}"
SRC_URI[aarch64_texlive-hycolor.sha256sum] = "c330e74b21e4cd4f648ea43536d10c6e154d2fe9e324ea0fc767ed783456dfc9"

URI_aarch64_texlive-hypcap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hypcap-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hypcap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hypcap}"
SRC_URI[aarch64_texlive-hypcap.sha256sum] = "8137e25d64285242f5758bbda2d319a8f69b60d827596d2d6186bb862b485cfa"

URI_aarch64_texlive-hypdoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hypdoc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hypdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hypdoc}"
SRC_URI[aarch64_texlive-hypdoc.sha256sum] = "c209a690a2c3b28af06f6f82dbaa3c2b2a83a87b44374ebb8329dd35094ae8d1"

URI_aarch64_texlive-hyperref = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hyperref-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hyperref;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyperref}"
SRC_URI[aarch64_texlive-hyperref.sha256sum] = "6735a664b72db7c3298cd6ef15b0c19e0c51f2ea9cbdfc844cf3dc81c27eb190"

URI_aarch64_texlive-hyph-utf8 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hyph-utf8-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hyph-utf8;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyph-utf8}"
SRC_URI[aarch64_texlive-hyph-utf8.sha256sum] = "9794a180018ec35022869b853f9cae21062c5bf4275c3a659c7ddaa83143d5db"

URI_aarch64_texlive-hyphen-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hyphen-base-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hyphen-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyphen-base}"
SRC_URI[aarch64_texlive-hyphen-base.sha256sum] = "b5a454a75041f5dcf148f982a47d80e61ece196e8c447bc0978ef178ef235457"

URI_aarch64_texlive-hyphenat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hyphenat-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hyphenat;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyphenat}"
SRC_URI[aarch64_texlive-hyphenat.sha256sum] = "a746206e0ff95b5af04df4c8d63194f183997e8c42edbc41cc516ba2a2654d11"

URI_aarch64_texlive-hyphenex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hyphenex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-hyphenex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyphenex}"
SRC_URI[aarch64_texlive-hyphenex.sha256sum] = "f0bfa96740fb55186e8531dda7574cfbf5fb452bd48c016f94a0dc98807925ce"

URI_aarch64_texlive-ifmtarg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ifmtarg-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ifmtarg;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ifmtarg}"
SRC_URI[aarch64_texlive-ifmtarg.sha256sum] = "25fb8260d4591ede2ddd1004b1ce88b26f845567deb606d9a89d21af13dea7e1"

URI_aarch64_texlive-ifoddpage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ifoddpage-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ifoddpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ifoddpage}"
SRC_URI[aarch64_texlive-ifoddpage.sha256sum] = "3d9283f8bd9ad361b7fa599f335f33b312f78bd8191fd5699f464009031bf542"

URI_aarch64_texlive-ifplatform = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ifplatform-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ifplatform;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ifplatform}"
SRC_URI[aarch64_texlive-ifplatform.sha256sum] = "28f733a8174665781981d85062669200cd3b8ea30a372f2e58fdcdfe62517542"

URI_aarch64_texlive-iftex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-iftex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-iftex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-iftex}"
SRC_URI[aarch64_texlive-iftex.sha256sum] = "7b6bb8f38a019559345afe8b21146f336defb6b3527fcf1af8c8dbd574920d67"

URI_aarch64_texlive-import = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-import-20240311-6.el10.noarch.rpm;name=aarch64_texlive-import;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-import}"
SRC_URI[aarch64_texlive-import.sha256sum] = "35eedd23d1e8c157f40a5b3703165b347f3cb889bf6230dd674abe76d68eca8b"

URI_aarch64_texlive-index = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-index-20240311-6.el10.noarch.rpm;name=aarch64_texlive-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-index}"
SRC_URI[aarch64_texlive-index.sha256sum] = "0de27ff6c09af51b1a1aac5bfe4456c6c3095d0f335cce1652cead6086015319"

URI_aarch64_texlive-infwarerr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-infwarerr-20240311-6.el10.noarch.rpm;name=aarch64_texlive-infwarerr;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-infwarerr}"
SRC_URI[aarch64_texlive-infwarerr.sha256sum] = "c7995e906c968ba217a18cd527cc9525cd2c6373badd40eb49e21db4fe8c7569"

URI_aarch64_texlive-intcalc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-intcalc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-intcalc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-intcalc}"
SRC_URI[aarch64_texlive-intcalc.sha256sum] = "70c9cf07a0386aaf0fe53469c9dc0729e721feda7661e76833aa892190b9a04e"

URI_aarch64_texlive-jadetex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-jadetex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-jadetex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-jadetex}"
SRC_URI[aarch64_texlive-jadetex.sha256sum] = "79149cafe1aea68a2d62eb99fe68a795b92bd5ab87328ebb0e6d5a12f01a186e"

URI_aarch64_texlive-jknapltx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-jknapltx-20240311-6.el10.noarch.rpm;name=aarch64_texlive-jknapltx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-jknapltx}"
SRC_URI[aarch64_texlive-jknapltx.sha256sum] = "d3bf00b6d605ddd6f20141ae6bdf8b2c87e8a787582ebf4a048b2c13c9ca06cf"

URI_aarch64_texlive-kastrup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kastrup-20240311-6.el10.noarch.rpm;name=aarch64_texlive-kastrup;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kastrup}"
SRC_URI[aarch64_texlive-kastrup.sha256sum] = "c934653c5573b70b8893d9d9a5cafd1e0550cdea135b63e1908132d42837a221"

URI_aarch64_texlive-kerkis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kerkis-20240311-6.el10.noarch.rpm;name=aarch64_texlive-kerkis;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kerkis}"
SRC_URI[aarch64_texlive-kerkis.sha256sum] = "14fcf15d08fff01562c99ed73eea202086d35ac0bbebfdcafc38ec5df996dddb"

URI_aarch64_texlive-knuth-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-knuth-lib-20240311-6.el10.noarch.rpm;name=aarch64_texlive-knuth-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-knuth-lib}"
SRC_URI[aarch64_texlive-knuth-lib.sha256sum] = "802f92ece8e88b852b1e14ab3dbae5696420303122502c95bf85ab53e0918cf4"

URI_aarch64_texlive-knuth-local = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-knuth-local-20240311-6.el10.noarch.rpm;name=aarch64_texlive-knuth-local;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-knuth-local}"
SRC_URI[aarch64_texlive-knuth-local.sha256sum] = "fa5ae7b52e7dc20126ae4c2915f0bb483e4c6b7c302d35fde64767a2db082714"

URI_aarch64_texlive-koma-script = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-koma-script-20240311-6.el10.noarch.rpm;name=aarch64_texlive-koma-script;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-koma-script}"
SRC_URI[aarch64_texlive-koma-script.sha256sum] = "ce096d7829992ed04bb4b6f745c1114810c96d02d9eadd776c0ca1c44e4326e6"

URI_aarch64_texlive-kpathsea = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kpathsea-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-kpathsea;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kpathsea}"
SRC_URI[aarch64_texlive-kpathsea.sha256sum] = "d3966f349c5d6bb86b2b4bb6d9733ae87d60ed2868d61406ff2b358e9023f8ad"

URI_aarch64_texlive-kvdefinekeys = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kvdefinekeys-20240311-6.el10.noarch.rpm;name=aarch64_texlive-kvdefinekeys;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kvdefinekeys}"
SRC_URI[aarch64_texlive-kvdefinekeys.sha256sum] = "d11aee3f00acfdfe93357fbdaa83c13fa1d74053edc2393f759ac0ba1e57862f"

URI_aarch64_texlive-kvoptions = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kvoptions-20240311-6.el10.noarch.rpm;name=aarch64_texlive-kvoptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kvoptions}"
SRC_URI[aarch64_texlive-kvoptions.sha256sum] = "6d897439b5aedeaf1289186c082c67fb4eed0ea804e2fa23fe64c293c4c8f40e"

URI_aarch64_texlive-kvsetkeys = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kvsetkeys-20240311-6.el10.noarch.rpm;name=aarch64_texlive-kvsetkeys;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kvsetkeys}"
SRC_URI[aarch64_texlive-kvsetkeys.sha256sum] = "f9e53e1c1c129e160b3e2f33dfc615a3109a52df64068f6d13e2f7049be4a22f"

URI_aarch64_texlive-l3backend = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-l3backend-20240311-6.el10.noarch.rpm;name=aarch64_texlive-l3backend;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-l3backend}"
SRC_URI[aarch64_texlive-l3backend.sha256sum] = "c80a4b490da01a6c086be0d02bddabbe9a44f4de8e10fccf8c0f707f60022521"

URI_aarch64_texlive-l3experimental = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-l3experimental-20240311-6.el10.noarch.rpm;name=aarch64_texlive-l3experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-l3experimental}"
SRC_URI[aarch64_texlive-l3experimental.sha256sum] = "a408a27aadf3dba403cf8bd8520a8aa7abdaeb3fcc26406d45999599f28c111d"

URI_aarch64_texlive-l3kernel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-l3kernel-20240311-6.el10.noarch.rpm;name=aarch64_texlive-l3kernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-l3kernel}"
SRC_URI[aarch64_texlive-l3kernel.sha256sum] = "429c8afda0240d1c16cd8fa4f0b8cb66c659cb7b22966ecda2ad0be17af8c725"

URI_aarch64_texlive-l3packages = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-l3packages-20240311-6.el10.noarch.rpm;name=aarch64_texlive-l3packages;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-l3packages}"
SRC_URI[aarch64_texlive-l3packages.sha256sum] = "bb91ffc69d003542afdf0395752eb5e4bb40582f123ee20f1b9be891ad17abbe"

URI_aarch64_texlive-lastpage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lastpage-20240311-6.el10.noarch.rpm;name=aarch64_texlive-lastpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lastpage}"
SRC_URI[aarch64_texlive-lastpage.sha256sum] = "fd1b8f3fd8d386783689bb444385291e43b2a8f6d2eb48e7b81960d3f6acac55"

URI_aarch64_texlive-latex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-latex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-latex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex}"
SRC_URI[aarch64_texlive-latex.sha256sum] = "a463504942d7afe874247573cae24c4a9500d099b4c3fe34b2f422ca646dad4c"
RPROVIDES:texlive-latex:append:aarch64 = " virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_ virtual/texlive-latex"

URI_aarch64_texlive-latex-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-latex-fonts-20240311-6.el10.noarch.rpm;name=aarch64_texlive-latex-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex-fonts}"
SRC_URI[aarch64_texlive-latex-fonts.sha256sum] = "c956e5756398df793f5a761f27ae25bccd109a28a0d4dc1c9e8b5831e350281f"

URI_aarch64_texlive-latex2man = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-latex2man-20240311-6.el10.noarch.rpm;name=aarch64_texlive-latex2man;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex2man}"
SRC_URI[aarch64_texlive-latex2man.sha256sum] = "0eb0ab627050c0f44dd8abdf5ace4eca1236eeaf2bd03c7459e36b00f5c46e94"

URI_aarch64_texlive-latexbug = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-latexbug-20240311-6.el10.noarch.rpm;name=aarch64_texlive-latexbug;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latexbug}"
SRC_URI[aarch64_texlive-latexbug.sha256sum] = "27c00c69f68270e70cb447e096996eeacedb1d49834e5c5c5ccdd9bfc3ab9522"

URI_aarch64_texlive-latexconfig = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-latexconfig-20240311-6.el10.noarch.rpm;name=aarch64_texlive-latexconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latexconfig}"
SRC_URI[aarch64_texlive-latexconfig.sha256sum] = "d3088136fd669c7162a9ef3a3e54842d607bd424d7eb7b39c06af2e6071f4edb"

URI_aarch64_texlive-letltxmacro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-letltxmacro-20240311-6.el10.noarch.rpm;name=aarch64_texlive-letltxmacro;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-letltxmacro}"
SRC_URI[aarch64_texlive-letltxmacro.sha256sum] = "08d50f4fb413fb8a6d4ba2d8807cdb704f947d50f8df52badfaab6ddbf219b40"

URI_aarch64_texlive-lettrine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lettrine-20240311-6.el10.noarch.rpm;name=aarch64_texlive-lettrine;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lettrine}"
SRC_URI[aarch64_texlive-lettrine.sha256sum] = "fbc5a9bcb4401363b227d12f53c34e48caa97d9c83b4bf2a2e90acc37e5bf4cd"

URI_aarch64_texlive-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lib-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lib}"
SRC_URI[aarch64_texlive-lib.sha256sum] = "a1dc241f8f36cff5148e02c722d878e903cfa4846130c0dccd700463e7b71be2"

URI_aarch64_texlive-lib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/texlive-lib-devel-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-lib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lib-devel}"
SRC_URI[aarch64_texlive-lib-devel.sha256sum] = "f957e9e4cb3cd17dbf76c0382fc445aed02b3a70820e1357fad481d61dfee05d"

URI_aarch64_texlive-linegoal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-linegoal-20240311-6.el10.noarch.rpm;name=aarch64_texlive-linegoal;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-linegoal}"
SRC_URI[aarch64_texlive-linegoal.sha256sum] = "ff0fa91cf992fab9cb765687ab0e8ea1a8100b40e73d365521ad626d52aa24a5"

URI_aarch64_texlive-lineno = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lineno-20240311-6.el10.noarch.rpm;name=aarch64_texlive-lineno;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lineno}"
SRC_URI[aarch64_texlive-lineno.sha256sum] = "847b1214306bf9a12376816fb6f1087b24bde8013be20120e1a4d9af987cab5c"

URI_aarch64_texlive-listings = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-listings-20240311-6.el10.noarch.rpm;name=aarch64_texlive-listings;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-listings}"
SRC_URI[aarch64_texlive-listings.sha256sum] = "5db64f123427d23848ea6c4cf69724f5efa8ecf729758c9c69e72ede20838482"

URI_aarch64_texlive-listofitems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-listofitems-20240311-6.el10.noarch.rpm;name=aarch64_texlive-listofitems;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-listofitems}"
SRC_URI[aarch64_texlive-listofitems.sha256sum] = "74d9224b08b2a3d57c621b0c76ceb6218721a83fb2bf47c1136cf52ff9b81be2"

URI_aarch64_texlive-lm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lm-20240311-6.el10.noarch.rpm;name=aarch64_texlive-lm;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lm}"
SRC_URI[aarch64_texlive-lm.sha256sum] = "870d37c634dabb82020062dedec56bff418ba0ff304982c5533ea1adc6539fa7"

URI_aarch64_texlive-lm-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lm-math-20240311-6.el10.noarch.rpm;name=aarch64_texlive-lm-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lm-math}"
SRC_URI[aarch64_texlive-lm-math.sha256sum] = "9a6836fc0d1398a3c83f08f0f94dcaa270c47bb6611ae5f6f71214018fe464c8"

URI_aarch64_texlive-ltabptch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ltabptch-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ltabptch;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ltabptch}"
SRC_URI[aarch64_texlive-ltabptch.sha256sum] = "18757d34b6eba9f14e4ef2030149bce36a87f34f28968ddc7ddab4f51e5f619f"

URI_aarch64_texlive-ltxcmds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ltxcmds-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ltxcmds;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ltxcmds}"
SRC_URI[aarch64_texlive-ltxcmds.sha256sum] = "d89ae7253ef2157870421edd5315876a305fb81e4b9b30eedaa579be7898f800"

URI_aarch64_texlive-ltxmisc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ltxmisc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ltxmisc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ltxmisc}"
SRC_URI[aarch64_texlive-ltxmisc.sha256sum] = "044f16dad4052a6d07b5b42e71c2435302809f2575a352c721db938c072cf84c"

URI_aarch64_texlive-lua-alt-getopt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lua-alt-getopt-20240311-6.el10.noarch.rpm;name=aarch64_texlive-lua-alt-getopt;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lua-alt-getopt}"
SRC_URI[aarch64_texlive-lua-alt-getopt.sha256sum] = "4fb6f1101924010b4808f86f5c9b47f89ec8d9d7c2ff9bf2ab0504afa8cafe10"

URI_aarch64_texlive-lua-uni-algos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lua-uni-algos-20240311-6.el10.noarch.rpm;name=aarch64_texlive-lua-uni-algos;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lua-uni-algos}"
SRC_URI[aarch64_texlive-lua-uni-algos.sha256sum] = "f259f0841946fb4b935603e711f15ad8c1e179105cdd3aaa9aa2ebf407a544d0"

URI_aarch64_texlive-luahbtex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-luahbtex-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-luahbtex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luahbtex}"
SRC_URI[aarch64_texlive-luahbtex.sha256sum] = "9db24995997a59cf6374ac390208039a11557f6d8343dec3d7e43f68305aced0"

URI_aarch64_texlive-lualatex-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lualatex-math-20240311-6.el10.noarch.rpm;name=aarch64_texlive-lualatex-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lualatex-math}"
SRC_URI[aarch64_texlive-lualatex-math.sha256sum] = "d83022e6241054eafd5ee02f340a4957da15937101784ea473af65f9ea4399c8"

URI_aarch64_texlive-lualibs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lualibs-20240311-6.el10.noarch.rpm;name=aarch64_texlive-lualibs;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lualibs}"
SRC_URI[aarch64_texlive-lualibs.sha256sum] = "e2a2d5708f33880c34d692510a6e86929a4e57fbdd6b12f570af486f858daea4"

URI_aarch64_texlive-luaotfload = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-luaotfload-20240311-6.el10.noarch.rpm;name=aarch64_texlive-luaotfload;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luaotfload}"
SRC_URI[aarch64_texlive-luaotfload.sha256sum] = "37a85f96ca94f90cb74c216b3b767d21c567ced9ff05bc24501f2fd39fcebc9f"

URI_aarch64_texlive-luatex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-luatex-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-luatex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luatex}"
SRC_URI[aarch64_texlive-luatex.sha256sum] = "4ce2b8a9f9ea8046b70571163aadf1e2982e14889fc62e8f95a203f1c68bb455"

URI_aarch64_texlive-luatex85 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-luatex85-20240311-6.el10.noarch.rpm;name=aarch64_texlive-luatex85;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luatex85}"
SRC_URI[aarch64_texlive-luatex85.sha256sum] = "ebdc1cd8e63eeef456cefeaa6c9a4f8398ae98237eba37010c65f72736c40b4d"

URI_aarch64_texlive-luatexbase = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-luatexbase-20240311-6.el10.noarch.rpm;name=aarch64_texlive-luatexbase;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luatexbase}"
SRC_URI[aarch64_texlive-luatexbase.sha256sum] = "7e7a20a1335817cffdc69f91f9023fa74bd9c238d94ef3d87fec0e68b119e944"

URI_aarch64_texlive-lwarp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lwarp-20240311-6.el10.noarch.rpm;name=aarch64_texlive-lwarp;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lwarp}"
SRC_URI[aarch64_texlive-lwarp.sha256sum] = "c035115151353c752431808c16d6800242f84b177f0d966cac217b6062a3f4ec"

URI_aarch64_texlive-makecmds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-makecmds-20240311-6.el10.noarch.rpm;name=aarch64_texlive-makecmds;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-makecmds}"
SRC_URI[aarch64_texlive-makecmds.sha256sum] = "491d07fda42ca73f24dde21d4b12f34e1ecce134fca26329d00ec27ca3acefeb"

URI_aarch64_texlive-makeindex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-makeindex-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-makeindex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-makeindex}"
SRC_URI[aarch64_texlive-makeindex.sha256sum] = "d74a8a1c60d87016c64f69229c615b0a97b88d8a9ac5342d91a70325df102ec1"

URI_aarch64_texlive-manfnt-font = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-manfnt-font-20240311-6.el10.noarch.rpm;name=aarch64_texlive-manfnt-font;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-manfnt-font}"
SRC_URI[aarch64_texlive-manfnt-font.sha256sum] = "9cec5bcb7cf06278a2eb0d3c1ada61f7b78292a7da1c5f6ad5e3f28958bdc547"

URI_aarch64_texlive-marginnote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-marginnote-20240311-6.el10.noarch.rpm;name=aarch64_texlive-marginnote;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-marginnote}"
SRC_URI[aarch64_texlive-marginnote.sha256sum] = "c4fdd82885a218939ac1a95fa711e61749d907362f191220a9c151f44e724b2b"

URI_aarch64_texlive-marvosym = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-marvosym-20240311-6.el10.noarch.rpm;name=aarch64_texlive-marvosym;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-marvosym}"
SRC_URI[aarch64_texlive-marvosym.sha256sum] = "078bc7b64a9a3b0b87edcdd3638e8c5ed452fadaa0f845cd5624ac696f8d33d7"

URI_aarch64_texlive-mathpazo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mathpazo-20240311-6.el10.noarch.rpm;name=aarch64_texlive-mathpazo;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mathpazo}"
SRC_URI[aarch64_texlive-mathpazo.sha256sum] = "115b2120f6f4fdd4c2a018c123848b67031eaa782388e8d5d27efe3979293175"

URI_aarch64_texlive-mathspec = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mathspec-20240311-6.el10.noarch.rpm;name=aarch64_texlive-mathspec;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mathspec}"
SRC_URI[aarch64_texlive-mathspec.sha256sum] = "d12563ef1f8be490df25d75a553be08bec71a88d794daf71914cb5ed2331d64f"

URI_aarch64_texlive-mathtools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mathtools-20240311-6.el10.noarch.rpm;name=aarch64_texlive-mathtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mathtools}"
SRC_URI[aarch64_texlive-mathtools.sha256sum] = "4be2776d66c339ee7d1198ee8b9ef71ac0a10c85c2d4e3f1704cae3df7851b8c"

URI_aarch64_texlive-mdwtools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mdwtools-20240311-6.el10.noarch.rpm;name=aarch64_texlive-mdwtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mdwtools}"
SRC_URI[aarch64_texlive-mdwtools.sha256sum] = "28d8a857e825c8ea7031a9cf641752a80ee323b3f7cc681b4cd7c64d76a7699a"

URI_aarch64_texlive-memoir = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-memoir-20240311-6.el10.noarch.rpm;name=aarch64_texlive-memoir;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-memoir}"
SRC_URI[aarch64_texlive-memoir.sha256sum] = "15223364fe278176dd67ec9ff604e6a0ea060e7c424a70be6e2a2ac9f0427e88"

URI_aarch64_texlive-metafont = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-metafont-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-metafont;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-metafont}"
SRC_URI[aarch64_texlive-metafont.sha256sum] = "83a6e12e3461e9d0bd5e1e7bc0f0f06f3df1c01f96e876c197b396a4965bcfef"

URI_aarch64_texlive-metalogo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-metalogo-20240311-6.el10.noarch.rpm;name=aarch64_texlive-metalogo;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-metalogo}"
SRC_URI[aarch64_texlive-metalogo.sha256sum] = "8efc7ea8af63eafaf11f691ffe06ffb8a005a3d4a19f50a0f2ea70e9ee4d40af"

URI_aarch64_texlive-metapost = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-metapost-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-metapost;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-metapost}"
SRC_URI[aarch64_texlive-metapost.sha256sum] = "078263ed551eecf1b9074f9639a68fad0b7d3891daaf7b6cdb9326d74ccc0c3c"

URI_aarch64_texlive-mflogo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mflogo-20240311-6.el10.noarch.rpm;name=aarch64_texlive-mflogo;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mflogo}"
SRC_URI[aarch64_texlive-mflogo.sha256sum] = "cbdfd878c8f3b3ef4b63548114ba0a862a9dc1842f018d548223ca900dbe6e11"

URI_aarch64_texlive-mflogo-font = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mflogo-font-20240311-6.el10.noarch.rpm;name=aarch64_texlive-mflogo-font;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mflogo-font}"
SRC_URI[aarch64_texlive-mflogo-font.sha256sum] = "b9e1d6f6a34897ef76094a79201bf6c5eddfcb71e0caae54e23a177b2615b9ea"

URI_aarch64_texlive-mfnfss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mfnfss-20240311-6.el10.noarch.rpm;name=aarch64_texlive-mfnfss;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mfnfss}"
SRC_URI[aarch64_texlive-mfnfss.sha256sum] = "130c4044a96ef88759dcb4e5e2323682120852f82e25dc4a888fb40272010d92"

URI_aarch64_texlive-mfware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mfware-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-mfware;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mfware}"
SRC_URI[aarch64_texlive-mfware.sha256sum] = "df3e09f9883c73803e4b5aa50ddaeab0c4dbf2cbfaa9c8b40b64895c9776a50c"

URI_aarch64_texlive-microtype = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-microtype-20240311-6.el10.noarch.rpm;name=aarch64_texlive-microtype;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-microtype}"
SRC_URI[aarch64_texlive-microtype.sha256sum] = "8031a0a3568539b1c8aba69b68cd1089a5c37c51a8acaa8d688ba898a6770c62"

URI_aarch64_texlive-minitoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-minitoc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-minitoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-minitoc}"
SRC_URI[aarch64_texlive-minitoc.sha256sum] = "f5043f59eb717d72c7af353180c2a94dfa363d4baf087293b6ba940842e112cc"

URI_aarch64_texlive-mnsymbol = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mnsymbol-20240311-6.el10.noarch.rpm;name=aarch64_texlive-mnsymbol;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mnsymbol}"
SRC_URI[aarch64_texlive-mnsymbol.sha256sum] = "b14f13a8b7e9c1c7ae8de31d0b6c677ed9bfd4d91d55b8dda4bdbedf4769f683"

URI_aarch64_texlive-modes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-modes-20240311-6.el10.noarch.rpm;name=aarch64_texlive-modes;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-modes}"
SRC_URI[aarch64_texlive-modes.sha256sum] = "4418dc9e04558a355851cf1ec52d2a30a165ddedf6967caf2fb1c2ac195c746d"

URI_aarch64_texlive-mparhack = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mparhack-20240311-6.el10.noarch.rpm;name=aarch64_texlive-mparhack;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mparhack}"
SRC_URI[aarch64_texlive-mparhack.sha256sum] = "7b9a819c9119ea302dfc44cf9e839e062ff121015f6e1b269abcead4868da4aa"

URI_aarch64_texlive-mptopdf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mptopdf-20240311-6.el10.noarch.rpm;name=aarch64_texlive-mptopdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mptopdf}"
SRC_URI[aarch64_texlive-mptopdf.sha256sum] = "ec7accf5f4f4d36ddd23a313656bd5b8af31fb199afd5cc50c89d82236b872d7"

URI_aarch64_texlive-multido = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-multido-20240311-6.el10.noarch.rpm;name=aarch64_texlive-multido;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-multido}"
SRC_URI[aarch64_texlive-multido.sha256sum] = "a3e14ac997a1d378ef977d99667bf9542934056b581e449865f431f05c1a3d67"

URI_aarch64_texlive-multirow = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-multirow-20240311-6.el10.noarch.rpm;name=aarch64_texlive-multirow;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-multirow}"
SRC_URI[aarch64_texlive-multirow.sha256sum] = "f7273ef1874d2ad0658339d7770b8ef91b1dbfbbb5191a4b2f9955a5d690a01f"

URI_aarch64_texlive-multitoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-multitoc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-multitoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-multitoc}"
SRC_URI[aarch64_texlive-multitoc.sha256sum] = "f47ffd1665ec47b2b6c218cf851b4c85dc720d3df52fcc03a53e7aff1944a588"

URI_aarch64_texlive-natbib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-natbib-20240311-6.el10.noarch.rpm;name=aarch64_texlive-natbib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-natbib}"
SRC_URI[aarch64_texlive-natbib.sha256sum] = "da51fcbc61ad8871d446522661b2647df0ca2b93b5d4512981e79be906291051"

URI_aarch64_texlive-ncctools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ncctools-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ncctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ncctools}"
SRC_URI[aarch64_texlive-ncctools.sha256sum] = "1f860592d1796afcc34bee0e3c4e7c9cd7fbd5dad83d53266df08de312cdc908"

URI_aarch64_texlive-ncntrsbk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ncntrsbk-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ncntrsbk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ncntrsbk}"
SRC_URI[aarch64_texlive-ncntrsbk.sha256sum] = "6251576f9368a7563aad9da161e5f1d6389cc0d974e9cbc9d05cc4af24f77e62"

URI_aarch64_texlive-needspace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-needspace-20240311-6.el10.noarch.rpm;name=aarch64_texlive-needspace;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-needspace}"
SRC_URI[aarch64_texlive-needspace.sha256sum] = "a4682c25896fcbb371c56c78365ccd8aa280e79effd5323883eb91a4e651f912"

URI_aarch64_texlive-newfloat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-newfloat-20240311-6.el10.noarch.rpm;name=aarch64_texlive-newfloat;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-newfloat}"
SRC_URI[aarch64_texlive-newfloat.sha256sum] = "1504537a82467927678ced0c0e859a699d712a95b4600dfb7afde1d0af7bbbb1"

URI_aarch64_texlive-newunicodechar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-newunicodechar-20240311-6.el10.noarch.rpm;name=aarch64_texlive-newunicodechar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-newunicodechar}"
SRC_URI[aarch64_texlive-newunicodechar.sha256sum] = "cf1949ec476bf8f2934c5ed6db14ee7010c53a5d12bd22a87b97ba6a0e94e637"

URI_aarch64_texlive-norasi-c90 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-norasi-c90-20240311-6.el10.noarch.rpm;name=aarch64_texlive-norasi-c90;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-norasi-c90}"
SRC_URI[aarch64_texlive-norasi-c90.sha256sum] = "8f058965dce5a913d3ac36d25b3344233d5acf9ce26efe7e56ed5fac199c51c3"

URI_aarch64_texlive-notoccite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-notoccite-20240311-6.el10.noarch.rpm;name=aarch64_texlive-notoccite;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-notoccite}"
SRC_URI[aarch64_texlive-notoccite.sha256sum] = "3ae343008dc1ac2de9742625cbd8635d62f557ea6cd58ee63e1a59b2712c9480"

URI_aarch64_texlive-ntgclass = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ntgclass-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ntgclass;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ntgclass}"
SRC_URI[aarch64_texlive-ntgclass.sha256sum] = "dcd8de656d6be698858bb1d92f9933a3e6590fd09059efa9eb016b02fb43e912"

URI_aarch64_texlive-oberdiek = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-oberdiek-20240311-6.el10.noarch.rpm;name=aarch64_texlive-oberdiek;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-oberdiek}"
SRC_URI[aarch64_texlive-oberdiek.sha256sum] = "4669c32a90e8515ca3a55685bdfd87e7bc3688392b0b2a22de8e25ece6cd2d07"

URI_aarch64_texlive-overpic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-overpic-20240311-6.el10.noarch.rpm;name=aarch64_texlive-overpic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-overpic}"
SRC_URI[aarch64_texlive-overpic.sha256sum] = "6afc155d6b0569a71c8cf047dca6f999b818142e72f9772681e99dcdf3a54795"

URI_aarch64_texlive-palatino = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-palatino-20240311-6.el10.noarch.rpm;name=aarch64_texlive-palatino;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-palatino}"
SRC_URI[aarch64_texlive-palatino.sha256sum] = "1043000116fd5af45278b7204eba7f6b4e3e44d96e7fc80e198c16c790e2920a"

URI_aarch64_texlive-paralist = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-paralist-20240311-6.el10.noarch.rpm;name=aarch64_texlive-paralist;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-paralist}"
SRC_URI[aarch64_texlive-paralist.sha256sum] = "3ae6ca32c4c581d3ea2adb0f3b429244c20a509798b25fd676daf638f04858e3"

URI_aarch64_texlive-parallel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-parallel-20240311-6.el10.noarch.rpm;name=aarch64_texlive-parallel;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-parallel}"
SRC_URI[aarch64_texlive-parallel.sha256sum] = "3ad9eef2fa82fcf12e51f4a7dc3e2c1b75f7b8007c67fb8e429929a6477ed5e1"

URI_aarch64_texlive-parskip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-parskip-20240311-6.el10.noarch.rpm;name=aarch64_texlive-parskip;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-parskip}"
SRC_URI[aarch64_texlive-parskip.sha256sum] = "ad057883cf28ca7f334690bc3e91a16f7964c3ce7915b4687fa9c44ca854580f"

URI_aarch64_texlive-passivetex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-passivetex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-passivetex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-passivetex}"
SRC_URI[aarch64_texlive-passivetex.sha256sum] = "1068ea61ed7e8a7317e5c100a6016261cd0df91bdcd7858365497b3ac534e031"

URI_aarch64_texlive-pdfcol = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfcol-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pdfcol;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfcol}"
SRC_URI[aarch64_texlive-pdfcol.sha256sum] = "dfe4c5b0c3e5bb182e6b0e4d4e0e7d40afc36bccab13bebcfe178712c3b8a8fc"

URI_aarch64_texlive-pdfcolfoot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfcolfoot-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pdfcolfoot;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfcolfoot}"
SRC_URI[aarch64_texlive-pdfcolfoot.sha256sum] = "3971f8a891fbc91735b54c7ea44ffd86d09bd663ef5370bec233bd96dee1ee2a"

URI_aarch64_texlive-pdfcolmk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfcolmk-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pdfcolmk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfcolmk}"
SRC_URI[aarch64_texlive-pdfcolmk.sha256sum] = "ee6a4d241edf9555b09b0b602f261416720e4964d565cbb33f18581e7bbb9eff"

URI_aarch64_texlive-pdfescape = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfescape-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pdfescape;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfescape}"
SRC_URI[aarch64_texlive-pdfescape.sha256sum] = "55688d02facaa9cf6f4c07092a6fd427715e1b77ba4e3eba26aa5b7c65cd0a9b"

URI_aarch64_texlive-pdflscape = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdflscape-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pdflscape;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdflscape}"
SRC_URI[aarch64_texlive-pdflscape.sha256sum] = "315c87a8df3eae1482b4b82068bb08c758ee759dfe3a4f5065be96abdd656b71"

URI_aarch64_texlive-pdfmanagement-testphase = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfmanagement-testphase-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pdfmanagement-testphase;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfmanagement-testphase}"
SRC_URI[aarch64_texlive-pdfmanagement-testphase.sha256sum] = "7422f1121ada16fcc037680b844f22bce7d5a74fce0f467a8894e4a262e7bd62"

URI_aarch64_texlive-pdfpages = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfpages-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pdfpages;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfpages}"
SRC_URI[aarch64_texlive-pdfpages.sha256sum] = "24b64b1776f43c1d30789e120d3737b66793c498641aabf744ab49d2650914db"

URI_aarch64_texlive-pdftex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdftex-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-pdftex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdftex}"
SRC_URI[aarch64_texlive-pdftex.sha256sum] = "9572d951e8d10d3ce2730e10ef91fe0cee4a0b3b0bb84d6220d1477a8a5186b4"

URI_aarch64_texlive-pdftexcmds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdftexcmds-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pdftexcmds;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdftexcmds}"
SRC_URI[aarch64_texlive-pdftexcmds.sha256sum] = "b108e09f93ae42aa27eef17110ed236d420d5e71bfe025d7688608c45408ce59"

URI_aarch64_texlive-pgf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pgf-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pgf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pgf}"
SRC_URI[aarch64_texlive-pgf.sha256sum] = "2a963c70cf2e1648e43ab37068847a9b43aff66e0b3dd82041fd14e254bd6ed7"

URI_aarch64_texlive-philokalia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-philokalia-20240311-6.el10.noarch.rpm;name=aarch64_texlive-philokalia;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-philokalia}"
SRC_URI[aarch64_texlive-philokalia.sha256sum] = "a12b0cfb225676af7b7adb96c0dd6af3eca33c1f0bfdd70837cd343b878a0981"

URI_aarch64_texlive-placeins = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-placeins-20240311-6.el10.noarch.rpm;name=aarch64_texlive-placeins;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-placeins}"
SRC_URI[aarch64_texlive-placeins.sha256sum] = "c88da1b2d7e321d13f7822085a25098f29c50a384792489ca0ae4475691d2ab4"

URI_aarch64_texlive-plain = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-plain-20240311-6.el10.noarch.rpm;name=aarch64_texlive-plain;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-plain}"
SRC_URI[aarch64_texlive-plain.sha256sum] = "17d99b9e0821f701556b2d62642624ec50e3dee44e8b543767c33c8e1d437362"

URI_aarch64_texlive-polyglossia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-polyglossia-20240311-6.el10.noarch.rpm;name=aarch64_texlive-polyglossia;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-polyglossia}"
SRC_URI[aarch64_texlive-polyglossia.sha256sum] = "878086d830fd66800eb70e738048a823cb4e2458ac1abb6048a527d967503233"

URI_aarch64_texlive-powerdot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-powerdot-20240311-6.el10.noarch.rpm;name=aarch64_texlive-powerdot;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-powerdot}"
SRC_URI[aarch64_texlive-powerdot.sha256sum] = "59eaf25da2702bce4dcb734daa815c346c0dde474cdcd74b219ee340917ee530"

URI_aarch64_texlive-preprint = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-preprint-20240311-6.el10.noarch.rpm;name=aarch64_texlive-preprint;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-preprint}"
SRC_URI[aarch64_texlive-preprint.sha256sum] = "e0f8c1eb0b595683dbf3776218850ff3c83b7ac44511d6d446c922b89f184fb8"

URI_aarch64_texlive-psfrag = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-psfrag-20240311-6.el10.noarch.rpm;name=aarch64_texlive-psfrag;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-psfrag}"
SRC_URI[aarch64_texlive-psfrag.sha256sum] = "d1ea2a7d96f5db9b13cebc06c2cce52545d0dacdab574d9255844b27d0c53671"

URI_aarch64_texlive-pslatex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pslatex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pslatex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pslatex}"
SRC_URI[aarch64_texlive-pslatex.sha256sum] = "142f19aa4bb22f2e7e1f3cc35e5c450a1ea99d2f2db7edd4596bc432ad52d670"

URI_aarch64_texlive-psnfss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-psnfss-20240311-6.el10.noarch.rpm;name=aarch64_texlive-psnfss;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-psnfss}"
SRC_URI[aarch64_texlive-psnfss.sha256sum] = "d10837e1e574330699b490438a37bf2b4df781cb75a4a5a58361f5155025c8c7"

URI_aarch64_texlive-pspicture = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pspicture-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pspicture;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pspicture}"
SRC_URI[aarch64_texlive-pspicture.sha256sum] = "8ab4d439b459e252ac9a70d1c9d87591ec2f53129789f5c3cbe8d216b0e7ecbe"

URI_aarch64_texlive-pst-3d = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-3d-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-3d}"
SRC_URI[aarch64_texlive-pst-3d.sha256sum] = "efac7c1f4911f82cfcaf8af5f9d0cf93115ae8130d511b3c9f263bda2e0df622"

URI_aarch64_texlive-pst-arrow = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-arrow-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-arrow;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-arrow}"
SRC_URI[aarch64_texlive-pst-arrow.sha256sum] = "1c985bfbfbe7a73b0edd94ea84fc7c19cb16164478a8f32e2dead0db3421b663"

URI_aarch64_texlive-pst-blur = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-blur-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-blur;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-blur}"
SRC_URI[aarch64_texlive-pst-blur.sha256sum] = "f36bf6ecb5689270d916536171b260f73de9b1a1d427c27c23cc6923caf4a7bc"

URI_aarch64_texlive-pst-coil = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-coil-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-coil;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-coil}"
SRC_URI[aarch64_texlive-pst-coil.sha256sum] = "267015b1412f6662a96000ce6385e57cbdb1012ea16247bb3d872fd1c4dafd90"

URI_aarch64_texlive-pst-eps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-eps-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-eps;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-eps}"
SRC_URI[aarch64_texlive-pst-eps.sha256sum] = "8a830840ff11690118dd4524fbcb7b9b073b344f3bf471bae2be1d8807996c16"

URI_aarch64_texlive-pst-fill = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-fill-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-fill;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-fill}"
SRC_URI[aarch64_texlive-pst-fill.sha256sum] = "96dc7a756e8834a6afbc1d8a7918c1fdc73a7ac46e20be1ab62687ad66d4fc40"

URI_aarch64_texlive-pst-grad = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-grad-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-grad;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-grad}"
SRC_URI[aarch64_texlive-pst-grad.sha256sum] = "c1e4ac5c00244a7339ede6b3af0b0b0e1631f0961bc3fb7b65fbe7ff9704d534"

URI_aarch64_texlive-pst-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-math-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-math}"
SRC_URI[aarch64_texlive-pst-math.sha256sum] = "9c173ec926580063a1d78c81de3add5baee30f2f304a4fed6abd485c4710be1c"

URI_aarch64_texlive-pst-node = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-node-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-node;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-node}"
SRC_URI[aarch64_texlive-pst-node.sha256sum] = "119ab3c28982638c47db4c70816cdfc6fbe1e5ed940f475a2cf6320d772894d2"

URI_aarch64_texlive-pst-plot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-plot-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-plot;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-plot}"
SRC_URI[aarch64_texlive-pst-plot.sha256sum] = "20e09a14e2fa2fcb8db313f471f2218ee2ae97151509dc66a2945e6ddcdb0451"

URI_aarch64_texlive-pst-slpe = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-slpe-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-slpe;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-slpe}"
SRC_URI[aarch64_texlive-pst-slpe.sha256sum] = "ba682149cee935ffd676df9e6f086123f4c4e4e6d7744181017ab9215b9dd599"

URI_aarch64_texlive-pst-text = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-text-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-text}"
SRC_URI[aarch64_texlive-pst-text.sha256sum] = "a0f4f0432d09b53275329216fdfeb6534216eb496183ca8891ff23520a85d4a1"

URI_aarch64_texlive-pst-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-tools-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-tools}"
SRC_URI[aarch64_texlive-pst-tools.sha256sum] = "9f80e4a8587530ad6471bd2c0de7614bd3bf4f8a83a36917abfe5026ae2cdfe4"

URI_aarch64_texlive-pst-tree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-tree-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pst-tree;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-tree}"
SRC_URI[aarch64_texlive-pst-tree.sha256sum] = "dfbf53f0a3d5550210e014aa3c5883f9828ef28db880db1caf7892e316fed449"

URI_aarch64_texlive-pstricks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pstricks-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pstricks;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pstricks}"
SRC_URI[aarch64_texlive-pstricks.sha256sum] = "aff55ebb65afd55ab64c606063ea5e7b565a8b21ed189300651d4969ec308710"

URI_aarch64_texlive-pstricks-add = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pstricks-add-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pstricks-add;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pstricks-add}"
SRC_URI[aarch64_texlive-pstricks-add.sha256sum] = "8527c2d3188501330928d5799714a9fa7bd6665a7ced118c87b4c9066e42db74"

URI_aarch64_texlive-ptext = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ptext-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ptext;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptext}"
SRC_URI[aarch64_texlive-ptext.sha256sum] = "03ec72f59f89c83b86ac9ce286c7465445499c554a2b1df4bf5156fffe41075a"

URI_aarch64_texlive-pxfonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pxfonts-20240311-6.el10.noarch.rpm;name=aarch64_texlive-pxfonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pxfonts}"
SRC_URI[aarch64_texlive-pxfonts.sha256sum] = "28bdd60ee035061e6a882a1ad823bae4cab70b71f9495519164c5c7dee0c97cc"

URI_aarch64_texlive-qstest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-qstest-20240311-6.el10.noarch.rpm;name=aarch64_texlive-qstest;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-qstest}"
SRC_URI[aarch64_texlive-qstest.sha256sum] = "3661c41e9750061c30e533ac706811b00d62d7c08394be1108886e29437cc242"

URI_aarch64_texlive-ragged2e = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ragged2e-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ragged2e;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ragged2e}"
SRC_URI[aarch64_texlive-ragged2e.sha256sum] = "da2688c1a2f78d3294b568c97ca79ee7fba93101f44cfbeef09d8cda6984f2a3"

URI_aarch64_texlive-rcs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-rcs-20240311-6.el10.noarch.rpm;name=aarch64_texlive-rcs;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-rcs}"
SRC_URI[aarch64_texlive-rcs.sha256sum] = "0845c9d6c9a7090f7a7cfe973c6b49119446ffa6b347ff29028060399c545ae3"

URI_aarch64_texlive-realscripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-realscripts-20240311-6.el10.noarch.rpm;name=aarch64_texlive-realscripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-realscripts}"
SRC_URI[aarch64_texlive-realscripts.sha256sum] = "87d1c1b60f3af3f48b7a1f1df032c1bff91b66c7fe90357242e20f3625651ccf"

URI_aarch64_texlive-refcount = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-refcount-20240311-6.el10.noarch.rpm;name=aarch64_texlive-refcount;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-refcount}"
SRC_URI[aarch64_texlive-refcount.sha256sum] = "a3b5bd7aefe5870e20d056d705ca139550f25902caf22160c02227a9c651fb70"

URI_aarch64_texlive-relsize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-relsize-20240311-6.el10.noarch.rpm;name=aarch64_texlive-relsize;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-relsize}"
SRC_URI[aarch64_texlive-relsize.sha256sum] = "6ce2ac2f7dc69e2f6223d1975b9b2e6c5eb840eb7387a937af946b5186fa7aec"

URI_aarch64_texlive-rerunfilecheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-rerunfilecheck-20240311-6.el10.noarch.rpm;name=aarch64_texlive-rerunfilecheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-rerunfilecheck}"
SRC_URI[aarch64_texlive-rerunfilecheck.sha256sum] = "1a939772aa802ca2fc79fe6c18d46d80885f4a3ccea35c22e899f2253adbb995"

URI_aarch64_texlive-rsfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-rsfs-20240311-6.el10.noarch.rpm;name=aarch64_texlive-rsfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-rsfs}"
SRC_URI[aarch64_texlive-rsfs.sha256sum] = "534fffff5e5cba0a0b09fbaebc48bc01b373ef33cfe425519f0183721131f3d0"

URI_aarch64_texlive-sansmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sansmath-20240311-6.el10.noarch.rpm;name=aarch64_texlive-sansmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sansmath}"
SRC_URI[aarch64_texlive-sansmath.sha256sum] = "08283f85a678d569796d52cfb96f860170de03b80cc86e6a28eb57f9a9b87932"

URI_aarch64_texlive-sansmathaccent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sansmathaccent-20240311-6.el10.noarch.rpm;name=aarch64_texlive-sansmathaccent;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sansmathaccent}"
SRC_URI[aarch64_texlive-sansmathaccent.sha256sum] = "2c309ff48d5b6c331418f999bb947b18ecd3a1b95f8b0af617de7e548b07cdd2"

URI_aarch64_texlive-sauerj = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sauerj-20240311-6.el10.noarch.rpm;name=aarch64_texlive-sauerj;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sauerj}"
SRC_URI[aarch64_texlive-sauerj.sha256sum] = "0dee151aa4648617cee1c986a6a7856088e8763ed7cb1a2504ed1c240083ea71"

URI_aarch64_texlive-scheme-basic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-scheme-basic-20240311-6.el10.noarch.rpm;name=aarch64_texlive-scheme-basic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-scheme-basic}"
SRC_URI[aarch64_texlive-scheme-basic.sha256sum] = "7cb43973ec7e17e2f4fd1f5a5df221ed23c23f1d43be68ddce34e9f69eb4862e"

URI_aarch64_texlive-section = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-section-20240311-6.el10.noarch.rpm;name=aarch64_texlive-section;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-section}"
SRC_URI[aarch64_texlive-section.sha256sum] = "00f1e314b0060c903f28ff80f69eadbaf755c23a9df51e562f70a06492f17da8"

URI_aarch64_texlive-sectsty = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sectsty-20240311-6.el10.noarch.rpm;name=aarch64_texlive-sectsty;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sectsty}"
SRC_URI[aarch64_texlive-sectsty.sha256sum] = "4892147c37adbb06efebae4776844a74b2c2738b526a4bd1dc6c0b6db28719eb"

URI_aarch64_texlive-seminar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-seminar-20240311-6.el10.noarch.rpm;name=aarch64_texlive-seminar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-seminar}"
SRC_URI[aarch64_texlive-seminar.sha256sum] = "4184740d93d1a8f017d66e12b2ab4783dd70b87302dcbaf2183cb8bd9c29eb8d"

URI_aarch64_texlive-sepnum = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sepnum-20240311-6.el10.noarch.rpm;name=aarch64_texlive-sepnum;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sepnum}"
SRC_URI[aarch64_texlive-sepnum.sha256sum] = "8ae7b27a310e943c4e32b3ed51148af1217b263c97b9e3e127e52ad8e23e92cf"

URI_aarch64_texlive-setspace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-setspace-20240311-6.el10.noarch.rpm;name=aarch64_texlive-setspace;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-setspace}"
SRC_URI[aarch64_texlive-setspace.sha256sum] = "3c10e16e21bed84a7803ee46a79b80617a743a19a7c202e08af8b299ef5f702a"

URI_aarch64_texlive-sfmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sfmath-20240311-6.el10.noarch.rpm;name=aarch64_texlive-sfmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sfmath}"
SRC_URI[aarch64_texlive-sfmath.sha256sum] = "6553311a2eee5f21127f40e52feca5da18e394515771e7741a993efc63110093"

URI_aarch64_texlive-showexpl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-showexpl-20240311-6.el10.noarch.rpm;name=aarch64_texlive-showexpl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-showexpl}"
SRC_URI[aarch64_texlive-showexpl.sha256sum] = "491c1866d4b0ef9c0aca2943d0afdb1ca24dde8257a31858b3b31fe84264518e"

URI_aarch64_texlive-soul = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-soul-20240311-6.el10.noarch.rpm;name=aarch64_texlive-soul;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-soul}"
SRC_URI[aarch64_texlive-soul.sha256sum] = "47d703c5a949adabcabd0dc1e3ff6fef61c9a4b6ff7293d94c7e181ad799eec5"

URI_aarch64_texlive-stackengine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-stackengine-20240311-6.el10.noarch.rpm;name=aarch64_texlive-stackengine;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-stackengine}"
SRC_URI[aarch64_texlive-stackengine.sha256sum] = "c23ea31b76538f456d5abab1c818e3881493af0e96c0af5ee92111dde67811a0"

URI_aarch64_texlive-stmaryrd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-stmaryrd-20240311-6.el10.noarch.rpm;name=aarch64_texlive-stmaryrd;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-stmaryrd}"
SRC_URI[aarch64_texlive-stmaryrd.sha256sum] = "ccfed540249465ffa89699bd24cb4368d4c531313767279ee28ae1930653784e"

URI_aarch64_texlive-stringenc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-stringenc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-stringenc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-stringenc}"
SRC_URI[aarch64_texlive-stringenc.sha256sum] = "f7af7fc98f76993aad383347652050912b8b7f7c701ef1e0d5106ed0899dadff"

URI_aarch64_texlive-subfig = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-subfig-20240311-6.el10.noarch.rpm;name=aarch64_texlive-subfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-subfig}"
SRC_URI[aarch64_texlive-subfig.sha256sum] = "6a92670a22d86a4ae0d58696d55b12eba88fadb7d770ba1de554745d07b9183f"

URI_aarch64_texlive-subfigure = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-subfigure-20240311-6.el10.noarch.rpm;name=aarch64_texlive-subfigure;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-subfigure}"
SRC_URI[aarch64_texlive-subfigure.sha256sum] = "9ba539b29bffb9e076f52f838cb88a876def656eeb065cca46d32a064aaa385e"

URI_aarch64_texlive-svn-prov = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-svn-prov-20240311-6.el10.noarch.rpm;name=aarch64_texlive-svn-prov;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-svn-prov}"
SRC_URI[aarch64_texlive-svn-prov.sha256sum] = "fbf4c8f8c751e9382507180807e9136fb600bd5473eeda22c2a396f001772db1"

URI_aarch64_texlive-symbol = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-symbol-20240311-6.el10.noarch.rpm;name=aarch64_texlive-symbol;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-symbol}"
SRC_URI[aarch64_texlive-symbol.sha256sum] = "462cdcfa00e4399cff2c39179124a1ea13aebbe6bf2b0116223d9a98ea6ab213"

URI_aarch64_texlive-t2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-t2-20240311-6.el10.noarch.rpm;name=aarch64_texlive-t2;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-t2}"
SRC_URI[aarch64_texlive-t2.sha256sum] = "bbfd737544f9067434ef308f6de40ec28f6c797848debee03c2ea06b08289f6a"

URI_aarch64_texlive-tabu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tabu-20240311-6.el10.noarch.rpm;name=aarch64_texlive-tabu;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tabu}"
SRC_URI[aarch64_texlive-tabu.sha256sum] = "5c2f6cebbfad62c218feac42937f4a9ced2214d34b20ff1cb6742596896784aa"

URI_aarch64_texlive-tabulary = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tabulary-20240311-6.el10.noarch.rpm;name=aarch64_texlive-tabulary;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tabulary}"
SRC_URI[aarch64_texlive-tabulary.sha256sum] = "a3b8c25b09b443338d08c97e243a489aca02b198698018ba0607db739b228fb7"

URI_aarch64_texlive-tex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tex-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-tex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tex}"
SRC_URI[aarch64_texlive-tex.sha256sum] = "a25251edee75ecd42bd3bab605c2e0b20097221a31622df308218d869ab40bd3"

URI_aarch64_texlive-tex-gyre = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tex-gyre-20240311-6.el10.noarch.rpm;name=aarch64_texlive-tex-gyre;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tex-gyre}"
SRC_URI[aarch64_texlive-tex-gyre.sha256sum] = "9477722053646030e21371854dd81dd891d8ef2d8d325d71d187c9349526d00b"

URI_aarch64_texlive-tex-gyre-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tex-gyre-math-20240311-6.el10.noarch.rpm;name=aarch64_texlive-tex-gyre-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tex-gyre-math}"
SRC_URI[aarch64_texlive-tex-gyre-math.sha256sum] = "5ec8584e24053305e5e5e119dfd396765de5526c7df024cb302b8e9f6b20c013"

URI_aarch64_texlive-tex-ini-files = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tex-ini-files-20240311-6.el10.noarch.rpm;name=aarch64_texlive-tex-ini-files;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tex-ini-files}"
SRC_URI[aarch64_texlive-tex-ini-files.sha256sum] = "fe197c833a773a1e52ca6c625999238d2583f6faa3f0b0f6bbe24c8bde1fdab1"

URI_aarch64_texlive-tex4ht = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tex4ht-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-tex4ht;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tex4ht}"
SRC_URI[aarch64_texlive-tex4ht.sha256sum] = "cfda38dd0214325b527b56b09805a2e2c603619f9c4e6d049da09feb4d3706f9"

URI_aarch64_texlive-texlive-common-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive-common-doc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-texlive-common-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive-common-doc}"
SRC_URI[aarch64_texlive-texlive-common-doc.sha256sum] = "8f5594caf4b732b24fd825b851ad960270ad45c411f29f10963a9e1de93b7123"

URI_aarch64_texlive-texlive-en = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive-en-20240311-6.el10.noarch.rpm;name=aarch64_texlive-texlive-en;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive-en}"
SRC_URI[aarch64_texlive-texlive-en.sha256sum] = "2c1881bbe5c7ddcabe7dfa4108c18e143cd4229c4d9cd4da20529ea2eab6ea82"

URI_aarch64_texlive-texlive-msg-translations = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive-msg-translations-20240311-6.el10.noarch.rpm;name=aarch64_texlive-texlive-msg-translations;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive-msg-translations}"
SRC_URI[aarch64_texlive-texlive-msg-translations.sha256sum] = "69f01cfb30a9c0bb51967c3beb2e6e119d97ee4036be17f46774d1b385127e90"

URI_aarch64_texlive-texlive-scripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive-scripts-20240311-6.el10.noarch.rpm;name=aarch64_texlive-texlive-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive-scripts}"
SRC_URI[aarch64_texlive-texlive-scripts.sha256sum] = "47008a42465488d481cf440e5518cc0763de2a788ce58a2e05e5ab5bc7d17b8d"

URI_aarch64_texlive-texlive-scripts-extra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive-scripts-extra-20240311-6.el10.noarch.rpm;name=aarch64_texlive-texlive-scripts-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive-scripts-extra}"
SRC_URI[aarch64_texlive-texlive-scripts-extra.sha256sum] = "4c4a42eaa607c8a3eee96ae6abd9f482d0ea80502a4366279c45f10528cd5b8e"

URI_aarch64_texlive-texlive.infra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive.infra-20240311-6.el10.noarch.rpm;name=aarch64_texlive-texlive.infra;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive.infra}"
SRC_URI[aarch64_texlive-texlive.infra.sha256sum] = "d2d0ad3d87954fb35aa4136d2d5f02c59416e414b1d760273ef4901659b48092"

URI_aarch64_texlive-textcase = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-textcase-20240311-6.el10.noarch.rpm;name=aarch64_texlive-textcase;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-textcase}"
SRC_URI[aarch64_texlive-textcase.sha256sum] = "a8589fc5649923dc42f488cc0a12d8420a98dfc9abd82790076453951de0f107"

URI_aarch64_texlive-textpos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-textpos-20240311-6.el10.noarch.rpm;name=aarch64_texlive-textpos;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-textpos}"
SRC_URI[aarch64_texlive-textpos.sha256sum] = "6ed267cb379e611a9315d4b05f26d3e84a597d4c880743ac6d0708f09bc425f4"

URI_aarch64_texlive-threeparttable = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-threeparttable-20240311-6.el10.noarch.rpm;name=aarch64_texlive-threeparttable;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-threeparttable}"
SRC_URI[aarch64_texlive-threeparttable.sha256sum] = "79ccb1fc7ea156e0aae04aa824674f4f0320aa93d5d1ba3afa360c36f93f286a"

URI_aarch64_texlive-thumbpdf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-thumbpdf-20240311-6.el10.noarch.rpm;name=aarch64_texlive-thumbpdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-thumbpdf}"
SRC_URI[aarch64_texlive-thumbpdf.sha256sum] = "8f5322e45629481367f5f077e4d8ad6f1924b6e35f07b9d02a5782c0fa3579d4"

URI_aarch64_texlive-times = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-times-20240311-6.el10.noarch.rpm;name=aarch64_texlive-times;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-times}"
SRC_URI[aarch64_texlive-times.sha256sum] = "c998d0d28a39aded84916dd0abd11ebf8bc5df57333e8479675036fae5ce9b83"

URI_aarch64_texlive-tipa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tipa-20240311-6.el10.noarch.rpm;name=aarch64_texlive-tipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tipa}"
SRC_URI[aarch64_texlive-tipa.sha256sum] = "0d398e0eefb856a633b90b48c1e68f5fd1267307ecef521c6d0455f56473f920"

URI_aarch64_texlive-titlesec = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-titlesec-20240311-6.el10.noarch.rpm;name=aarch64_texlive-titlesec;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-titlesec}"
SRC_URI[aarch64_texlive-titlesec.sha256sum] = "da6573fffc12935cd74b9cf465dd422bd8925a42ab608f2f71147565839c447e"

URI_aarch64_texlive-titling = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-titling-20240311-6.el10.noarch.rpm;name=aarch64_texlive-titling;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-titling}"
SRC_URI[aarch64_texlive-titling.sha256sum] = "498abc15ad57f1a50c00498ca25b93ccb8ff053d60671688d3d3246a2965a6d9"

URI_aarch64_texlive-tocloft = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tocloft-20240311-6.el10.noarch.rpm;name=aarch64_texlive-tocloft;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tocloft}"
SRC_URI[aarch64_texlive-tocloft.sha256sum] = "f40b4b64e9cf47717b5fa616bae8f745a7a369dbfb1f51ad47f16c02b4bde4b0"

URI_aarch64_texlive-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tools-20240311-6.el10.noarch.rpm;name=aarch64_texlive-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tools}"
SRC_URI[aarch64_texlive-tools.sha256sum] = "c7c2eea487d65fdfc1fbb3a8e7ad3f97a1a34d79f6380438cdfba055d2e3c475"

URI_aarch64_texlive-translator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-translator-20240311-6.el10.noarch.rpm;name=aarch64_texlive-translator;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-translator}"
SRC_URI[aarch64_texlive-translator.sha256sum] = "feb68bcc9cddc9becde221920762c0986f863a034812d433a192148773dc42ff"

URI_aarch64_texlive-trimspaces = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-trimspaces-20240311-6.el10.noarch.rpm;name=aarch64_texlive-trimspaces;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-trimspaces}"
SRC_URI[aarch64_texlive-trimspaces.sha256sum] = "ec0e6bd400e5d7c6d3542440984756c7bab669cf41633ae30346af7f4370d697"

URI_aarch64_texlive-txfonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-txfonts-20240311-6.el10.noarch.rpm;name=aarch64_texlive-txfonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-txfonts}"
SRC_URI[aarch64_texlive-txfonts.sha256sum] = "b8a28f5fec69945f6ec15b8d399e7d8b47e15dc3cbc9cc96daa2a8b0eb234d7c"

URI_aarch64_texlive-type1cm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-type1cm-20240311-6.el10.noarch.rpm;name=aarch64_texlive-type1cm;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-type1cm}"
SRC_URI[aarch64_texlive-type1cm.sha256sum] = "96773f276fb1e7285382ea36fcc4e88a82b0b8f81c8a7f84d57e84749e56e237"

URI_aarch64_texlive-typehtml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-typehtml-20240311-6.el10.noarch.rpm;name=aarch64_texlive-typehtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-typehtml}"
SRC_URI[aarch64_texlive-typehtml.sha256sum] = "aa4949317fdf900360ac175d7c649999dd2f623db3be23a637f3659f352feab3"

URI_aarch64_texlive-ucharcat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ucharcat-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ucharcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ucharcat}"
SRC_URI[aarch64_texlive-ucharcat.sha256sum] = "ad54b94fa23b0f7966542e072466e219a6aef74b9fc95afc5aa4aef558227a19"

URI_aarch64_texlive-ucharclasses = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ucharclasses-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ucharclasses;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ucharclasses}"
SRC_URI[aarch64_texlive-ucharclasses.sha256sum] = "cb272b35fa21ec04d1c095695fb916da9fc05f30e4598bb541e1e257a2a1a2d0"

URI_aarch64_texlive-ucs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ucs-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ucs;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ucs}"
SRC_URI[aarch64_texlive-ucs.sha256sum] = "686387a5d6d63add465b955117818f9be23ba022329ec3686aac17410ea7c8ac"

URI_aarch64_texlive-uhc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-uhc-20240311-6.el10.noarch.rpm;name=aarch64_texlive-uhc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uhc}"
SRC_URI[aarch64_texlive-uhc.sha256sum] = "907aa8902573f451790e48f29e3a8f4992900c7e738260e12a8511a963602b9f"

URI_aarch64_texlive-ulem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ulem-20240311-6.el10.noarch.rpm;name=aarch64_texlive-ulem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ulem}"
SRC_URI[aarch64_texlive-ulem.sha256sum] = "09dc20f3c6a9b6fe167ddb9070a212717e7bf0afc3af5cd7d38827586c1c69b5"

URI_aarch64_texlive-underscore = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-underscore-20240311-6.el10.noarch.rpm;name=aarch64_texlive-underscore;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-underscore}"
SRC_URI[aarch64_texlive-underscore.sha256sum] = "92c90bafe1a5d5122db0085c70de880f9f742b98955b0d1380edb544e07eace1"

URI_aarch64_texlive-unicode-data = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-unicode-data-20240311-6.el10.noarch.rpm;name=aarch64_texlive-unicode-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-unicode-data}"
SRC_URI[aarch64_texlive-unicode-data.sha256sum] = "2f4cfe0404f81cd34acbbecf80f1c439acf9ce03de7ddd76fc9a1db55004d2df"

URI_aarch64_texlive-unicode-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-unicode-math-20240311-6.el10.noarch.rpm;name=aarch64_texlive-unicode-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-unicode-math}"
SRC_URI[aarch64_texlive-unicode-math.sha256sum] = "a97f3acefcf20e55432ebecaaf075ff55f68d7da21c0c995bafc53fba65ca246"

URI_aarch64_texlive-uniquecounter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-uniquecounter-20240311-6.el10.noarch.rpm;name=aarch64_texlive-uniquecounter;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uniquecounter}"
SRC_URI[aarch64_texlive-uniquecounter.sha256sum] = "25ac8cc440a5218370f12526cd8d9aaf48d0417c5afd1466c410aef7dc1c231e"

URI_aarch64_texlive-unisugar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-unisugar-20240311-6.el10.noarch.rpm;name=aarch64_texlive-unisugar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-unisugar}"
SRC_URI[aarch64_texlive-unisugar.sha256sum] = "c36473c164a16069b4b3531d706dcc4ff2f42317e485c2ea34b68b77c82d752e"

URI_aarch64_texlive-upquote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-upquote-20240311-6.el10.noarch.rpm;name=aarch64_texlive-upquote;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-upquote}"
SRC_URI[aarch64_texlive-upquote.sha256sum] = "e961a1f925ee1175b557d4a87666a2e04dfbb5e3d9d99540cd003cc675d0d595"

URI_aarch64_texlive-url = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-url-20240311-6.el10.noarch.rpm;name=aarch64_texlive-url;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-url}"
SRC_URI[aarch64_texlive-url.sha256sum] = "76479c34e7c405bb03960719dc4cafb1cc53f1a9363a33155fe9f57e6142eb98"

URI_aarch64_texlive-utopia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-utopia-20240311-6.el10.noarch.rpm;name=aarch64_texlive-utopia;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-utopia}"
SRC_URI[aarch64_texlive-utopia.sha256sum] = "72d41fec45217ab1cba71552298ec4fa7a05d4ed9d37e6240d12bad0e8dbbf04"

URI_aarch64_texlive-varwidth = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-varwidth-20240311-6.el10.noarch.rpm;name=aarch64_texlive-varwidth;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-varwidth}"
SRC_URI[aarch64_texlive-varwidth.sha256sum] = "b61e56625b11644a0bd9b41d4b3cdd86703e298e88070b7af8a73dba14689df6"

URI_aarch64_texlive-wadalab = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-wadalab-20240311-6.el10.noarch.rpm;name=aarch64_texlive-wadalab;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-wadalab}"
SRC_URI[aarch64_texlive-wadalab.sha256sum] = "d3f648dbd83842ba9a09fdc5ab34060d75984a2ab5c870745d730a7ff288b76e"

URI_aarch64_texlive-was = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-was-20240311-6.el10.noarch.rpm;name=aarch64_texlive-was;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-was}"
SRC_URI[aarch64_texlive-was.sha256sum] = "28765f7b1eb4eea284a484d641c4c61ebfd6b6bc42b30d5158821ec6ee592810"

URI_aarch64_texlive-wasy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-wasy-20240311-6.el10.noarch.rpm;name=aarch64_texlive-wasy;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-wasy}"
SRC_URI[aarch64_texlive-wasy.sha256sum] = "e5cf1fc9c604cad9cc33e3f21c5eddd479419c383c61efc8b5f7d35d2a5f1767"

URI_aarch64_texlive-wasy-type1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-wasy-type1-20240311-6.el10.noarch.rpm;name=aarch64_texlive-wasy-type1;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-wasy-type1}"
SRC_URI[aarch64_texlive-wasy-type1.sha256sum] = "18333b06115981355ba90798814e8c61b3b065ec6b1684452be78ba03a429e15"

URI_aarch64_texlive-wasysym = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-wasysym-20240311-6.el10.noarch.rpm;name=aarch64_texlive-wasysym;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-wasysym}"
SRC_URI[aarch64_texlive-wasysym.sha256sum] = "f616fdb95d8376a384679e126a77074e04cd0cd5b1faa52ead32057c54d714e2"

URI_aarch64_texlive-wrapfig = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-wrapfig-20240311-6.el10.noarch.rpm;name=aarch64_texlive-wrapfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-wrapfig}"
SRC_URI[aarch64_texlive-wrapfig.sha256sum] = "d44f2bb170f03794bbb78bb98d2e51acfb2a2ba41afe352b120caa0e6c813d56"

URI_aarch64_texlive-xcolor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xcolor-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xcolor;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xcolor}"
SRC_URI[aarch64_texlive-xcolor.sha256sum] = "0716c198a759790a84bab8e1ed32a9248fe1d09244d84c848ffda6d7944f347b"

URI_aarch64_texlive-xecolor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xecolor-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xecolor;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xecolor}"
SRC_URI[aarch64_texlive-xecolor.sha256sum] = "00fc9cf59105133861f60c3891ab810966c93164712e603de20809aff8345cd5"

URI_aarch64_texlive-xecyr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xecyr-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xecyr;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xecyr}"
SRC_URI[aarch64_texlive-xecyr.sha256sum] = "2ddabc8e6d4964fcb3bb201cf8d6f80554c5753f31fb174ea171815aa5456aa6"

URI_aarch64_texlive-xeindex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xeindex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xeindex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xeindex}"
SRC_URI[aarch64_texlive-xeindex.sha256sum] = "303ec55d1cf0672db7ff54c701b88f01bb67ded32b397117bd6aaf4717260ceb"

URI_aarch64_texlive-xepersian = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xepersian-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xepersian;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xepersian}"
SRC_URI[aarch64_texlive-xepersian.sha256sum] = "371e1e3c8196f820c4af39b512f9191195cbdc3edf26aba55e7a2a6ece5019c2"

URI_aarch64_texlive-xesearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xesearch-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xesearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xesearch}"
SRC_URI[aarch64_texlive-xesearch.sha256sum] = "d5ffcd5fa1bcc9ee12cf34126d99ddbbb5394a732a28a937f8642241cf65e1c7"

URI_aarch64_texlive-xetex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xetex-20240311-6.el10.aarch64.rpm;name=aarch64_texlive-xetex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xetex}"
SRC_URI[aarch64_texlive-xetex.sha256sum] = "128a2471d847484f5e223cec3d086d64c07592e0cbda3fd89b74878cb1d6dcbb"

URI_aarch64_texlive-xetex-itrans = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xetex-itrans-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xetex-itrans;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xetex-itrans}"
SRC_URI[aarch64_texlive-xetex-itrans.sha256sum] = "68f82005c91c958d9bbf006643c66e0d91c42d8f63d9e32c97709fed745f550d"

URI_aarch64_texlive-xetex-pstricks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xetex-pstricks-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xetex-pstricks;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xetex-pstricks}"
SRC_URI[aarch64_texlive-xetex-pstricks.sha256sum] = "822b13c650e0d6303ddda5ddefb5f9dd4d125bcb57fd8627c826dce9bdaa7dea"

URI_aarch64_texlive-xetexconfig = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xetexconfig-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xetexconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xetexconfig}"
SRC_URI[aarch64_texlive-xetexconfig.sha256sum] = "072d0b4ce773f44d9c2e7397ff9d99fb50282c5b2fcfbe5b2af078326c416c8d"

URI_aarch64_texlive-xetexfontinfo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xetexfontinfo-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xetexfontinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xetexfontinfo}"
SRC_URI[aarch64_texlive-xetexfontinfo.sha256sum] = "d4d9afd56325bd54225b7980bb2cfb64cf98f841f2eac57df3302d016978c07f"

URI_aarch64_texlive-xfrac = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xfrac-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xfrac;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xfrac}"
SRC_URI[aarch64_texlive-xfrac.sha256sum] = "c8740829e27a5120ec556092fd8ba0ede523c6188b1ebc190fbddc75382533f9"

URI_aarch64_texlive-xifthen = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xifthen-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xifthen;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xifthen}"
SRC_URI[aarch64_texlive-xifthen.sha256sum] = "724d6b18154cbf0bdce87647e49748aeac271b47d541f3a4327fe5b1c082a64c"

URI_aarch64_texlive-xkeyval = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xkeyval-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xkeyval;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xkeyval}"
SRC_URI[aarch64_texlive-xkeyval.sha256sum] = "2204fe2dcfe8aad8b790ca4a7456bb01a582436108b5d4f9dce101a7b7ae6e29"

URI_aarch64_texlive-xltxtra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xltxtra-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xltxtra;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xltxtra}"
SRC_URI[aarch64_texlive-xltxtra.sha256sum] = "64e484df7726e2d779515f67e6b0cc45c41ca0971125fa755de4dbc6edae168d"

URI_aarch64_texlive-xmltex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xmltex-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xmltex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xmltex}"
SRC_URI[aarch64_texlive-xmltex.sha256sum] = "ef3b9c3649ec7abfcf46096876e068ea45da17f2b8c9476f8c54f062bbef5e01"

URI_aarch64_texlive-xpatch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xpatch-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xpatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xpatch}"
SRC_URI[aarch64_texlive-xpatch.sha256sum] = "9b24932987901a82c54659ff050a46036e3a89d6a0f435ce19dc66187449b419"

URI_aarch64_texlive-xstring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xstring-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xstring;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xstring}"
SRC_URI[aarch64_texlive-xstring.sha256sum] = "154f936a07b8cdeecb554e099b96b0f3cdf11230d8443c48fd41d9c58e4cf091"

URI_aarch64_texlive-xtab = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xtab-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xtab;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xtab}"
SRC_URI[aarch64_texlive-xtab.sha256sum] = "dfccf1d73357635f3673328adda2e9a11bb656ee446a36ef3f2d34d7e602637b"

URI_aarch64_texlive-xunicode = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xunicode-20240311-6.el10.noarch.rpm;name=aarch64_texlive-xunicode;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xunicode}"
SRC_URI[aarch64_texlive-xunicode.sha256sum] = "e8175e59ac471ec808a62f8474516741ae23519a4840b13338d3c86cafe3b90e"

URI_aarch64_texlive-zapfchan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-zapfchan-20240311-6.el10.noarch.rpm;name=aarch64_texlive-zapfchan;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zapfchan}"
SRC_URI[aarch64_texlive-zapfchan.sha256sum] = "9c87a4ff8c1a2f0c15f2db323f5c5f019b504625f226f56d6a697a4b610b3293"

URI_aarch64_texlive-zapfding = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-zapfding-20240311-6.el10.noarch.rpm;name=aarch64_texlive-zapfding;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zapfding}"
SRC_URI[aarch64_texlive-zapfding.sha256sum] = "3dfbeef3adb0ad11633cf41b9c2f1f017f4aeb12fbf51c5b1ead585f6f664747"

URI_aarch64_texlive-zref = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-zref-20240311-6.el10.noarch.rpm;name=aarch64_texlive-zref;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zref}"
SRC_URI[aarch64_texlive-zref.sha256sum] = "895ec361386b9d93411a3df565dd4efbfeb8f33a0c7b668e7647d7fb2d572c8e"

RDEPENDS:texlive = " \
 texlive-collection-latexrecommended \
 texlive-kpathsea \
 texlive-scheme-basic \
 "
RDEPENDS:texlive-acronym = " \
 texlive-base \
 texlive-bigfoot \
 texlive-kpathsea \
 texlive-relsize \
 texlive-xstring \
 "
RDEPENDS:texlive-adjustbox = " \
 texlive-base \
 texlive-collectbox \
 texlive-graphics \
 texlive-ifoddpage \
 texlive-kpathsea \
 texlive-pgf \
 texlive-tools \
 texlive-varwidth \
 texlive-xkeyval \
 "
RDEPENDS:texlive-ae = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-algorithms = " \
 texlive-base \
 texlive-float \
 texlive-graphics \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-alphalph = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-amscls = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 texlive-url \
 virtual/tex_doc.sty_ \
 "
RDEPENDS:texlive-amsfonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-amsmath = " \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-anyfontsize = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-anysize = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-appendix = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-arphic = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-atbegshi = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-attachfile = " \
 texlive-base \
 texlive-graphics \
 texlive-hyperref \
 texlive-iftex \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-attachfile2 = " \
 perl-Digest-MD5 \
 perl-Getopt-Long \
 perl-POSIX \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-atveryend = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-auxhook = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-avantgar = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-awesomebox = " \
 texlive-base \
 texlive-fontawesome \
 texlive-iftex \
 texlive-tools \
 texlive-xcolor \
 texlive-xltxtra \
 "
RDEPENDS:texlive-babel = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-babel-english = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-babelbib = " \
 texlive-babel \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-base = " \
 bash \
 virtual/coreutils \
 "
RDEPENDS:texlive-beamer = " \
 texlive-amscls \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-atbegshi \
 texlive-base \
 texlive-beamer \
 texlive-etoolbox \
 texlive-geometry \
 texlive-graphics \
 texlive-hyperref \
 texlive-iftex \
 texlive-kpathsea \
 texlive-pgf \
 texlive-sansmathaccent \
 texlive-tools \
 texlive-translator \
 texlive-ucs \
 texlive-xcolor \
 virtual/tex_inputenc.sty_ \
 "
RDEPENDS:texlive-bera = " \
 texlive-base \
 texlive-bera \
 texlive-graphics \
 texlive-kpathsea \
 virtual/tex_fontenc.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-beton = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bibtex = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-bibtopic = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-bidi = " \
 texlive-auxhook \
 texlive-base \
 texlive-bidi \
 texlive-changepage \
 texlive-etoolbox \
 texlive-fancyhdr \
 texlive-geometry \
 texlive-graphics \
 texlive-hopatch \
 texlive-hyperref \
 texlive-iftex \
 texlive-kpathsea \
 texlive-ltxcmds \
 texlive-marvosym \
 texlive-natbib \
 texlive-paralist \
 texlive-placeins \
 texlive-ragged2e \
 texlive-sauerj \
 texlive-setspace \
 texlive-showexpl \
 texlive-titlesec \
 texlive-tools \
 texlive-url \
 texlive-xcolor \
 texlive-xifthen \
 texlive-zref \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-bigfoot = " \
 texlive-base \
 texlive-bigfoot \
 texlive-etex-pkg \
 texlive-kpathsea \
 texlive-ncctools \
 "
RDEPENDS:texlive-bigintcalc = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bitset = " \
 texlive-bigintcalc \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bookman = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bookmark = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-booktabs = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-breakurl = " \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-xkeyval \
 "
RDEPENDS:texlive-breqn = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-tools \
 "
RDEPENDS:texlive-capt-of = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-caption = " \
 texlive-base \
 texlive-caption \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-carlisle = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-catchfile = " \
 texlive-etexcmds \
 texlive-infwarerr \
 texlive-kpathsea \
 texlive-ltxcmds \
 "
RDEPENDS:texlive-changebar = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-changepage = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-charter = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-chngcntr = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cite = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-classpack = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cm = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cm-lgc = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cm-super = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_t1cmr.fd_ \
 "
RDEPENDS:texlive-cmap = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cmextra = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cns = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-collectbox = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-collection-basic = " \
 texlive-amsfonts \
 texlive-base \
 texlive-bibtex \
 texlive-cm \
 texlive-colorprofiles \
 texlive-dvipdfmx \
 texlive-dvips \
 texlive-ec \
 texlive-enctex \
 texlive-etex \
 texlive-etex-pkg \
 texlive-glyphlist \
 texlive-graphics-def \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-hyphenex \
 texlive-ifplatform \
 texlive-iftex \
 texlive-knuth-lib \
 texlive-knuth-local \
 texlive-kpathsea \
 texlive-lua-alt-getopt \
 texlive-luahbtex \
 texlive-luatex \
 texlive-makeindex \
 texlive-metafont \
 texlive-mflogo \
 texlive-mfware \
 texlive-modes \
 texlive-pdftex \
 texlive-plain \
 texlive-tex \
 texlive-tex-ini-files \
 texlive-texlive-common-doc \
 texlive-texlive-en \
 texlive-texlive-msg-translations \
 texlive-texlive-scripts \
 texlive-texlive.infra \
 texlive-unicode-data \
 "
RDEPENDS:texlive-collection-fontsrecommended = " \
 texlive-avantgar \
 texlive-base \
 texlive-bookman \
 texlive-charter \
 texlive-cm-super \
 texlive-cmextra \
 texlive-collection-basic \
 texlive-courier \
 texlive-ec \
 texlive-euro \
 texlive-eurosym \
 texlive-fpl \
 texlive-helvetic \
 texlive-lm \
 texlive-lm-math \
 texlive-manfnt-font \
 texlive-marvosym \
 texlive-mathpazo \
 texlive-mflogo-font \
 texlive-ncntrsbk \
 texlive-palatino \
 texlive-pxfonts \
 texlive-rsfs \
 texlive-symbol \
 texlive-tex-gyre \
 texlive-tex-gyre-math \
 texlive-times \
 texlive-tipa \
 texlive-txfonts \
 texlive-utopia \
 texlive-wasy \
 texlive-wasy-type1 \
 texlive-wasysym \
 texlive-zapfchan \
 texlive-zapfding \
 "
RDEPENDS:texlive-collection-htmlxml = " \
 texlive-base \
 texlive-classpack \
 texlive-collection-basic \
 texlive-collection-fontsrecommended \
 texlive-collection-latex \
 texlive-jadetex \
 texlive-passivetex \
 texlive-tex-ini-files \
 texlive-tex4ht \
 texlive-xmltex \
 "
RDEPENDS:texlive-collection-latex = " \
 texlive-ae \
 texlive-amscls \
 texlive-amsmath \
 texlive-atbegshi \
 texlive-atveryend \
 texlive-auxhook \
 texlive-babel \
 texlive-babel-english \
 texlive-babelbib \
 texlive-base \
 texlive-bitset \
 texlive-bookmark \
 texlive-carlisle \
 texlive-collection-basic \
 texlive-colortbl \
 texlive-epstopdf-pkg \
 texlive-etexcmds \
 texlive-fancyhdr \
 texlive-firstaid \
 texlive-fix2col \
 texlive-geometry \
 texlive-gettitlestring \
 texlive-graphics \
 texlive-graphics-cfg \
 texlive-grfext \
 texlive-hycolor \
 texlive-hypcap \
 texlive-hyperref \
 texlive-intcalc \
 texlive-kvdefinekeys \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-latex \
 texlive-latex-fonts \
 texlive-latexconfig \
 texlive-letltxmacro \
 texlive-ltxcmds \
 texlive-ltxmisc \
 texlive-mfnfss \
 texlive-mptopdf \
 texlive-natbib \
 texlive-oberdiek \
 texlive-pdfescape \
 texlive-pslatex \
 texlive-psnfss \
 texlive-pspicture \
 texlive-refcount \
 texlive-rerunfilecheck \
 texlive-stringenc \
 texlive-tools \
 texlive-uniquecounter \
 texlive-url \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-collection-latexrecommended = " \
 texlive-anysize \
 texlive-attachfile2 \
 texlive-base \
 texlive-beamer \
 texlive-booktabs \
 texlive-breqn \
 texlive-caption \
 texlive-cite \
 texlive-cmap \
 texlive-collection-fontsrecommended \
 texlive-collection-latex \
 texlive-count1to \
 texlive-crop \
 texlive-ctable \
 texlive-eso-pic \
 texlive-etoolbox \
 texlive-euenc \
 texlive-euler \
 texlive-everysel \
 texlive-everyshi \
 texlive-extsizes \
 texlive-fancybox \
 texlive-fancyref \
 texlive-fancyvrb \
 texlive-filehook \
 texlive-float \
 texlive-fontspec \
 texlive-footnotehyper \
 texlive-fp \
 texlive-grffile \
 texlive-hologo \
 texlive-index \
 texlive-infwarerr \
 texlive-jknapltx \
 texlive-koma-script \
 texlive-l3experimental \
 texlive-latexbug \
 texlive-lineno \
 texlive-listings \
 texlive-lwarp \
 texlive-mathspec \
 texlive-mathtools \
 texlive-mdwtools \
 texlive-memoir \
 texlive-metalogo \
 texlive-microtype \
 texlive-multitoc \
 texlive-newfloat \
 texlive-ntgclass \
 texlive-parskip \
 texlive-pdfcolfoot \
 texlive-pdflscape \
 texlive-pdfmanagement-testphase \
 texlive-pdfpages \
 texlive-polyglossia \
 texlive-psfrag \
 texlive-ragged2e \
 texlive-rcs \
 texlive-sansmath \
 texlive-section \
 texlive-seminar \
 texlive-sepnum \
 texlive-setspace \
 texlive-subfig \
 texlive-textcase \
 texlive-thumbpdf \
 texlive-translator \
 texlive-typehtml \
 texlive-ucharcat \
 texlive-underscore \
 texlive-unicode-math \
 texlive-xcolor \
 texlive-xfrac \
 texlive-xkeyval \
 texlive-xltxtra \
 texlive-xunicode \
 "
RDEPENDS:texlive-collection-xetex = " \
 texlive-awesomebox \
 texlive-base \
 texlive-collection-basic \
 texlive-fixlatvian \
 texlive-fontbook \
 texlive-fontwrap \
 texlive-philokalia \
 texlive-ptext \
 texlive-realscripts \
 texlive-ucharclasses \
 texlive-unisugar \
 texlive-xecolor \
 texlive-xecyr \
 texlive-xeindex \
 texlive-xesearch \
 texlive-xetex \
 texlive-xetex-itrans \
 texlive-xetex-pstricks \
 texlive-xetexconfig \
 texlive-xetexfontinfo \
 "
RDEPENDS:texlive-colorprofiles = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-colortbl = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-context = " \
 bash \
 perl-Tk \
 perl-base \
 perl-libs \
 texlive-amsfonts \
 texlive-base \
 texlive-kpathsea \
 texlive-lm \
 texlive-lm-math \
 texlive-luatex \
 texlive-manfnt-font \
 texlive-metapost \
 texlive-mflogo-font \
 texlive-mptopdf \
 texlive-pdftex \
 texlive-pst-plot \
 texlive-pstricks \
 texlive-stmaryrd \
 texlive-texlive-scripts \
 texlive-xetex \
 virtual/coreutils \
 "
RDEPENDS:texlive-count1to = " \
 texlive-base \
 texlive-everyshi \
 texlive-kpathsea \
 "
RDEPENDS:texlive-courier = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-crop = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-csquotes = " \
 texlive-base \
 texlive-etoolbox \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ctable = " \
 bash \
 texlive-base \
 texlive-booktabs \
 texlive-etoolbox \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 texlive-xkeyval \
 "
RDEPENDS:texlive-ctablestack = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-currfile = " \
 texlive-base \
 texlive-filehook \
 texlive-kpathsea \
 texlive-kvoptions \
 "
RDEPENDS:texlive-datetime = " \
 texlive-base \
 texlive-fmtcount \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-dehyph = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-dvipdfmx = " \
 bash \
 texlive-base \
 texlive-glyphlist \
 texlive-graphics-def \
 texlive-kpathsea \
 texlive-xetex \
 "
RDEPENDS:texlive-dvipng = " \
 freetype \
 gd \
 glibc \
 info \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-dvips = " \
 glibc \
 info \
 texlive-base \
 texlive-kpathsea \
 texlive-latex-fonts \
 texlive-lib \
 "
RDEPENDS:texlive-dvisvgm = " \
 freetype \
 glibc \
 libgcc \
 libgs \
 libstdc++ \
 potrace \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 zlib-ng-compat \
 "
RDEPENDS:texlive-ec = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-eepic = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-enctex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-enumitem = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-environ = " \
 texlive-base \
 texlive-kpathsea \
 texlive-trimspaces \
 "
RDEPENDS:texlive-epsf = " \
 bash \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-epstopdf = " \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-epstopdf-pkg = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-eqparbox = " \
 texlive-base \
 texlive-environ \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-eso-pic = " \
 texlive-atbegshi \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-xcolor \
 "
RDEPENDS:texlive-etex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-etex-pkg = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-etexcmds = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-etoc = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-etoolbox = " \
 texlive-base \
 texlive-etex-pkg \
 texlive-kpathsea \
 "
RDEPENDS:texlive-euenc = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-euler = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-euro = " \
 texlive-base \
 texlive-fp \
 texlive-kpathsea \
 "
RDEPENDS:texlive-eurosym = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-everysel = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-everyshi = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-extsizes = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_exscale.sty_ \
 "
RDEPENDS:texlive-fancybox = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fancyhdr = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fancyref = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-fancyvrb = " \
 texlive-base \
 texlive-fancyvrb \
 texlive-graphics \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-filecontents = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-filehook = " \
 texlive-base \
 texlive-currfile \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-pgf \
 "
RDEPENDS:texlive-finstrut = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-firstaid = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fix2col = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fixlatvian = " \
 texlive-base \
 texlive-bigfoot \
 texlive-caption \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-polyglossia \
 texlive-svn-prov \
 texlive-tools \
 texlive-was \
 texlive-xstring \
 "
RDEPENDS:texlive-float = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fmtcount = " \
 texlive-amsmath \
 texlive-base \
 texlive-etoolbox \
 texlive-graphics \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-fncychap = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fontawesome = " \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-texlive-scripts \
 "
RDEPENDS:texlive-fontbook = " \
 texlive-base \
 texlive-etoolbox \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-xunicode \
 "
RDEPENDS:texlive-fonts-tlwg = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fontspec = " \
 texlive-base \
 texlive-kastrup \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-lm \
 texlive-luaotfload \
 texlive-xunicode \
 virtual/tex_fixltx2e.sty_ \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-fontware = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-fontwrap = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-footmisc = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-footnotehyper = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fp = " \
 texlive-base \
 texlive-fp \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fpl = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-framed = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-garuda-c90 = " \
 texlive-base \
 texlive-fonts-tlwg \
 texlive-kpathsea \
 "
RDEPENDS:texlive-geometry = " \
 texlive-atbegshi \
 texlive-base \
 texlive-graphics \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-gettitlestring = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-glyphlist = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-gnu-freefont = " \
 bash \
 fontforge \
 perl-interpreter \
 python-unversioned-command \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-graphics = " \
 texlive-base \
 texlive-graphics-cfg \
 texlive-kpathsea \
 "
RDEPENDS:texlive-graphics-cfg = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-graphics-def = " \
 texlive-base \
 texlive-epstopdf-pkg \
 texlive-kpathsea \
 "
RDEPENDS:texlive-grfext = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-grffile = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-gsftopk = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-hanging = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-helvetic = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hobsub = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hologo = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hopatch = " \
 texlive-kpathsea \
 texlive-ltxcmds \
 "
RDEPENDS:texlive-hycolor = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hypcap = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hypdoc = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyperref = " \
 texlive-atbegshi \
 texlive-auxhook \
 texlive-base \
 texlive-bitset \
 texlive-etexcmds \
 texlive-gettitlestring \
 texlive-graphics \
 texlive-hobsub \
 texlive-hycolor \
 texlive-iftex \
 texlive-infwarerr \
 texlive-intcalc \
 texlive-kpathsea \
 texlive-kvdefinekeys \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-letltxmacro \
 texlive-ltxcmds \
 texlive-memoir \
 texlive-pdfescape \
 texlive-pdftexcmds \
 texlive-refcount \
 texlive-rerunfilecheck \
 texlive-stringenc \
 texlive-url \
 texlive-zapfding \
 "
RDEPENDS:texlive-hyph-utf8 = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyphen-base = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyphenat = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyphenex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ifmtarg = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ifoddpage = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ifplatform = " \
 texlive-base \
 texlive-catchfile \
 texlive-iftex \
 texlive-kpathsea \
 texlive-pdftexcmds \
 "
RDEPENDS:texlive-iftex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-import = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-index = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-infwarerr = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-intcalc = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-jadetex = " \
 texlive-base \
 texlive-kpathsea \
 texlive-latex \
 texlive-passivetex \
 texlive-pdftex \
 texlive-tex \
 texlive-texlive-scripts \
 virtual/coreutils \
 "
RDEPENDS:texlive-jknapltx = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-kastrup = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-kerkis = " \
 texlive-base \
 texlive-kpathsea \
 texlive-txfonts \
 "
RDEPENDS:texlive-knuth-lib = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-knuth-local = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-koma-script = " \
 texlive-amsmath \
 texlive-babelbib \
 texlive-base \
 texlive-bookmark \
 texlive-booktabs \
 texlive-etoolbox \
 texlive-geometry \
 texlive-graphics \
 texlive-hyperref \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-listings \
 texlive-marginnote \
 texlive-mparhack \
 texlive-tools \
 texlive-xcolor \
 virtual/tex_fontenc.sty_ \
 virtual/tex_inputenc.sty_ \
 virtual/tex_makeidx.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-kpathsea = " \
 bash \
 glibc \
 grep \
 texlive-base \
 texlive-lib \
 texlive-texlive-scripts \
 virtual/coreutils \
 "
RDEPENDS:texlive-kvdefinekeys = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-kvoptions = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-kvsetkeys = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-l3backend = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-l3experimental = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-l3kernel = " \
 texlive-alphalph \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-booktabs \
 texlive-colortbl \
 texlive-csquotes \
 texlive-enumitem \
 texlive-fancyvrb \
 texlive-graphics \
 texlive-hologo \
 texlive-hypdoc \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-lm \
 texlive-psnfss \
 texlive-tools \
 texlive-underscore \
 virtual/tex_doc.sty_ \
 virtual/tex_fontenc.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-l3packages = " \
 texlive-amsmath \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-l3kernel \
 "
RDEPENDS:texlive-lastpage = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex = " \
 texlive-base \
 texlive-cm-super \
 texlive-hypdoc \
 texlive-hyperref \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-latex-fonts \
 texlive-latexconfig \
 texlive-luatex \
 texlive-pdftex \
 texlive-psnfss \
 texlive-tools \
 texlive-url \
 virtual/coreutils \
 "
RDEPENDS:texlive-latex-fonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex2man = " \
 info \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-libs \
 texlive-base \
 texlive-fancyhdr \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-latexbug = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latexconfig = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-letltxmacro = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lettrine = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lib = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:texlive-lib-devel = " \
 pkgconf-pkg-config \
 texlive-lib \
 texlive-lib-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:texlive-linegoal = " \
 texlive-base \
 texlive-etex-pkg \
 texlive-kpathsea \
 texlive-zref \
 "
RDEPENDS:texlive-lineno = " \
 texlive-base \
 texlive-finstrut \
 texlive-kpathsea \
 texlive-ltabptch \
 texlive-tools \
 "
RDEPENDS:texlive-listings = " \
 texlive-algorithms \
 texlive-base \
 texlive-fancyvrb \
 texlive-graphics \
 texlive-hyperref \
 texlive-kpathsea \
 texlive-url \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-listofitems = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lm = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lm-math = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ltabptch = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-ltxcmds = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ltxmisc = " \
 texlive-base \
 texlive-beton \
 texlive-euler \
 texlive-graphics \
 texlive-kpathsea \
 texlive-minitoc \
 texlive-natbib \
 texlive-psnfss \
 texlive-tools \
 virtual/tex_makeidx.sty_ \
 "
RDEPENDS:texlive-lua-alt-getopt = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lua-uni-algos = " \
 texlive-kpathsea \
 texlive-luatex \
 texlive-unicode-data \
 "
RDEPENDS:texlive-luahbtex:x86_64_v2 = " \
 glibc \
 harfbuzz \
 libgcc \
 libpng \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-luatex \
 texlive-plain \
 texlive-tex-ini-files \
 texlive-unicode-data \
 zlib-ng-compat \
 zziplib \
"
RDEPENDS:texlive-luahbtex:aarch64 = " \
 glibc \
 harfbuzz \
 libpng \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-luatex \
 texlive-plain \
 texlive-tex-ini-files \
 texlive-unicode-data \
 zlib-ng-compat \
 zziplib \
"
RDEPENDS:texlive-lualatex-math = " \
 texlive-base \
 texlive-etoolbox \
 texlive-filehook \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-luatexbase \
 "
RDEPENDS:texlive-lualibs = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-luaotfload = " \
 texlive-base \
 texlive-kpathsea \
 texlive-lua-alt-getopt \
 texlive-lua-uni-algos \
 texlive-lualibs \
 texlive-luatexbase \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-luatex = " \
 glibc \
 libpng \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-graphics-def \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-tex-ini-files \
 texlive-texlive-scripts \
 texlive-unicode-data \
 virtual/coreutils \
 zlib-ng-compat \
 zziplib \
 "
RDEPENDS:texlive-luatex85 = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-luatexbase = " \
 texlive-base \
 texlive-etex-pkg \
 texlive-iftex \
 texlive-kpathsea \
 texlive-luatexbase \
 "
RDEPENDS:texlive-lwarp = " \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-makecmds = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-makeindex = " \
 bash \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-manfnt-font = " \
 texlive-base \
 texlive-kpathsea \
 texlive-texlive-scripts \
 "
RDEPENDS:texlive-marginnote = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-marvosym = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mathpazo = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mathspec = " \
 texlive-amsmath \
 texlive-base \
 texlive-etoolbox \
 texlive-fontspec \
 texlive-iftex \
 texlive-kpathsea \
 texlive-mnsymbol \
 texlive-xkeyval \
 "
RDEPENDS:texlive-mathtools = " \
 texlive-amsmath \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-mathtools \
 texlive-tools \
 "
RDEPENDS:texlive-mdwtools = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-memoir = " \
 texlive-base \
 texlive-etex-pkg \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-metafont = " \
 glibc \
 libX11 \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 texlive-texlive-scripts \
 virtual/coreutils \
 "
RDEPENDS:texlive-metalogo = " \
 texlive-base \
 texlive-fontspec \
 texlive-graphics \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-metapost = " \
 cairo \
 glibc \
 gmp \
 libpng \
 mpfr \
 pixman \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 texlive-texlive-scripts \
 zlib-ng-compat \
 "
RDEPENDS:texlive-mflogo = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mflogo-font = " \
 texlive-base \
 texlive-kpathsea \
 texlive-texlive-scripts \
 "
RDEPENDS:texlive-mfnfss = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mfware = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 texlive-mfware \
 "
RDEPENDS:texlive-microtype = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-minitoc = " \
 texlive-base \
 texlive-kpathsea \
 texlive-minitoc \
 texlive-notoccite \
 texlive-placeins \
 virtual/tex_flafter.sty_ \
 "
RDEPENDS:texlive-mnsymbol = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-modes = " \
 bash \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mparhack = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mptopdf = " \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 texlive-texlive-scripts \
 virtual/coreutils \
 "
RDEPENDS:texlive-multido = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-multirow = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-multitoc = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-natbib = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ncctools = " \
 texlive-amsmath \
 texlive-base \
 texlive-bigfoot \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ncntrsbk = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-needspace = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-newfloat = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-newunicodechar = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-norasi-c90 = " \
 texlive-base \
 texlive-fonts-tlwg \
 texlive-kpathsea \
 "
RDEPENDS:texlive-notoccite = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ntgclass = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-oberdiek = " \
 texlive-amsmath \
 texlive-atveryend \
 texlive-auxhook \
 texlive-base \
 texlive-bigintcalc \
 texlive-carlisle \
 texlive-etexcmds \
 texlive-fontspec \
 texlive-fp \
 texlive-graphics \
 texlive-grfext \
 texlive-grffile \
 texlive-hologo \
 texlive-hypcap \
 texlive-hypdoc \
 texlive-hyperref \
 texlive-iftex \
 texlive-index \
 texlive-infwarerr \
 texlive-intcalc \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-letltxmacro \
 texlive-ltxcmds \
 texlive-parallel \
 texlive-pdfcol \
 texlive-pdfescape \
 texlive-pdftexcmds \
 texlive-sauerj \
 texlive-tools \
 texlive-unicode-math \
 texlive-uniquecounter \
 texlive-zref \
 "
RDEPENDS:texlive-overpic = " \
 texlive-base \
 texlive-eepic \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-palatino = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-paralist = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-parallel = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-parskip = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-passivetex = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-graphics \
 texlive-hyperref \
 texlive-kpathsea \
 texlive-marvosym \
 texlive-passivetex \
 texlive-psnfss \
 texlive-tipa \
 texlive-tools \
 texlive-ulem \
 texlive-url \
 virtual/tex_fontenc.sty_ \
 virtual/tex_ifthen.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-pdfcol = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdfcolfoot = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdfcolmk = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdfescape = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdflscape = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdfmanagement-testphase = " \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdfpages = " \
 texlive-base \
 texlive-count1to \
 texlive-eso-pic \
 texlive-graphics \
 texlive-kpathsea \
 texlive-pdflscape \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-pdftex = " \
 bash \
 glibc \
 libgcc \
 libpng \
 libstdc++ \
 perl-libs \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-graphics-def \
 texlive-hyphen-base \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-tex-ini-files \
 texlive-texlive-scripts \
 virtual//usr/bin/env \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:texlive-pdftexcmds = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pgf = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-pgf \
 texlive-xcolor \
 texlive-xkeyval \
 "
RDEPENDS:texlive-philokalia = " \
 texlive-base \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-lettrine \
 texlive-xltxtra \
 texlive-xunicode \
 "
RDEPENDS:texlive-placeins = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-plain = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-polyglossia = " \
 texlive-base \
 texlive-bidi \
 texlive-etoolbox \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-makecmds \
 texlive-polyglossia \
 texlive-tools \
 texlive-xkeyval \
 "
RDEPENDS:texlive-powerdot = " \
 texlive-amsfonts \
 texlive-base \
 texlive-enumitem \
 texlive-geometry \
 texlive-graphics \
 texlive-hyperref \
 texlive-iftex \
 texlive-kpathsea \
 texlive-psnfss \
 texlive-pst-blur \
 texlive-pst-grad \
 texlive-pst-slpe \
 texlive-pst-text \
 texlive-pstricks \
 texlive-tools \
 texlive-type1cm \
 texlive-xcolor \
 texlive-xkeyval \
 "
RDEPENDS:texlive-preprint = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-psfrag = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pslatex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-psnfss = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-symbol \
 texlive-zapfding \
 "
RDEPENDS:texlive-pspicture = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pst-3d = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-arrow = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pst-blur = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-coil = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-eps = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-fill = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-grad = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-math = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pst-node = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-plot = " \
 texlive-base \
 texlive-kpathsea \
 texlive-multido \
 texlive-pstricks \
 texlive-xkeyval \
 "
RDEPENDS:texlive-pst-slpe = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-text = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-tools = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-tree = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pstricks = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-babel \
 texlive-base \
 texlive-bera \
 texlive-booktabs \
 texlive-breakurl \
 texlive-caption \
 texlive-chngcntr \
 texlive-eso-pic \
 texlive-fancyvrb \
 texlive-filecontents \
 texlive-footmisc \
 texlive-graphics \
 texlive-hyperref \
 texlive-iftex \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-multido \
 texlive-paralist \
 texlive-pst-3d \
 texlive-pst-arrow \
 texlive-pst-coil \
 texlive-pst-eps \
 texlive-pst-fill \
 texlive-pst-grad \
 texlive-pst-node \
 texlive-pst-plot \
 texlive-pst-text \
 texlive-pst-tools \
 texlive-pst-tree \
 texlive-pstricks-add \
 texlive-ragged2e \
 texlive-setspace \
 texlive-showexpl \
 texlive-subfig \
 texlive-tools \
 texlive-xcolor \
 texlive-xkeyval \
 virtual/tex_fontenc.sty_ \
 virtual/tex_makeidx.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-pstricks-add = " \
 texlive-base \
 texlive-kpathsea \
 texlive-multido \
 texlive-pst-3d \
 texlive-pst-math \
 texlive-pst-node \
 texlive-pst-plot \
 texlive-pstricks \
 "
RDEPENDS:texlive-ptext = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pxfonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-qstest = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-ragged2e = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-rcs = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-realscripts = " \
 texlive-base \
 texlive-fontspec \
 texlive-kpathsea \
 "
RDEPENDS:texlive-refcount = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-relsize = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-rerunfilecheck = " \
 texlive-atveryend \
 texlive-kpathsea \
 texlive-uniquecounter \
 "
RDEPENDS:texlive-rsfs = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sansmath = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sansmathaccent = " \
 texlive-base \
 texlive-filehook \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sauerj = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-scheme-basic = " \
 texlive-base \
 texlive-collection-basic \
 texlive-collection-latex \
 virtual/coreutils \
 "
RDEPENDS:texlive-section = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sectsty = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-seminar = " \
 bash \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-sepnum = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-setspace = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sfmath = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-showexpl = " \
 texlive-attachfile \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-listings \
 texlive-tools \
 texlive-varwidth \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-soul = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-stackengine = " \
 texlive-base \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-listofitems \
 "
RDEPENDS:texlive-stmaryrd = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-stringenc = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-subfig = " \
 texlive-base \
 texlive-caption \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-subfigure = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-svn-prov = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-symbol = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-t2 = " \
 texlive-amsfonts \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-tabu = " \
 texlive-base \
 texlive-kpathsea \
 texlive-linegoal \
 texlive-tools \
 texlive-varwidth \
 "
RDEPENDS:texlive-tabulary = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-tex = " \
 glibc \
 texlive-base \
 texlive-cm \
 texlive-hyphen-base \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-texlive-scripts \
 virtual/coreutils \
 "
RDEPENDS:texlive-tex-gyre = " \
 texlive-base \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-tex-gyre \
 "
RDEPENDS:texlive-tex-gyre-math = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tex-ini-files = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tex4ht = " \
 bash \
 glibc \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-texlive-common-doc = " \
 "
RDEPENDS:texlive-texlive-en = " \
 bash \
 info \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-texlive-msg-translations = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-texlive-scripts = " \
 bash \
 perl-File-Basename \
 perl-File-Find \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Usage \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 texlive-texlive.infra \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-texlive-scripts-extra = " \
 bash \
 texlive-base \
 texlive-kpathsea \
 texlive-texlive.infra \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-texlive.infra = " \
 bash \
 perl-Digest-MD5 \
 perl-Exporter \
 perl-File-Find \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Text-Unidecode \
 perl-XML-Parser \
 perl-XML-XPath \
 perl-constant \
 perl-libs \
 perl-vars \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-textcase = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-textpos = " \
 texlive-base \
 texlive-everyshi \
 texlive-kpathsea \
 "
RDEPENDS:texlive-threeparttable = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-thumbpdf = " \
 ghostscript \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-times = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tipa = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tipa \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-titlesec = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-titling = " \
 texlive-base \
 texlive-kpathsea \
 virtual/coreutils \
 "
RDEPENDS:texlive-tocloft = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tools = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-translator = " \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-trimspaces = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-txfonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-type1cm = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-typehtml = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_exscale.sty_ \
 "
RDEPENDS:texlive-ucharcat = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ucharclasses = " \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ucs = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Getopt-Long \
 perl-IO \
 perl-interpreter \
 perl-libs \
 perl-vars \
 texlive-base \
 texlive-graphics \
 texlive-hyperref \
 texlive-kpathsea \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-uhc = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ulem = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-underscore = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-unicode-data = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-unicode-math = " \
 texlive-base \
 texlive-catchfile \
 texlive-filehook \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-lualatex-math \
 texlive-luaotfload \
 texlive-luatexbase \
 virtual/tex_fix-cm.sty_ \
 "
RDEPENDS:texlive-uniquecounter = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-unisugar = " \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-upquote = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-url = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-utopia = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-varwidth = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-wadalab = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-was = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-wasy = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-wasy-type1 = " \
 texlive-kpathsea \
 texlive-wasy \
 "
RDEPENDS:texlive-wasysym = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-wrapfig = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xcolor = " \
 texlive-base \
 texlive-colortbl \
 texlive-kpathsea \
 texlive-pdfcolmk \
 "
RDEPENDS:texlive-xecolor = " \
 texlive-base \
 texlive-fontspec \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xecyr = " \
 texlive-base \
 texlive-kpathsea \
 texlive-t2 \
 texlive-xltxtra \
 texlive-xunicode \
 "
RDEPENDS:texlive-xeindex = " \
 texlive-base \
 texlive-kpathsea \
 texlive-xesearch \
 virtual/tex_makeidx.sty_ \
 "
RDEPENDS:texlive-xepersian = " \
 python-unversioned-command \
 texlive-base \
 texlive-bidi \
 texlive-datetime \
 texlive-fancybox \
 texlive-fancyhdr \
 texlive-fontspec \
 texlive-geometry \
 texlive-hyphenat \
 texlive-iftex \
 texlive-kpathsea \
 texlive-lastpage \
 texlive-multido \
 texlive-preprint \
 texlive-psnfss \
 texlive-ragged2e \
 texlive-setspace \
 texlive-textpos \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-xesearch = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xetex = " \
 fontconfig \
 freetype \
 glibc \
 graphite2 \
 harfbuzz \
 libgcc \
 libicu \
 libpaper \
 libpng \
 libstdc++ \
 teckit \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-dvipdfmx \
 texlive-etex \
 texlive-graphics-def \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-latex-fonts \
 texlive-lib \
 texlive-lm \
 texlive-plain \
 texlive-tex-ini-files \
 texlive-unicode-data \
 texlive-xetexconfig \
 virtual/coreutils \
 virtual/texlive-latex \
 zlib-ng-compat \
 "
RDEPENDS:texlive-xetex-itrans = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xetex-pstricks = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xetexconfig = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xetexfontinfo = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xfrac = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xifthen = " \
 texlive-base \
 texlive-etex-pkg \
 texlive-ifmtarg \
 texlive-kpathsea \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-xkeyval = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-xltxtra = " \
 texlive-base \
 texlive-fontspec \
 texlive-iftex \
 texlive-kpathsea \
 texlive-metalogo \
 texlive-realscripts \
 "
RDEPENDS:texlive-xmltex = " \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-dehyph \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex-fonts \
 texlive-latexconfig \
 texlive-pdftex \
 texlive-tex \
 texlive-tex-ini-files \
 texlive-unicode-data \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-xpatch = " \
 texlive-base \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-xstring = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xtab = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xunicode = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tipa \
 "
RDEPENDS:texlive-zapfchan = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zapfding = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zref = " \
 texlive-kpathsea \
 "
