# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-python-pkginfo"
PV = "0.6.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-python-pkginfo+bzip2-devel \
 rust-python-pkginfo+default-devel \
 rust-python-pkginfo+deprecated-formats-devel \
 rust-python-pkginfo+serde-devel \
 rust-python-pkginfo+xz-devel \
 rust-python-pkginfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-python-pkginfo-0.6.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80a882f57c5759f36059399aebfbf5e2e1ad0177e2c6d5da0f13c455f4d36af5"

URI_x86_64_v2_rust-python-pkginfo+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+bzip2-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+bzip2-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+bzip2-devel.sha256sum] = "6e7738a1c446184fb7ad2712afaab755a2905eb281dd7bea9a311367960e566a"

URI_x86_64_v2_rust-python-pkginfo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+default-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+default-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+default-devel.sha256sum] = "84233acbe28cd68d3338d2e32199671de6a2ec428da133057fa828b64005f03c"

URI_x86_64_v2_rust-python-pkginfo+deprecated-formats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+deprecated-formats-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+deprecated-formats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+deprecated-formats-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+deprecated-formats-devel.sha256sum] = "043505e23d4970a91173cf4cdbd31f8adeffb4733d1bb123e6259c5f90fda766"

URI_x86_64_v2_rust-python-pkginfo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+serde-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+serde-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+serde-devel.sha256sum] = "9f12c3396027b8fdddd610d36467f53d71781d38e320c47d5b40f9e597f18dae"

URI_x86_64_v2_rust-python-pkginfo+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+xz-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+xz-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+xz-devel.sha256sum] = "7d93fe6df805072094831626986ebfa19e8d3fe1abdc33cd6fb07a51e7fe69f7"

URI_x86_64_v2_rust-python-pkginfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo-devel-0.6.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo-devel.sha256sum] = "a216b74ecc4c67613b53730f30bae991a8711223796306004015fa9e7ed5587a"

URI_aarch64_rust-python-pkginfo+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+bzip2-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-python-pkginfo+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+bzip2-devel}"
SRC_URI[aarch64_rust-python-pkginfo+bzip2-devel.sha256sum] = "5016fb4a954b1b5484450099d15767104c1f16547418619f37ffcff49f781af6"

URI_aarch64_rust-python-pkginfo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+default-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-python-pkginfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+default-devel}"
SRC_URI[aarch64_rust-python-pkginfo+default-devel.sha256sum] = "97332c423908ceb87f0e7d878357b3e0d000e7682830839f3cc13656fd3cd104"

URI_aarch64_rust-python-pkginfo+deprecated-formats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+deprecated-formats-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-python-pkginfo+deprecated-formats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+deprecated-formats-devel}"
SRC_URI[aarch64_rust-python-pkginfo+deprecated-formats-devel.sha256sum] = "de247ff4fd772602076f2555638bcb34eeb2aa0be0972354c57943459bed5b28"

URI_aarch64_rust-python-pkginfo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+serde-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-python-pkginfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+serde-devel}"
SRC_URI[aarch64_rust-python-pkginfo+serde-devel.sha256sum] = "1948f44a4cca5ff5bdba53929c3c91af6800a649dca473c50604695999181583"

URI_aarch64_rust-python-pkginfo+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+xz-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-python-pkginfo+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+xz-devel}"
SRC_URI[aarch64_rust-python-pkginfo+xz-devel.sha256sum] = "dd35578c23511231078517e356b0c4343cd07e5fcf9fac783bf87a3981c12bca"

URI_aarch64_rust-python-pkginfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo-devel-0.6.8-1.el10_3.noarch.rpm;name=aarch64_rust-python-pkginfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo-devel}"
SRC_URI[aarch64_rust-python-pkginfo-devel.sha256sum] = "95ba1ff1b03513bed4f1fcaca4423f546a990ee08a23c3f19896f0eba72e1f60"

RDEPENDS:rust-python-pkginfo+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-python-pkginfo-devel \
 "
RDEPENDS:rust-python-pkginfo+default-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 "
RDEPENDS:rust-python-pkginfo+deprecated-formats-devel = " \
 cargo \
 rust-python-pkginfo+bzip2-devel \
 rust-python-pkginfo+xz-devel \
 rust-python-pkginfo-devel \
 virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_9.0.0~ \
 "
RDEPENDS:rust-python-pkginfo+serde-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-python-pkginfo+xz-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 rust-xz2+default-devel \
 "
RDEPENDS:rust-python-pkginfo-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-fs-err+default-devel \
 rust-mailparse+default-devel \
 rust-rfc2047-decoder+default-devel \
 rust-tar+default-devel \
 rust-thiserror+default-devel \
 virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_9.0.0~ \
 virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_9.0.0~ \
 "
