# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radare2"
PV = "5.9.8"
PR = "4.el10_0"
PACKAGES = " \
 radare2 \
 radare2-common \
 radare2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/radare2-5.9.8-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "785c17a5c487aa609550aa7ce387f734802cc2cbe32f54753ea7699cc79b5629"

URI_x86_64_v2_radare2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radare2-5.9.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radare2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radare2}"
SRC_URI[x86_64_v2_radare2.sha256sum] = "6962b0d8f484cbac1a79e4411d57db0a0be82f51ecaf099523843df198e2bec0"

URI_x86_64_v2_radare2-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radare2-common-5.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_radare2-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radare2-common}"
SRC_URI[x86_64_v2_radare2-common.sha256sum] = "c951d29b5061ce1e418df646c9ff16ea23143962186f57d07fbab701699d895a"

URI_x86_64_v2_radare2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radare2-devel-5.9.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radare2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radare2-devel}"
SRC_URI[x86_64_v2_radare2-devel.sha256sum] = "9e4ac3646a95bcebf53dcb3c71c75044a22aca9e215f1916c21e873ee6e00341"

URI_aarch64_radare2 = "${EPEL_MIRROR}/aarch64/Packages/r/radare2-5.9.8-4.el10_0.aarch64.rpm;name=aarch64_radare2;unpack=0"
SRC_URI:append = " ${URI_aarch64_radare2}"
SRC_URI[aarch64_radare2.sha256sum] = "d2585136ca224361693ba21155993c197e92d1ba2c6a49fdd9a5e833170a7b2b"

URI_aarch64_radare2-common = "${EPEL_MIRROR}/aarch64/Packages/r/radare2-common-5.9.8-4.el10_0.noarch.rpm;name=aarch64_radare2-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_radare2-common}"
SRC_URI[aarch64_radare2-common.sha256sum] = "72e18d41eb9e531735d696641c09246154ca64f993c5d3be3a06219ccdee2d49"

URI_aarch64_radare2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/radare2-devel-5.9.8-4.el10_0.aarch64.rpm;name=aarch64_radare2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_radare2-devel}"
SRC_URI[aarch64_radare2-devel.sha256sum] = "a7ed84f5104dd0bac6126d78fc143d100cf82ba131e845d2e96d26d8efcf369c"

RDEPENDS:radare2 = " \
 capstone \
 file-libs \
 glibc \
 libgcc \
 libuv \
 libzip \
 lz4-libs \
 radare2-common \
 xxhash-libs \
 zlib-ng-compat \
 "
RDEPENDS:radare2-common = " \
 radare2 \
 "
RDEPENDS:radare2-devel = " \
 capstone-devel \
 file-devel \
 libuv-devel \
 libzip-devel \
 lz4-devel \
 openssl-devel \
 pkgconf-pkg-config \
 radare2 \
 radare2-devel \
 xxhash-devel \
 zlib-ng-compat-devel \
 "
