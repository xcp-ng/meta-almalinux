# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project"
PV = "1.1.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-pin-project+default-devel \
 rust-pin-project-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-1.1.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d46337d3caa75f9e72db769e9885ec772275357b527dcb9c0320140ac5411ddf"

URI_x86_64_v2_rust-pin-project+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project+default-devel-1.1.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project+default-devel.sha256sum] = "8ebfd925f518a1b958585296acbb1896793e71a726b441e5e65dd9483992eccb"

URI_x86_64_v2_rust-pin-project-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-devel-1.1.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-devel}"
SRC_URI[x86_64_v2_rust-pin-project-devel.sha256sum] = "ef16ba9f15dda2bf7a766677d8ca2f6d3329ffe46f4d3595e7a14f972139d04c"

URI_aarch64_rust-pin-project+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project+default-devel-1.1.10-1.el10_1.noarch.rpm;name=aarch64_rust-pin-project+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project+default-devel}"
SRC_URI[aarch64_rust-pin-project+default-devel.sha256sum] = "17f857df75b49c420f521e5714dde877ae1134afdf803a9426dab8a5bf22c29a"

URI_aarch64_rust-pin-project-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-devel-1.1.10-1.el10_1.noarch.rpm;name=aarch64_rust-pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-devel}"
SRC_URI[aarch64_rust-pin-project-devel.sha256sum] = "10e9df4eebdd4a28a2f8c0135de30d68c3de6a1bfd22c6432d85ea71871d9ec1"

RDEPENDS:rust-pin-project+default-devel = " \
 cargo \
 rust-pin-project-devel \
 "
RDEPENDS:rust-pin-project-devel = " \
 cargo \
 rust \
 rust-pin-project-internal+default-devel \
 "
