# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nco"
PV = "5.3.3"
PR = "1.el10_0"
PACKAGES = " \
 nco \
 nco-devel \
 nco-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nco-5.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56845983477aebcce14784d9b9f616e01c3d6a53406fed9c3483584afab4000f"

URI_x86_64_v2_nco = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nco-5.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nco;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nco}"
SRC_URI[x86_64_v2_nco.sha256sum] = "b7ca5b0426270e3706344f133894c67927dde20b4b08969a5c6e446f7ca145f7"

URI_x86_64_v2_nco-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nco-devel-5.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nco-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nco-devel}"
SRC_URI[x86_64_v2_nco-devel.sha256sum] = "9907c355fedbb4399c73bde5a4b174c95c1aef1cbabd76d74e44aaf5ea036d31"

URI_x86_64_v2_nco-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nco-static-5.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nco-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nco-static}"
SRC_URI[x86_64_v2_nco-static.sha256sum] = "25f15388b642dfa34c6efbbacdfeb8e22c5fe9625d49bed8a0cca42dbc1f5b05"

URI_aarch64_nco = "${EPEL_MIRROR}/aarch64/Packages/n/nco-5.3.3-1.el10_0.aarch64.rpm;name=aarch64_nco;unpack=0"
SRC_URI:append = " ${URI_aarch64_nco}"
SRC_URI[aarch64_nco.sha256sum] = "4b28310d1a60aa7a5bc683fae8ada6885aee3ee9a533f5b21cbb0d9989915599"

URI_aarch64_nco-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nco-devel-5.3.3-1.el10_0.aarch64.rpm;name=aarch64_nco-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nco-devel}"
SRC_URI[aarch64_nco-devel.sha256sum] = "a46cb500637a3ad6d3b6a0bfb4ea898b144a8db003eeb5376ce81fe2912595a9"

URI_aarch64_nco-static = "${EPEL_MIRROR}/aarch64/Packages/n/nco-static-5.3.3-1.el10_0.aarch64.rpm;name=aarch64_nco-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_nco-static}"
SRC_URI[aarch64_nco-static.sha256sum] = "56187ed0b36916805b4315030d9c4558ab18bbd444393f2b58f5c6e906a54c3a"

RDEPENDS:nco = " \
 bash \
 glibc \
 gsl \
 libgcc \
 libgomp \
 libstdc++ \
 netcdf \
 udunits2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:nco-devel = " \
 nco \
 "
RDEPENDS:nco-static = " \
 nco-devel \
 "
