# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tmux"
PV = "3.3a"
PR = "13.20230918gitb202a2f.el10"
PACKAGES = " \
 tmux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tmux-3.3a-13.20230918gitb202a2f.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ef85c3eea100cb8881e674a24a8cc08968e29fa9895e800005d2e804bf2e1b4"

URI_x86_64_v2_tmux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tmux-3.3a-13.20230918gitb202a2f.el10.x86_64_v2.rpm;name=x86_64_v2_tmux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmux}"
SRC_URI[x86_64_v2_tmux.sha256sum] = "8de6cc986b38436f4a852165e7c391cb5ada15936342e67fa134e80a1d79cf47"

URI_aarch64_tmux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tmux-3.3a-13.20230918gitb202a2f.el10.aarch64.rpm;name=aarch64_tmux;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmux}"
SRC_URI[aarch64_tmux.sha256sum] = "8714d21741d993970f9757b698f8e4ab88fc55a89bc53e654d730bd8da4a68fd"

RDEPENDS:tmux = " \
 bash \
 glibc \
 libevent \
 ncurses-libs \
 systemd-libs \
 "
