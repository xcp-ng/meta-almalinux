# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax"
PV = "40.5.11"
PR = "1.el10.alma.1"
PACKAGES = " \
 lorax \
 lorax-docs \
 lorax-lmc-novirt \
 lorax-lmc-virt \
 lorax-templates-generic \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-40.5.11-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9988f2f38096dea5e2adad8419cf4f9dfe026edf771549db650f83fc4bc81bfa"

URI_x86_64_v2_lorax = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-40.5.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax}"
SRC_URI[x86_64_v2_lorax.sha256sum] = "0ddca6999873542a94e0c0408e36ed34c999620a756ed3633317f6e44224a3e4"

URI_x86_64_v2_lorax-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-docs-40.5.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-docs}"
SRC_URI[x86_64_v2_lorax-docs.sha256sum] = "06705a9c89fb366d37019e522f55a10fb76740316f26ca080643fcf780c6c8be"

URI_x86_64_v2_lorax-lmc-novirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-lmc-novirt-40.5.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-lmc-novirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-lmc-novirt}"
SRC_URI[x86_64_v2_lorax-lmc-novirt.sha256sum] = "052c7c14d0b67bf5a79583dc1f1fc8f7b5210f073fa7dc11edc091f91f308f1f"

URI_x86_64_v2_lorax-lmc-virt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-lmc-virt-40.5.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-lmc-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-lmc-virt}"
SRC_URI[x86_64_v2_lorax-lmc-virt.sha256sum] = "2259aca4143a585af6bd3acd9afadc233000b3395d4e3091c96bb4733446a344"

URI_x86_64_v2_lorax-templates-generic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-generic-40.5.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-templates-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-generic}"
SRC_URI[x86_64_v2_lorax-templates-generic.sha256sum] = "63657aa0003b7d21c6f500e1ab2a3cda883736f2466e5765c973698934cd3112"
RPROVIDES:lorax-templates-generic:x86_64_v2 = "virtual/lorax-templates"

URI_aarch64_lorax = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-40.5.11-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax}"
SRC_URI[aarch64_lorax.sha256sum] = "5d5d2645ba1e45e0150e6567eae01d4779bf634dad5ef26aaa287375172c646a"

URI_aarch64_lorax-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-docs-40.5.11-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-docs}"
SRC_URI[aarch64_lorax-docs.sha256sum] = "092141cb546ea9eda255da420d4b2b5e2ff49859ec795e1c2d32738f5769a713"

URI_aarch64_lorax-lmc-novirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-lmc-novirt-40.5.11-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-lmc-novirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-lmc-novirt}"
SRC_URI[aarch64_lorax-lmc-novirt.sha256sum] = "b3eab02dbd4f3357876bc3b5e8307955d53ed43a9e31da139aa6fa98e88f1760"

URI_aarch64_lorax-lmc-virt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-lmc-virt-40.5.11-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-lmc-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-lmc-virt}"
SRC_URI[aarch64_lorax-lmc-virt.sha256sum] = "10a7456f4af403a1e6657f354a8e851199ad86e0f09e2f4f18262a50f794ae17"

URI_aarch64_lorax-templates-generic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-generic-40.5.11-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-templates-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-generic}"
SRC_URI[aarch64_lorax-templates-generic.sha256sum] = "2a2c7a1ca52f495d8895b4bdab79a89d58956e63635d5d6e04a141060444bfe4"
RPROVIDES:lorax-templates-generic:aarch64 = "virtual/lorax-templates"

RDEPENDS:lorax:x86_64_v2 = " \
 cpio \
 device-mapper \
 dosfstools \
 dracut \
 e2fsprogs \
 erofs-utils \
 findutils \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 grub2-pc \
 grub2-tools \
 gzip \
 isomd5sum \
 kmod \
 kpartx \
 lorax-templates-rhel \
 parted \
 pbzip2 \
 pigz \
 psmisc \
 python3 \
 python3-dnf \
 python3-kickstart \
 python3-librepo \
 python3-libselinux \
 python3-mako \
 python3-pycdio \
 squashfs-tools \
 util-linux \
 virtual/lorax-templates \
 xorriso \
 xz \
 xz-lzma-compat \
"
RDEPENDS:lorax:aarch64 = " \
 cpio \
 device-mapper \
 dosfstools \
 dracut \
 e2fsprogs \
 erofs-utils \
 findutils \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 gzip \
 isomd5sum \
 kmod \
 kpartx \
 lorax-templates-rhel \
 parted \
 pbzip2 \
 pigz \
 psmisc \
 python3 \
 python3-dnf \
 python3-kickstart \
 python3-librepo \
 python3-libselinux \
 python3-mako \
 python3-pycdio \
 squashfs-tools \
 util-linux \
 virtual/lorax-templates \
 xorriso \
 xz \
 xz-lzma-compat \
"
RDEPENDS:lorax-docs = " \
 lorax \
 "
RDEPENDS:lorax-lmc-novirt = " \
 almalinux-logos \
 anaconda-core \
 anaconda-install-env-deps \
 anaconda-tui \
 lorax \
 python3-psutil \
 tar \
 "
RDEPENDS:lorax-lmc-virt:x86_64_v2 = " \
 edk2-ovmf \
 lorax \
 qemu-kvm \
 tar \
"
RDEPENDS:lorax-lmc-virt:aarch64 = " \
 edk2-aarch64 \
 lorax \
 qemu-kvm \
 tar \
"
RDEPENDS:lorax-templates-generic = " \
 lorax \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/lorax-templates"

PROVIDES:append:aarch64 = " rpm/virtual/lorax-templates"
