# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ryu"
PV = "1.0.23"
PR = "1.el10_2"
PACKAGES = " \
 rust-ryu+default-devel \
 rust-ryu+no-panic-devel \
 rust-ryu+small-devel \
 rust-ryu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ryu-1.0.23-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a71555c6d9776878119c721be068767ac85df5dbef249e3f8a5074183682cfc0"

URI_x86_64_v2_rust-ryu+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+default-devel-1.0.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+default-devel}"
SRC_URI[x86_64_v2_rust-ryu+default-devel.sha256sum] = "4b96c1185d9dd7ce159d5bf9249c40be5945f4220b8e39464debce7257c395f5"

URI_x86_64_v2_rust-ryu+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+no-panic-devel-1.0.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+no-panic-devel}"
SRC_URI[x86_64_v2_rust-ryu+no-panic-devel.sha256sum] = "db09e2e93082fc198db8c0c9fd4db58728b6b0abc0ce737225de2bc2e4a8c9c9"

URI_x86_64_v2_rust-ryu+small-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+small-devel-1.0.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+small-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+small-devel}"
SRC_URI[x86_64_v2_rust-ryu+small-devel.sha256sum] = "a9fbfafc34d1212eb27165ac3ffdcd2642e7f19957ad43329ee883f5bb356f21"

URI_x86_64_v2_rust-ryu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu-devel-1.0.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu-devel}"
SRC_URI[x86_64_v2_rust-ryu-devel.sha256sum] = "fae88d4e7224a86a467d874dd3a7a01632706bfdac8b7b03914240793036a4e4"

URI_aarch64_rust-ryu+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+default-devel-1.0.23-1.el10_2.noarch.rpm;name=aarch64_rust-ryu+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+default-devel}"
SRC_URI[aarch64_rust-ryu+default-devel.sha256sum] = "9717edf1b80455ae0f1e6be1b2b23a0665ceb450f4afb0567a456bd22be6531f"

URI_aarch64_rust-ryu+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+no-panic-devel-1.0.23-1.el10_2.noarch.rpm;name=aarch64_rust-ryu+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+no-panic-devel}"
SRC_URI[aarch64_rust-ryu+no-panic-devel.sha256sum] = "43e97f3bef8856ade96fdcf6cac955e1acd4a2b2531dd136ab288cd4416e1b5c"

URI_aarch64_rust-ryu+small-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+small-devel-1.0.23-1.el10_2.noarch.rpm;name=aarch64_rust-ryu+small-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+small-devel}"
SRC_URI[aarch64_rust-ryu+small-devel.sha256sum] = "204d44aea217c9c8874cd40063a0b29aafa9c67191b0dfc461b7824b7a2363ac"

URI_aarch64_rust-ryu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu-devel-1.0.23-1.el10_2.noarch.rpm;name=aarch64_rust-ryu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu-devel}"
SRC_URI[aarch64_rust-ryu-devel.sha256sum] = "a2f61abaf5c2e52876d8f74061530775693be88431e8a524a455955d22d1e90a"

RDEPENDS:rust-ryu+default-devel = " \
 cargo \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu+no-panic-devel = " \
 cargo \
 rust-no-panic+default-devel \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu+small-devel = " \
 cargo \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu-devel = " \
 cargo \
 rust \
 "
