# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-core"
PV = "0.5.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-zune-core+default-devel \
 rust-zune-core+log-devel \
 rust-zune-core+serde-devel \
 rust-zune-core+std-devel \
 rust-zune-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zune-core-0.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b84ed70a32b753827c3df1d4ed76932bc8233ccd75a3f644ac7da9ca7496239"

URI_x86_64_v2_rust-zune-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+default-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+default-devel}"
SRC_URI[x86_64_v2_rust-zune-core+default-devel.sha256sum] = "83e65a1784bd9f9884f52b033174bb0f9368c7ef5e9d85cb72f8d085d27cd759"

URI_x86_64_v2_rust-zune-core+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+log-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+log-devel}"
SRC_URI[x86_64_v2_rust-zune-core+log-devel.sha256sum] = "c6d7f9ca4b02f573781a017eb4ffd165d63062dc530dadab7755253e24bacbb5"

URI_x86_64_v2_rust-zune-core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+serde-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+serde-devel}"
SRC_URI[x86_64_v2_rust-zune-core+serde-devel.sha256sum] = "cb93d4077aad7d06b3c75add5e3a6206156d273f592ee23fb7c3836b1e9d6726"

URI_x86_64_v2_rust-zune-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+std-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+std-devel}"
SRC_URI[x86_64_v2_rust-zune-core+std-devel.sha256sum] = "f5bd89e263bb5ed8a8b02295be174b53ceeff97d5fa5a983692e02dcbb1fc078"

URI_x86_64_v2_rust-zune-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core-devel}"
SRC_URI[x86_64_v2_rust-zune-core-devel.sha256sum] = "05ee7e081ecfec2fead806cfbe6ff6b86e295a56d7814f69751fb5b6f3f5db18"

URI_aarch64_rust-zune-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+default-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-zune-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+default-devel}"
SRC_URI[aarch64_rust-zune-core+default-devel.sha256sum] = "3469222aae6d17ff0889102929493e3cfa65addaf42d4856c15d9932f00ee8bb"

URI_aarch64_rust-zune-core+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+log-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-zune-core+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+log-devel}"
SRC_URI[aarch64_rust-zune-core+log-devel.sha256sum] = "f0fa04e588f71310633ec403fd975ee56b65d960dd85b2af1d3a8c72a2a2b13b"

URI_aarch64_rust-zune-core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+serde-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-zune-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+serde-devel}"
SRC_URI[aarch64_rust-zune-core+serde-devel.sha256sum] = "5cb3f5356ffbce7d1a2a7b271a46bdfe69b1b859bdbd27ccd7096798ea46d4a0"

URI_aarch64_rust-zune-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+std-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-zune-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+std-devel}"
SRC_URI[aarch64_rust-zune-core+std-devel.sha256sum] = "034eb0b1f98712a4973732b3a059e9bee3eef6d4a14a41149c962c11eb2c202c"

URI_aarch64_rust-zune-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-zune-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core-devel}"
SRC_URI[aarch64_rust-zune-core-devel.sha256sum] = "23ca048053da6c0684260ab7f82e77d5f4e8205e8ba9db45408970fdddeb277a"

RDEPENDS:rust-zune-core+default-devel = " \
 cargo \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core+std-devel = " \
 cargo \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core-devel = " \
 cargo \
 rust \
 "
