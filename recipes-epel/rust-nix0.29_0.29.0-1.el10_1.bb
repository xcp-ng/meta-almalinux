# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nix0.29"
PV = "0.29.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-nix0.29+acct-devel \
 rust-nix0.29+aio-devel \
 rust-nix0.29+default-devel \
 rust-nix0.29+dir-devel \
 rust-nix0.29+env-devel \
 rust-nix0.29+event-devel \
 rust-nix0.29+fanotify-devel \
 rust-nix0.29+feature-devel \
 rust-nix0.29+fs-devel \
 rust-nix0.29+hostname-devel \
 rust-nix0.29+inotify-devel \
 rust-nix0.29+ioctl-devel \
 rust-nix0.29+kmod-devel \
 rust-nix0.29+memoffset-devel \
 rust-nix0.29+mman-devel \
 rust-nix0.29+mount-devel \
 rust-nix0.29+mqueue-devel \
 rust-nix0.29+net-devel \
 rust-nix0.29+personality-devel \
 rust-nix0.29+pin-utils-devel \
 rust-nix0.29+poll-devel \
 rust-nix0.29+process-devel \
 rust-nix0.29+pthread-devel \
 rust-nix0.29+ptrace-devel \
 rust-nix0.29+quota-devel \
 rust-nix0.29+reboot-devel \
 rust-nix0.29+resource-devel \
 rust-nix0.29+sched-devel \
 rust-nix0.29+signal-devel \
 rust-nix0.29+socket-devel \
 rust-nix0.29+term-devel \
 rust-nix0.29+time-devel \
 rust-nix0.29+ucontext-devel \
 rust-nix0.29+uio-devel \
 rust-nix0.29+user-devel \
 rust-nix0.29+zerocopy-devel \
 rust-nix0.29-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nix0.29-0.29.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf3359a1bc8bc3fa99e5cba6e8f13b792b466b71e493b5ad43a49caf20ea2a04"

URI_x86_64_v2_rust-nix0.29+acct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+acct-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+acct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+acct-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+acct-devel.sha256sum] = "6773bb1cde3df3b06dd35d10659aef2e653e7fdda243f231f679642a7c91b87e"

URI_x86_64_v2_rust-nix0.29+aio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+aio-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+aio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+aio-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+aio-devel.sha256sum] = "25eb473848e7dd4f9f72d284bb418754d394282779f61d601557abbf6cd15232"

URI_x86_64_v2_rust-nix0.29+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+default-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+default-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+default-devel.sha256sum] = "75597bab64ab8294fab55cfbfd8e53000ad6023dbeaafaa3e32e5222d8827f43"

URI_x86_64_v2_rust-nix0.29+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+dir-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+dir-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+dir-devel.sha256sum] = "c7339a0a0443816f40b464cdad0be563f17dd7d2ec4fb2a6d0f051511fde53f9"

URI_x86_64_v2_rust-nix0.29+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+env-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+env-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+env-devel.sha256sum] = "20c18dcf9768dff2e3ebdd80a7d31f4a248772ddeac2fc8cb445de5ca1295d86"

URI_x86_64_v2_rust-nix0.29+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+event-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+event-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+event-devel.sha256sum] = "64d2466390293ddfa568ab2465437e68f7ebadad283b186f6193781bbe1c5f15"

URI_x86_64_v2_rust-nix0.29+fanotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+fanotify-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+fanotify-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+fanotify-devel.sha256sum] = "8d804ecc0be2f31e4d5b8e793527d2cce9a85b93da3dd037bca3f77929dfd9e9"

URI_x86_64_v2_rust-nix0.29+feature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+feature-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+feature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+feature-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+feature-devel.sha256sum] = "a22a4d10c501e7e46b900051b9e76f783f446486ec4771f8f74b53dccaa0cf6a"
RPROVIDES:rust-nix0.29+feature-devel:x86_64_v2 = "virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~"

URI_x86_64_v2_rust-nix0.29+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+fs-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+fs-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+fs-devel.sha256sum] = "474341ca9d3e9ba9b28f911a4f5f679af7b3b61efd8521745daec6aee8ea9f1f"

URI_x86_64_v2_rust-nix0.29+hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+hostname-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+hostname-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+hostname-devel.sha256sum] = "003f66dab9f46e56a3b4986e073febd6da06188d4c8b1d986e847386ee4e663e"

URI_x86_64_v2_rust-nix0.29+inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+inotify-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+inotify-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+inotify-devel.sha256sum] = "d2dd6c6caafa68e1ef85d95fd7978f6922277e1499c1b1753c3b3a9826e7597a"

URI_x86_64_v2_rust-nix0.29+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+ioctl-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+ioctl-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+ioctl-devel.sha256sum] = "a28b370e013ec0e0ea0f28bd8656fd9075190feabdcd366adf16d1c8ed9f2b0d"

URI_x86_64_v2_rust-nix0.29+kmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+kmod-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+kmod-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+kmod-devel.sha256sum] = "d38aef5d03ec4acc32dad83a260d1a9962b1f03ca4583eaab7c31b79925da3eb"

URI_x86_64_v2_rust-nix0.29+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+memoffset-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+memoffset-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+memoffset-devel.sha256sum] = "d328445084208e06ed51ece17e6067bff01bf75055a1f405d182cdaf3276a828"

URI_x86_64_v2_rust-nix0.29+mman-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+mman-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+mman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+mman-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+mman-devel.sha256sum] = "71e3222a39af281dd6055570a019f3283c80e13af060c576f90a8ca49b8e0092"

URI_x86_64_v2_rust-nix0.29+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+mount-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+mount-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+mount-devel.sha256sum] = "66d41a46c05a43fbb7c6c5ec30ac8ad7d4e8e0fdb974c684a7ff80ad154943f0"

URI_x86_64_v2_rust-nix0.29+mqueue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+mqueue-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+mqueue-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+mqueue-devel.sha256sum] = "a37f8cbb7b5207e3369a4632460f5b230cecea8bde16ccdc03ae982404d57490"

URI_x86_64_v2_rust-nix0.29+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+net-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+net-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+net-devel.sha256sum] = "b6b1b62902f970a53b6ac760224820279bab91abab1e9a7aa1574618e6afde72"

URI_x86_64_v2_rust-nix0.29+personality-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+personality-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+personality-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+personality-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+personality-devel.sha256sum] = "18d41c24feb0fc15fe3a05cd74e8ba6aa50d51e9ac7665e6e1f61b5911cb7a0e"

URI_x86_64_v2_rust-nix0.29+pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+pin-utils-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+pin-utils-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+pin-utils-devel.sha256sum] = "67273c9c471a33484fcb8f21fe1e69e420eca54f8885f66d358b18a81b1ca180"

URI_x86_64_v2_rust-nix0.29+poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+poll-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+poll-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+poll-devel.sha256sum] = "c4094c709d14b3f8f2ade44bd25aecb1d8078ea4e6c0c512b89be692c8c60b23"

URI_x86_64_v2_rust-nix0.29+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+process-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+process-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+process-devel.sha256sum] = "697c996f7b8a49310b69dbe25b713b51b930eeca882a79d430a368b3961bc808"

URI_x86_64_v2_rust-nix0.29+pthread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+pthread-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+pthread-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+pthread-devel.sha256sum] = "4d8ff547d2541fb358eebfcca0c958635f8a33eeae8ebb7d349f8d47d7a25bd7"

URI_x86_64_v2_rust-nix0.29+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+ptrace-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+ptrace-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+ptrace-devel.sha256sum] = "8554a09666e683e191d261b6e4bdf6e8295a24e4e7fec8a941b3170802c64ec9"

URI_x86_64_v2_rust-nix0.29+quota-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+quota-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+quota-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+quota-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+quota-devel.sha256sum] = "c0f3658f23fef66c4ef09b4c34eee835656f3a75b98eee6812aa8d49c9b3f538"

URI_x86_64_v2_rust-nix0.29+reboot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+reboot-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+reboot-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+reboot-devel.sha256sum] = "6da684de5204e374a0adf6650f0d63f3b1b91652866baa4d2b9baff96b461998"

URI_x86_64_v2_rust-nix0.29+resource-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+resource-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+resource-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+resource-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+resource-devel.sha256sum] = "bfc958c9a51ff6de857392fcd7797538e38c332304a20b232c2b571cc0d61d61"

URI_x86_64_v2_rust-nix0.29+sched-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+sched-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+sched-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+sched-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+sched-devel.sha256sum] = "78012486227dead5159509763caf72429b66beecfa0fe06d291a0c7c13de0d7a"

URI_x86_64_v2_rust-nix0.29+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+signal-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+signal-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+signal-devel.sha256sum] = "3f2cd0257430ee213e7830507efec3d5ef1ab99317603d7ee47d892632cc024a"

URI_x86_64_v2_rust-nix0.29+socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+socket-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+socket-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+socket-devel.sha256sum] = "e1e1c96ea2d4b9d94db26f4cfe6c6ea64f8d3668619459a23bc231acd8877d94"

URI_x86_64_v2_rust-nix0.29+term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+term-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+term-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+term-devel.sha256sum] = "3fdf55359b81520764e670c06c04b2f52b7342a80e8a449b27b6fd330b59fb7d"

URI_x86_64_v2_rust-nix0.29+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+time-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+time-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+time-devel.sha256sum] = "e5bb1e50b3c30f2149479ac7905f63074dc8f023a24525b9813180c18618746c"

URI_x86_64_v2_rust-nix0.29+ucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+ucontext-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+ucontext-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+ucontext-devel.sha256sum] = "805109f93ddf9dc645eb6d60423f5495cb4ef1e2c4b0913340ad6a21eb6bbbdc"

URI_x86_64_v2_rust-nix0.29+uio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+uio-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+uio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+uio-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+uio-devel.sha256sum] = "a3d7e2c2391b7a7a920eda12021603e8f1c5a4253c0196c174371c74cdc8b577"

URI_x86_64_v2_rust-nix0.29+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+user-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+user-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+user-devel.sha256sum] = "53be09343b31b8da58ca3a975840ff6e47b6aa49ea06752e2228ecb49a26a112"

URI_x86_64_v2_rust-nix0.29+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29+zerocopy-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-nix0.29+zerocopy-devel.sha256sum] = "0a234143e7582c93e3c84a841ff896a75edf2ef8ef37f55feadfb26e896ea1c4"

URI_x86_64_v2_rust-nix0.29-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.29-devel-0.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.29-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.29-devel}"
SRC_URI[x86_64_v2_rust-nix0.29-devel.sha256sum] = "7682a020146c321cde17ba3782714975e591713f5b93311b5e2d20185388f115"
RPROVIDES:rust-nix0.29-devel:x86_64_v2 = "virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"

URI_aarch64_rust-nix0.29+acct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+acct-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+acct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+acct-devel}"
SRC_URI[aarch64_rust-nix0.29+acct-devel.sha256sum] = "8129a025f5bae546401cdf153a0042bb4a8d15f0fd303c6f6c716fe491b900a5"

URI_aarch64_rust-nix0.29+aio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+aio-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+aio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+aio-devel}"
SRC_URI[aarch64_rust-nix0.29+aio-devel.sha256sum] = "c416831ac02eef6a9c1a882353bfb884b515320ecfbe52e73be0ac034e3281ef"

URI_aarch64_rust-nix0.29+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+default-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+default-devel}"
SRC_URI[aarch64_rust-nix0.29+default-devel.sha256sum] = "844fb235c18cdce8a8ac5120c076a1f221aaac8fa133220b2cf18347f52ca74b"

URI_aarch64_rust-nix0.29+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+dir-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+dir-devel}"
SRC_URI[aarch64_rust-nix0.29+dir-devel.sha256sum] = "dc46c7464fbd262bd54f7ee9b122294c7093bdcd05875bd6965274f07a842283"

URI_aarch64_rust-nix0.29+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+env-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+env-devel}"
SRC_URI[aarch64_rust-nix0.29+env-devel.sha256sum] = "916db5a80fb0c21e28d6b5bf0ae09ce9daa03a9e47b654a20a31c9661ad06373"

URI_aarch64_rust-nix0.29+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+event-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+event-devel}"
SRC_URI[aarch64_rust-nix0.29+event-devel.sha256sum] = "bbe384699391135b7591fa4d2c5b02ea8886f5f30c75419139679020610f0004"

URI_aarch64_rust-nix0.29+fanotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+fanotify-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+fanotify-devel}"
SRC_URI[aarch64_rust-nix0.29+fanotify-devel.sha256sum] = "1cded8b22722fe081e7b094ded0c2d4d880a6bd47cde9609ff2cd90606f6616b"

URI_aarch64_rust-nix0.29+feature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+feature-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+feature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+feature-devel}"
SRC_URI[aarch64_rust-nix0.29+feature-devel.sha256sum] = "6464a062ed2aa5bb8303b21a0bca8d429a04a9fac41cce51434b9937fb92d185"
RPROVIDES:rust-nix0.29+feature-devel:aarch64 = "virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~"

URI_aarch64_rust-nix0.29+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+fs-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+fs-devel}"
SRC_URI[aarch64_rust-nix0.29+fs-devel.sha256sum] = "bd217f691a1f840cf94dfce6b7c7ae6b5513b9e0eb82e3c65e440be7167fd1a9"

URI_aarch64_rust-nix0.29+hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+hostname-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+hostname-devel}"
SRC_URI[aarch64_rust-nix0.29+hostname-devel.sha256sum] = "52e8fbf389e1c679100749f582f91dcf3657c1f61d07ce6aac6705d05ad132f4"

URI_aarch64_rust-nix0.29+inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+inotify-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+inotify-devel}"
SRC_URI[aarch64_rust-nix0.29+inotify-devel.sha256sum] = "eb0447c2da5e550ace58b90d258826f3fd24a0f8cb30b7bb5566432d3e17c3a4"

URI_aarch64_rust-nix0.29+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+ioctl-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+ioctl-devel}"
SRC_URI[aarch64_rust-nix0.29+ioctl-devel.sha256sum] = "718fd180b444b39ae3b18cdbc68558e821e44a6f1a943312ffc2163b2f95278e"

URI_aarch64_rust-nix0.29+kmod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+kmod-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+kmod-devel}"
SRC_URI[aarch64_rust-nix0.29+kmod-devel.sha256sum] = "26059559383e8a605add1db1c838d91b7526e8582da53575ee33bcc8117ffd85"

URI_aarch64_rust-nix0.29+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+memoffset-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+memoffset-devel}"
SRC_URI[aarch64_rust-nix0.29+memoffset-devel.sha256sum] = "f407e8807cb51d858e8f17b5f9156df806cf26b70d84d0c9a8d0e4991700b62b"

URI_aarch64_rust-nix0.29+mman-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+mman-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+mman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+mman-devel}"
SRC_URI[aarch64_rust-nix0.29+mman-devel.sha256sum] = "66a4ca8cc8ebec96cf3c9a7e9d23c7710d238c217c6860990b007969ea560983"

URI_aarch64_rust-nix0.29+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+mount-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+mount-devel}"
SRC_URI[aarch64_rust-nix0.29+mount-devel.sha256sum] = "a7f5cca1b314f22338ba2c055e4c6da5021966be6eeae67a5fc1ba4028f4a7fb"

URI_aarch64_rust-nix0.29+mqueue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+mqueue-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+mqueue-devel}"
SRC_URI[aarch64_rust-nix0.29+mqueue-devel.sha256sum] = "8d08ec56f7cb65f0bf5b1dc36abf2301a167dc077673bec4cd482608fc4f848e"

URI_aarch64_rust-nix0.29+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+net-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+net-devel}"
SRC_URI[aarch64_rust-nix0.29+net-devel.sha256sum] = "2a7d0af1eacae0335f27d66a46d39ee2a7a07e19c3da9e4b0e34c9bfa770c143"

URI_aarch64_rust-nix0.29+personality-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+personality-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+personality-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+personality-devel}"
SRC_URI[aarch64_rust-nix0.29+personality-devel.sha256sum] = "e0785950110c32f46c2ef179f6a0066b700a829896d90ae14ed195ec9c7a6b7c"

URI_aarch64_rust-nix0.29+pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+pin-utils-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+pin-utils-devel}"
SRC_URI[aarch64_rust-nix0.29+pin-utils-devel.sha256sum] = "8bdf0eb7e9afd1c2d0d3743918214d6f7429363c01e44bc689bb2524da2365bb"

URI_aarch64_rust-nix0.29+poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+poll-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+poll-devel}"
SRC_URI[aarch64_rust-nix0.29+poll-devel.sha256sum] = "5022ff03685c61e4bbed6287fcc26e88438607ea7f165d0c2c939abe30798564"

URI_aarch64_rust-nix0.29+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+process-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+process-devel}"
SRC_URI[aarch64_rust-nix0.29+process-devel.sha256sum] = "a8b9ecd38eaecb01a89def06229ffcc709b77a01ba9934c854b75216924b63d9"

URI_aarch64_rust-nix0.29+pthread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+pthread-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+pthread-devel}"
SRC_URI[aarch64_rust-nix0.29+pthread-devel.sha256sum] = "9008605169c9412cf217e30996b6164331ba4761cac9b31253b3c73b17916376"

URI_aarch64_rust-nix0.29+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+ptrace-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+ptrace-devel}"
SRC_URI[aarch64_rust-nix0.29+ptrace-devel.sha256sum] = "86f63232d528452e52fa3ab7f7b9f71d1b31633dab980a210e3983649df4d1b1"

URI_aarch64_rust-nix0.29+quota-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+quota-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+quota-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+quota-devel}"
SRC_URI[aarch64_rust-nix0.29+quota-devel.sha256sum] = "4078b7abd19529ca8dafd9d374aa6730c87de9c5acbf6ad78ad715f6605d788f"

URI_aarch64_rust-nix0.29+reboot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+reboot-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+reboot-devel}"
SRC_URI[aarch64_rust-nix0.29+reboot-devel.sha256sum] = "eacdbd31004036ebcccb8b74ba92367b9c6cd29aec1857e38ca3d7e3a9775ed8"

URI_aarch64_rust-nix0.29+resource-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+resource-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+resource-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+resource-devel}"
SRC_URI[aarch64_rust-nix0.29+resource-devel.sha256sum] = "8d79d4b1b8cebfdc9fbb237c5b70d5409711514749b2fe6ca79bc31344111798"

URI_aarch64_rust-nix0.29+sched-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+sched-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+sched-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+sched-devel}"
SRC_URI[aarch64_rust-nix0.29+sched-devel.sha256sum] = "42a8593ba777bc3c043b6ffa9eb859e1752f9a4b3731cd4a057b4c4f3b3bfc98"

URI_aarch64_rust-nix0.29+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+signal-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+signal-devel}"
SRC_URI[aarch64_rust-nix0.29+signal-devel.sha256sum] = "e66580ef0711e6f1f2d535250d35d53d2b5a383d9236e0e48f519cae02edfb60"

URI_aarch64_rust-nix0.29+socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+socket-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+socket-devel}"
SRC_URI[aarch64_rust-nix0.29+socket-devel.sha256sum] = "bddd90bc7c3c2f713e2920528a89c5161466ae138cbcfec4ea29ef9ba0bf399a"

URI_aarch64_rust-nix0.29+term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+term-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+term-devel}"
SRC_URI[aarch64_rust-nix0.29+term-devel.sha256sum] = "32742acf21b8207a3e169abd195e29df005eabe6c04061278a57fc5fed17a463"

URI_aarch64_rust-nix0.29+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+time-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+time-devel}"
SRC_URI[aarch64_rust-nix0.29+time-devel.sha256sum] = "9eb6181d1c33f24578f6b98d738d58eb00bb54c699e3457cc90b72c962adafbf"

URI_aarch64_rust-nix0.29+ucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+ucontext-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+ucontext-devel}"
SRC_URI[aarch64_rust-nix0.29+ucontext-devel.sha256sum] = "f8a5477be7a9e4c00191820842f5649695b2017f2fae5f3e66f3fe8937d14c46"

URI_aarch64_rust-nix0.29+uio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+uio-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+uio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+uio-devel}"
SRC_URI[aarch64_rust-nix0.29+uio-devel.sha256sum] = "a0cb1604db3f0abeb80f349a614247e3a710ee92a90dd9f0cf248072ac0aa95b"

URI_aarch64_rust-nix0.29+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+user-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+user-devel}"
SRC_URI[aarch64_rust-nix0.29+user-devel.sha256sum] = "41ae6d7b102747e46d3c961eef191ecedb90f1e45f584148a33f65c0de66ef83"

URI_aarch64_rust-nix0.29+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29+zerocopy-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29+zerocopy-devel}"
SRC_URI[aarch64_rust-nix0.29+zerocopy-devel.sha256sum] = "b9af28d8993fa40ba3a2d1729454b0fce3dc267ed80c48e01ada5d5832c7af01"

URI_aarch64_rust-nix0.29-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.29-devel-0.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-nix0.29-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.29-devel}"
SRC_URI[aarch64_rust-nix0.29-devel.sha256sum] = "dc4669e947c377fd87b5892ed54895c6e4421b8c62a256c0cf2d0fc9b8b6f202"
RPROVIDES:rust-nix0.29-devel:aarch64 = "virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"

RDEPENDS:rust-nix0.29+acct-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+aio-devel = " \
 cargo \
 rust-nix0.29+pin-utils-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+default-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+dir-devel = " \
 cargo \
 rust-nix0.29+fs-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+env-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+event-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+fanotify-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+feature-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+fs-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+hostname-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+inotify-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+ioctl-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+kmod-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+mman-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+mount-devel = " \
 cargo \
 rust-nix0.29+uio-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+mqueue-devel = " \
 cargo \
 rust-nix0.29+fs-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+net-devel = " \
 cargo \
 rust-nix0.29+socket-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+personality-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+pin-utils-devel = " \
 cargo \
 rust-nix0.29-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-nix0.29+poll-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+process-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+pthread-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+ptrace-devel = " \
 cargo \
 rust-nix0.29+process-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+quota-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+reboot-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+resource-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+sched-devel = " \
 cargo \
 rust-nix0.29+process-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+signal-devel = " \
 cargo \
 rust-nix0.29+process-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+socket-devel = " \
 cargo \
 rust-nix0.29+memoffset-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+term-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+time-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+ucontext-devel = " \
 cargo \
 rust-nix0.29+signal-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+uio-devel = " \
 cargo \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+user-devel = " \
 cargo \
 rust-nix0.29+feature-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29+zerocopy-devel = " \
 cargo \
 rust-nix0.29+fs-devel \
 rust-nix0.29+uio-devel \
 rust-nix0.29-devel \
 "
RDEPENDS:rust-nix0.29-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-cfg_aliases+default-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~ rpm/virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~ rpm/virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"
