# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-TreeBuilder-XPath"
PV = "0.14"
PR = "39.el10_0"
PACKAGES = " \
 perl-HTML-TreeBuilder-XPath \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-TreeBuilder-XPath-0.14-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d9ad8497e55f2456661f924bd89f223a2881bc9169866b327eaa9f901858bb3"

URI_x86_64_v2_perl-HTML-TreeBuilder-XPath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-TreeBuilder-XPath-0.14-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-TreeBuilder-XPath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-TreeBuilder-XPath}"
SRC_URI[x86_64_v2_perl-HTML-TreeBuilder-XPath.sha256sum] = "9eb7b20e454f64a53f4c7edf53a48643cf5b77ab8ec4c85a9451934d864a45b0"

URI_aarch64_perl-HTML-TreeBuilder-XPath = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-TreeBuilder-XPath-0.14-39.el10_0.noarch.rpm;name=aarch64_perl-HTML-TreeBuilder-XPath;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-TreeBuilder-XPath}"
SRC_URI[aarch64_perl-HTML-TreeBuilder-XPath.sha256sum] = "5a9430644bbed06e2658363ecc57215c0ccbda7c18c8f60c2ada5c62e81de568"

RDEPENDS:perl-HTML-TreeBuilder-XPath = " \
 perl-HTML-Tree \
 perl-Scalar-List-Utils \
 perl-XML-XPathEngine \
 perl-base \
 perl-libs \
 perl-vars \
 "
