# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnupg2"
PV = "2.4.5"
PR = "2.el10"
PACKAGES = " \
 gnupg2 \
 gnupg2-smime \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gnupg2-2.4.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01b1828fdd46826e77da2ef5a924aea8203f4d4ba05934c608edb060bf6d1a13"

URI_x86_64_v2_gnupg2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gnupg2-2.4.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_gnupg2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnupg2}"
SRC_URI[x86_64_v2_gnupg2.sha256sum] = "724d68767c8ea3141292c3af3f4b0a7c6ab422fc1f393146c6889513a06cf560"

URI_x86_64_v2_gnupg2-smime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnupg2-smime-2.4.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_gnupg2-smime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnupg2-smime}"
SRC_URI[x86_64_v2_gnupg2-smime.sha256sum] = "f19c98ad9fcbb0b2965808516288a9b9fe4d723432e55b13084f1c90bb130fa9"

URI_aarch64_gnupg2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gnupg2-2.4.5-2.el10.aarch64.rpm;name=aarch64_gnupg2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnupg2}"
SRC_URI[aarch64_gnupg2.sha256sum] = "9871c044cee092b1a2bd5f5328150b1630384e477464f9c5b8983ac528447639"

URI_aarch64_gnupg2-smime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnupg2-smime-2.4.5-2.el10.aarch64.rpm;name=aarch64_gnupg2-smime;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnupg2-smime}"
SRC_URI[aarch64_gnupg2-smime.sha256sum] = "4cba9280e29ed2068c699929e6da609b955b74b34b992f4d71ef8805c764c971"

RDEPENDS:gnupg2 = " \
 bash \
 bzip2-libs \
 glibc \
 gnutls \
 libassuan \
 libgcrypt \
 libgpg-error \
 libksba \
 npth \
 openldap \
 readline \
 sqlite-libs \
 tpm2-tss \
 zlib-ng-compat \
 "
RDEPENDS:gnupg2-smime = " \
 glibc \
 gnupg2 \
 libassuan \
 libgcrypt \
 libgpg-error \
 libksba \
 npth \
 readline \
 "
