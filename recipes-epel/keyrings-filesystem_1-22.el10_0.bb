# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keyrings-filesystem"
PV = "1"
PR = "22.el10_0"
PACKAGES = " \
 keyrings-filesystem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keyrings-filesystem-1-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a0f6562ff2a442b474ea4d29ebe854a184490061a21217dfff707ce35691c07"

URI_x86_64_v2_keyrings-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keyrings-filesystem-1-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_keyrings-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keyrings-filesystem}"
SRC_URI[x86_64_v2_keyrings-filesystem.sha256sum] = "350defe4774cae49b5c40175bf3b80d7e5818869f5ec462cdf1ce093fd111956"

URI_aarch64_keyrings-filesystem = "${EPEL_MIRROR}/aarch64/Packages/k/keyrings-filesystem-1-22.el10_0.noarch.rpm;name=aarch64_keyrings-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_keyrings-filesystem}"
SRC_URI[aarch64_keyrings-filesystem.sha256sum] = "f8c7e0ca2394276e6070a6eb20ddceff81520d6eacba6199de6adb433fae3b02"

RDEPENDS:keyrings-filesystem = " \
 filesystem \
 rpm \
 "
