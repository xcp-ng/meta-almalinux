# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-xid"
PV = "0.2.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-unicode-xid+default-devel \
 rust-unicode-xid+no_std-devel \
 rust-unicode-xid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-xid-0.2.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38746cc4528c29f20c7baf44c1baf5c91c056db794def2571d5149b606cce283"

URI_x86_64_v2_rust-unicode-xid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-xid+default-devel-0.2.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-xid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-xid+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-xid+default-devel.sha256sum] = "3a5721a872032d4c479ddddb5636e461928493a3102c0712a6cd70a375344767"

URI_x86_64_v2_rust-unicode-xid+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-xid+no_std-devel-0.2.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-xid+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-xid+no_std-devel}"
SRC_URI[x86_64_v2_rust-unicode-xid+no_std-devel.sha256sum] = "0e7bdd2111f968f07e057e44e09ace94a778097faf550849d8f20633693b33e6"

URI_x86_64_v2_rust-unicode-xid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-xid-devel-0.2.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-xid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-xid-devel}"
SRC_URI[x86_64_v2_rust-unicode-xid-devel.sha256sum] = "62f282fd97a78b0f5fc1ceab9c6811e47f0635c90614f8b051f55ae885cabd77"

URI_aarch64_rust-unicode-xid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-xid+default-devel-0.2.6-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-xid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-xid+default-devel}"
SRC_URI[aarch64_rust-unicode-xid+default-devel.sha256sum] = "5261f4fc9c6bea7706152a513731334c4359fd52df0ff30541115c1cb732c0e2"

URI_aarch64_rust-unicode-xid+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-xid+no_std-devel-0.2.6-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-xid+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-xid+no_std-devel}"
SRC_URI[aarch64_rust-unicode-xid+no_std-devel.sha256sum] = "fda522cc8ca13c35faa8eb66090f2362e67d10f9a73f41d90a34e2961e9ba5ad"

URI_aarch64_rust-unicode-xid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-xid-devel-0.2.6-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-xid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-xid-devel}"
SRC_URI[aarch64_rust-unicode-xid-devel.sha256sum] = "7bd7eef2447d4712660042acec20687dba66ed920d2a9f8d10a5c41569c80e9a"

RDEPENDS:rust-unicode-xid+default-devel = " \
 cargo \
 rust-unicode-xid-devel \
 "
RDEPENDS:rust-unicode-xid+no_std-devel = " \
 cargo \
 rust-unicode-xid-devel \
 "
RDEPENDS:rust-unicode-xid-devel = " \
 cargo \
 rust \
 "
