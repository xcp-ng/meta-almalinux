# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-inline"
PV = "0.3.21"
PR = "7.el10_3"
PACKAGES = " \
 R-inline \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-inline-0.3.21-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d16999fbd90cec1b09b1abadf15cc3879ab6ae39dbe5f949e3f27f94a7126ac"

URI_x86_64_v2_R-inline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-inline-0.3.21-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_R-inline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-inline}"
SRC_URI[x86_64_v2_R-inline.sha256sum] = "a21f3a2f888097a7f41edd6ae7dcad07a6ea725321753c02ce2a3f68aa1680d5"

URI_aarch64_R-inline = "${EPEL_MIRROR}/aarch64/Packages/r/R-inline-0.3.21-7.el10_3.noarch.rpm;name=aarch64_R-inline;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-inline}"
SRC_URI[aarch64_R-inline.sha256sum] = "94751d7cb14a0595c4e1a0c31752dc9446ad0cd1ff7a618012a105655e1f1bc4"

RDEPENDS:R-inline = " \
 R-core \
 "
