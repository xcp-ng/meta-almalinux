# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktexttemplate"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-ktexttemplate \
 kf6-ktexttemplate-devel \
 kf6-ktexttemplate-doc \
 kf6-ktexttemplate-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-ktexttemplate-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a2b420cfbe721f282fdf7437b654927d412c1fff65dc3049d29d2837590bb1a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexttemplate;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexttemplate.sha256sum] = "80fd8a6c7b0e9771e78b38a7b823673952f9c2e1c261ebfba1215c75d5733ab5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexttemplate-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexttemplate-devel.sha256sum] = "606d67fd94fc3f2f7a95cdbd405b3b92589997d1797c028486f880c8fb99a59c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexttemplate-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexttemplate-doc.sha256sum] = "73f326a553ad1e1e9bf85d415a1b30dd43f03d515a0b703509117d183c9d2355"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexttemplate-html;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexttemplate-html.sha256sum] = "8c7bf4db39dc6f239f7465f37b194c5d8821746ffe537fecbb58e184d07f4c49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktexttemplate;unpack=0"
SRC_URI[aarch64_kf6-ktexttemplate.sha256sum] = "689f27fb24972a05218680c896d5c6c7845613e77bc05a3010363a78c8231b73"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktexttemplate-devel;unpack=0"
SRC_URI[aarch64_kf6-ktexttemplate-devel.sha256sum] = "9417548bde73ebf78998ca6358117c2363dda444d00303b786cbd4f730531785"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktexttemplate-doc;unpack=0"
SRC_URI[aarch64_kf6-ktexttemplate-doc.sha256sum] = "96992c8f2e22244fcd0573283de65ede8765a977327a343706b0dc07891c765e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktexttemplate-html;unpack=0"
SRC_URI[aarch64_kf6-ktexttemplate-html.sha256sum] = "6029d1517c214461629720c31cf2044e44232b55a6eb705074ea8b46b597c10d"

RDEPENDS:kf6-ktexttemplate = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-ktexttemplate-devel = " \
 cmake-filesystem \
 kf6-ktexttemplate \
 "
RDEPENDS:kf6-ktexttemplate-doc = " \
 "
RDEPENDS:kf6-ktexttemplate-html = " \
 "
