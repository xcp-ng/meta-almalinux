# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-pcre2"
PV = "0.1.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-grep-pcre2+default-devel \
 rust-grep-pcre2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-pcre2-0.1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4d1274eb6fd0e966f4aa065b43a188be18aa1d0cee5b7e31cb934aa2c7b8bee"

URI_x86_64_v2_rust-grep-pcre2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-pcre2+default-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-pcre2+default-devel}"
SRC_URI[x86_64_v2_rust-grep-pcre2+default-devel.sha256sum] = "a1cabea69923345cf156f7aaba9b9351105ea4c52af8fca9198c7ed7393112ad"

URI_x86_64_v2_rust-grep-pcre2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-pcre2-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-pcre2-devel}"
SRC_URI[x86_64_v2_rust-grep-pcre2-devel.sha256sum] = "edde89c1052ba7d86e1a1a124cc2b8d57eea107b29944e8beef130570598883c"

URI_aarch64_rust-grep-pcre2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-pcre2+default-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-grep-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-pcre2+default-devel}"
SRC_URI[aarch64_rust-grep-pcre2+default-devel.sha256sum] = "f8491794e5e7038c2a2a7a064e8c729e9480242dca766e7abc4de381b566cf4c"

URI_aarch64_rust-grep-pcre2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-pcre2-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-pcre2-devel}"
SRC_URI[aarch64_rust-grep-pcre2-devel.sha256sum] = "af3a416bb2077b2c91ad10a7e30567604763c9097d4e9b4494d35606298046d3"

RDEPENDS:rust-grep-pcre2+default-devel = " \
 cargo \
 rust-grep-pcre2-devel \
 "
RDEPENDS:rust-grep-pcre2-devel = " \
 cargo \
 rust-grep-matcher+default-devel \
 rust-log+default-devel \
 rust-pcre2+default-devel \
 "
