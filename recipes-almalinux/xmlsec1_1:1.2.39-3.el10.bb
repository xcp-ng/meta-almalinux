# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmlsec1"
PE = "1"
PV = "1.2.39"
PR = "3.el10"
PACKAGES = " \
 xmlsec1 \
 xmlsec1-devel \
 xmlsec1-nss \
 xmlsec1-openssl \
 xmlsec1-openssl-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xmlsec1-1.2.39-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8039d87833da7ba15538ba44fea81d12cf0fa749925236680e98972dbfb84d61"

URI_x86_64_v2_xmlsec1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xmlsec1-1.2.39-3.el10.x86_64_v2.rpm;name=x86_64_v2_xmlsec1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlsec1}"
SRC_URI[x86_64_v2_xmlsec1.sha256sum] = "fa29fa72f9237ba251c9ca9cfea84e47eaf4358cdc3211e9254b7f2973a1bb0e"

URI_x86_64_v2_xmlsec1-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmlsec1-devel-1.2.39-3.el10.x86_64_v2.rpm;name=x86_64_v2_xmlsec1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlsec1-devel}"
SRC_URI[x86_64_v2_xmlsec1-devel.sha256sum] = "7ffdd5d7fa4445cfb9a02efd51530e9d8bc6efc2fbf690229aaf85e2415b6607"

URI_x86_64_v2_xmlsec1-nss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xmlsec1-nss-1.2.39-3.el10.x86_64_v2.rpm;name=x86_64_v2_xmlsec1-nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlsec1-nss}"
SRC_URI[x86_64_v2_xmlsec1-nss.sha256sum] = "f33fb69dbca936cadcb0cc716cedfa9e312ba4ecf7208f6985dd57d4c785c163"

URI_x86_64_v2_xmlsec1-openssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xmlsec1-openssl-1.2.39-3.el10.x86_64_v2.rpm;name=x86_64_v2_xmlsec1-openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlsec1-openssl}"
SRC_URI[x86_64_v2_xmlsec1-openssl.sha256sum] = "bc67e573155944fe1748459447b8f614cfa7c9b935c1cdbba70b5dd0077d6742"

URI_x86_64_v2_xmlsec1-openssl-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmlsec1-openssl-devel-1.2.39-3.el10.x86_64_v2.rpm;name=x86_64_v2_xmlsec1-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlsec1-openssl-devel}"
SRC_URI[x86_64_v2_xmlsec1-openssl-devel.sha256sum] = "5e477ac91a31250bed910f0734bbfc31b5c4a32533ab4109e3c0c6211ef83d7e"

URI_aarch64_xmlsec1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xmlsec1-1.2.39-3.el10.aarch64.rpm;name=aarch64_xmlsec1;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlsec1}"
SRC_URI[aarch64_xmlsec1.sha256sum] = "efd467a48547dadb51f2137e30d4c958fceddfd8ac64ec852dd5ddcac3db498b"

URI_aarch64_xmlsec1-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmlsec1-devel-1.2.39-3.el10.aarch64.rpm;name=aarch64_xmlsec1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlsec1-devel}"
SRC_URI[aarch64_xmlsec1-devel.sha256sum] = "835869f6a82b8b1a710b88a4642372be4059cb25a34559ea314f6c7f7005ebbe"

URI_aarch64_xmlsec1-nss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xmlsec1-nss-1.2.39-3.el10.aarch64.rpm;name=aarch64_xmlsec1-nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlsec1-nss}"
SRC_URI[aarch64_xmlsec1-nss.sha256sum] = "1bd7e1aace7caa2d8890f1793fd2a7981c32f05c876346fc60e3f992f9938040"

URI_aarch64_xmlsec1-openssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xmlsec1-openssl-1.2.39-3.el10.aarch64.rpm;name=aarch64_xmlsec1-openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlsec1-openssl}"
SRC_URI[aarch64_xmlsec1-openssl.sha256sum] = "94ee63c67193e56d5e0816f5690f99dccda087cc3b6b72164e97f3a367cab279"

URI_aarch64_xmlsec1-openssl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmlsec1-openssl-devel-1.2.39-3.el10.aarch64.rpm;name=aarch64_xmlsec1-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlsec1-openssl-devel}"
SRC_URI[aarch64_xmlsec1-openssl-devel.sha256sum] = "c6ef1ceba9e1a0f026c913aeda7289a58c9c3fafa48358457a003caab5849c2d"

RDEPENDS:xmlsec1 = " \
 glibc \
 libtool-ltdl \
 libxml2 \
 libxslt \
 "
RDEPENDS:xmlsec1-devel = " \
 bash \
 libxml2-devel \
 libxslt-devel \
 openssl-devel \
 pkgconf-pkg-config \
 xmlsec1 \
 "
RDEPENDS:xmlsec1-nss = " \
 glibc \
 libtool-ltdl \
 libxml2 \
 libxslt \
 nspr \
 nss \
 nss-util \
 xmlsec1 \
 "
RDEPENDS:xmlsec1-openssl = " \
 glibc \
 libtool-ltdl \
 libxml2 \
 libxslt \
 openssl-libs \
 xmlsec1 \
 "
RDEPENDS:xmlsec1-openssl-devel = " \
 libxml2-devel \
 libxslt-devel \
 pkgconf-pkg-config \
 xmlsec1-devel \
 xmlsec1-openssl \
 "
