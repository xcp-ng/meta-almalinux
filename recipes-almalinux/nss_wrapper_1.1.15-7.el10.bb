# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nss_wrapper"
PV = "1.1.15"
PR = "7.el10"
PACKAGES = " \
 nss_wrapper \
 nss_wrapper-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nss_wrapper-1.1.15-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0a24d7337ffe9883687d6c92ed9280002bfe66037e60c695cfaa761c3f7b7c3"

URI_x86_64_v2_nss_wrapper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss_wrapper-1.1.15-7.el10.x86_64_v2.rpm;name=x86_64_v2_nss_wrapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss_wrapper}"
SRC_URI[x86_64_v2_nss_wrapper.sha256sum] = "58e10ca4722de500f92982da14a5da856b43b143d1077a7b9f3cece7a53cb3fc"

URI_x86_64_v2_nss_wrapper-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss_wrapper-libs-1.1.15-7.el10.x86_64_v2.rpm;name=x86_64_v2_nss_wrapper-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss_wrapper-libs}"
SRC_URI[x86_64_v2_nss_wrapper-libs.sha256sum] = "35566c2503c168002180ec58e8a2bba1905e7cc5b2a996030724c2e7ead83071"

URI_aarch64_nss_wrapper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss_wrapper-1.1.15-7.el10.aarch64.rpm;name=aarch64_nss_wrapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss_wrapper}"
SRC_URI[aarch64_nss_wrapper.sha256sum] = "10bf0a1c585b6260a2457f9c584bae5a47a64e9ee8b521f1a501fa94f2e5c58a"

URI_aarch64_nss_wrapper-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss_wrapper-libs-1.1.15-7.el10.aarch64.rpm;name=aarch64_nss_wrapper-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss_wrapper-libs}"
SRC_URI[aarch64_nss_wrapper-libs.sha256sum] = "1794c0d82f7913a60488e35bfd4ac7ab7c7d027c824a878dc90c02e745af229a"

RDEPENDS:nss_wrapper = " \
 cmake-filesystem \
 nss_wrapper-libs \
 perl-Getopt-Long \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:nss_wrapper-libs = " \
 glibc \
 "
