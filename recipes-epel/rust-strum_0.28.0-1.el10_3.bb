# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum"
PV = "0.28.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-strum+phf-devel \
 rust-strum+std-devel \
 rust-strum+strum_macros-devel \
 rust-strum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum-0.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f700a2bf6adb694b2dec3b67edb2be11f5324ee2b0780f0f750c9b1c7b99608"

URI_x86_64_v2_rust-strum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+default-devel-0.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+default-devel}"
SRC_URI[x86_64_v2_rust-strum+default-devel.sha256sum] = "2097fab21aa396f2351a6de71a55b50dfed6e73d73bbc76a10d3af82a5a4b1d4"

URI_x86_64_v2_rust-strum+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+derive-devel-0.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+derive-devel}"
SRC_URI[x86_64_v2_rust-strum+derive-devel.sha256sum] = "cd801da72a541b916884de94ff37301b60572a59ecb6d3469e35e175f2efc368"

URI_x86_64_v2_rust-strum+phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+phf-devel-0.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+phf-devel}"
SRC_URI[x86_64_v2_rust-strum+phf-devel.sha256sum] = "112b9c0c22bc4729c8c21e20a910ba6e79eec500b4c9a6d21e72cfc05b432635"

URI_x86_64_v2_rust-strum+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+std-devel-0.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+std-devel}"
SRC_URI[x86_64_v2_rust-strum+std-devel.sha256sum] = "7e4690b3d952474fc511e6d2cfef539af21c4a01cca9a0863a341c98aebceafe"

URI_x86_64_v2_rust-strum+strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+strum_macros-devel-0.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum+strum_macros-devel.sha256sum] = "6a0279f37b3b8189f85c07b6a9b175d4db1c2067b3b5f342b96f0838a362524b"

URI_x86_64_v2_rust-strum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum-devel-0.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum-devel}"
SRC_URI[x86_64_v2_rust-strum-devel.sha256sum] = "01f7f588172f1a9bb00a4be1a78a69facb24eaa956f22d66331198d3d89333e6"

URI_aarch64_rust-strum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+default-devel-0.28.0-1.el10_3.noarch.rpm;name=aarch64_rust-strum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+default-devel}"
SRC_URI[aarch64_rust-strum+default-devel.sha256sum] = "0eb458464c719025d06a4310b4f560790a574b252190060fead4c736b97d751e"

URI_aarch64_rust-strum+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+derive-devel-0.28.0-1.el10_3.noarch.rpm;name=aarch64_rust-strum+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+derive-devel}"
SRC_URI[aarch64_rust-strum+derive-devel.sha256sum] = "326ce6c6e1c2e12e39b043e5da5f4124ee0e91907d5164d1feec49df979247bf"

URI_aarch64_rust-strum+phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+phf-devel-0.28.0-1.el10_3.noarch.rpm;name=aarch64_rust-strum+phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+phf-devel}"
SRC_URI[aarch64_rust-strum+phf-devel.sha256sum] = "f2ddebc45440c8decd7a83f1476d01aad2b916b2aadcd70f97cd074a896ac08b"

URI_aarch64_rust-strum+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+std-devel-0.28.0-1.el10_3.noarch.rpm;name=aarch64_rust-strum+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+std-devel}"
SRC_URI[aarch64_rust-strum+std-devel.sha256sum] = "33e4fe01b7d8e8153a8240fb875862607aa7b6f01493ab0e7b1834b025b67d07"

URI_aarch64_rust-strum+strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+strum_macros-devel-0.28.0-1.el10_3.noarch.rpm;name=aarch64_rust-strum+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+strum_macros-devel}"
SRC_URI[aarch64_rust-strum+strum_macros-devel.sha256sum] = "7c80163b4921711d39da7206948c84ba876d57b0ce64c50ffbf1b27b455adc3b"

URI_aarch64_rust-strum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum-devel-0.28.0-1.el10_3.noarch.rpm;name=aarch64_rust-strum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum-devel}"
SRC_URI[aarch64_rust-strum-devel.sha256sum] = "b6a96bb5c544634e572e04ad3ac24fba35fe1f9aae3f0f3ec308641ef8696cbd"

RDEPENDS:rust-strum+default-devel = " \
 cargo \
 rust-strum+std-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+derive-devel = " \
 cargo \
 rust-strum+strum_macros-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+phf-devel = " \
 cargo \
 rust-phf+default-devel \
 rust-phf+macros-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+std-devel = " \
 cargo \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+strum_macros-devel = " \
 cargo \
 rust-strum-devel \
 rust-strum_macros+default-devel \
 "
RDEPENDS:rust-strum-devel = " \
 cargo \
 rust \
 "
