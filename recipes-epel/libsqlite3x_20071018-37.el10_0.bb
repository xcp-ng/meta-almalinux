# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsqlite3x"
PV = "20071018"
PR = "37.el10_0"
PACKAGES = " \
 libsq3 \
 libsq3-devel \
 libsqlite3x \
 libsqlite3x-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libsqlite3x-20071018-37.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81c1193f712ea9b299055565066ffa84d02e8ba18d6929090df9db9f90a36611"

URI_x86_64_v2_libsq3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsq3-20071018-37.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsq3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsq3}"
SRC_URI[x86_64_v2_libsq3.sha256sum] = "4362c0f3b90cd9675cb606676016d91ec3602d8fb5cc8b3639f9b18d41a3c0e2"

URI_x86_64_v2_libsq3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsq3-devel-20071018-37.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsq3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsq3-devel}"
SRC_URI[x86_64_v2_libsq3-devel.sha256sum] = "5f2cb9d299359436a5b22eed9095dbe54e0ee97a4bb5aaa95ae6076bb8a58c55"

URI_x86_64_v2_libsqlite3x = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsqlite3x-20071018-37.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsqlite3x;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsqlite3x}"
SRC_URI[x86_64_v2_libsqlite3x.sha256sum] = "bb6a38308fd77621dd78283420bc9ccd3ed86918323cb1339f505cf229a617ea"

URI_x86_64_v2_libsqlite3x-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsqlite3x-devel-20071018-37.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsqlite3x-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsqlite3x-devel}"
SRC_URI[x86_64_v2_libsqlite3x-devel.sha256sum] = "80b9aeb481aa801241570f7fa3e0a73442727ec0cf0548b2f099959202df534e"

URI_aarch64_libsq3 = "${EPEL_MIRROR}/aarch64/Packages/l/libsq3-20071018-37.el10_0.aarch64.rpm;name=aarch64_libsq3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsq3}"
SRC_URI[aarch64_libsq3.sha256sum] = "1b7d13c4ef3cacab271d7d7029cc38f42c12c960b000f5c9e3e7c4133a1b46dd"

URI_aarch64_libsq3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsq3-devel-20071018-37.el10_0.aarch64.rpm;name=aarch64_libsq3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsq3-devel}"
SRC_URI[aarch64_libsq3-devel.sha256sum] = "2dbfca9ac37221142be3fc018e8fa0ffbc1f25aff3f4525632dcaeffc12139c6"

URI_aarch64_libsqlite3x = "${EPEL_MIRROR}/aarch64/Packages/l/libsqlite3x-20071018-37.el10_0.aarch64.rpm;name=aarch64_libsqlite3x;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsqlite3x}"
SRC_URI[aarch64_libsqlite3x.sha256sum] = "8cc66e88a2067bbd89479ab397f493bbf437881e323b07e1f20b61aa82a09167"

URI_aarch64_libsqlite3x-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsqlite3x-devel-20071018-37.el10_0.aarch64.rpm;name=aarch64_libsqlite3x-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsqlite3x-devel}"
SRC_URI[aarch64_libsqlite3x-devel.sha256sum] = "1370a01a50530bd077036bb09c4e8d560ebc81bb317b22facda71241d76d9f5b"

RDEPENDS:libsq3 = " \
 glibc \
 libgcc \
 libstdc++ \
 sqlite-libs \
 "
RDEPENDS:libsq3-devel = " \
 libsq3 \
 pkgconf-pkg-config \
 sqlite-devel \
 "
RDEPENDS:libsqlite3x = " \
 glibc \
 libgcc \
 libstdc++ \
 sqlite-libs \
 "
RDEPENDS:libsqlite3x-devel = " \
 libsqlite3x \
 pkgconf-pkg-config \
 sqlite-devel \
 "
