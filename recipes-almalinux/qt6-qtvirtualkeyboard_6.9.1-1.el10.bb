# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtvirtualkeyboard"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtvirtualkeyboard \
 qt6-qtvirtualkeyboard-devel \
 qt6-qtvirtualkeyboard-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtvirtualkeyboard-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18f4a16e42a64d50259dbfb30823eed067ca8b7ed0ce93b40769eb8153fde3f8"

URI_x86_64_v2_qt6-qtvirtualkeyboard = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtvirtualkeyboard}"
SRC_URI[x86_64_v2_qt6-qtvirtualkeyboard.sha256sum] = "b6ae371ff034774b65cbeca09e5758c60f6851f05d4358ebeca5b8b62fb94d62"

URI_x86_64_v2_qt6-qtvirtualkeyboard-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-devel-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtvirtualkeyboard-devel}"
SRC_URI[x86_64_v2_qt6-qtvirtualkeyboard-devel.sha256sum] = "cb2c6c0743bde599d86b57a49856d5b9f247abc222d72f6c6fb34f73d066e7eb"

URI_x86_64_v2_qt6-qtvirtualkeyboard-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-examples-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtvirtualkeyboard-examples}"
SRC_URI[x86_64_v2_qt6-qtvirtualkeyboard-examples.sha256sum] = "d3f0bf017d4b246f33660e275ac813da826528eba9dde7737f60d72a69087db0"

URI_aarch64_qt6-qtvirtualkeyboard = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtvirtualkeyboard-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtvirtualkeyboard}"
SRC_URI[aarch64_qt6-qtvirtualkeyboard.sha256sum] = "4b47e1776001f1fe03f27aa449e7e8d49d7ec7adf54ba15bb7bc44b4fc1f5777"

URI_aarch64_qt6-qtvirtualkeyboard-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtvirtualkeyboard-devel-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtvirtualkeyboard-devel}"
SRC_URI[aarch64_qt6-qtvirtualkeyboard-devel.sha256sum] = "93f606c3c9e86cd33975a1b44b17f16e603d8d4f597e0c505a6ddad4be7ce69b"

URI_aarch64_qt6-qtvirtualkeyboard-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtvirtualkeyboard-examples-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtvirtualkeyboard-examples}"
SRC_URI[aarch64_qt6-qtvirtualkeyboard-examples.sha256sum] = "31b92d583fc7e3eba65b607bf4d8ca1c4e2e97f83f74ace289f81ef863403b3d"

RDEPENDS:qt6-qtvirtualkeyboard = " \
 glibc \
 hunspell \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:qt6-qtvirtualkeyboard-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtvirtualkeyboard \
 qt6-qtvirtualkeyboard-devel \
 "
RDEPENDS:qt6-qtvirtualkeyboard-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtvirtualkeyboard \
 "
