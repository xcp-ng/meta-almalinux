# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-CommonMark"
PV = "0.9.1"
PR = "18.el10_0"
PACKAGES = " \
 python-CommonMark-doc \
 python-CommonMark-utils \
 python3-CommonMark \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-CommonMark-0.9.1-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b54cff41d6c002b3f77ce212a54b0886902e9cf7f0b2df7d4dbfa14e5e2ca37"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-CommonMark-doc-0.9.1-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-CommonMark-doc;unpack=0"
SRC_URI[x86_64_v2_python-CommonMark-doc.sha256sum] = "efd0a80ee84d33acb124ed6b73c6bdb0a8be41b30d9d4995b647f8fb2d18c95b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-CommonMark-utils-0.9.1-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-CommonMark-utils;unpack=0"
SRC_URI[x86_64_v2_python-CommonMark-utils.sha256sum] = "b6a9913280a2ce865fff710ef85ea3f636cee40950a53e64d6c18d8423df9215"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-CommonMark-0.9.1-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-CommonMark;unpack=0"
SRC_URI[x86_64_v2_python3-CommonMark.sha256sum] = "4f5d86d7e3b662b0e8f335a0b2e06661d980a0434efdc34d05281b45aab17230"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-CommonMark-doc-0.9.1-18.el10_0.noarch.rpm;name=aarch64_python-CommonMark-doc;unpack=0"
SRC_URI[aarch64_python-CommonMark-doc.sha256sum] = "609e091c2f5ea6d6a60bdbf03ba550aee7dd76786fae2a8ae9562fe525ea931b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-CommonMark-utils-0.9.1-18.el10_0.noarch.rpm;name=aarch64_python-CommonMark-utils;unpack=0"
SRC_URI[aarch64_python-CommonMark-utils.sha256sum] = "d8b95d74d4e931a04c72d2460ecd14721e9c365851a83eb870209f0c8effb6a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-CommonMark-0.9.1-18.el10_0.noarch.rpm;name=aarch64_python3-CommonMark;unpack=0"
SRC_URI[aarch64_python3-CommonMark.sha256sum] = "694427020b30cf1191c59a1244477303cceee93b9f7c8308cd4f733a6179a4f7"

RDEPENDS:python-CommonMark-doc = " \
 "
RDEPENDS:python-CommonMark-utils = " \
 python3 \
 "
RDEPENDS:python3-CommonMark = " \
 python3 \
 "
