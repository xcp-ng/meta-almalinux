# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-proxy-ssl"
PV = "6.6"
PR = "1.el10_1"
PACKAGES = " \
 globus-gsi-proxy-ssl \
 globus-gsi-proxy-ssl-devel \
 globus-gsi-proxy-ssl-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-proxy-ssl-6.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8723acef69349cc9aad4107b2bf56c7b690c67f6471889b72e0a0f82659b208"

URI_x86_64_v2_globus-gsi-proxy-ssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-ssl-6.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-proxy-ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-ssl}"
SRC_URI[x86_64_v2_globus-gsi-proxy-ssl.sha256sum] = "dd3ad1add1a0031f72d18b3ec583f0413660fdf5341c5561ac422a23379b9db5"

URI_x86_64_v2_globus-gsi-proxy-ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-ssl-devel-6.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-proxy-ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-ssl-devel}"
SRC_URI[x86_64_v2_globus-gsi-proxy-ssl-devel.sha256sum] = "e8e2f39bf2fc5e5cf607f0b3f0a3cf9bbd701d6aed85ee6d3fcb37b4e26107ca"

URI_x86_64_v2_globus-gsi-proxy-ssl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-ssl-doc-6.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-proxy-ssl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-ssl-doc}"
SRC_URI[x86_64_v2_globus-gsi-proxy-ssl-doc.sha256sum] = "3a68366ee384e85ae0f6d11c01f8b66d4bebd380108d9b9a53f6d06effcc8080"

URI_aarch64_globus-gsi-proxy-ssl = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-ssl-6.6-1.el10_1.aarch64.rpm;name=aarch64_globus-gsi-proxy-ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-ssl}"
SRC_URI[aarch64_globus-gsi-proxy-ssl.sha256sum] = "962f560f4cf4a3a263ed5591938a5f2e2971d4c2500bba500d2a99ad3fc1f5ac"

URI_aarch64_globus-gsi-proxy-ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-ssl-devel-6.6-1.el10_1.aarch64.rpm;name=aarch64_globus-gsi-proxy-ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-ssl-devel}"
SRC_URI[aarch64_globus-gsi-proxy-ssl-devel.sha256sum] = "540dad311c758313552cf938abca43862e7d0ba4f4cfc1b915b69e3117a5ac7e"

URI_aarch64_globus-gsi-proxy-ssl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-ssl-doc-6.6-1.el10_1.noarch.rpm;name=aarch64_globus-gsi-proxy-ssl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-ssl-doc}"
SRC_URI[aarch64_globus-gsi-proxy-ssl-doc.sha256sum] = "3eaa593c5c110ef749f41fd5eb0d661fcac007a9e1c9c06334744efde13aaad2"

RDEPENDS:globus-gsi-proxy-ssl = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:globus-gsi-proxy-ssl-devel = " \
 globus-gsi-proxy-ssl \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-proxy-ssl-doc = " \
 "
