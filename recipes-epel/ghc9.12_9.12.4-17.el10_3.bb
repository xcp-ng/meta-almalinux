# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.12"
PV = "9.12.4"
PR = "17.el10_3"
PACKAGES:x86_64_v2 = " \
 ghc9.12 \
 ghc9.12-Cabal \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-doc \
 ghc9.12-Cabal-syntax \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-Cabal-syntax-doc \
 ghc9.12-array \
 ghc9.12-array-devel \
 ghc9.12-array-doc \
 ghc9.12-base \
 ghc9.12-base-devel \
 ghc9.12-base-doc \
 ghc9.12-binary \
 ghc9.12-binary-devel \
 ghc9.12-binary-doc \
 ghc9.12-bytestring \
 ghc9.12-bytestring-devel \
 ghc9.12-bytestring-doc \
 ghc9.12-compiler \
 ghc9.12-compiler-default \
 ghc9.12-containers \
 ghc9.12-containers-devel \
 ghc9.12-containers-doc \
 ghc9.12-deepseq \
 ghc9.12-deepseq-devel \
 ghc9.12-deepseq-doc \
 ghc9.12-devel \
 ghc9.12-directory \
 ghc9.12-directory-devel \
 ghc9.12-directory-doc \
 ghc9.12-doc \
 ghc9.12-doc-index \
 ghc9.12-exceptions \
 ghc9.12-exceptions-devel \
 ghc9.12-exceptions-doc \
 ghc9.12-file-io \
 ghc9.12-file-io-devel \
 ghc9.12-file-io-doc \
 ghc9.12-filepath \
 ghc9.12-filepath-devel \
 ghc9.12-filepath-doc \
 ghc9.12-filesystem \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-bignum-devel \
 ghc9.12-ghc-bignum-doc \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-doc \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-boot-th-doc \
 ghc9.12-ghc-compact \
 ghc9.12-ghc-compact-devel \
 ghc9.12-ghc-compact-doc \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-doc \
 ghc9.12-ghc-experimental \
 ghc9.12-ghc-experimental-devel \
 ghc9.12-ghc-experimental-doc \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghc-heap-doc \
 ghc9.12-ghc-platform \
 ghc9.12-ghc-platform-devel \
 ghc9.12-ghc-platform-doc \
 ghc9.12-ghc-toolchain \
 ghc9.12-ghc-toolchain-devel \
 ghc9.12-ghc-toolchain-doc \
 ghc9.12-ghci \
 ghc9.12-ghci-devel \
 ghc9.12-ghci-doc \
 ghc9.12-haddock-api \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-api-doc \
 ghc9.12-haddock-library \
 ghc9.12-haddock-library-devel \
 ghc9.12-haddock-library-doc \
 ghc9.12-hadrian \
 ghc9.12-haskeline \
 ghc9.12-haskeline-devel \
 ghc9.12-haskeline-doc \
 ghc9.12-hpc \
 ghc9.12-hpc-devel \
 ghc9.12-hpc-doc \
 ghc9.12-manual \
 ghc9.12-mtl \
 ghc9.12-mtl-devel \
 ghc9.12-mtl-doc \
 ghc9.12-os-string \
 ghc9.12-os-string-devel \
 ghc9.12-os-string-doc \
 ghc9.12-parsec \
 ghc9.12-parsec-devel \
 ghc9.12-parsec-doc \
 ghc9.12-pretty \
 ghc9.12-pretty-devel \
 ghc9.12-pretty-doc \
 ghc9.12-process \
 ghc9.12-process-devel \
 ghc9.12-process-doc \
 ghc9.12-semaphore-compat \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-semaphore-compat-doc \
 ghc9.12-stm \
 ghc9.12-stm-devel \
 ghc9.12-stm-doc \
 ghc9.12-template-haskell \
 ghc9.12-template-haskell-devel \
 ghc9.12-template-haskell-doc \
 ghc9.12-terminfo \
 ghc9.12-terminfo-devel \
 ghc9.12-terminfo-doc \
 ghc9.12-text \
 ghc9.12-text-devel \
 ghc9.12-text-doc \
 ghc9.12-time \
 ghc9.12-time-devel \
 ghc9.12-time-doc \
 ghc9.12-transformers \
 ghc9.12-transformers-devel \
 ghc9.12-transformers-doc \
 ghc9.12-unix \
 ghc9.12-unix-devel \
 ghc9.12-unix-doc \
 ghc9.12-xhtml \
 ghc9.12-xhtml-devel \
 ghc9.12-xhtml-doc \
"
PACKAGES:aarch64 = " \
 ghc9.12 \
 ghc9.12-Cabal \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-doc \
 ghc9.12-Cabal-prof \
 ghc9.12-Cabal-syntax \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-Cabal-syntax-doc \
 ghc9.12-Cabal-syntax-prof \
 ghc9.12-array \
 ghc9.12-array-devel \
 ghc9.12-array-doc \
 ghc9.12-array-prof \
 ghc9.12-base \
 ghc9.12-base-devel \
 ghc9.12-base-doc \
 ghc9.12-base-prof \
 ghc9.12-binary \
 ghc9.12-binary-devel \
 ghc9.12-binary-doc \
 ghc9.12-binary-prof \
 ghc9.12-bytestring \
 ghc9.12-bytestring-devel \
 ghc9.12-bytestring-doc \
 ghc9.12-bytestring-prof \
 ghc9.12-compiler \
 ghc9.12-compiler-default \
 ghc9.12-containers \
 ghc9.12-containers-devel \
 ghc9.12-containers-doc \
 ghc9.12-containers-prof \
 ghc9.12-deepseq \
 ghc9.12-deepseq-devel \
 ghc9.12-deepseq-doc \
 ghc9.12-deepseq-prof \
 ghc9.12-devel \
 ghc9.12-directory \
 ghc9.12-directory-devel \
 ghc9.12-directory-doc \
 ghc9.12-directory-prof \
 ghc9.12-doc \
 ghc9.12-doc-index \
 ghc9.12-exceptions \
 ghc9.12-exceptions-devel \
 ghc9.12-exceptions-doc \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io \
 ghc9.12-file-io-devel \
 ghc9.12-file-io-doc \
 ghc9.12-file-io-prof \
 ghc9.12-filepath \
 ghc9.12-filepath-devel \
 ghc9.12-filepath-doc \
 ghc9.12-filepath-prof \
 ghc9.12-filesystem \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-bignum-devel \
 ghc9.12-ghc-bignum-doc \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-doc \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-boot-th-doc \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-compact \
 ghc9.12-ghc-compact-devel \
 ghc9.12-ghc-compact-doc \
 ghc9.12-ghc-compact-prof \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-doc \
 ghc9.12-ghc-experimental \
 ghc9.12-ghc-experimental-devel \
 ghc9.12-ghc-experimental-doc \
 ghc9.12-ghc-experimental-prof \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghc-heap-doc \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform \
 ghc9.12-ghc-platform-devel \
 ghc9.12-ghc-platform-doc \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghc-prof \
 ghc9.12-ghc-toolchain \
 ghc9.12-ghc-toolchain-devel \
 ghc9.12-ghc-toolchain-doc \
 ghc9.12-ghc-toolchain-prof \
 ghc9.12-ghci \
 ghc9.12-ghci-devel \
 ghc9.12-ghci-doc \
 ghc9.12-ghci-prof \
 ghc9.12-haddock-api \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-api-doc \
 ghc9.12-haddock-api-prof \
 ghc9.12-haddock-library \
 ghc9.12-haddock-library-devel \
 ghc9.12-haddock-library-doc \
 ghc9.12-haddock-library-prof \
 ghc9.12-hadrian \
 ghc9.12-haskeline \
 ghc9.12-haskeline-devel \
 ghc9.12-haskeline-doc \
 ghc9.12-haskeline-prof \
 ghc9.12-hpc \
 ghc9.12-hpc-devel \
 ghc9.12-hpc-doc \
 ghc9.12-hpc-prof \
 ghc9.12-manual \
 ghc9.12-mtl \
 ghc9.12-mtl-devel \
 ghc9.12-mtl-doc \
 ghc9.12-mtl-prof \
 ghc9.12-os-string \
 ghc9.12-os-string-devel \
 ghc9.12-os-string-doc \
 ghc9.12-os-string-prof \
 ghc9.12-parsec \
 ghc9.12-parsec-devel \
 ghc9.12-parsec-doc \
 ghc9.12-parsec-prof \
 ghc9.12-pretty \
 ghc9.12-pretty-devel \
 ghc9.12-pretty-doc \
 ghc9.12-pretty-prof \
 ghc9.12-process \
 ghc9.12-process-devel \
 ghc9.12-process-doc \
 ghc9.12-process-prof \
 ghc9.12-prof \
 ghc9.12-semaphore-compat \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-semaphore-compat-doc \
 ghc9.12-semaphore-compat-prof \
 ghc9.12-stm \
 ghc9.12-stm-devel \
 ghc9.12-stm-doc \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell \
 ghc9.12-template-haskell-devel \
 ghc9.12-template-haskell-doc \
 ghc9.12-template-haskell-prof \
 ghc9.12-terminfo \
 ghc9.12-terminfo-devel \
 ghc9.12-terminfo-doc \
 ghc9.12-terminfo-prof \
 ghc9.12-text \
 ghc9.12-text-devel \
 ghc9.12-text-doc \
 ghc9.12-text-prof \
 ghc9.12-time \
 ghc9.12-time-devel \
 ghc9.12-time-doc \
 ghc9.12-time-prof \
 ghc9.12-transformers \
 ghc9.12-transformers-devel \
 ghc9.12-transformers-doc \
 ghc9.12-transformers-prof \
 ghc9.12-unix \
 ghc9.12-unix-devel \
 ghc9.12-unix-doc \
 ghc9.12-unix-prof \
 ghc9.12-xhtml \
 ghc9.12-xhtml-devel \
 ghc9.12-xhtml-doc \
 ghc9.12-xhtml-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.12-9.12.4-17.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed235fc1387cece85fb251eadac31c4e28b142cfc8e987706289ebf34cbbf10b"

URI_x86_64_v2_ghc9.12 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12}"
SRC_URI[x86_64_v2_ghc9.12.sha256sum] = "ea69342bd208aab904485d4f258e080e740e1d7494c13d5ca43bd4a2677b3133"

URI_x86_64_v2_ghc9.12-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-3.14.2.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal}"
SRC_URI[x86_64_v2_ghc9.12-Cabal.sha256sum] = "b34ac99c83ef1f119369d15f67641afefe6d19a03764ab25f1995c3ff54fa1be"

URI_x86_64_v2_ghc9.12-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-devel-3.14.2.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-devel.sha256sum] = "a7a13c06b4ea2c1860454d6a08f2c366c5bb40ef8a38c7869bfd70f7752db87f"

URI_x86_64_v2_ghc9.12-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-doc-3.14.2.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-doc.sha256sum] = "f102ec3ece096e38db035aebf1d00f665eb23d0cbb8c49e5a7c42e9a68f6537d"

URI_x86_64_v2_ghc9.12-Cabal-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-syntax-3.14.2.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-syntax}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-syntax.sha256sum] = "c0a00f5b202121c52126356e68f54e30560661c1b671fbd9b72abbc3b83c4596"

URI_x86_64_v2_ghc9.12-Cabal-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-syntax-devel-3.14.2.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-syntax-devel}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-syntax-devel.sha256sum] = "0b20fb4421c2a62d00ce48799b5652a5205569fc766649e1a200c654b5cb903c"

URI_x86_64_v2_ghc9.12-Cabal-syntax-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-syntax-doc-3.14.2.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-syntax-doc}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-syntax-doc.sha256sum] = "239c54cc88b115731012e0242930a7fb36c40d9084bf90fce98e2f17cfcc6070"

URI_x86_64_v2_ghc9.12-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-array-0.5.8.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-array}"
SRC_URI[x86_64_v2_ghc9.12-array.sha256sum] = "d69becbb85a4e5c45a9752c83b82487b6d4ae075ac64ae710a350ae494bfe238"

URI_x86_64_v2_ghc9.12-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-array-devel-0.5.8.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-array-devel}"
SRC_URI[x86_64_v2_ghc9.12-array-devel.sha256sum] = "3831fdedb8885a27b9f5639dc1e06f17e528fe5464899e61dfc0b8f1ad2a143e"

URI_x86_64_v2_ghc9.12-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-array-doc-0.5.8.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-array-doc}"
SRC_URI[x86_64_v2_ghc9.12-array-doc.sha256sum] = "f276ebb301335a13378c31a219142057c6c84b7e138a214122579b92ede8a63a"

URI_x86_64_v2_ghc9.12-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-base-4.21.2.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-base}"
SRC_URI[x86_64_v2_ghc9.12-base.sha256sum] = "00804dbbe521c53f72d0f2cc7f494e6e29bcbdafb0835f936ec729f81f5df59b"

URI_x86_64_v2_ghc9.12-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-base-devel-4.21.2.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-base-devel}"
SRC_URI[x86_64_v2_ghc9.12-base-devel.sha256sum] = "c841eea9f1daf9503806daa093ff7ccd2894e0fd41c759004e95222c84e53ecc"

URI_x86_64_v2_ghc9.12-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-base-doc-4.21.2.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-base-doc}"
SRC_URI[x86_64_v2_ghc9.12-base-doc.sha256sum] = "fe457a0874dbbec53d284a14ec05707304ef216acf0bcd911bca35ab4abc4f07"

URI_x86_64_v2_ghc9.12-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-binary-0.8.9.3-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-binary}"
SRC_URI[x86_64_v2_ghc9.12-binary.sha256sum] = "262f0ef4016bf95410da5e9694bf859b11f8af551da613f88d1dfaae6cf46d25"

URI_x86_64_v2_ghc9.12-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-binary-devel-0.8.9.3-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-binary-devel}"
SRC_URI[x86_64_v2_ghc9.12-binary-devel.sha256sum] = "c13db6d6914a08fbb0859f135df0727fb1504020265db8374f535eaad59bcbb1"

URI_x86_64_v2_ghc9.12-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-binary-doc-0.8.9.3-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-binary-doc}"
SRC_URI[x86_64_v2_ghc9.12-binary-doc.sha256sum] = "fd6ab1eca1dce6600d4c7d3c2ccf3d0087ffa37b4f598571a300125f177405e7"

URI_x86_64_v2_ghc9.12-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-bytestring-0.12.2.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-bytestring}"
SRC_URI[x86_64_v2_ghc9.12-bytestring.sha256sum] = "6f08f979d3161c59e806e2ed4ad15620e94266fef8006b68d89f54e9ab9da73d"

URI_x86_64_v2_ghc9.12-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-bytestring-devel-0.12.2.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.12-bytestring-devel.sha256sum] = "3fa31100a81996419aa53a48cdce2ec79cd58f9498d99837a44baf239b7e151a"

URI_x86_64_v2_ghc9.12-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-bytestring-doc-0.12.2.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.12-bytestring-doc.sha256sum] = "294b3bcf76b54c8d1e95c8051a1ddaa407af37f5f29678b2aedafeb78f61de30"

URI_x86_64_v2_ghc9.12-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-compiler-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-compiler}"
SRC_URI[x86_64_v2_ghc9.12-compiler.sha256sum] = "c9ab8d069235245b70dfcc6598772bffd542828a9ded457cfcb2789fac244777"

URI_x86_64_v2_ghc9.12-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-compiler-default-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-compiler-default}"
SRC_URI[x86_64_v2_ghc9.12-compiler-default.sha256sum] = "2347ec684ed15c7f167a05ffb1aa2a07775c2d3ee1bc046ca51d3d55f3d3aab4"

URI_x86_64_v2_ghc9.12-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-containers-0.7-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-containers}"
SRC_URI[x86_64_v2_ghc9.12-containers.sha256sum] = "c444844ad58e22af158d33086bf53d8eac3aa64ae4cf4e2b2a01ddfe904f6c5e"

URI_x86_64_v2_ghc9.12-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-containers-devel-0.7-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-containers-devel}"
SRC_URI[x86_64_v2_ghc9.12-containers-devel.sha256sum] = "a980bbdedd5d63f02162c8831b2bf76c4e02ccf22162f1eec6f69e1a4640107c"

URI_x86_64_v2_ghc9.12-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-containers-doc-0.7-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-containers-doc}"
SRC_URI[x86_64_v2_ghc9.12-containers-doc.sha256sum] = "99fc2ae45de58d16bad4ba1bf8c88516682259ecd2923551df92b66675f90cf8"

URI_x86_64_v2_ghc9.12-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-deepseq-1.5.1.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-deepseq}"
SRC_URI[x86_64_v2_ghc9.12-deepseq.sha256sum] = "da9267964950166383d8db00fe06474274d9ef85d91b34ebdf066f352a3f100a"

URI_x86_64_v2_ghc9.12-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-deepseq-devel-1.5.1.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.12-deepseq-devel.sha256sum] = "e55817734a617b83c05c88df0958f714344a623d602c42fc58c549f9e24bea7b"

URI_x86_64_v2_ghc9.12-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-deepseq-doc-1.5.1.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.12-deepseq-doc.sha256sum] = "fd78683cc7d2e0f8135d27038f1f41e1bd7623190cf7721aeaef1c0e8e1de5e3"

URI_x86_64_v2_ghc9.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-devel-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-devel}"
SRC_URI[x86_64_v2_ghc9.12-devel.sha256sum] = "f394e2b742bf44f3318ce495834fcb4868c872cf8b5fe95e310c56365f35fe8b"

URI_x86_64_v2_ghc9.12-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-directory-1.3.10.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-directory}"
SRC_URI[x86_64_v2_ghc9.12-directory.sha256sum] = "b01c2386fbe9fb8c6afb2e898deb059e7380f99c3b2d173359c00b67b2c6b6d0"

URI_x86_64_v2_ghc9.12-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-directory-devel-1.3.10.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-directory-devel}"
SRC_URI[x86_64_v2_ghc9.12-directory-devel.sha256sum] = "9072e2d3acc88af0ef81323f20863d946c0533af52ab54c6886be14c789afa7c"

URI_x86_64_v2_ghc9.12-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-directory-doc-1.3.10.1-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-directory-doc}"
SRC_URI[x86_64_v2_ghc9.12-directory-doc.sha256sum] = "43f079e85fa7a17bd8ccd9b821f30a5058c361aa47f940fd71ba59a37887440e"

URI_x86_64_v2_ghc9.12-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-doc-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-doc}"
SRC_URI[x86_64_v2_ghc9.12-doc.sha256sum] = "3656f73089be8ade361f4149ae4f83960a97b17ef1ff94ec5a51f656ca5556d3"

URI_x86_64_v2_ghc9.12-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-doc-index-9.12.4-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-doc-index}"
SRC_URI[x86_64_v2_ghc9.12-doc-index.sha256sum] = "cc6ea6a489a99825a1cc0bf1651a8a7067a2a61675d6484c5b25c039535f14c1"

URI_x86_64_v2_ghc9.12-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-exceptions-0.10.12-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-exceptions}"
SRC_URI[x86_64_v2_ghc9.12-exceptions.sha256sum] = "302045cc0005a8d6391d6aefdc931af0a9333de93a8855e41a4ccd9966bbae1c"

URI_x86_64_v2_ghc9.12-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-exceptions-devel-0.10.12-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.12-exceptions-devel.sha256sum] = "030c2b8d64245b002b73980a29ec52227445c80a99304a0e5dffcd83fc38daf4"

URI_x86_64_v2_ghc9.12-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-exceptions-doc-0.10.12-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.12-exceptions-doc.sha256sum] = "c55e77e93d64cb85bf98bffd9dabd37ce6c90293cf31d12f027456216ec3bec6"

URI_x86_64_v2_ghc9.12-file-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-file-io-0.1.6-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-file-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-file-io}"
SRC_URI[x86_64_v2_ghc9.12-file-io.sha256sum] = "309d10281229fa672154de026c3eb0324700a7ac363f6d676d5056add8fdb5ff"

URI_x86_64_v2_ghc9.12-file-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-file-io-devel-0.1.6-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-file-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-file-io-devel}"
SRC_URI[x86_64_v2_ghc9.12-file-io-devel.sha256sum] = "62a88c3641621bdb9e6b97e96846d23233bb658c910a9529feca7210afaa67cd"

URI_x86_64_v2_ghc9.12-file-io-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-file-io-doc-0.1.6-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-file-io-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-file-io-doc}"
SRC_URI[x86_64_v2_ghc9.12-file-io-doc.sha256sum] = "eaf2c6ea5e0ce014fbac2a5f768fc96d97548a13b686aff601b64043a90afe36"

URI_x86_64_v2_ghc9.12-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filepath-1.5.5.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filepath}"
SRC_URI[x86_64_v2_ghc9.12-filepath.sha256sum] = "852960e6f1d0368bd24a9c056c678a2aebaeada291a282a02e0a700d78557c7e"

URI_x86_64_v2_ghc9.12-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filepath-devel-1.5.5.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.12-filepath-devel.sha256sum] = "c7c620648a250a5d2ae28b281a7510a0c1cff9ca78582da74b5f03ad24e59f93"

URI_x86_64_v2_ghc9.12-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filepath-doc-1.5.5.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.12-filepath-doc.sha256sum] = "94bd8000637ca1a2ee139b7b65cbb2a9239e33a882b1e602507145dd7e2854ef"

URI_x86_64_v2_ghc9.12-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filesystem-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filesystem}"
SRC_URI[x86_64_v2_ghc9.12-filesystem.sha256sum] = "44d2fa8040e866198df97eb7e76ee7c955e3dc502ea70c6d15d0b3407750be06"

URI_x86_64_v2_ghc9.12-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc}"
SRC_URI[x86_64_v2_ghc9.12-ghc.sha256sum] = "7f0413ab2666391b1ad48f7316d4a8648c40c61eefd362808c0778317dff563a"

URI_x86_64_v2_ghc9.12-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-bignum-1.3-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.12-ghc-bignum.sha256sum] = "4c828f8571b0b43c23bc606b597af89c4cce9f8d7f7e028bfd451406b664ada5"

URI_x86_64_v2_ghc9.12-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-bignum-devel-1.3-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-bignum-devel.sha256sum] = "e1b2e10053a62024d7de8694f8dc538e1df06ab066696f6bb3e73385ce577c6f"

URI_x86_64_v2_ghc9.12-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-bignum-doc-1.3-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-bignum-doc.sha256sum] = "be9b006642f3b1a439ddf635149fe1aad2bf50d6d77ea2ca0b5eea85ff6c93d8"

URI_x86_64_v2_ghc9.12-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot.sha256sum] = "31a11198dbaa4eab6b86682e49369f0486ca7e0660d853d5dedbfc8154eb207f"

URI_x86_64_v2_ghc9.12-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-devel-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-devel.sha256sum] = "55dd7f12922aa03d6ffcd7eea62fe2d700378a65c00f1e2dd2a17e78b1f88025"

URI_x86_64_v2_ghc9.12-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-doc-9.12.4-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-doc.sha256sum] = "53f4f7191144df45dacc76c3dbdc424c7c947dca811a7915620df88f43865540"

URI_x86_64_v2_ghc9.12-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-th-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-th.sha256sum] = "c24c5a64ef0d8369626af25dd90679b535f1b93836c9c2a247c6c7186dacb641"

URI_x86_64_v2_ghc9.12-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-th-devel-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-th-devel.sha256sum] = "f9b7a66e56713c299890895ab94c58029cb09fda646972a5b791e17a75c7e971"

URI_x86_64_v2_ghc9.12-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-th-doc-9.12.4-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-th-doc.sha256sum] = "dd2794667d056ff8462dd57cbaf44834a95d5e6ce2438ef912b136a7b7ea6063"

URI_x86_64_v2_ghc9.12-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-compact-0.1.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.12-ghc-compact.sha256sum] = "84f99c9860246c8071df9fa84b65b598eb4756d352cd7270500c571d976d6d42"

URI_x86_64_v2_ghc9.12-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-compact-devel-0.1.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-compact-devel.sha256sum] = "e0a03c7c52f778a236d6c6bf787336b5cc6a76d28aaf5262c78f9e9d63c26749"

URI_x86_64_v2_ghc9.12-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-compact-doc-0.1.0.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-compact-doc.sha256sum] = "dc5466f4b367ea67259ad86880e4f345dd38579e9298d2978955bfe6c082e99d"

URI_x86_64_v2_ghc9.12-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-devel-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-devel.sha256sum] = "9fa2a4b65d79f8cdee28ebea41627e8a1d239617387d38e6e02b8252f2ed348e"

URI_x86_64_v2_ghc9.12-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-doc-9.12.4-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-doc.sha256sum] = "84a961fcdf77b3f804ff681227cbdfacdea2d23585358aaaddbc6226a674bbb0"

URI_x86_64_v2_ghc9.12-ghc-experimental = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-experimental-9.1204.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-experimental}"
SRC_URI[x86_64_v2_ghc9.12-ghc-experimental.sha256sum] = "134f49626b37fb5cef5103b29dc4159389762f9a763427aa54f54a4a34791a1d"

URI_x86_64_v2_ghc9.12-ghc-experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-experimental-devel-9.1204.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-experimental-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-experimental-devel.sha256sum] = "91d4baf3cdc1141cee5690689d8250c8bdd716b806683a2eee9eecec53df6715"

URI_x86_64_v2_ghc9.12-ghc-experimental-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-experimental-doc-9.1204.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-experimental-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-experimental-doc.sha256sum] = "8a2e88e14624a1d1d8803117bf2950017cc02456354aaa8226b0d23e7a407995"

URI_x86_64_v2_ghc9.12-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-heap-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.12-ghc-heap.sha256sum] = "01eed7ac9f3a7cdf63d8c880fe2bb0b893748d60671df3b5e02c3a3a89251af9"

URI_x86_64_v2_ghc9.12-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-heap-devel-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-heap-devel.sha256sum] = "958131c4094986b2c453f73db396ea615c2eaa5e5bf00922e6ce7260fcce1dfa"

URI_x86_64_v2_ghc9.12-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-heap-doc-9.12.4-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-heap-doc.sha256sum] = "588d3af02f7fa1850df8e55c8af2f74da2c703d95efbae094bd848858b6367dd"

URI_x86_64_v2_ghc9.12-ghc-platform = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-platform-0.1.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-platform}"
SRC_URI[x86_64_v2_ghc9.12-ghc-platform.sha256sum] = "4fb1c06a9d8847f9f1fd10c118aa3e2275cf65da9fbbec14a9c6c5c96e3140ab"

URI_x86_64_v2_ghc9.12-ghc-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-platform-devel-0.1.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-platform-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-platform-devel.sha256sum] = "6c0e83f9d56acd289bdc4643f25b04912bed1198c3d2f8e3b130c67900ab28df"

URI_x86_64_v2_ghc9.12-ghc-platform-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-platform-doc-0.1.0.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-platform-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-platform-doc.sha256sum] = "5ea37ef2dfe5647908589dbea9a79df014021a1a8f8ff9fbbe3896ce5cdac8d7"

URI_x86_64_v2_ghc9.12-ghc-toolchain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-toolchain-0.1.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-toolchain}"
SRC_URI[x86_64_v2_ghc9.12-ghc-toolchain.sha256sum] = "a9533c28acc3ad82f9595950c6b4680a3a6c8b18accd257c9150fa5531d8f950"

URI_x86_64_v2_ghc9.12-ghc-toolchain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-toolchain-devel-0.1.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-toolchain-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-toolchain-devel.sha256sum] = "4bab51e4865ee7aaed5782360ad0c825d30bd76d99358599a389b65264e42757"

URI_x86_64_v2_ghc9.12-ghc-toolchain-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-toolchain-doc-0.1.0.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-toolchain-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-toolchain-doc.sha256sum] = "15e3cd6364d0affe7c4d0440a743cc610544f36e1cb2cb390d4b6619743d82e1"

URI_x86_64_v2_ghc9.12-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghci-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghci}"
SRC_URI[x86_64_v2_ghc9.12-ghci.sha256sum] = "b23f304fcc0fec6c3a47259612958224c395cc4d13ead800fd6e2be12817d064"

URI_x86_64_v2_ghc9.12-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghci-devel-9.12.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghci-devel.sha256sum] = "55cc7e198bf8ffea779fcc67d40920eefaff7bd251d2d1d762bebfbe5c77c9f7"

URI_x86_64_v2_ghc9.12-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghci-doc-9.12.4-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghci-doc.sha256sum] = "ffd0fe5a95b34e9600fe2fb7f4fba3c8d746431a7e4e5444ceb58525df7bde1b"

URI_x86_64_v2_ghc9.12-haddock-api = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-api-2.32.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-api}"
SRC_URI[x86_64_v2_ghc9.12-haddock-api.sha256sum] = "3d15cbe4c3a8c2f0c10061dae0caee1fd79377c401255f08252d45f85bc4a3a7"

URI_x86_64_v2_ghc9.12-haddock-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-api-devel-2.32.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-api-devel}"
SRC_URI[x86_64_v2_ghc9.12-haddock-api-devel.sha256sum] = "6609f454a1c61d8907ca624236e42cadaa306526cb80aec6aa1c3bf4a7854b46"

URI_x86_64_v2_ghc9.12-haddock-api-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-api-doc-2.32.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-haddock-api-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-api-doc}"
SRC_URI[x86_64_v2_ghc9.12-haddock-api-doc.sha256sum] = "9521f62e80a20617cc17b401f1ce834e26b06e28d9b51b4d30ac832ec4057da9"

URI_x86_64_v2_ghc9.12-haddock-library = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-library-1.11.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-library;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-library}"
SRC_URI[x86_64_v2_ghc9.12-haddock-library.sha256sum] = "54eef0542b84a4ab6dbfab69b84395f0b6a54065bbe2826a452c7cb887967d1a"

URI_x86_64_v2_ghc9.12-haddock-library-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-library-devel-1.11.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-library-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-library-devel}"
SRC_URI[x86_64_v2_ghc9.12-haddock-library-devel.sha256sum] = "298b559c1b822ae4b9a0798d9d821b002558ce7385e1257a1980391fe80e9733"

URI_x86_64_v2_ghc9.12-haddock-library-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-library-doc-1.11.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-haddock-library-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-library-doc}"
SRC_URI[x86_64_v2_ghc9.12-haddock-library-doc.sha256sum] = "0a608515ab5d75131829cbb66aa565687f0dff6474bdb1f6eae05491b0ee6b5d"

URI_x86_64_v2_ghc9.12-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hadrian-0.1.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hadrian}"
SRC_URI[x86_64_v2_ghc9.12-hadrian.sha256sum] = "5effd431e7b18f907534c8ddd6ec48af921cc01b3a03a6b87b77ef55c3ac329e"

URI_x86_64_v2_ghc9.12-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haskeline-0.8.4.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haskeline}"
SRC_URI[x86_64_v2_ghc9.12-haskeline.sha256sum] = "2fcd02b039c5b5b7cd74c74fa53c3e7365e6b3ea6343f351c166e7ff9ab5357c"

URI_x86_64_v2_ghc9.12-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haskeline-devel-0.8.4.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.12-haskeline-devel.sha256sum] = "a3579cfd322fb751a4cc242463249e38165323d41bd3c6d1a0df0b86c19629a8"

URI_x86_64_v2_ghc9.12-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haskeline-doc-0.8.4.1-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.12-haskeline-doc.sha256sum] = "3068ae912ceacad8761ae0e0d7637c29f748796b24c29aee1b5ec1af98027014"

URI_x86_64_v2_ghc9.12-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hpc-0.7.0.2-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hpc}"
SRC_URI[x86_64_v2_ghc9.12-hpc.sha256sum] = "86182936d979b355898a1ed76e558717f8ecd0db86d929592fa8d7d1c1e87e29"

URI_x86_64_v2_ghc9.12-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hpc-devel-0.7.0.2-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.12-hpc-devel.sha256sum] = "eee376eddc7c8ed29d33111e1a6c3299e2191bc023d2ff574c57ba23c6bb8bbc"

URI_x86_64_v2_ghc9.12-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hpc-doc-0.7.0.2-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.12-hpc-doc.sha256sum] = "602fdac65af977be1383627a925f1dcfecd9d9f8d0361d252368b13d1ae81f5a"

URI_x86_64_v2_ghc9.12-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-manual-9.12.4-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-manual}"
SRC_URI[x86_64_v2_ghc9.12-manual.sha256sum] = "c39f5e9ef0a40bede4a45fe09d648579ab28391aed9e7ce8ddd73a00aa9ae656"

URI_x86_64_v2_ghc9.12-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-mtl-2.3.2-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-mtl}"
SRC_URI[x86_64_v2_ghc9.12-mtl.sha256sum] = "3dda6980f0ae9c721691bcb5bfd87733990c8fb437683dad8b2d6f65a7321c22"

URI_x86_64_v2_ghc9.12-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-mtl-devel-2.3.2-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.12-mtl-devel.sha256sum] = "de5e4c65fd0b99cd09f3f50a8f107a6adcbc32ccc855a553ec43e6ede6b7cab9"

URI_x86_64_v2_ghc9.12-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-mtl-doc-2.3.2-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.12-mtl-doc.sha256sum] = "517616d5c2a5ccb5d2d6b965518bf582bda644d648c494fb00857aa38ad1857a"

URI_x86_64_v2_ghc9.12-os-string = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-os-string-2.0.10-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-os-string;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-os-string}"
SRC_URI[x86_64_v2_ghc9.12-os-string.sha256sum] = "3043dd388ffcb8248f3cabbfd3d14f3432529332170eaf3eaf376c0a2976464a"

URI_x86_64_v2_ghc9.12-os-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-os-string-devel-2.0.10-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-os-string-devel}"
SRC_URI[x86_64_v2_ghc9.12-os-string-devel.sha256sum] = "d5e65760bfdec92aff972e6f3491937056c4265fcbe4ef41392c3739bfa2ebe8"

URI_x86_64_v2_ghc9.12-os-string-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-os-string-doc-2.0.10-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-os-string-doc}"
SRC_URI[x86_64_v2_ghc9.12-os-string-doc.sha256sum] = "e211ad43388122e099eb8238dfb172f5b552ebaa2a28d0790d433fe1e58fa28f"

URI_x86_64_v2_ghc9.12-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-parsec-3.1.18.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-parsec}"
SRC_URI[x86_64_v2_ghc9.12-parsec.sha256sum] = "88544f2874f285e5580c97850f11cd69aa6c5de7f1e1c554e28ef9ea86ca02eb"

URI_x86_64_v2_ghc9.12-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-parsec-devel-3.1.18.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.12-parsec-devel.sha256sum] = "b7bd0950accf2699376efd3f3b4d11ba198f93203a58b1dda0e88d89dbd5c6df"

URI_x86_64_v2_ghc9.12-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-parsec-doc-3.1.18.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.12-parsec-doc.sha256sum] = "080b245cf9319737ef622f2ff479f10117e9c1391ba0600c7296ab5fc82eafc6"

URI_x86_64_v2_ghc9.12-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-pretty-1.1.3.6-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-pretty}"
SRC_URI[x86_64_v2_ghc9.12-pretty.sha256sum] = "196dfdc859b12a3e7f6a3910d9e4edfbed669bf97d8e61f65dc1f1f4c7ec922c"

URI_x86_64_v2_ghc9.12-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-pretty-devel-1.1.3.6-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.12-pretty-devel.sha256sum] = "9e89a98123bb85e2af045f31803d58b4196dbf4179064a26a6b83a3409a2f640"

URI_x86_64_v2_ghc9.12-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-pretty-doc-1.1.3.6-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.12-pretty-doc.sha256sum] = "c354e36e86192556fdda91a1fdf007cf6d5bbdac43d612aa9b43f51fd6ff4584"

URI_x86_64_v2_ghc9.12-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-process-1.6.26.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-process}"
SRC_URI[x86_64_v2_ghc9.12-process.sha256sum] = "381378e18d0a97e25e5d7b71a8296cbadfb6b8fb74a50932287664a1e827f551"

URI_x86_64_v2_ghc9.12-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-process-devel-1.6.26.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-process-devel}"
SRC_URI[x86_64_v2_ghc9.12-process-devel.sha256sum] = "1abf3464fc76206a6b26dedd67f3a39a5cabd3882d0963f1a0d483191aaeaf17"

URI_x86_64_v2_ghc9.12-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-process-doc-1.6.26.1-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-process-doc}"
SRC_URI[x86_64_v2_ghc9.12-process-doc.sha256sum] = "aae85d5c11fd66ddbf656274f5ce2d5282360710c3090c6e2859413a01abe438"

URI_x86_64_v2_ghc9.12-semaphore-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-semaphore-compat-1.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-semaphore-compat}"
SRC_URI[x86_64_v2_ghc9.12-semaphore-compat.sha256sum] = "4c6e786bfa2f93fd8276e3e2a5180d07a00574b7324493def2b851334ad62439"

URI_x86_64_v2_ghc9.12-semaphore-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-semaphore-compat-devel-1.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-semaphore-compat-devel}"
SRC_URI[x86_64_v2_ghc9.12-semaphore-compat-devel.sha256sum] = "5476f98cbe584853502dfc7e5b8b66f08a150e8be8874b02d7397f4132fc17ca"

URI_x86_64_v2_ghc9.12-semaphore-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-semaphore-compat-doc-1.0.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-semaphore-compat-doc}"
SRC_URI[x86_64_v2_ghc9.12-semaphore-compat-doc.sha256sum] = "c92b8690e12b3e647048b10922b356cbb1c3161676620632a647701e4230a1b7"

URI_x86_64_v2_ghc9.12-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-stm-2.5.3.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-stm}"
SRC_URI[x86_64_v2_ghc9.12-stm.sha256sum] = "b93b0a67bd9faa1ecb8a81a63018626907c0437cdb2c3c9d2182a6071d0c970c"

URI_x86_64_v2_ghc9.12-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-stm-devel-2.5.3.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-stm-devel}"
SRC_URI[x86_64_v2_ghc9.12-stm-devel.sha256sum] = "d2f8c6edbc74632d7c4245e58b2016b078bf70fcfbaad2817d5ed93272734f28"

URI_x86_64_v2_ghc9.12-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-stm-doc-2.5.3.1-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-stm-doc}"
SRC_URI[x86_64_v2_ghc9.12-stm-doc.sha256sum] = "bfa51ca29d0eefb292d2e8c3883745d2ccb1b81718cc21694946b63cac5d90eb"

URI_x86_64_v2_ghc9.12-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-template-haskell-2.23.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-template-haskell}"
SRC_URI[x86_64_v2_ghc9.12-template-haskell.sha256sum] = "04e858c0355e00d6b5df99aa25d1b88c543f40a7b6929eb1d3ae4fff29660b43"

URI_x86_64_v2_ghc9.12-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-template-haskell-devel-2.23.0.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.12-template-haskell-devel.sha256sum] = "d5813fa9b79ff7934ee175ac18c5a5477cf1b252d9d9847b219a7e4cf1353369"

URI_x86_64_v2_ghc9.12-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-template-haskell-doc-2.23.0.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.12-template-haskell-doc.sha256sum] = "b2514437df24985055a6f5c537b4a871808ae6167323f358b363273834c0e50b"

URI_x86_64_v2_ghc9.12-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-terminfo-0.4.1.7-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-terminfo}"
SRC_URI[x86_64_v2_ghc9.12-terminfo.sha256sum] = "de5d9401bbe4ee1d9ce3276ca9f88b0b76f4a9a3c402b584fde2c3f4eca8e3ef"

URI_x86_64_v2_ghc9.12-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-terminfo-devel-0.4.1.7-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.12-terminfo-devel.sha256sum] = "ebecf03fd9d4d0b398792bb76e63dec379a68a1c586ef15b77196677c32061b8"

URI_x86_64_v2_ghc9.12-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-terminfo-doc-0.4.1.7-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.12-terminfo-doc.sha256sum] = "2b85e4794a5143b27191cae01a37a5d192eb17d402c09fb3a62544e12152deef"

URI_x86_64_v2_ghc9.12-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-text-2.1.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-text}"
SRC_URI[x86_64_v2_ghc9.12-text.sha256sum] = "405eedf94b6b59677e1e7c91718ab201e5ec1df1d82d7516986d417a953e7a56"

URI_x86_64_v2_ghc9.12-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-text-devel-2.1.4-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-text-devel}"
SRC_URI[x86_64_v2_ghc9.12-text-devel.sha256sum] = "6b6cc8da28c93c25391b643b5111e1e0f813eca458dba448cc0ec18dea231009"

URI_x86_64_v2_ghc9.12-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-text-doc-2.1.4-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-text-doc}"
SRC_URI[x86_64_v2_ghc9.12-text-doc.sha256sum] = "5e676225f3aec3855f5c0569f6fe07291ef1f41851f22fa150f8546f954e04a6"

URI_x86_64_v2_ghc9.12-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-time-1.14-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-time}"
SRC_URI[x86_64_v2_ghc9.12-time.sha256sum] = "40aaf01e864d0567ba7b0421668f98c286c74ffcdb73fc30855cb9fbf33d6647"

URI_x86_64_v2_ghc9.12-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-time-devel-1.14-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-time-devel}"
SRC_URI[x86_64_v2_ghc9.12-time-devel.sha256sum] = "34bea893b340ec2f0bd40cabcaf5005b52e3447d8503683b37141bf1b1f0240e"

URI_x86_64_v2_ghc9.12-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-time-doc-1.14-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-time-doc}"
SRC_URI[x86_64_v2_ghc9.12-time-doc.sha256sum] = "1cbbb6c14f8bddc4c613d8b3b552c0f6da532c3a1140b302ca0cf1c58bc72e1f"

URI_x86_64_v2_ghc9.12-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-transformers-0.6.3.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-transformers}"
SRC_URI[x86_64_v2_ghc9.12-transformers.sha256sum] = "fee3f947c42a3313bf82550d121bc4fc7b3deac449c95e355a68825e67319332"

URI_x86_64_v2_ghc9.12-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-transformers-devel-0.6.3.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.12-transformers-devel.sha256sum] = "7010fff84dc247c9f47955a8023c5486bb29947ed8cb18c6e9cf2affc7bffb21"

URI_x86_64_v2_ghc9.12-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-transformers-doc-0.6.3.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.12-transformers-doc.sha256sum] = "c492dd8573e41b71bf4ba52a2043c2c52cfb2338083b3f9bb1a0355e1faa5fa7"

URI_x86_64_v2_ghc9.12-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-unix-2.8.8.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-unix}"
SRC_URI[x86_64_v2_ghc9.12-unix.sha256sum] = "a2eebd9e97be1689555502049ed2fc1a4bdbd832b7e9e87ada061651048b062c"

URI_x86_64_v2_ghc9.12-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-unix-devel-2.8.8.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-unix-devel}"
SRC_URI[x86_64_v2_ghc9.12-unix-devel.sha256sum] = "f38cb396988e49220739d7963bbb2d8c89b43b0872187d443c0cdfe732a187d4"

URI_x86_64_v2_ghc9.12-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-unix-doc-2.8.8.0-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-unix-doc}"
SRC_URI[x86_64_v2_ghc9.12-unix-doc.sha256sum] = "548b2bc4c43e7f1de839e24baa59c4b45514517e926245f5f372aec63d472aaf"

URI_x86_64_v2_ghc9.12-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-xhtml-3000.2.2.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-xhtml}"
SRC_URI[x86_64_v2_ghc9.12-xhtml.sha256sum] = "8457d3603a8c069fd7e1620f64b700ffb984d11ed01c7dcf9db7ebd1f567f40e"

URI_x86_64_v2_ghc9.12-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-xhtml-devel-3000.2.2.1-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.12-xhtml-devel.sha256sum] = "68d6faf9f821beda3c64bd4e4a4f826c1692b04ff497d33c3f74bd58510fc929"

URI_x86_64_v2_ghc9.12-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-xhtml-doc-3000.2.2.1-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.12-xhtml-doc.sha256sum] = "eb583d15bc112d31db1989540fcaf7bdf9f7add033ef8eebfb09aadbedb2f631"

URI_aarch64_ghc9.12 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12}"
SRC_URI[aarch64_ghc9.12.sha256sum] = "7f22e180e5791eab58b0fa08b54fba633171f35f153b332ccc5f547cf558c9c1"

URI_aarch64_ghc9.12-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-3.14.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal}"
SRC_URI[aarch64_ghc9.12-Cabal.sha256sum] = "77f25a08f82679dae89bdfeb72fe1af64f851ac3f2eed442207ab045fb429735"

URI_aarch64_ghc9.12-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-devel-3.14.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-devel}"
SRC_URI[aarch64_ghc9.12-Cabal-devel.sha256sum] = "529433593cbd3240e18e2c61462461f41223a675e3175061668c0d911069d85d"

URI_aarch64_ghc9.12-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-doc-3.14.2.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-doc}"
SRC_URI[aarch64_ghc9.12-Cabal-doc.sha256sum] = "8eb3065a200f93ba9f360343cc73afcf3a7f990bc1adfa421214c8b9ee9847fb"

URI_aarch64_ghc9.12-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-prof-3.14.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-prof}"
SRC_URI[aarch64_ghc9.12-Cabal-prof.sha256sum] = "f106a4944b3ac5ebda91921eb1dd52ff7129ec550db2f1d773adbae0e4068f6b"

URI_aarch64_ghc9.12-Cabal-syntax = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-3.14.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax.sha256sum] = "179be0a62217398bb581cb437cf7a563e6b18d45f3915b391887dba84f8a303b"

URI_aarch64_ghc9.12-Cabal-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-devel-3.14.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax-devel}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax-devel.sha256sum] = "ff8a460bd249ddbda9ee1bb1c67e8afa463c5d1eabe1d71b6e9b43b85b034f35"

URI_aarch64_ghc9.12-Cabal-syntax-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-doc-3.14.2.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax-doc}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax-doc.sha256sum] = "c71ea738d160e411bef3a090c99c14c5c3a80d627f7de4f324de0870b79bd2f3"

URI_aarch64_ghc9.12-Cabal-syntax-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-prof-3.14.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax-prof}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax-prof.sha256sum] = "f871d0c298c7fbd3a1cb8aa3e8cc4f3e1307077dcb02045381ae55630aef06bf"

URI_aarch64_ghc9.12-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-0.5.8.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array}"
SRC_URI[aarch64_ghc9.12-array.sha256sum] = "fce4ab318dd48fca6da53eebf9e01db5c2d6d4d2430174650b72346d4443a64e"

URI_aarch64_ghc9.12-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-devel-0.5.8.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array-devel}"
SRC_URI[aarch64_ghc9.12-array-devel.sha256sum] = "a9dfbcc6a74b7066ded257527517fff13c4fb6a0d2714ff5a1cf0fa819d1f6a5"

URI_aarch64_ghc9.12-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-doc-0.5.8.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array-doc}"
SRC_URI[aarch64_ghc9.12-array-doc.sha256sum] = "69f794d5d982a70c64bcf350e53763ff84b4b3568af2e89446a9cdbaeb59e918"

URI_aarch64_ghc9.12-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-prof-0.5.8.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array-prof}"
SRC_URI[aarch64_ghc9.12-array-prof.sha256sum] = "fb5f7ca4feeef1d29217ddb9aea7022afd80db156bfcda6fd98a11bdccd49327"

URI_aarch64_ghc9.12-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-4.21.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base}"
SRC_URI[aarch64_ghc9.12-base.sha256sum] = "8c046281f45d5d7cc9694e484745b8d7a7c8130348f130e18fde00dcc871bc60"

URI_aarch64_ghc9.12-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-devel-4.21.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base-devel}"
SRC_URI[aarch64_ghc9.12-base-devel.sha256sum] = "4cf19e8073640d1664894bfe7712787ee1f79642e5bca10c5f742c4467816a1e"

URI_aarch64_ghc9.12-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-doc-4.21.2.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base-doc}"
SRC_URI[aarch64_ghc9.12-base-doc.sha256sum] = "eec9d53399b9500a2a463a37c928e3239710d18cc23b9f52854d9dd8bead6ed8"

URI_aarch64_ghc9.12-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-prof-4.21.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base-prof}"
SRC_URI[aarch64_ghc9.12-base-prof.sha256sum] = "437f3bcb4f97b859c87e75658d02845ca9f899f518f488f60dcecbc046811613"

URI_aarch64_ghc9.12-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-0.8.9.3-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary}"
SRC_URI[aarch64_ghc9.12-binary.sha256sum] = "3f5b89781dbe9e36a8471ca57bde941178cf7058a87e0fbeeba6257220a668e8"

URI_aarch64_ghc9.12-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-devel-0.8.9.3-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary-devel}"
SRC_URI[aarch64_ghc9.12-binary-devel.sha256sum] = "cbc8c2e39d461aa9d9b7ef173b7ec927f51743345c9cabea83caec4ebfeade70"

URI_aarch64_ghc9.12-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-doc-0.8.9.3-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary-doc}"
SRC_URI[aarch64_ghc9.12-binary-doc.sha256sum] = "38f8b07f56564b16ccf414c303db11c80f0eb189a8429e429b6fac4a50082882"

URI_aarch64_ghc9.12-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-prof-0.8.9.3-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary-prof}"
SRC_URI[aarch64_ghc9.12-binary-prof.sha256sum] = "0e70370744f2375b7e4e2a6da6e3162823bfb75fe2b814e76324314e55dc9b95"

URI_aarch64_ghc9.12-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-0.12.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring}"
SRC_URI[aarch64_ghc9.12-bytestring.sha256sum] = "5393818dead617791db86369b5d68e245463f801762a8b1e64b09259bacd93d7"

URI_aarch64_ghc9.12-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-devel-0.12.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring-devel}"
SRC_URI[aarch64_ghc9.12-bytestring-devel.sha256sum] = "07e697c91b0ddd034a18b916f38ca6e485cd2201df6fdd858f8810ab42e6e8c8"

URI_aarch64_ghc9.12-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-doc-0.12.2.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring-doc}"
SRC_URI[aarch64_ghc9.12-bytestring-doc.sha256sum] = "625e10b796a3e3008cc86b5d40681c049dc4e1201c59062d07b42b90c7fef776"

URI_aarch64_ghc9.12-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-prof-0.12.2.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring-prof}"
SRC_URI[aarch64_ghc9.12-bytestring-prof.sha256sum] = "2a2a7a989fc857a83496a54331bb34e4d7d763c485ccce349bb3e5c2d06ec0bd"

URI_aarch64_ghc9.12-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-compiler-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-compiler}"
SRC_URI[aarch64_ghc9.12-compiler.sha256sum] = "c02d3fdd37d66a7eff49a1203bfe5488cd2c26307b65e336dc3dd9865a4a93de"

URI_aarch64_ghc9.12-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-compiler-default-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-compiler-default}"
SRC_URI[aarch64_ghc9.12-compiler-default.sha256sum] = "cf6b1b1716626259259a8764dcde3fd9191dcd3b6baec9e1e2a6dcc1f64145a7"

URI_aarch64_ghc9.12-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-0.7-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers}"
SRC_URI[aarch64_ghc9.12-containers.sha256sum] = "55c3af65ee674b9419ced2544ccf5e08f843a2569beb8fd2718e19ee1564dc0c"

URI_aarch64_ghc9.12-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-devel-0.7-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers-devel}"
SRC_URI[aarch64_ghc9.12-containers-devel.sha256sum] = "11008e89fb8750f5658545bc00b1ce929bdfc391e6fde184d3e39d96bf6b9332"

URI_aarch64_ghc9.12-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-doc-0.7-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers-doc}"
SRC_URI[aarch64_ghc9.12-containers-doc.sha256sum] = "4a6465aab61f09baf15db2c3f63978590f0c83e540627c6daee1eb7129243cd2"

URI_aarch64_ghc9.12-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-prof-0.7-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers-prof}"
SRC_URI[aarch64_ghc9.12-containers-prof.sha256sum] = "9865e43578ac37210f5085b212484b8ef7b48af391691f18633a93bbe2ec0588"

URI_aarch64_ghc9.12-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-1.5.1.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq}"
SRC_URI[aarch64_ghc9.12-deepseq.sha256sum] = "99e9cb71c5d57962007a63ac3a5736ff18078f32d7be8cbf0a46ca4e42bf8e4e"

URI_aarch64_ghc9.12-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-devel-1.5.1.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq-devel}"
SRC_URI[aarch64_ghc9.12-deepseq-devel.sha256sum] = "ec0b291324072b8369956bf3615a38d3fe42378cef34fce6807bdd5d6ee23200"

URI_aarch64_ghc9.12-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-doc-1.5.1.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq-doc}"
SRC_URI[aarch64_ghc9.12-deepseq-doc.sha256sum] = "9a40b3cd9cdfa3c2da27f87b2f2d5fece682fdefaf482eeeccaad07e47334a77"

URI_aarch64_ghc9.12-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-prof-1.5.1.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq-prof}"
SRC_URI[aarch64_ghc9.12-deepseq-prof.sha256sum] = "23416291a739ff9182c194d63f641fff2e25a46261d67689bde6935beb38c942"

URI_aarch64_ghc9.12-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-devel-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-devel}"
SRC_URI[aarch64_ghc9.12-devel.sha256sum] = "0b231c926b4b455f9cf84a2bdeefc1341006149bf4dc2c5a621bc77d26d337cb"

URI_aarch64_ghc9.12-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-1.3.10.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory}"
SRC_URI[aarch64_ghc9.12-directory.sha256sum] = "17d8a3405e57d8c47ae50b9841d9bc9ad5873b79c3143671b16a66c540f19fba"

URI_aarch64_ghc9.12-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-devel-1.3.10.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory-devel}"
SRC_URI[aarch64_ghc9.12-directory-devel.sha256sum] = "13e227b30a849ba26310e0d3c7bde65d846709aab820ed6f65efa3dd59c90377"

URI_aarch64_ghc9.12-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-doc-1.3.10.1-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory-doc}"
SRC_URI[aarch64_ghc9.12-directory-doc.sha256sum] = "ef6ef3987464da2d92d6be685c33e186f17b58eeb9db69b3396b0927bdf7d9c9"

URI_aarch64_ghc9.12-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-prof-1.3.10.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory-prof}"
SRC_URI[aarch64_ghc9.12-directory-prof.sha256sum] = "ebc12b04f8e10d7fb23b0ec7a159000fb011c4e0a8bea887209013553cac04e3"

URI_aarch64_ghc9.12-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-doc-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-doc}"
SRC_URI[aarch64_ghc9.12-doc.sha256sum] = "a1573505d6edae5e1368e1f963d4ad400696213c5acdd42afa930fb0472e5867"

URI_aarch64_ghc9.12-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-doc-index-9.12.4-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-doc-index}"
SRC_URI[aarch64_ghc9.12-doc-index.sha256sum] = "f97d9bd1c0b18f2e5e85fc89679d52b36ba83447faf8d71b498b6387bc8f1a5d"

URI_aarch64_ghc9.12-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-0.10.12-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions}"
SRC_URI[aarch64_ghc9.12-exceptions.sha256sum] = "5b7bcd6d5e05aaef159e45c61f4053cdb74c35ecd37d2f764e30d6c57be256e8"

URI_aarch64_ghc9.12-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-devel-0.10.12-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions-devel}"
SRC_URI[aarch64_ghc9.12-exceptions-devel.sha256sum] = "6ddc604491dfa2590e6b3ea730ce01d862ed8154957fe201312b09ebb812e007"

URI_aarch64_ghc9.12-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-doc-0.10.12-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions-doc}"
SRC_URI[aarch64_ghc9.12-exceptions-doc.sha256sum] = "6f80c7687974c0b00e75a33d71a23495c9493ebffb0ed29b2a219de63c95f5c3"

URI_aarch64_ghc9.12-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-prof-0.10.12-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions-prof}"
SRC_URI[aarch64_ghc9.12-exceptions-prof.sha256sum] = "fd8cc9a58fca12a1a78a4600284aea86d66791fb5eb06e7788ce4e6fa29d5d02"

URI_aarch64_ghc9.12-file-io = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-0.1.6-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-file-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io}"
SRC_URI[aarch64_ghc9.12-file-io.sha256sum] = "24c8a9a669d67dc3fa3c38ddb7fffb20111e3fd3e7f358c0468526b476b3df9e"

URI_aarch64_ghc9.12-file-io-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-devel-0.1.6-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-file-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io-devel}"
SRC_URI[aarch64_ghc9.12-file-io-devel.sha256sum] = "92e5044f98d0a86bb20937b2324eb151ce074301b3e7af6c9bcbd453d7ec90ed"

URI_aarch64_ghc9.12-file-io-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-doc-0.1.6-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-file-io-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io-doc}"
SRC_URI[aarch64_ghc9.12-file-io-doc.sha256sum] = "254f89f4659910bb2eebe8f6f3a41fefda7c8488f3147aaea30821f1e4506688"

URI_aarch64_ghc9.12-file-io-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-prof-0.1.6-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-file-io-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io-prof}"
SRC_URI[aarch64_ghc9.12-file-io-prof.sha256sum] = "0deb30f2dbfb089fda55ee45e121694bbed838b261c66cd88eb919ae478dd2d0"

URI_aarch64_ghc9.12-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-1.5.5.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath}"
SRC_URI[aarch64_ghc9.12-filepath.sha256sum] = "e1a38ef53691929c3695e915437181bc511fb4fe9febf00eef3868b86c279a31"

URI_aarch64_ghc9.12-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-devel-1.5.5.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath-devel}"
SRC_URI[aarch64_ghc9.12-filepath-devel.sha256sum] = "f12c25259f8788226b586f27021c0c64253d33fa2a7b057318b925cd43056eab"

URI_aarch64_ghc9.12-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-doc-1.5.5.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath-doc}"
SRC_URI[aarch64_ghc9.12-filepath-doc.sha256sum] = "400bb48022d3c45eededad818f1fccf05e59bc31177dbc2a66ba667c02d3464c"

URI_aarch64_ghc9.12-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-prof-1.5.5.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath-prof}"
SRC_URI[aarch64_ghc9.12-filepath-prof.sha256sum] = "d59fec4c7e901a19d3bb71e68ae06539a26bd1dcdf79134592ebe06b71d6b6a8"

URI_aarch64_ghc9.12-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filesystem-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filesystem}"
SRC_URI[aarch64_ghc9.12-filesystem.sha256sum] = "bc57e32b5677ec0f4e196376edc879698f529a527274cde1341b74d937a3ced3"

URI_aarch64_ghc9.12-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc}"
SRC_URI[aarch64_ghc9.12-ghc.sha256sum] = "0db6f4563770f3847fbd456ce40c4a3230525cdbab3502ae148c8277d78fbef7"

URI_aarch64_ghc9.12-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-1.3-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum}"
SRC_URI[aarch64_ghc9.12-ghc-bignum.sha256sum] = "8644dd9270c5be4fce7382d08b0b5357729917ad2288abf6da494e254acc8e64"

URI_aarch64_ghc9.12-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-devel-1.3-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.12-ghc-bignum-devel.sha256sum] = "a53cc09d504ed5ded6cad14627b5c5ec573a4d67af6f3977ae675514dcf0b17e"

URI_aarch64_ghc9.12-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-doc-1.3-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.12-ghc-bignum-doc.sha256sum] = "883567eabd708f441bdb9ae6b9d67f9ecd2de9ebe849f063bd224c3cce10c470"

URI_aarch64_ghc9.12-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-prof-1.3-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.12-ghc-bignum-prof.sha256sum] = "f0d81f14e7ac352066677ca84eb6d77a3e174f1d2d04d6ece7be91d1419a0975"

URI_aarch64_ghc9.12-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot}"
SRC_URI[aarch64_ghc9.12-ghc-boot.sha256sum] = "3c594c86ff76f3df03b901c0c6ab2126032330b1ca28336d5c8d0e3d5f379e07"

URI_aarch64_ghc9.12-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-devel-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.12-ghc-boot-devel.sha256sum] = "40972995873c294e12c10730712b51bcbb2a8a47ea8d8ed0fcbc43faa2ac1c44"

URI_aarch64_ghc9.12-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-doc-9.12.4-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.12-ghc-boot-doc.sha256sum] = "84c0ac06f42b42fb04ef73d43615b161a1d463668676f7d5bb1f97de648d00b9"

URI_aarch64_ghc9.12-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-prof-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.12-ghc-boot-prof.sha256sum] = "261dd963cebadaf3b3d9bf2326246f4c02302c3629888cd1260ce14de8820b44"

URI_aarch64_ghc9.12-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th.sha256sum] = "71dce48218f344d099df31e29a34e692117402bbc48643d6ed5f0c88424400cd"

URI_aarch64_ghc9.12-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-devel-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th-devel.sha256sum] = "05fb6d1f4f6dd2a308804c11c02d044c0e60722abb96ef4cc1cd1d25b2bda928"

URI_aarch64_ghc9.12-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-doc-9.12.4-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th-doc.sha256sum] = "6a951c757289dbcbc4dbdc010315684dc2fac5e6037a80caebeb706512e373a7"

URI_aarch64_ghc9.12-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-prof-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th-prof.sha256sum] = "96d8482f4261b377c054c6ce02ac4112b28fe5248814d92f26fa9834afd848d8"

URI_aarch64_ghc9.12-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-0.1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact}"
SRC_URI[aarch64_ghc9.12-ghc-compact.sha256sum] = "cdf90499dce3245a8b0dd25e39962e6764e9739a8e3869b6ce0827a638fe5a9c"

URI_aarch64_ghc9.12-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-devel-0.1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.12-ghc-compact-devel.sha256sum] = "0077df95f64fe7734ef630a2337ca3d407314b26b8bf199cae1e0e9865ba00fe"

URI_aarch64_ghc9.12-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-doc-0.1.0.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.12-ghc-compact-doc.sha256sum] = "8d5762ae1baac033dbba72c23a206320bae7016b18e963a8acba78ece9aca8d2"

URI_aarch64_ghc9.12-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-prof-0.1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.12-ghc-compact-prof.sha256sum] = "c0b7fd78a744d4e055bdb4687bb04c53ee469c6f17393d456783c24049c5dbf9"

URI_aarch64_ghc9.12-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-devel-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-devel}"
SRC_URI[aarch64_ghc9.12-ghc-devel.sha256sum] = "565d6d05ca6e2854378c40fed87fd922d9271a4f63388644d657166f87192fe3"

URI_aarch64_ghc9.12-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-doc-9.12.4-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-doc}"
SRC_URI[aarch64_ghc9.12-ghc-doc.sha256sum] = "7ef959562e1ce0473e8d552826c4fcf3e4d5791c6c61185bc8d567d5b5178dd5"

URI_aarch64_ghc9.12-ghc-experimental = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-9.1204.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental}"
SRC_URI[aarch64_ghc9.12-ghc-experimental.sha256sum] = "94bf41ce753a1c9c523c656fa10e740a37fd5421b56bdf51a3010e007245bfe7"

URI_aarch64_ghc9.12-ghc-experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-devel-9.1204.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental-devel}"
SRC_URI[aarch64_ghc9.12-ghc-experimental-devel.sha256sum] = "d68a9b29300115ca7a0a2a40a8242a336fbd7f377c18ff143c8933c546c13d31"

URI_aarch64_ghc9.12-ghc-experimental-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-doc-9.1204.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental-doc}"
SRC_URI[aarch64_ghc9.12-ghc-experimental-doc.sha256sum] = "eb849ba52151e1b18078a9f27fd791e5c4516fdac0fd08ea06fe7124d82d378d"

URI_aarch64_ghc9.12-ghc-experimental-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-prof-9.1204.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-experimental-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental-prof}"
SRC_URI[aarch64_ghc9.12-ghc-experimental-prof.sha256sum] = "23fce973c638ab55247b05c976df37faaf1d81e8ebba4a606574ba83bee8790d"

URI_aarch64_ghc9.12-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap}"
SRC_URI[aarch64_ghc9.12-ghc-heap.sha256sum] = "f212d8cee253ed01f74c219caac714ea4434bd31a0755f42ba630913bd59e5a6"

URI_aarch64_ghc9.12-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-devel-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.12-ghc-heap-devel.sha256sum] = "33c2b23afc52a3b33cd542fba210bd550ba0070977fe9430503baf11d2de4cbe"

URI_aarch64_ghc9.12-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-doc-9.12.4-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.12-ghc-heap-doc.sha256sum] = "e5c3db350117ee7bb43851b713639dc8c5fc8373a3f821bebb35d18a97ed0105"

URI_aarch64_ghc9.12-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-prof-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.12-ghc-heap-prof.sha256sum] = "03e4d2eda5019926dbfa957f003f1c6b20d97e3f9b65c2ed953c423649de973d"

URI_aarch64_ghc9.12-ghc-platform = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-0.1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform}"
SRC_URI[aarch64_ghc9.12-ghc-platform.sha256sum] = "1502935919c108ce13c475731c9e20e92d1051de24350e9e19a35e6a8afd6138"

URI_aarch64_ghc9.12-ghc-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-devel-0.1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform-devel}"
SRC_URI[aarch64_ghc9.12-ghc-platform-devel.sha256sum] = "839b4eb2b9a02092302be3061d86128e7a202833d11f21922af0da9cbd0763dc"

URI_aarch64_ghc9.12-ghc-platform-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-doc-0.1.0.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform-doc}"
SRC_URI[aarch64_ghc9.12-ghc-platform-doc.sha256sum] = "b73b369ff544cd845a5c87cddaf4b0ca6647aa70d87168f145ba267f5c33ce08"

URI_aarch64_ghc9.12-ghc-platform-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-prof-0.1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-platform-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform-prof}"
SRC_URI[aarch64_ghc9.12-ghc-platform-prof.sha256sum] = "87e4262db52d485b9f008c4e5e1400d489a8959ac76164f77cbdd67919d3b7da"

URI_aarch64_ghc9.12-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-prof-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-prof}"
SRC_URI[aarch64_ghc9.12-ghc-prof.sha256sum] = "b6dede227897395403c22d074d3e141ade1e4a9418bdea03889cd2a5060f481c"

URI_aarch64_ghc9.12-ghc-toolchain = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-0.1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain.sha256sum] = "a4c665dcf4c79d8c0ca986bff9d3333bb0db24884872b302db395e8dad00806e"

URI_aarch64_ghc9.12-ghc-toolchain-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-devel-0.1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain-devel}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain-devel.sha256sum] = "fc5d896777ab3111a53b03e14aab3308d647928082f053bd1d8c91014ce90aa7"

URI_aarch64_ghc9.12-ghc-toolchain-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-doc-0.1.0.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain-doc}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain-doc.sha256sum] = "3c23f266aa0fac6cb96ada4b41020a2b3f5ae95673272928c9e04f957ffb55f7"

URI_aarch64_ghc9.12-ghc-toolchain-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-prof-0.1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghc-toolchain-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain-prof}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain-prof.sha256sum] = "5ff4c544b18695022781955007672d9308374f666cbcbe94f1a8b86d04a4a310"

URI_aarch64_ghc9.12-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci}"
SRC_URI[aarch64_ghc9.12-ghci.sha256sum] = "e095a24941ee4ca7f02e922b43b9038bec6dfce7c11fa43ff370d1d8d243d7d7"

URI_aarch64_ghc9.12-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-devel-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci-devel}"
SRC_URI[aarch64_ghc9.12-ghci-devel.sha256sum] = "aaf076373140cd37347b13cfb8171a60aebc03ecd091d44ef56e7b68dad94195"

URI_aarch64_ghc9.12-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-doc-9.12.4-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci-doc}"
SRC_URI[aarch64_ghc9.12-ghci-doc.sha256sum] = "042bb115c618a692544650aff9165d2b9595e762eb652a69c874322026343e34"

URI_aarch64_ghc9.12-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-prof-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci-prof}"
SRC_URI[aarch64_ghc9.12-ghci-prof.sha256sum] = "7c87c3292e19c7658c10c12e139b6a7c4254a8144ca0e6f449e9cc3030105dad"

URI_aarch64_ghc9.12-haddock-api = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-2.32.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-haddock-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api}"
SRC_URI[aarch64_ghc9.12-haddock-api.sha256sum] = "f0de46cc94ad6a96f5a61efd0e4f2c75b001d0498c436a15fd520853037743c0"

URI_aarch64_ghc9.12-haddock-api-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-devel-2.32.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-haddock-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api-devel}"
SRC_URI[aarch64_ghc9.12-haddock-api-devel.sha256sum] = "fef2a90c6b6590213512b9e6a7a4a4ccde7793edc892d3c9696d6d16e28c1426"

URI_aarch64_ghc9.12-haddock-api-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-doc-2.32.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-haddock-api-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api-doc}"
SRC_URI[aarch64_ghc9.12-haddock-api-doc.sha256sum] = "dc3644037e62b8ffc894e00181d4292fc15ebe3df458163ad3de4d9248c22685"

URI_aarch64_ghc9.12-haddock-api-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-prof-2.32.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-haddock-api-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api-prof}"
SRC_URI[aarch64_ghc9.12-haddock-api-prof.sha256sum] = "048a52b8f9cab0944d16eeb5612804eb39373ac193457bf87fc5426fe1edc21f"

URI_aarch64_ghc9.12-haddock-library = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-1.11.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-haddock-library;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library}"
SRC_URI[aarch64_ghc9.12-haddock-library.sha256sum] = "952d276c9296fd09ee96ca4f4a408ba7ffd0516921d37788139fe727021e7640"

URI_aarch64_ghc9.12-haddock-library-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-devel-1.11.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-haddock-library-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library-devel}"
SRC_URI[aarch64_ghc9.12-haddock-library-devel.sha256sum] = "b8dcb667fd838e7dcc1a2085bad7c43ed201a358bc878dc97051703d9e320e69"

URI_aarch64_ghc9.12-haddock-library-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-doc-1.11.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-haddock-library-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library-doc}"
SRC_URI[aarch64_ghc9.12-haddock-library-doc.sha256sum] = "f8dddeb0dd138a6f00b794121174cfb4077bb3f75af8d6de1ae366ad2089a085"

URI_aarch64_ghc9.12-haddock-library-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-prof-1.11.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-haddock-library-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library-prof}"
SRC_URI[aarch64_ghc9.12-haddock-library-prof.sha256sum] = "3621226ef03d6c8955be77fa063882a6daa6743ebf0d3441a83c7d2e758035f2"

URI_aarch64_ghc9.12-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hadrian-0.1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hadrian}"
SRC_URI[aarch64_ghc9.12-hadrian.sha256sum] = "38455948bde1805cdb30f60b47fb4e9c1ba4a8e395419674fb5120eaff1a098d"

URI_aarch64_ghc9.12-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-0.8.4.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline}"
SRC_URI[aarch64_ghc9.12-haskeline.sha256sum] = "149dabcb711a74ef60b11ec1d2eff60d8307376445da4784974c5e9353f20f00"

URI_aarch64_ghc9.12-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-devel-0.8.4.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline-devel}"
SRC_URI[aarch64_ghc9.12-haskeline-devel.sha256sum] = "c6cd590cb778bf7f99c805eed7a46f557359eec643b0e722a2bd78ccd9934575"

URI_aarch64_ghc9.12-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-doc-0.8.4.1-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline-doc}"
SRC_URI[aarch64_ghc9.12-haskeline-doc.sha256sum] = "9175e0e24fc877663eda0c0bc9ecc5067258b8418f269bceaec22a3841532a03"

URI_aarch64_ghc9.12-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-prof-0.8.4.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline-prof}"
SRC_URI[aarch64_ghc9.12-haskeline-prof.sha256sum] = "689864f7661492f4df3f9ae766550b9d4a304fea4f7d0954bc3f72e1134cf5c6"

URI_aarch64_ghc9.12-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-0.7.0.2-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc}"
SRC_URI[aarch64_ghc9.12-hpc.sha256sum] = "1b4ff9dab492a4da213ec35c2c11771b4ce07f64f7ee486392823d30fff740c6"

URI_aarch64_ghc9.12-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-devel-0.7.0.2-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc-devel}"
SRC_URI[aarch64_ghc9.12-hpc-devel.sha256sum] = "7660e655aaef9265e0633738bc572197011f83d0cbd892429ec7d56168086210"

URI_aarch64_ghc9.12-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-doc-0.7.0.2-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc-doc}"
SRC_URI[aarch64_ghc9.12-hpc-doc.sha256sum] = "f815e7dcd1f0ba4297e688a74bab6bdd9e8ca7c7e75a3c90c8fa7b5ebd234a36"

URI_aarch64_ghc9.12-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-prof-0.7.0.2-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc-prof}"
SRC_URI[aarch64_ghc9.12-hpc-prof.sha256sum] = "19eee2e4380b2c29f22a0f62a046beb6d1f5fcb0c0850dfa9f247418c0846a50"

URI_aarch64_ghc9.12-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-manual-9.12.4-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-manual}"
SRC_URI[aarch64_ghc9.12-manual.sha256sum] = "8b541938e8e2a4a62a7458718e886b7b60fc2c78de5f176646432a4bfb8a190a"

URI_aarch64_ghc9.12-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-2.3.2-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl}"
SRC_URI[aarch64_ghc9.12-mtl.sha256sum] = "d07368b71a6e689a5491f1bcd315f0cf61a67477b6b7da39e1df12c024339cd9"

URI_aarch64_ghc9.12-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-devel-2.3.2-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl-devel}"
SRC_URI[aarch64_ghc9.12-mtl-devel.sha256sum] = "f7fc3340e53061b0ed9e8f4d547e922ec768b3d9eac905088ba891f887d38cf1"

URI_aarch64_ghc9.12-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-doc-2.3.2-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl-doc}"
SRC_URI[aarch64_ghc9.12-mtl-doc.sha256sum] = "088ea3c822b4f0b14ea1ebd971308a53edac25e59dba968ff3d650aa3c26e08a"

URI_aarch64_ghc9.12-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-prof-2.3.2-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl-prof}"
SRC_URI[aarch64_ghc9.12-mtl-prof.sha256sum] = "864e4779e4dcb72f8407a69eb6a6a5f69bc5747ff03da960c798ccda5103062e"

URI_aarch64_ghc9.12-os-string = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-2.0.10-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-os-string;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string}"
SRC_URI[aarch64_ghc9.12-os-string.sha256sum] = "375b56fdb5f1ffd6a192d2419b1d808bfca62ccc9766b4525126efbb5f741c57"

URI_aarch64_ghc9.12-os-string-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-devel-2.0.10-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string-devel}"
SRC_URI[aarch64_ghc9.12-os-string-devel.sha256sum] = "adecc4f325cf3f2b2f5c7dfcea93c83c33c5a8354e41b6c50f5fb91a468886d5"

URI_aarch64_ghc9.12-os-string-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-doc-2.0.10-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string-doc}"
SRC_URI[aarch64_ghc9.12-os-string-doc.sha256sum] = "393601971099f1b0258dbd54261e42fd4318660582b43880788e5efb2c4d0788"

URI_aarch64_ghc9.12-os-string-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-prof-2.0.10-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-os-string-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string-prof}"
SRC_URI[aarch64_ghc9.12-os-string-prof.sha256sum] = "e8fb32f3a30d634a0b2a991fb6f7bc9a5526c0acd4c26a7aca2c25bb6b6c9a3b"

URI_aarch64_ghc9.12-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-3.1.18.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec}"
SRC_URI[aarch64_ghc9.12-parsec.sha256sum] = "762dc8cd9f3d7ca88dc2ffeb8c20ec43714ffa5111de7b17821312cf239cf87f"

URI_aarch64_ghc9.12-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-devel-3.1.18.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec-devel}"
SRC_URI[aarch64_ghc9.12-parsec-devel.sha256sum] = "81d2130fc01bf4096566846065ebaf04d84877cae419c600bca4a394b635c37a"

URI_aarch64_ghc9.12-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-doc-3.1.18.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec-doc}"
SRC_URI[aarch64_ghc9.12-parsec-doc.sha256sum] = "9e0d956331b8cc4e3a0fa4ff9f8cc4829db22a3b635da3d819d79fae89c8dc42"

URI_aarch64_ghc9.12-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-prof-3.1.18.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec-prof}"
SRC_URI[aarch64_ghc9.12-parsec-prof.sha256sum] = "e23de98f06c14f8eaa94be8a1d00d13fb4c49dad3ed14f8bc2acdeec77a59a4c"

URI_aarch64_ghc9.12-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-1.1.3.6-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty}"
SRC_URI[aarch64_ghc9.12-pretty.sha256sum] = "6688f0aaaaaec06612bb9ac0bf58d35e8d86da277ccfb085eee8b59b160ff014"

URI_aarch64_ghc9.12-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-devel-1.1.3.6-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty-devel}"
SRC_URI[aarch64_ghc9.12-pretty-devel.sha256sum] = "6d1823954d193a005a68c1b3602dccc987880fbf4373ca18f8b5d7f359066396"

URI_aarch64_ghc9.12-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-doc-1.1.3.6-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty-doc}"
SRC_URI[aarch64_ghc9.12-pretty-doc.sha256sum] = "a0cd49a1ad0f47870b429cd299b4db98aaec476596acd93cdfb538c31ab32283"

URI_aarch64_ghc9.12-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-prof-1.1.3.6-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty-prof}"
SRC_URI[aarch64_ghc9.12-pretty-prof.sha256sum] = "e74f973032c923334fa1089adf465280a9aa8ed48a2f38717727bce3c52eb599"

URI_aarch64_ghc9.12-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-1.6.26.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process}"
SRC_URI[aarch64_ghc9.12-process.sha256sum] = "d7d80e08253839402b03b1906a8e0c2a3514629cbb0fbcaa31f52bcd38bd2f89"

URI_aarch64_ghc9.12-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-devel-1.6.26.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process-devel}"
SRC_URI[aarch64_ghc9.12-process-devel.sha256sum] = "a766fb3838b5cbfe7464f2ce3afaeb969424ab96bac5a9f6b23c39ef25653f22"

URI_aarch64_ghc9.12-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-doc-1.6.26.1-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process-doc}"
SRC_URI[aarch64_ghc9.12-process-doc.sha256sum] = "ac2dce39555576a2c4807b4c57a098955b3caa8ec95881292908a9cdae0933bd"

URI_aarch64_ghc9.12-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-prof-1.6.26.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process-prof}"
SRC_URI[aarch64_ghc9.12-process-prof.sha256sum] = "2ca31fbd828ae861b5683b5edf395c21d120d0a72e5ca27f913164b37c30d221"

URI_aarch64_ghc9.12-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-prof-9.12.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-prof}"
SRC_URI[aarch64_ghc9.12-prof.sha256sum] = "d97dd390f8984e36b326985856e18f67e6ba3e60069c8d9541c877f7a8a92b29"

URI_aarch64_ghc9.12-semaphore-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat}"
SRC_URI[aarch64_ghc9.12-semaphore-compat.sha256sum] = "ed2f697298c8c16fbd68ed31915a77ca88bd29a4410a8a2124a5ac267f205657"

URI_aarch64_ghc9.12-semaphore-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-devel-1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat-devel}"
SRC_URI[aarch64_ghc9.12-semaphore-compat-devel.sha256sum] = "1d881f9e352e53d9c79fa1eafa5012c585825f4535ff092ba3a2f4868aed93d7"

URI_aarch64_ghc9.12-semaphore-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-doc-1.0.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat-doc}"
SRC_URI[aarch64_ghc9.12-semaphore-compat-doc.sha256sum] = "c63d24749ecc13bd7fa390eff82bc95d63a5d26ebf8b620f71de39f0af587a61"

URI_aarch64_ghc9.12-semaphore-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-prof-1.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-semaphore-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat-prof}"
SRC_URI[aarch64_ghc9.12-semaphore-compat-prof.sha256sum] = "fbf3f6101476087e69d9a9c63b5f478eb107d8f9b1f6818927db1b2f5022bf6b"

URI_aarch64_ghc9.12-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-2.5.3.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm}"
SRC_URI[aarch64_ghc9.12-stm.sha256sum] = "6e447338fe8902bede4319eb4aac88cc248f7010150d92df56741039ff625b00"

URI_aarch64_ghc9.12-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-devel-2.5.3.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm-devel}"
SRC_URI[aarch64_ghc9.12-stm-devel.sha256sum] = "42901f5ae1daeb6e0590477ef22080c1008025baca282430bfb0d428da26493f"

URI_aarch64_ghc9.12-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-doc-2.5.3.1-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm-doc}"
SRC_URI[aarch64_ghc9.12-stm-doc.sha256sum] = "88769a7e40593ce9f4055edecef975dfd6fa987d7cdce449544616644d379907"

URI_aarch64_ghc9.12-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-prof-2.5.3.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm-prof}"
SRC_URI[aarch64_ghc9.12-stm-prof.sha256sum] = "276e019627570ae91b165f84e044d48c6d725d1901fbe90beaeb0756f666de16"

URI_aarch64_ghc9.12-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-2.23.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell}"
SRC_URI[aarch64_ghc9.12-template-haskell.sha256sum] = "a3268f8885b07296dd1b657c916e5930c0c932cb40fcf9c6874bb405a69206d6"

URI_aarch64_ghc9.12-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-devel-2.23.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell-devel}"
SRC_URI[aarch64_ghc9.12-template-haskell-devel.sha256sum] = "9b1c94bfd5b4c44965c372388e5d031efd8a619d16aefd77df0bf94ede25ed56"

URI_aarch64_ghc9.12-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-doc-2.23.0.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell-doc}"
SRC_URI[aarch64_ghc9.12-template-haskell-doc.sha256sum] = "93eef639f12ef8b27815e1511644879195b5a494219120e58d6e1658550d721e"

URI_aarch64_ghc9.12-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-prof-2.23.0.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell-prof}"
SRC_URI[aarch64_ghc9.12-template-haskell-prof.sha256sum] = "1e1c30db6373bcd1f710dc1da095829372d22234c83611687416ce0ce7080261"

URI_aarch64_ghc9.12-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-0.4.1.7-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo}"
SRC_URI[aarch64_ghc9.12-terminfo.sha256sum] = "0c8fa5454c09d48a29b807d146695d927d696e9f6c27cfce14523e0cd3aeb0c2"

URI_aarch64_ghc9.12-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-devel-0.4.1.7-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo-devel}"
SRC_URI[aarch64_ghc9.12-terminfo-devel.sha256sum] = "0f77ca8070a8251429eaeba76b25f542f3799bd2faa05cda30e142f8d777593f"

URI_aarch64_ghc9.12-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-doc-0.4.1.7-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo-doc}"
SRC_URI[aarch64_ghc9.12-terminfo-doc.sha256sum] = "2b42cbcd667541832fa45dbde9292811e3055f06e815842364b8b005dd814f9a"

URI_aarch64_ghc9.12-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-prof-0.4.1.7-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo-prof}"
SRC_URI[aarch64_ghc9.12-terminfo-prof.sha256sum] = "aac8faa9f0e5afd306c8ea737e0592cab88870050ef96606534a368ea2b41a98"

URI_aarch64_ghc9.12-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-2.1.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text}"
SRC_URI[aarch64_ghc9.12-text.sha256sum] = "f2acec743c861a77aab332be29cedd23ef1fee05c5896f734449e3419731edd2"

URI_aarch64_ghc9.12-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-devel-2.1.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text-devel}"
SRC_URI[aarch64_ghc9.12-text-devel.sha256sum] = "a17f38dd61dd3d55c45f32552cca989e45f76ad0b2071d9be9e6d2e184915f1e"

URI_aarch64_ghc9.12-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-doc-2.1.4-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text-doc}"
SRC_URI[aarch64_ghc9.12-text-doc.sha256sum] = "13196c5c72c940bfee36bc3238eca8eb16503cb628db226eb85c4a068fb065ec"

URI_aarch64_ghc9.12-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-prof-2.1.4-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text-prof}"
SRC_URI[aarch64_ghc9.12-text-prof.sha256sum] = "ca9f277bab86102a1a14816ef5993c0b955c22a70876f809cf2dbc5a77060fab"

URI_aarch64_ghc9.12-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-1.14-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time}"
SRC_URI[aarch64_ghc9.12-time.sha256sum] = "015789b23522cc2fc6d17b97ef66d58bbe2c85e74688f308f7d4579d8183157f"

URI_aarch64_ghc9.12-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-devel-1.14-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time-devel}"
SRC_URI[aarch64_ghc9.12-time-devel.sha256sum] = "a9ce30614f6ff6f0fee93c990c4c78a23a6af7cacff6940e035be73c6b078588"

URI_aarch64_ghc9.12-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-doc-1.14-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time-doc}"
SRC_URI[aarch64_ghc9.12-time-doc.sha256sum] = "09ab1c94ca86ef5b8a10ff20ed98ac84b690d318fdf7ac655f94d0580177a67e"

URI_aarch64_ghc9.12-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-prof-1.14-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time-prof}"
SRC_URI[aarch64_ghc9.12-time-prof.sha256sum] = "8937748d4c3418b251d3a312077e2716c72a9f58dc810bcf9cfa37c1260add81"

URI_aarch64_ghc9.12-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-0.6.3.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers}"
SRC_URI[aarch64_ghc9.12-transformers.sha256sum] = "268daa55cfee1d1b1a32bb09873f6bae86ff47644372140641ed892743e9c0ed"

URI_aarch64_ghc9.12-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-devel-0.6.3.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers-devel}"
SRC_URI[aarch64_ghc9.12-transformers-devel.sha256sum] = "0c4356f4f79ce2f386df358a9f54f6a40b8ea48431d5449a370512f7a84a2d81"

URI_aarch64_ghc9.12-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-doc-0.6.3.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers-doc}"
SRC_URI[aarch64_ghc9.12-transformers-doc.sha256sum] = "9ba73a4967bfac3c3d29fedccc4d954643fa3e5409a35f8077f0e07788ae8537"

URI_aarch64_ghc9.12-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-prof-0.6.3.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers-prof}"
SRC_URI[aarch64_ghc9.12-transformers-prof.sha256sum] = "e49c2ab925d1bcb812512e17d153d558fb811814fa8de4ac20c8375e8f8aa25f"

URI_aarch64_ghc9.12-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-2.8.8.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix}"
SRC_URI[aarch64_ghc9.12-unix.sha256sum] = "d13eced90934dbeea11d81e0478618496aa32bdc56ee2b586fbce0540a1aa103"

URI_aarch64_ghc9.12-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-devel-2.8.8.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix-devel}"
SRC_URI[aarch64_ghc9.12-unix-devel.sha256sum] = "d517463815cd4784b9381873f5c397ecb77745c7145b7740ffebd5ec64915e4c"

URI_aarch64_ghc9.12-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-doc-2.8.8.0-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix-doc}"
SRC_URI[aarch64_ghc9.12-unix-doc.sha256sum] = "0fec4ff579cd0010542d81b1205c2af37991e9cdf2bd8c25bcc0dc0088e94866"

URI_aarch64_ghc9.12-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-prof-2.8.8.0-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix-prof}"
SRC_URI[aarch64_ghc9.12-unix-prof.sha256sum] = "19f53f9f3e7f205f71ff75d36f6cab7ecc31dd6309cf7bd0d7d033566ddb3b36"

URI_aarch64_ghc9.12-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-3000.2.2.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml}"
SRC_URI[aarch64_ghc9.12-xhtml.sha256sum] = "cb398e40818639b1a5da46881414ff4690e86595a15e612208ee89d42d871d08"

URI_aarch64_ghc9.12-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-devel-3000.2.2.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml-devel}"
SRC_URI[aarch64_ghc9.12-xhtml-devel.sha256sum] = "b68bdaf4c991d7e7d8e04d10eac7470f6dd3c1c026fb098d3c1697c2e4db5d04"

URI_aarch64_ghc9.12-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-doc-3000.2.2.1-17.el10_3.noarch.rpm;name=aarch64_ghc9.12-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml-doc}"
SRC_URI[aarch64_ghc9.12-xhtml-doc.sha256sum] = "f803a8e551089b48a92bba32483db879543e95150587088bca75a4bc5d745c76"

URI_aarch64_ghc9.12-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-prof-3000.2.2.1-17.el10_3.aarch64.rpm;name=aarch64_ghc9.12-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml-prof}"
SRC_URI[aarch64_ghc9.12-xhtml-prof.sha256sum] = "685e8bb90ccbddce421bd4506181ac95b73d92a5ed39d6ca2dc5e283e0ed5026"

RDEPENDS:ghc9.12 = " \
 ghc9.12-compiler \
 ghc9.12-devel \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-compact-devel \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghci-devel \
 ghc9.12-hpc-devel \
 "
RDEPENDS:ghc9.12-Cabal = " \
 ghc9.12-Cabal-syntax \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-Cabal-devel = " \
 ghc9.12-Cabal \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-mtl-devel \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-devel \
 ghc9.12-process-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-Cabal-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-Cabal-syntax = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-Cabal-syntax-devel = " \
 ghc9.12-Cabal-syntax \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-mtl-devel \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-devel \
 ghc9.12-text-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-Cabal-syntax-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-array = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-array-devel = " \
 ghc9.12-array \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-array-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-base = " \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.12-base-devel = " \
 ghc9.12-base \
 ghc9.12-compiler \
 ghc9.12-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 numactl-devel \
 "
RDEPENDS:ghc9.12-base-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-binary = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-binary-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 "
RDEPENDS:ghc9.12-binary-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-bytestring = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-bytestring-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-bytestring-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-compiler = " \
 bash \
 binutils \
 gcc \
 ghc9.12-Cabal \
 ghc9.12-Cabal-syntax \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-base-devel \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-filesystem \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-ghc-toolchain \
 ghc9.12-ghci \
 ghc9.12-haddock-api \
 ghc9.12-haddock-library \
 ghc9.12-haskeline \
 ghc9.12-hpc \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-semaphore-compat \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-terminfo \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 ghc9.12-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 numactl-libs \
 "
RDEPENDS:ghc9.12-compiler-default = " \
 bash \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-containers = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-containers-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-containers-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-deepseq = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-deepseq-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq \
 "
RDEPENDS:ghc9.12-deepseq-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-devel = " \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-file-io-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-library-devel \
 ghc9.12-haskeline-devel \
 ghc9.12-mtl-devel \
 ghc9.12-os-string-devel \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-devel \
 ghc9.12-process-devel \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-stm-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-terminfo-devel \
 ghc9.12-text-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 ghc9.12-xhtml-devel \
 "
RDEPENDS:ghc9.12-directory = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-directory-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-directory \
 ghc9.12-file-io-devel \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-time-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-directory-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-doc = " \
 "
RDEPENDS:ghc9.12-doc-index = " \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-exceptions = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-exceptions-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-exceptions \
 ghc9.12-mtl-devel \
 ghc9.12-stm-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-exceptions-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-file-io = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-file-io-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-file-io \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-file-io-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-filepath = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-filepath-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath \
 ghc9.12-os-string-devel \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-filepath-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-filesystem = " \
 "
RDEPENDS:ghc9.12-ghc = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-ghci \
 ghc9.12-hpc \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-semaphore-compat \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-bignum = " \
 ghc9.12-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-bignum-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-bignum \
 "
RDEPENDS:ghc9.12-ghc-bignum-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-boot = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-platform \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-devel = " \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-platform-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-ghc-boot-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-boot-th = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-th-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty-devel \
 "
RDEPENDS:ghc9.12-ghc-boot-th-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-compact = " \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-compact-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-compact \
 "
RDEPENDS:ghc9.12-ghc-compact-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghci-devel \
 ghc9.12-hpc-devel \
 ghc9.12-os-string-devel \
 ghc9.12-process-devel \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-stm-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-ghc-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-experimental = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-experimental-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-experimental \
 "
RDEPENDS:ghc9.12-ghc-experimental-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-heap = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-heap-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-ghc-heap \
 "
RDEPENDS:ghc9.12-ghc-heap-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-platform = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-platform-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-platform \
 "
RDEPENDS:ghc9.12-ghc-platform-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-toolchain = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-platform \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-toolchain-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-platform-devel \
 ghc9.12-ghc-toolchain \
 ghc9.12-process-devel \
 ghc9.12-text-devel \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-ghc-toolchain-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghci = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghci-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghci \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-ghci-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-haddock-api = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-ghci \
 ghc9.12-haddock-library \
 ghc9.12-hpc \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-semaphore-compat \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 ghc9.12-xhtml \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-api-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-devel \
 ghc9.12-haddock-api \
 ghc9.12-haddock-library-devel \
 ghc9.12-mtl-devel \
 ghc9.12-parsec-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 ghc9.12-xhtml-devel \
 "
RDEPENDS:ghc9.12-haddock-api-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-haddock-library = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-library-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-haddock-library \
 ghc9.12-parsec-devel \
 ghc9.12-text-devel \
 "
RDEPENDS:ghc9.12-haddock-library-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.12-haskeline = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-terminfo \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-haskeline-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath-devel \
 ghc9.12-haskeline \
 ghc9.12-process-devel \
 ghc9.12-stm-devel \
 ghc9.12-terminfo-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-haskeline-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-hpc = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-hpc-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-hpc \
 ghc9.12-time-devel \
 "
RDEPENDS:ghc9.12-hpc-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-manual = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-mtl = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-mtl-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-mtl \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-mtl-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-os-string = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-os-string-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-os-string \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-os-string-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-parsec = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-parsec-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-mtl-devel \
 ghc9.12-parsec \
 ghc9.12-text-devel \
 "
RDEPENDS:ghc9.12-parsec-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-pretty = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-pretty-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-pretty \
 "
RDEPENDS:ghc9.12-pretty-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-process = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-process-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-process \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-process-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-semaphore-compat = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-semaphore-compat-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-exceptions-devel \
 ghc9.12-semaphore-compat \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-semaphore-compat-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-stm = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-stm-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-stm \
 "
RDEPENDS:ghc9.12-stm-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-template-haskell = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-template-haskell-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-template-haskell \
 "
RDEPENDS:ghc9.12-template-haskell-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-terminfo = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-terminfo-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.12-terminfo-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-text = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-text-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-text \
 "
RDEPENDS:ghc9.12-text-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-time = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-time-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-time \
 "
RDEPENDS:ghc9.12-time-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-transformers = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-transformers-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-transformers \
 "
RDEPENDS:ghc9.12-transformers-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-unix = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-unix-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-time-devel \
 ghc9.12-unix \
 "
RDEPENDS:ghc9.12-unix-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-xhtml = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-xhtml-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-xhtml \
 "
RDEPENDS:ghc9.12-xhtml-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-Cabal-prof = " \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-syntax-prof \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-Cabal-syntax-prof = " \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-array-prof = " \
 ghc9.12-array-devel \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-base-prof = " \
 ghc9.12-base-devel \
 ghc9.12-ghc-bignum-prof \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.12-binary-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-bytestring-prof = " \
 ghc9.12-base-prof \
 ghc9.12-bytestring-devel \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-containers-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-deepseq-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-devel \
 ghc9.12-ghc-bignum-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-directory-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-exceptions-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-devel \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-file-io-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-devel \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-filepath-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-bignum-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-th-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-pretty-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-compact-prof = " \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-compact-devel \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-experimental-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-experimental-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-heap-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-heap-devel \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-platform-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-platform-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghci-prof \
 ghc9.12-hpc-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-semaphore-compat-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-toolchain-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghc-toolchain-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghci-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghci-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-api-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghc-prof \
 ghc9.12-ghci-prof \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-library-prof \
 ghc9.12-hpc-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-semaphore-compat-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 ghc9.12-xhtml-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-library-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-haddock-library-devel \
 ghc9.12-mtl-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haskeline-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-haskeline-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-terminfo-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-hpc-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-hpc-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-mtl-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-mtl-devel \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-os-string-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-devel \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-parsec-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-pretty-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-pretty-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-process-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-devel \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-prof = " \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-semaphore-compat-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-stm-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-stm-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-template-haskell-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-terminfo-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-terminfo-devel \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-text-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-time-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-transformers-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-transformers-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-unix-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-xhtml-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-xhtml-devel \
 glibc \
 gmp \
 "
