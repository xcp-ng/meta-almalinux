# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-core"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-zune-core+default-devel \
 rust-zune-core+log-devel \
 rust-zune-core+serde-devel \
 rust-zune-core+std-devel \
 rust-zune-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zune-core-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b32bb36a86497ef5288bc5c28b73708a7dc4db3caf1832e19f34da9ecefe347b"

URI_x86_64_v2_rust-zune-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+default-devel}"
SRC_URI[x86_64_v2_rust-zune-core+default-devel.sha256sum] = "aa2df87ad3e7297d477435ba9bd9b2249e17995a66815a5f84b752edd71a01d3"

URI_x86_64_v2_rust-zune-core+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+log-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+log-devel}"
SRC_URI[x86_64_v2_rust-zune-core+log-devel.sha256sum] = "b959d2e2c9fdbc82528237decac7c8d8bf029f25ca79d78b79cc7e196193318a"

URI_x86_64_v2_rust-zune-core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+serde-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+serde-devel}"
SRC_URI[x86_64_v2_rust-zune-core+serde-devel.sha256sum] = "ed5cdf3ea15e1c8e0c05ac3164a5dc166b4586787bfa732e217f36452e36f195"

URI_x86_64_v2_rust-zune-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+std-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+std-devel}"
SRC_URI[x86_64_v2_rust-zune-core+std-devel.sha256sum] = "7bb52cc3f98461de7b5a55bbb717c417276b30c33adf03dbf50e5fd63575272d"

URI_x86_64_v2_rust-zune-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core-devel}"
SRC_URI[x86_64_v2_rust-zune-core-devel.sha256sum] = "00e20ef3633bfc5595dddcd4081f4ee94ef268c4d60a4c5ade09ca2196350854"

URI_aarch64_rust-zune-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-zune-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+default-devel}"
SRC_URI[aarch64_rust-zune-core+default-devel.sha256sum] = "1fe024518f81fc76db51909a28fd1a84c2666c7bb952d7c24bf6398fa79c4155"

URI_aarch64_rust-zune-core+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+log-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-zune-core+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+log-devel}"
SRC_URI[aarch64_rust-zune-core+log-devel.sha256sum] = "c033b2b1ab1ab33f4270c7f3659f45f961b470b6d9fef5f037e644029f2d92ad"

URI_aarch64_rust-zune-core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+serde-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-zune-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+serde-devel}"
SRC_URI[aarch64_rust-zune-core+serde-devel.sha256sum] = "b4f3e85351f03385c40ea86c71e9344c5e9fc4b616e70d230e0fbd90a68408a0"

URI_aarch64_rust-zune-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+std-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-zune-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+std-devel}"
SRC_URI[aarch64_rust-zune-core+std-devel.sha256sum] = "78bd99a571f5c2f804ee0bc05609d70a8ad04ef0b2428345b53c95ec3b3a4335"

URI_aarch64_rust-zune-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-zune-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core-devel}"
SRC_URI[aarch64_rust-zune-core-devel.sha256sum] = "ede84b521457735b60bee0423dacd421e49a5ed94d0521eac49b18d8a4e5ea55"

RDEPENDS:rust-zune-core+default-devel = " \
 cargo \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core+std-devel = " \
 cargo \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core-devel = " \
 cargo \
 rust \
 "
