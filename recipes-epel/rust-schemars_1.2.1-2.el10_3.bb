# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-schemars"
PV = "1.2.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-schemars+arrayvec07-devel \
 rust-schemars+bigdecimal04-devel \
 rust-schemars+bytes1-devel \
 rust-schemars+chrono04-devel \
 rust-schemars+default-devel \
 rust-schemars+derive-devel \
 rust-schemars+either1-devel \
 rust-schemars+indexmap2-devel \
 rust-schemars+jiff02-devel \
 rust-schemars+preserve_order-devel \
 rust-schemars+raw_value-devel \
 rust-schemars+rust_decimal1-devel \
 rust-schemars+schemars_derive-devel \
 rust-schemars+semver1-devel \
 rust-schemars+smallvec1-devel \
 rust-schemars+smol_str02-devel \
 rust-schemars+smol_str03-devel \
 rust-schemars+std-devel \
 rust-schemars+url2-devel \
 rust-schemars+uuid1-devel \
 rust-schemars-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-schemars-1.2.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34dec2b354271fc20aefe9285fccf8b8ecfab8fe686c02d66867ef566ac6cd38"

URI_x86_64_v2_rust-schemars+arrayvec07-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+arrayvec07-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+arrayvec07-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+arrayvec07-devel}"
SRC_URI[x86_64_v2_rust-schemars+arrayvec07-devel.sha256sum] = "ff2a44c458a561da7447cbd104d1669b6eb57784cc0beeb4c87905c919317064"

URI_x86_64_v2_rust-schemars+bigdecimal04-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+bigdecimal04-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+bigdecimal04-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+bigdecimal04-devel}"
SRC_URI[x86_64_v2_rust-schemars+bigdecimal04-devel.sha256sum] = "3749399bbacdff106f6e2d1396b7e1dacee95b19a9faaa9cab073f18f26b3703"

URI_x86_64_v2_rust-schemars+bytes1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+bytes1-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+bytes1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+bytes1-devel}"
SRC_URI[x86_64_v2_rust-schemars+bytes1-devel.sha256sum] = "1c5e71e97a00ce001813182eae2487e66206de4965aaabd11ea8ccf5c08529e5"

URI_x86_64_v2_rust-schemars+chrono04-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+chrono04-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+chrono04-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+chrono04-devel}"
SRC_URI[x86_64_v2_rust-schemars+chrono04-devel.sha256sum] = "32fddbf58ada6da44dac2bf84d11baa37b07a01dd14b0a9cf4610461b42476cf"

URI_x86_64_v2_rust-schemars+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+default-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+default-devel}"
SRC_URI[x86_64_v2_rust-schemars+default-devel.sha256sum] = "b7490a3a6a29c6aabeecc0111d1a395edf0ff8efdeda52cf708fc3fa5cbc822e"

URI_x86_64_v2_rust-schemars+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+derive-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+derive-devel}"
SRC_URI[x86_64_v2_rust-schemars+derive-devel.sha256sum] = "9da5eb97e425d1061c92e89caf230c418e636d40d555ec5096ca59610b64804a"

URI_x86_64_v2_rust-schemars+either1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+either1-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+either1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+either1-devel}"
SRC_URI[x86_64_v2_rust-schemars+either1-devel.sha256sum] = "494fb65779d83a5365e622d85f77e36fdb432552fb42a22bf08404d8d1003f1e"

URI_x86_64_v2_rust-schemars+indexmap2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+indexmap2-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+indexmap2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+indexmap2-devel}"
SRC_URI[x86_64_v2_rust-schemars+indexmap2-devel.sha256sum] = "e30d5e2e068836ea2fa2160f90069c01ba918425a1d0b0d8c7ef81a057377e79"

URI_x86_64_v2_rust-schemars+jiff02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+jiff02-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+jiff02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+jiff02-devel}"
SRC_URI[x86_64_v2_rust-schemars+jiff02-devel.sha256sum] = "bc25c61cf4db11511db68e8d62d0ad98d57a85ce3cb94489f9ce1ebffd296a0b"

URI_x86_64_v2_rust-schemars+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+preserve_order-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-schemars+preserve_order-devel.sha256sum] = "92f38b9c9c9d987e0a2683c190efb720bd11b4101752d0a76cd1093eca7e5065"

URI_x86_64_v2_rust-schemars+raw_value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+raw_value-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+raw_value-devel}"
SRC_URI[x86_64_v2_rust-schemars+raw_value-devel.sha256sum] = "be3cdd41a7c3cb7b44ffd6068d03477fa6dfdb17471983002f0c8bda3e29cb6e"

URI_x86_64_v2_rust-schemars+rust_decimal1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+rust_decimal1-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+rust_decimal1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+rust_decimal1-devel}"
SRC_URI[x86_64_v2_rust-schemars+rust_decimal1-devel.sha256sum] = "8066f2068a87bba329d972d3dc6aadd37cafdf1a076c0744e1792bc87f1a7b9c"

URI_x86_64_v2_rust-schemars+schemars_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+schemars_derive-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+schemars_derive-devel}"
SRC_URI[x86_64_v2_rust-schemars+schemars_derive-devel.sha256sum] = "fe3fdc5a5aea22b8071853ba06cded6a56df84e571ca15915c031567a0d2c65d"

URI_x86_64_v2_rust-schemars+semver1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+semver1-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+semver1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+semver1-devel}"
SRC_URI[x86_64_v2_rust-schemars+semver1-devel.sha256sum] = "0e8ff2e10dc90227c4afff7d7899c874cbfcc069b3ca00a10869443bc017f00c"

URI_x86_64_v2_rust-schemars+smallvec1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smallvec1-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smallvec1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smallvec1-devel}"
SRC_URI[x86_64_v2_rust-schemars+smallvec1-devel.sha256sum] = "3825b5cba1053cb58c7323d0303329e8c23940c27fe6b8e8a1603a698f01e4ea"

URI_x86_64_v2_rust-schemars+smol_str02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smol_str02-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smol_str02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smol_str02-devel}"
SRC_URI[x86_64_v2_rust-schemars+smol_str02-devel.sha256sum] = "57a5360a86e08858333861fbb1f6efef0f4dae647a2768062c51ef55d6c64b6c"

URI_x86_64_v2_rust-schemars+smol_str03-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smol_str03-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smol_str03-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smol_str03-devel}"
SRC_URI[x86_64_v2_rust-schemars+smol_str03-devel.sha256sum] = "825f31b7459e80f1590ab9c63c7169af5347679705db565fbc796354d84fcde1"

URI_x86_64_v2_rust-schemars+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+std-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+std-devel}"
SRC_URI[x86_64_v2_rust-schemars+std-devel.sha256sum] = "c4de8f0d9c70936672f08390b110735269f48df36b1be020763bcce6b494cde5"

URI_x86_64_v2_rust-schemars+url2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+url2-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+url2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+url2-devel}"
SRC_URI[x86_64_v2_rust-schemars+url2-devel.sha256sum] = "09b8a597c914f4ae07d97e725be91fb150688a3e135f28108ccdbd53a82a5acb"

URI_x86_64_v2_rust-schemars+uuid1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+uuid1-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+uuid1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+uuid1-devel}"
SRC_URI[x86_64_v2_rust-schemars+uuid1-devel.sha256sum] = "e253496e9995defe64a2a324298376b1033a383f6c93d84b08a23b7de345e31e"

URI_x86_64_v2_rust-schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars-devel-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars-devel}"
SRC_URI[x86_64_v2_rust-schemars-devel.sha256sum] = "3b4ba3dcb8bd123bab275bbfb7371e27d60a21f882e09ddccdf4e12487f3b0e3"

URI_aarch64_rust-schemars+arrayvec07-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+arrayvec07-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+arrayvec07-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+arrayvec07-devel}"
SRC_URI[aarch64_rust-schemars+arrayvec07-devel.sha256sum] = "b6dfa29d5d0ecc18d9ed105c4dd69765a4e6950b681dbfdf433a95d301b635b8"

URI_aarch64_rust-schemars+bigdecimal04-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+bigdecimal04-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+bigdecimal04-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+bigdecimal04-devel}"
SRC_URI[aarch64_rust-schemars+bigdecimal04-devel.sha256sum] = "79ab7d6e0cccbacdd501d142acafda66c64bfcd938f44d6724443a1825a178db"

URI_aarch64_rust-schemars+bytes1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+bytes1-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+bytes1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+bytes1-devel}"
SRC_URI[aarch64_rust-schemars+bytes1-devel.sha256sum] = "d96d568242f55ce1bb1a0dc9808d4ac12455b713a5a518326c5e1ab42adcd484"

URI_aarch64_rust-schemars+chrono04-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+chrono04-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+chrono04-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+chrono04-devel}"
SRC_URI[aarch64_rust-schemars+chrono04-devel.sha256sum] = "e0ca275ef80bc5a8951da3468649734c7da5cef9a5258d5c5eac86ab9dd5fe83"

URI_aarch64_rust-schemars+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+default-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+default-devel}"
SRC_URI[aarch64_rust-schemars+default-devel.sha256sum] = "f961a3a9c906e655ee6d475f33a78c1d3242bdc71c48db3603a127e348b1a6a4"

URI_aarch64_rust-schemars+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+derive-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+derive-devel}"
SRC_URI[aarch64_rust-schemars+derive-devel.sha256sum] = "b02eec959ebf8b1602aeca5611d48fc1568a96c8bcef56f49bef9ce1d1b831e2"

URI_aarch64_rust-schemars+either1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+either1-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+either1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+either1-devel}"
SRC_URI[aarch64_rust-schemars+either1-devel.sha256sum] = "fd8a30cc416b68e48055ba89b8f3021bc8626777623fa62c937a9a361a5bdf01"

URI_aarch64_rust-schemars+indexmap2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+indexmap2-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+indexmap2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+indexmap2-devel}"
SRC_URI[aarch64_rust-schemars+indexmap2-devel.sha256sum] = "51fa89c8826bda36ec9ec9ec304c30394bcadf48d395725f01ed8214636017d9"

URI_aarch64_rust-schemars+jiff02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+jiff02-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+jiff02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+jiff02-devel}"
SRC_URI[aarch64_rust-schemars+jiff02-devel.sha256sum] = "da691193370ccc7ef478d53b90043bc93027f1486de93afce2dfaa80c452ac63"

URI_aarch64_rust-schemars+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+preserve_order-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+preserve_order-devel}"
SRC_URI[aarch64_rust-schemars+preserve_order-devel.sha256sum] = "864a6258e447fda46f35d5053384a0ddbc634b597aea8d0deb8e50a5779afb1b"

URI_aarch64_rust-schemars+raw_value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+raw_value-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+raw_value-devel}"
SRC_URI[aarch64_rust-schemars+raw_value-devel.sha256sum] = "7cf43b12f7347960641d010990184300c6f8035991d2fcacafb87d6291e85ba6"

URI_aarch64_rust-schemars+rust_decimal1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+rust_decimal1-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+rust_decimal1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+rust_decimal1-devel}"
SRC_URI[aarch64_rust-schemars+rust_decimal1-devel.sha256sum] = "62f215a18f62453ad7fbd2b838100177713e3cb933b105849ef13dff80475932"

URI_aarch64_rust-schemars+schemars_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+schemars_derive-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+schemars_derive-devel}"
SRC_URI[aarch64_rust-schemars+schemars_derive-devel.sha256sum] = "0adb6e0cc99474bb808c8983464c190d6735e5a1f42a20e8a3eaa1846b0e9310"

URI_aarch64_rust-schemars+semver1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+semver1-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+semver1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+semver1-devel}"
SRC_URI[aarch64_rust-schemars+semver1-devel.sha256sum] = "f7171e6e7a12b7a4815a31f297f974f751ce990fc9e6978769a2aa0c73138c08"

URI_aarch64_rust-schemars+smallvec1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smallvec1-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+smallvec1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smallvec1-devel}"
SRC_URI[aarch64_rust-schemars+smallvec1-devel.sha256sum] = "cec869a2f9a55a0d4d46d3db9895693e96f0216e001f76740d5fcf9fc6aac61d"

URI_aarch64_rust-schemars+smol_str02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smol_str02-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+smol_str02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smol_str02-devel}"
SRC_URI[aarch64_rust-schemars+smol_str02-devel.sha256sum] = "8e2d97e95a2fef408af507049c4267a1da559c65629cdb2e05c24504ce6a78ef"

URI_aarch64_rust-schemars+smol_str03-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smol_str03-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+smol_str03-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smol_str03-devel}"
SRC_URI[aarch64_rust-schemars+smol_str03-devel.sha256sum] = "f5813f3eb5ab8fd73835ff700129a38ea27dff3ac5573f1af20796542c882571"

URI_aarch64_rust-schemars+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+std-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+std-devel}"
SRC_URI[aarch64_rust-schemars+std-devel.sha256sum] = "16d22d1f20f6fccc7b3b7012fcd5d8437c1797b63116e48eb794bfada0e8f64d"

URI_aarch64_rust-schemars+url2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+url2-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+url2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+url2-devel}"
SRC_URI[aarch64_rust-schemars+url2-devel.sha256sum] = "60e6fc42060b1752d8b9b056438769207cedc4e67d7463a436d373544e552a2f"

URI_aarch64_rust-schemars+uuid1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+uuid1-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars+uuid1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+uuid1-devel}"
SRC_URI[aarch64_rust-schemars+uuid1-devel.sha256sum] = "d5d40fcb8d41956636bca1c143f7ca7495c72c28897de5ad1c2f8795a030ddb2"

URI_aarch64_rust-schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars-devel-1.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars-devel}"
SRC_URI[aarch64_rust-schemars-devel.sha256sum] = "8b157a58fa2b5e1bc917495e44ee9bb57c58655a100649e5e04be010f4f8a502"

RDEPENDS:rust-schemars+arrayvec07-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+bigdecimal04-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+bytes1-devel = " \
 cargo \
 rust-bytes-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+chrono04-devel = " \
 cargo \
 rust-chrono-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+default-devel = " \
 cargo \
 rust-schemars+derive-devel \
 rust-schemars+std-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+derive-devel = " \
 cargo \
 rust-schemars+schemars_derive-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+either1-devel = " \
 cargo \
 rust-either-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+indexmap2-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+jiff02-devel = " \
 cargo \
 rust-jiff-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+preserve_order-devel = " \
 cargo \
 rust-schemars-devel \
 rust-serde_json+preserve_order-devel \
 "
RDEPENDS:rust-schemars+raw_value-devel = " \
 cargo \
 rust-schemars-devel \
 rust-serde_json+raw_value-devel \
 "
RDEPENDS:rust-schemars+rust_decimal1-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+schemars_derive-devel = " \
 cargo \
 rust-schemars-devel \
 rust-schemars_derive+default-devel \
 "
RDEPENDS:rust-schemars+semver1-devel = " \
 cargo \
 rust-schemars-devel \
 rust-semver-devel \
 "
RDEPENDS:rust-schemars+smallvec1-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-schemars+smol_str02-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smol_str0.2-devel \
 "
RDEPENDS:rust-schemars+smol_str03-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smol_str-devel \
 "
RDEPENDS:rust-schemars+std-devel = " \
 cargo \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+url2-devel = " \
 cargo \
 rust-schemars-devel \
 rust-url-devel \
 "
RDEPENDS:rust-schemars+uuid1-devel = " \
 cargo \
 rust-schemars-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-schemars-devel = " \
 cargo \
 rust \
 rust-dyn-clone+default-devel \
 rust-ref-cast+default-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-serde_json+alloc-devel \
 rust-serde_json-devel \
 "
