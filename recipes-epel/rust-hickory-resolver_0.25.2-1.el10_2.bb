# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-resolver"
PV = "0.25.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-hickory-resolver+backtrace-devel \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+rustls-platform-verifier-devel \
 rust-hickory-resolver+serde-devel \
 rust-hickory-resolver+system-config-devel \
 rust-hickory-resolver+tokio-devel \
 rust-hickory-resolver+webpki-roots-devel \
 rust-hickory-resolver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-resolver-0.25.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9be3bd83303a3461813c05c30e40e388f66ac1e0c63d4b671d72db67e67d798f"

URI_x86_64_v2_rust-hickory-resolver+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+backtrace-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+backtrace-devel.sha256sum] = "63dd0a433315d8fe8f85d55e56cbf918b97b1d40fc8d960ea2406e89ef6329b8"

URI_x86_64_v2_rust-hickory-resolver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+default-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+default-devel.sha256sum] = "81f73f311840e14fe71e9f94c141235847d4311189be8dca1f192e8d37f0eeb3"

URI_x86_64_v2_rust-hickory-resolver+rustls-platform-verifier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+rustls-platform-verifier-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+rustls-platform-verifier-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+rustls-platform-verifier-devel.sha256sum] = "c4cd883ecbab121af64c918594313cd6e4d95f1dfc1502eb1e2cca4b6faff783"

URI_x86_64_v2_rust-hickory-resolver+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+serde-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+serde-devel.sha256sum] = "a3e80ae0c9fc26c44e3f7fd4297f750a7fbcd4aae4edbe84d56f1407c69acdf2"

URI_x86_64_v2_rust-hickory-resolver+system-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+system-config-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+system-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+system-config-devel.sha256sum] = "67e72125beff9d86628d6ebab07f0f1bd9aeff1480c795e070e29d076f40435a"

URI_x86_64_v2_rust-hickory-resolver+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-devel.sha256sum] = "f0b3f44d8d714e2bfdd4f15bf4d8956ef67949f22294239bcb2fe0c5a7f54488"

URI_x86_64_v2_rust-hickory-resolver+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+webpki-roots-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+webpki-roots-devel.sha256sum] = "4b3ea2e3071dd365e9672fae752e77bcfee0ab9f1e6194b9c308c96f325639e0"

URI_x86_64_v2_rust-hickory-resolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver-devel-0.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver-devel.sha256sum] = "acf93ead88e65535cf8cb168e30725cf79c911951d7b3541df1f429481a31a45"

URI_aarch64_rust-hickory-resolver+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+backtrace-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-resolver+backtrace-devel.sha256sum] = "f1fcd4dc42f869e7a9caf5e3b889bb706d55e6c47b5eca64e7237a91a3c6132a"

URI_aarch64_rust-hickory-resolver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+default-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+default-devel}"
SRC_URI[aarch64_rust-hickory-resolver+default-devel.sha256sum] = "9a0588f3da3b578422dbe18e308d5781a69c7462805652693e32663a43cd7a84"

URI_aarch64_rust-hickory-resolver+rustls-platform-verifier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+rustls-platform-verifier-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver+rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+rustls-platform-verifier-devel}"
SRC_URI[aarch64_rust-hickory-resolver+rustls-platform-verifier-devel.sha256sum] = "1476e16823eee42dcbc3279214423a8dd00872fdcfd74ad9fc1083f841c6cd08"

URI_aarch64_rust-hickory-resolver+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+serde-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+serde-devel}"
SRC_URI[aarch64_rust-hickory-resolver+serde-devel.sha256sum] = "2c3a2cbed48b98189f5e72d098fd28e7ebd8f1dd79f88b03ab513999b898064f"

URI_aarch64_rust-hickory-resolver+system-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+system-config-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+system-config-devel}"
SRC_URI[aarch64_rust-hickory-resolver+system-config-devel.sha256sum] = "4307b05187841b4d16479159d4d00961a9d5535f19f0dcef820b671b6b7e6406"

URI_aarch64_rust-hickory-resolver+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+tokio-devel}"
SRC_URI[aarch64_rust-hickory-resolver+tokio-devel.sha256sum] = "d0c9342d29ed414f510d17bdee5a1de3f4834f845526db9b4c1b4a637fb6a5f6"

URI_aarch64_rust-hickory-resolver+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+webpki-roots-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+webpki-roots-devel}"
SRC_URI[aarch64_rust-hickory-resolver+webpki-roots-devel.sha256sum] = "3523658837d9341989c78ad53b3a2fb4fbcf93c02e5d5c0f82b0811e39874111"

URI_aarch64_rust-hickory-resolver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver-devel-0.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-hickory-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver-devel}"
SRC_URI[aarch64_rust-hickory-resolver-devel.sha256sum] = "346ea0498f093a2986cff2c493aa1e53a086e5992095344ba7aea5e13c7fffa5"

RDEPENDS:rust-hickory-resolver+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-hickory-proto+backtrace-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+default-devel = " \
 cargo \
 rust-hickory-resolver+system-config-devel \
 rust-hickory-resolver+tokio-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+rustls-platform-verifier-devel = " \
 cargo \
 rust-hickory-proto+rustls-platform-verifier-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+serde-devel = " \
 cargo \
 rust-hickory-proto+serde-devel \
 rust-hickory-resolver-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 "
RDEPENDS:rust-hickory-resolver+system-config-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-resolv-conf+default-devel \
 rust-resolv-conf+system-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-devel = " \
 cargo \
 rust-hickory-proto+tokio-devel \
 rust-hickory-resolver-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 "
RDEPENDS:rust-hickory-resolver+webpki-roots-devel = " \
 cargo \
 rust-hickory-proto+webpki-roots-devel \
 rust-hickory-resolver-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-hickory-resolver-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-moka+default-devel \
 rust-moka+sync-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 rust-parking_lot+default-devel \
 rust-rand0.9+alloc-devel \
 rust-rand0.9-devel \
 rust-smallvec+default-devel \
 rust-thiserror-devel \
 rust-tracing-devel \
 "
