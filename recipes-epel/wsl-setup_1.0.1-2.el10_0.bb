# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wsl-setup"
PV = "1.0.1"
PR = "2.el10_0"
PACKAGES = " \
 wsl-setup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wsl-setup-1.0.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "181ce6c94a17d9f8b8873b05f7a92ec910c4505d5aa78797abccb0b2656d5d36"

URI_x86_64_v2_wsl-setup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wsl-setup-1.0.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_wsl-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wsl-setup}"
SRC_URI[x86_64_v2_wsl-setup.sha256sum] = "319a083f3ad2842cea5df8987bad424c596cc14bb632eb1c6236bf1af589479e"

URI_aarch64_wsl-setup = "${EPEL_MIRROR}/aarch64/Packages/w/wsl-setup-1.0.1-2.el10_0.noarch.rpm;name=aarch64_wsl-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_wsl-setup}"
SRC_URI[aarch64_wsl-setup.sha256sum] = "a597254b2e5159270d44164b962e0bebdbe6b890ee242bf738981ab2c3fc0197"

RDEPENDS:wsl-setup = " \
 almalinux-logos \
 bash \
 "
