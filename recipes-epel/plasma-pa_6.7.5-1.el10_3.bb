# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-pa"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-pa \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-pa-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d71a06ec783ec2a4c768d0dff22cb15417b389bf950ee55e171362639aa3089"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-pa-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-pa;unpack=0"
SRC_URI[x86_64_v2_plasma-pa.sha256sum] = "7585250f8b1d69e871f2f9b444c85c4140d80620af50079be5c4a0088849f653"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-pa-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-pa;unpack=0"
SRC_URI[aarch64_plasma-pa.sha256sum] = "8144433a8aedbedce449a785bde7ac06906912d6c0f0f004bddd43451f923cfa"

RDEPENDS:plasma-pa = " \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kstatusnotifieritem \
 libcanberra \
 libplasma \
 libstdc++ \
 pipewire-pulseaudio \
 pulseaudio-libs \
 pulseaudio-qt-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
