# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jplephem"
PV = "2.24"
PR = "1.el10_3"
PACKAGES = " \
 python3-jplephem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jplephem-2.24-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2e064e5182bdc6049c8802944473683f70ea88cedae659b09ecfecd094092b0"

URI_x86_64_v2_python3-jplephem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jplephem-2.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jplephem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jplephem}"
SRC_URI[x86_64_v2_python3-jplephem.sha256sum] = "7989da505e873c99bc1ed6a9925f0bb243fb761e951a214021544e259a76ecc3"

URI_aarch64_python3-jplephem = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jplephem-2.24-1.el10_3.noarch.rpm;name=aarch64_python3-jplephem;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jplephem}"
SRC_URI[aarch64_python3-jplephem.sha256sum] = "df300c2e138ca54e05a63b5e015a127a537256911d8df1d21cff2f4befad4a50"

RDEPENDS:python3-jplephem = " \
 python3 \
 python3-numpy \
 "
