# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-iniparse"
PV = "0.5"
PR = "10.el10"
PACKAGES = " \
 python3-iniparse \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-iniparse-0.5-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6eb87be196f7639145908fc5118422a6f2bd5c6939d8d85d2481c5720495a1d2"

URI_x86_64_v2_python3-iniparse = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-iniparse-0.5-10.el10.noarch.rpm;name=x86_64_v2_python3-iniparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-iniparse}"
SRC_URI[x86_64_v2_python3-iniparse.sha256sum] = "d8e78ac33aa75e782f9d1914bab81b7985b599051ef154209cd0502717109714"

URI_aarch64_python3-iniparse = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-iniparse-0.5-10.el10.noarch.rpm;name=aarch64_python3-iniparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-iniparse}"
SRC_URI[aarch64_python3-iniparse.sha256sum] = "d8e78ac33aa75e782f9d1914bab81b7985b599051ef154209cd0502717109714"

RDEPENDS:python3-iniparse = " \
 python3 \
 python3-six \
 "
