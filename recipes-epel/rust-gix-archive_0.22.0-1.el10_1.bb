# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-archive"
PV = "0.22.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-archive+default-devel \
 rust-gix-archive+document-features-devel \
 rust-gix-archive+tar-devel \
 rust-gix-archive+tar_gz-devel \
 rust-gix-archive+zip-devel \
 rust-gix-archive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-archive-0.22.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fb689d8ccbf96562633024155d87084fef07e1db42acf44fbbe2b3554a66ec9"

URI_x86_64_v2_rust-gix-archive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+default-devel-0.22.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+default-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+default-devel.sha256sum] = "d9e56e68d6fa074ec0ab7691fdcba593eefc521c3a83a474f737cd720891b4b4"

URI_x86_64_v2_rust-gix-archive+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+document-features-devel-0.22.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+document-features-devel.sha256sum] = "ddfccfb616b639cbe049d15a031405830975272a40c52da18d90f8bc496fc1dd"

URI_x86_64_v2_rust-gix-archive+tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+tar-devel-0.22.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+tar-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+tar-devel.sha256sum] = "09ac32704fe64cba666a137dfa2ce4a0d66b7a8a1db96f96ca9b33d67bf33ad7"

URI_x86_64_v2_rust-gix-archive+tar_gz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+tar_gz-devel-0.22.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+tar_gz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+tar_gz-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+tar_gz-devel.sha256sum] = "9bff4aaeb09d0b9baea532e06688b27c5defbd31f58fc8c469a07854ed619686"

URI_x86_64_v2_rust-gix-archive+zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+zip-devel-0.22.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+zip-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+zip-devel.sha256sum] = "49d32ae8ac172cf82130758fcdd054798207fe266daf075ea13f0f88c84de12c"

URI_x86_64_v2_rust-gix-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive-devel-0.22.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive-devel}"
SRC_URI[x86_64_v2_rust-gix-archive-devel.sha256sum] = "d2791864abf9496deef54a4050544cda655fb7513c759b1662bac8c841913cf2"

URI_aarch64_rust-gix-archive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+default-devel-0.22.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-archive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+default-devel}"
SRC_URI[aarch64_rust-gix-archive+default-devel.sha256sum] = "7fde568661e21c492d4d3622690c93051d4fc230c4a00b17739bf039c1cf2cb4"

URI_aarch64_rust-gix-archive+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+document-features-devel-0.22.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-archive+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+document-features-devel}"
SRC_URI[aarch64_rust-gix-archive+document-features-devel.sha256sum] = "f69e0aa547b8edd747e8ce43fddd8b0183332bcf4d2f1d9e36a17cc5616b8c34"

URI_aarch64_rust-gix-archive+tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+tar-devel-0.22.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-archive+tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+tar-devel}"
SRC_URI[aarch64_rust-gix-archive+tar-devel.sha256sum] = "85879693da06113d51fab52726133474aa769ed29dbd22b3bb4eb94e6ce78e1e"

URI_aarch64_rust-gix-archive+tar_gz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+tar_gz-devel-0.22.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-archive+tar_gz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+tar_gz-devel}"
SRC_URI[aarch64_rust-gix-archive+tar_gz-devel.sha256sum] = "0407d5573eb7d5dc3bf1e40256aadc374452993d818d499ceff4759782f230f3"

URI_aarch64_rust-gix-archive+zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+zip-devel-0.22.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-archive+zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+zip-devel}"
SRC_URI[aarch64_rust-gix-archive+zip-devel.sha256sum] = "7ad499a446ea08a4d31d515cbedd5a527f904fba1859c5cfa7c25f827e694b20"

URI_aarch64_rust-gix-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive-devel-0.22.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive-devel}"
SRC_URI[aarch64_rust-gix-archive-devel.sha256sum] = "1cb215a415a6b6f0834ad31c7c235c91e813ee27e15e880e96ec2d6ff3798fec"

RDEPENDS:rust-gix-archive+default-devel = " \
 cargo \
 rust-gix-archive+tar-devel \
 rust-gix-archive+tar_gz-devel \
 rust-gix-archive+zip-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+tar-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-gix-path+default-devel \
 rust-tar+default-devel \
 "
RDEPENDS:rust-gix-archive+tar_gz-devel = " \
 cargo \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-gix-archive+tar-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+zip-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-gix-archive-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-object+default-devel \
 rust-gix-worktree-stream+default-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 rust-thiserror+default-devel \
 "
