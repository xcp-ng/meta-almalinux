# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "node-exporter"
PV = "1.12.1"
PR = "1.el10_3"
PACKAGES = " \
 node-exporter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/node-exporter-1.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecb0fd74f39c98c65c1fca719cb3baf1e7d1f8382c10bef2d1d6350b6c421568"

URI_x86_64_v2_node-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/node-exporter-1.12.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_node-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_node-exporter}"
SRC_URI[x86_64_v2_node-exporter.sha256sum] = "74e9eea34f0374b40e976b575f1a21ae44eadd6e73d61e9bdaaca1c9583b5c05"

URI_aarch64_node-exporter = "${EPEL_MIRROR}/aarch64/Packages/n/node-exporter-1.12.1-1.el10_3.aarch64.rpm;name=aarch64_node-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_node-exporter}"
SRC_URI[aarch64_node-exporter.sha256sum] = "5c3908b47ec0209313c8545360c57f0e09bed05d055668271102f3bd32fb1b8c"

RDEPENDS:node-exporter = " \
 bash \
 glibc \
 shadow-utils \
 "
