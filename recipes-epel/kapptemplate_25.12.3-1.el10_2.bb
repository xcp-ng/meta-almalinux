# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kapptemplate"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kapptemplate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kapptemplate-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d4a71dfaa3db451f851e0a051c97531d1a3ca11c2863ac587dbdb95ae0cdc9b"

URI_x86_64_v2_kapptemplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kapptemplate-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kapptemplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kapptemplate}"
SRC_URI[x86_64_v2_kapptemplate.sha256sum] = "6631672a938f16a085199bb7da3e58883fd40414ac2d32d3e9cc0f7f12f79332"

URI_aarch64_kapptemplate = "${EPEL_MIRROR}/aarch64/Packages/k/kapptemplate-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kapptemplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_kapptemplate}"
SRC_URI[aarch64_kapptemplate.sha256sum] = "c11358d8a5ba982cb9788864b1eae0bd21f7fa45f3d58a7abf8679ed175777b2"

RDEPENDS:kapptemplate = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
