# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-these"
PV = "1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-these \
 ghc-these-devel \
 ghc-these-doc \
 ghc-these-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-these-1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7687b30a9c517b8b6aedb2f3d2f3ac58cbe262f5914921edbcf702421fbf0bf0"

URI_x86_64_v2_ghc-these = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-these-1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-these;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-these}"
SRC_URI[x86_64_v2_ghc-these.sha256sum] = "5c7238fd1fd8d694d22a249533acbe8f0ebf05e056434e9af80652ec3717dab8"

URI_x86_64_v2_ghc-these-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-these-devel-1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-these-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-these-devel}"
SRC_URI[x86_64_v2_ghc-these-devel.sha256sum] = "8d0db9e00764d86fc1a5901a4cc62f66c51f41131cf3f25d9ad6489bad69946c"

URI_x86_64_v2_ghc-these-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-these-doc-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-these-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-these-doc}"
SRC_URI[x86_64_v2_ghc-these-doc.sha256sum] = "ac86b720d0cef652b6f10402bb1d6bdf4b2afc7ecb75049ee1c588604f8f56a7"

URI_x86_64_v2_ghc-these-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-these-prof-1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-these-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-these-prof}"
SRC_URI[x86_64_v2_ghc-these-prof.sha256sum] = "435d2d527b4a0726c54742efa9fa82cb17f5dc2cbd5b2a0e1a88b4488200c7fc"

URI_aarch64_ghc-these = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-these-1.2.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-these;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-these}"
SRC_URI[aarch64_ghc-these.sha256sum] = "4bc768c56b6f41daa11b1f32dd1e0bcf48f0f2ca5d622e35a00a74ea3d7311a4"

URI_aarch64_ghc-these-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-these-devel-1.2.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-these-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-these-devel}"
SRC_URI[aarch64_ghc-these-devel.sha256sum] = "27dd8b0d41a9b8138b21e22b8dc3cdf6cefaa0af46cf935eb10492f750748dba"

URI_aarch64_ghc-these-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-these-doc-1.2.1-1.el10_0.noarch.rpm;name=aarch64_ghc-these-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-these-doc}"
SRC_URI[aarch64_ghc-these-doc.sha256sum] = "5a84386db4facde4a703797e33121fd9d17314f5e00a49efbf41371b3bfc13bf"

URI_aarch64_ghc-these-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-these-prof-1.2.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-these-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-these-prof}"
SRC_URI[aarch64_ghc-these-prof.sha256sum] = "91e2bf066abedf202cbc06dcaf35ecad33e0e08fd0e5f3e0015e3ba4406f41c3"

RDEPENDS:ghc-these = " \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-these-devel = " \
 ghc-assoc-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-these \
 "
RDEPENDS:ghc-these-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-these-prof = " \
 ghc-assoc-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-these-devel \
 "
