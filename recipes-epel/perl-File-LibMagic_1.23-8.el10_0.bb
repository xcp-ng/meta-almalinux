# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-LibMagic"
PV = "1.23"
PR = "8.el10_0"
PACKAGES = " \
 perl-File-LibMagic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-LibMagic-1.23-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc8c69f86ef6ec2ce36fc06f9d79992376205fd1c49af5b603d9a6da9b4d0b1f"

URI_x86_64_v2_perl-File-LibMagic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-LibMagic-1.23-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-File-LibMagic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-LibMagic}"
SRC_URI[x86_64_v2_perl-File-LibMagic.sha256sum] = "7b05023fe3b9111afb5a3f7f71be867b285cf27f21425c3c4704366a6ace5b75"

URI_aarch64_perl-File-LibMagic = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-LibMagic-1.23-8.el10_0.aarch64.rpm;name=aarch64_perl-File-LibMagic;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-LibMagic}"
SRC_URI[aarch64_perl-File-LibMagic.sha256sum] = "787d84c512da7178607b73e1454a588b85f46cb8dca3459b991e04f9697a290d"

RDEPENDS:perl-File-LibMagic = " \
 file-libs \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-File-LibMagic \
 perl-Scalar-List-Utils \
 perl-libs \
 "
