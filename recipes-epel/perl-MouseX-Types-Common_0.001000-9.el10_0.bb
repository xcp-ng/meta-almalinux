# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MouseX-Types-Common"
PV = "0.001000"
PR = "9.el10_0"
PACKAGES = " \
 perl-MouseX-Types-Common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MouseX-Types-Common-0.001000-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca9b838a2fa71171cc6d0fbeda332c5eb6e5b306cbc9acf80b020053b0e56d5c"

URI_x86_64_v2_perl-MouseX-Types-Common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MouseX-Types-Common-0.001000-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MouseX-Types-Common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MouseX-Types-Common}"
SRC_URI[x86_64_v2_perl-MouseX-Types-Common.sha256sum] = "25f0d9940a7a0ca47ee2e96638449f44798b2da9aee40327bc4326461c5af106"

URI_aarch64_perl-MouseX-Types-Common = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MouseX-Types-Common-0.001000-9.el10_0.noarch.rpm;name=aarch64_perl-MouseX-Types-Common;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MouseX-Types-Common}"
SRC_URI[aarch64_perl-MouseX-Types-Common.sha256sum] = "e2f9bb7ff2081fe196b5cecbcf3cd387c9b5b40511e67389fce5893d152914f2"

RDEPENDS:perl-MouseX-Types-Common = " \
 perl-MouseX-Types \
 perl-libs \
 "
