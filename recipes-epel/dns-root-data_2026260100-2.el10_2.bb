# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dns-root-data"
PV = "2026260100"
PR = "2.el10_2"
PACKAGES = " \
 dns-root-data \
 dns-root-data-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dns-root-data-2026260100-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44d17d033e614a7bdfbbb4f058dcecbe74f0fdc872f1acd78388f7e9d09dd9bd"

URI_x86_64_v2_dns-root-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dns-root-data-2026260100-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dns-root-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dns-root-data}"
SRC_URI[x86_64_v2_dns-root-data.sha256sum] = "46f5a43a0c05b3130cda773d3ac2240fc92a5d0ac73fcf95606aa0a9484a0a1a"

URI_x86_64_v2_dns-root-data-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dns-root-data-utils-2026260100-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dns-root-data-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dns-root-data-utils}"
SRC_URI[x86_64_v2_dns-root-data-utils.sha256sum] = "740f704c8e25ca1db6df46f77f056b935b074457e56537247d8ff093cceddc05"

URI_aarch64_dns-root-data = "${EPEL_MIRROR}/aarch64/Packages/d/dns-root-data-2026260100-2.el10_2.noarch.rpm;name=aarch64_dns-root-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_dns-root-data}"
SRC_URI[aarch64_dns-root-data.sha256sum] = "8f502da04ce3f3cb17c8fada17f131c08f9c1e06e9a88404f83c5aff6d301420"

URI_aarch64_dns-root-data-utils = "${EPEL_MIRROR}/aarch64/Packages/d/dns-root-data-utils-2026260100-2.el10_2.noarch.rpm;name=aarch64_dns-root-data-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_dns-root-data-utils}"
SRC_URI[aarch64_dns-root-data-utils.sha256sum] = "19a7a0a7d6529cd6f89db3eb4861ad499853f06179bdfaff739d4d94825eec07"

RDEPENDS:dns-root-data = " \
 "
RDEPENDS:dns-root-data-utils = " \
 dns-root-data \
 openssl \
 python3 \
 python3-dns \
 "
