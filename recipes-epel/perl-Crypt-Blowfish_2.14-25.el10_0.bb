# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-Blowfish"
PV = "2.14"
PR = "25.el10_0"
PACKAGES = " \
 perl-Crypt-Blowfish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-Blowfish-2.14-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa76b0861f58695ec26609b37ea8cdf0593618b33b41c53180aef909ff3bc765"

URI_x86_64_v2_perl-Crypt-Blowfish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-Blowfish-2.14-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-Blowfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-Blowfish}"
SRC_URI[x86_64_v2_perl-Crypt-Blowfish.sha256sum] = "ea30cc082032aff292e134686e23fcd4a0050af11fc287ba3dc52bbe8ac6a490"

URI_aarch64_perl-Crypt-Blowfish = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-Blowfish-2.14-25.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-Blowfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-Blowfish}"
SRC_URI[aarch64_perl-Crypt-Blowfish.sha256sum] = "beb0bb261a4bbead557040a459f8b7716f2c6fe93da26033ad39ef92f534c2fb"

RDEPENDS:perl-Crypt-Blowfish = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
