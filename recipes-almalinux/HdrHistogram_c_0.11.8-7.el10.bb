# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "HdrHistogram_c"
PV = "0.11.8"
PR = "7.el10"
PACKAGES = " \
 HdrHistogram_c \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/HdrHistogram_c-0.11.8-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4786d67baf85ea4ca0856c9011a4ad9c0ad0d5822465f97f04067d9ba277ffda"

URI_x86_64_v2_HdrHistogram_c = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/HdrHistogram_c-0.11.8-7.el10.x86_64_v2.rpm;name=x86_64_v2_HdrHistogram_c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HdrHistogram_c}"
SRC_URI[x86_64_v2_HdrHistogram_c.sha256sum] = "b61276d3ce6b27673f86c102a3bb6c7bcbb6ad2de7e0c81d7d69eef44c13cd9b"

URI_aarch64_HdrHistogram_c = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/HdrHistogram_c-0.11.8-7.el10.aarch64.rpm;name=aarch64_HdrHistogram_c;unpack=0"
SRC_URI:append = " ${URI_aarch64_HdrHistogram_c}"
SRC_URI[aarch64_HdrHistogram_c.sha256sum] = "30c324d61354ec2f15d930ac90e1af35a7bf995b59c7df8bab4eaea080988f9a"

RDEPENDS:HdrHistogram_c = " \
 glibc \
 zlib-ng-compat \
 "
