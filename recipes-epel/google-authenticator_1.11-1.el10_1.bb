# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-authenticator"
PV = "1.11"
PR = "1.el10_1"
PACKAGES = " \
 google-authenticator \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/google-authenticator-1.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f6b100a713f56bf239bb76fb37cd7c0516b53ec628c212e39b987c7e91a52d6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-authenticator-1.11-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-authenticator;unpack=0"
SRC_URI[x86_64_v2_google-authenticator.sha256sum] = "a9504c01c1751d96f39d4ed38907005654bde4a4828da73563a7c307e16f521f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/google-authenticator-1.11-1.el10_1.aarch64.rpm;name=aarch64_google-authenticator;unpack=0"
SRC_URI[aarch64_google-authenticator.sha256sum] = "51f0b6937313c464a1c8786bab587eaa5c53323a17e72a1dd7be10c5163685d2"

RDEPENDS:google-authenticator = " \
 glibc \
 pam-libs \
 "
