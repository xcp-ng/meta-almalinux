# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kauth"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kauth \
 kf6-kauth-devel \
 kf6-kauth-doc \
 kf6-kauth-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kauth-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc7dabe590534a83133c81fd0a3f2d3b52fb09f195e3e3286de86d7eb3f8753d"

URI_x86_64_v2_kf6-kauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth}"
SRC_URI[x86_64_v2_kf6-kauth.sha256sum] = "7006ffa555642579084a1ed8c5877e6fa819f96b918723bf43fb50f97fb7569d"

URI_x86_64_v2_kf6-kauth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-devel}"
SRC_URI[x86_64_v2_kf6-kauth-devel.sha256sum] = "5f0cf5cdbceecc1533ff965c0bec80f0ef4cee7ae680c4c6c3ad41a103928d30"

URI_x86_64_v2_kf6-kauth-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kauth-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-doc}"
SRC_URI[x86_64_v2_kf6-kauth-doc.sha256sum] = "0d082a947f8dbc197229ba0733cfb9bdf7d6ca5ba2beccfbd297a4cb929b5cb0"

URI_x86_64_v2_kf6-kauth-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kauth-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-html}"
SRC_URI[x86_64_v2_kf6-kauth-html.sha256sum] = "03ac8ab0192df3887145af8fe2a321c63b80cce19d838dc0cd48034cad9e7add"

URI_aarch64_kf6-kauth = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth}"
SRC_URI[aarch64_kf6-kauth.sha256sum] = "b716a8ccbc6e940432996da8c5fadedf28529b5711ed52213ae9af642206e0ef"

URI_aarch64_kf6-kauth-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-devel}"
SRC_URI[aarch64_kf6-kauth-devel.sha256sum] = "881b6721734b549c2797cce345fe507968425f97588a685acfc147cfe004b4e4"

URI_aarch64_kf6-kauth-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kauth-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-doc}"
SRC_URI[aarch64_kf6-kauth-doc.sha256sum] = "2448b4a28e81aa5400bc9a2997f917819d84367941a8456e189fdf49ef83b517"

URI_aarch64_kf6-kauth-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kauth-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-html}"
SRC_URI[aarch64_kf6-kauth-html.sha256sum] = "3c381227ec0cdbab7a07a7cd9ec67137ef60172b73e6687152ef0216e1233a07"

RDEPENDS:kf6-kauth = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-kwindowsystem \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kauth-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons-devel \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kauth-doc = " \
 "
RDEPENDS:kf6-kauth-html = " \
 "
