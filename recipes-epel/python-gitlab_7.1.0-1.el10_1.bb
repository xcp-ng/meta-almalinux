# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gitlab"
PV = "7.1.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-gitlab \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-gitlab-7.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b66cb7577d88f64f9674857617526bf79ead94a1a89d4b1025139cfa3d5d4d65"

URI_x86_64_v2_python3-gitlab = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gitlab-7.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gitlab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gitlab}"
SRC_URI[x86_64_v2_python3-gitlab.sha256sum] = "aaa73f5447810de1c55e4582fcfe480611852f2dc1943a7bd1ca1ea3131acd7d"

URI_aarch64_python3-gitlab = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gitlab-7.1.0-1.el10_1.noarch.rpm;name=aarch64_python3-gitlab;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gitlab}"
SRC_URI[aarch64_python3-gitlab.sha256sum] = "44507cac6450225316ec9f22c2172984587debeb70a95c70e489a31c7f1b28e9"

RDEPENDS:python3-gitlab = " \
 python3 \
 python3-requests \
 python3-requests-toolbelt \
 "
