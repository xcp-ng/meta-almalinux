# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nix0.27"
PV = "0.27.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-nix0.27+acct-devel \
 rust-nix0.27+aio-devel \
 rust-nix0.27+default-devel \
 rust-nix0.27+dir-devel \
 rust-nix0.27+env-devel \
 rust-nix0.27+event-devel \
 rust-nix0.27+feature-devel \
 rust-nix0.27+fs-devel \
 rust-nix0.27+hostname-devel \
 rust-nix0.27+inotify-devel \
 rust-nix0.27+ioctl-devel \
 rust-nix0.27+kmod-devel \
 rust-nix0.27+memoffset-devel \
 rust-nix0.27+mman-devel \
 rust-nix0.27+mount-devel \
 rust-nix0.27+mqueue-devel \
 rust-nix0.27+net-devel \
 rust-nix0.27+personality-devel \
 rust-nix0.27+pin-utils-devel \
 rust-nix0.27+poll-devel \
 rust-nix0.27+process-devel \
 rust-nix0.27+pthread-devel \
 rust-nix0.27+ptrace-devel \
 rust-nix0.27+quota-devel \
 rust-nix0.27+reboot-devel \
 rust-nix0.27+resource-devel \
 rust-nix0.27+sched-devel \
 rust-nix0.27+signal-devel \
 rust-nix0.27+socket-devel \
 rust-nix0.27+term-devel \
 rust-nix0.27+time-devel \
 rust-nix0.27+ucontext-devel \
 rust-nix0.27+uio-devel \
 rust-nix0.27+user-devel \
 rust-nix0.27+zerocopy-devel \
 rust-nix0.27-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nix0.27-0.27.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "031733f6fc333cee042639185bfbf232f3ce1594b98829260e347909044fe658"

URI_x86_64_v2_rust-nix0.27+acct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+acct-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+acct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+acct-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+acct-devel.sha256sum] = "bbb58fffd0198d420cd34b7f7fc172bfbdd8dcc9500a1487dc81738a0b063e22"

URI_x86_64_v2_rust-nix0.27+aio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+aio-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+aio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+aio-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+aio-devel.sha256sum] = "9ed6618dff0f806ec081e44fd7476b7bfce437b1332c96a33d6725f51ed06e2a"

URI_x86_64_v2_rust-nix0.27+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+default-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+default-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+default-devel.sha256sum] = "c6e2e1d9d221cad86895cf7e92044d5f50b994801ac0eb9614abac936f248454"

URI_x86_64_v2_rust-nix0.27+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+dir-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+dir-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+dir-devel.sha256sum] = "e7b15432f7a872a9a61d41c10af3f9e960cc922cba481a2cd4e481d10619ef91"

URI_x86_64_v2_rust-nix0.27+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+env-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+env-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+env-devel.sha256sum] = "b32ac088efb10a3b8f1bd75e5597ee8954fc6ea8e3f0451eeb8fe0a7ed36dba2"

URI_x86_64_v2_rust-nix0.27+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+event-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+event-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+event-devel.sha256sum] = "20c3903523987fa85c1aeb344c293ed96d638435ce9d25601193bf764ac5641a"

URI_x86_64_v2_rust-nix0.27+feature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+feature-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+feature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+feature-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+feature-devel.sha256sum] = "245f13b2f2a4661c0fddd5ab72dbc5cdea0dcdb2f3fe98b182c1840d4f23e511"

URI_x86_64_v2_rust-nix0.27+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+fs-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+fs-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+fs-devel.sha256sum] = "aa3957158171e45d6aacdf937fb8f573b72231c83f62918724b6b53b3c8a09e6"

URI_x86_64_v2_rust-nix0.27+hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+hostname-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+hostname-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+hostname-devel.sha256sum] = "85b7da72f2319b74093759bd3f6a79d1647cf3f26de6e1b52426ba033972f07a"

URI_x86_64_v2_rust-nix0.27+inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+inotify-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+inotify-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+inotify-devel.sha256sum] = "d3652e30ed3225d23e76f2433d69be842e96f6104f16340ae56631133682a4df"

URI_x86_64_v2_rust-nix0.27+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+ioctl-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+ioctl-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+ioctl-devel.sha256sum] = "a36d91d071e45be43a265047a7a698cd3722ef27ffed40a121b78eea9e6037a6"

URI_x86_64_v2_rust-nix0.27+kmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+kmod-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+kmod-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+kmod-devel.sha256sum] = "dd472b118ecf7a99f663cb73c7512922cf034d7782b4a223692884c9aee3f707"

URI_x86_64_v2_rust-nix0.27+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+memoffset-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+memoffset-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+memoffset-devel.sha256sum] = "1fdee86399bd2ac21a033fff2f9cb202a0979d1b1b1a467ef8f3dbe4001c840b"

URI_x86_64_v2_rust-nix0.27+mman-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+mman-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+mman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+mman-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+mman-devel.sha256sum] = "674f3b2173a85cdbfd1a061e5fa8f672f3ba149533d800810fd57fc6b1b11f0f"

URI_x86_64_v2_rust-nix0.27+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+mount-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+mount-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+mount-devel.sha256sum] = "7beef864b212866d4d6e6848108415f80513f30d7055a4338ed1c44eeae5c207"

URI_x86_64_v2_rust-nix0.27+mqueue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+mqueue-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+mqueue-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+mqueue-devel.sha256sum] = "c9d17ba972983adbc420e7d90b206fc35e32997037b072d1ca6af86c303c036e"

URI_x86_64_v2_rust-nix0.27+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+net-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+net-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+net-devel.sha256sum] = "7d1d1752f8a3e6d30caa3bc30c7c144d9aea56c454df6c15bb6ed2156dba4a8d"

URI_x86_64_v2_rust-nix0.27+personality-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+personality-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+personality-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+personality-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+personality-devel.sha256sum] = "95300631c1d9055826f9f243f5a39210b07e9881a2b57c899f08facffe1c7183"

URI_x86_64_v2_rust-nix0.27+pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+pin-utils-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+pin-utils-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+pin-utils-devel.sha256sum] = "f99e2e275f6fb49fa1551f9f8cb8f635c08a47f27a63a81088c2ca4f0de0f6fc"

URI_x86_64_v2_rust-nix0.27+poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+poll-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+poll-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+poll-devel.sha256sum] = "42491719d2663b2d7d0cf1175d29abf2af9856f5df3b69cbb94e7302b59093c3"

URI_x86_64_v2_rust-nix0.27+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+process-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+process-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+process-devel.sha256sum] = "a0c8c3ffe9471c4ae2a44c389f865b567db0d511868f4993a464451c0479ea0f"

URI_x86_64_v2_rust-nix0.27+pthread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+pthread-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+pthread-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+pthread-devel.sha256sum] = "ea6fae6402cac5adba3e51ec0ba367dd6e0123c230f4c5e3c43a701ab465600c"

URI_x86_64_v2_rust-nix0.27+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+ptrace-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+ptrace-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+ptrace-devel.sha256sum] = "76506ff743a1ffb76efc947ace4e6bedc8c2836dbdd282c2e1ce924de937ee73"

URI_x86_64_v2_rust-nix0.27+quota-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+quota-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+quota-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+quota-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+quota-devel.sha256sum] = "a2be5ae1161e522dff53056f56e3cf19df346ec3af064c0a7d4d2fb3c93e5b65"

URI_x86_64_v2_rust-nix0.27+reboot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+reboot-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+reboot-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+reboot-devel.sha256sum] = "9a61e5d1528023748316ca1ec2e3ae9e68bcbae50bba39999c3c7deac0dee45e"

URI_x86_64_v2_rust-nix0.27+resource-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+resource-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+resource-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+resource-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+resource-devel.sha256sum] = "df32de856fcace22a5a2d919d75f05912f1eb0ba251852390007455f6436a280"

URI_x86_64_v2_rust-nix0.27+sched-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+sched-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+sched-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+sched-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+sched-devel.sha256sum] = "b0b65c9b8cb511560bd9e495d311aa0953c0ee486487b647912dda0baad0f4ad"

URI_x86_64_v2_rust-nix0.27+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+signal-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+signal-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+signal-devel.sha256sum] = "a192d5e5105e2057853353de47d333c1e72ea8f79b08f4fa70f6eec900bfd52c"

URI_x86_64_v2_rust-nix0.27+socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+socket-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+socket-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+socket-devel.sha256sum] = "844f80097c2254f171b1cf7a85f1a5acfe9b10386f2b8893dd1f0f695520ec2a"

URI_x86_64_v2_rust-nix0.27+term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+term-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+term-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+term-devel.sha256sum] = "98cb469901079c542890888bbef54287d39dc2928044fee9db0f7e9df6bab1de"

URI_x86_64_v2_rust-nix0.27+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+time-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+time-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+time-devel.sha256sum] = "5f17f9e5899659567d9dca98ef5130d334469cec573473ad968b03afba6e46ac"

URI_x86_64_v2_rust-nix0.27+ucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+ucontext-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+ucontext-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+ucontext-devel.sha256sum] = "4aea114176b503d8d378ed7032c46331e92fd8964725547c8d86fdf8f8336359"

URI_x86_64_v2_rust-nix0.27+uio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+uio-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+uio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+uio-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+uio-devel.sha256sum] = "3ed3a68b2ecebd3735b34731bba32b56e2ce66f60ddc03dbafbae7869161179f"

URI_x86_64_v2_rust-nix0.27+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+user-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+user-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+user-devel.sha256sum] = "28eacdc74dd5b642cc6d779db8f29ceb48ee1bd6e7887329da187e56d586bdd6"

URI_x86_64_v2_rust-nix0.27+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27+zerocopy-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-nix0.27+zerocopy-devel.sha256sum] = "c1dda00d2fd2dd97d10fbf3c32aac5110258eddd1bce937c3cb9e4f5eb628afd"

URI_x86_64_v2_rust-nix0.27-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix0.27-devel-0.27.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix0.27-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix0.27-devel}"
SRC_URI[x86_64_v2_rust-nix0.27-devel.sha256sum] = "193199a563a202fa00320956c5332074e0e104294d7c48398777b327a530ed26"

URI_aarch64_rust-nix0.27+acct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+acct-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+acct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+acct-devel}"
SRC_URI[aarch64_rust-nix0.27+acct-devel.sha256sum] = "c889ef6f17f489b5df0f17bc3c16caa3e975147a691c78c0d581d62ea4d24f09"

URI_aarch64_rust-nix0.27+aio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+aio-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+aio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+aio-devel}"
SRC_URI[aarch64_rust-nix0.27+aio-devel.sha256sum] = "e0cec38dce998022ce240bbc1084284715010950c2b58326e1ada675087e44e3"

URI_aarch64_rust-nix0.27+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+default-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+default-devel}"
SRC_URI[aarch64_rust-nix0.27+default-devel.sha256sum] = "ccca6ec30ec806e74dd388072ef1a88f2346461cd198d81b5e42d47d471c7d0f"

URI_aarch64_rust-nix0.27+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+dir-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+dir-devel}"
SRC_URI[aarch64_rust-nix0.27+dir-devel.sha256sum] = "28b74394c5aa8f653be1e5057e10f1768f697c5a0fa072a6c00e1eeb1f8fdc20"

URI_aarch64_rust-nix0.27+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+env-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+env-devel}"
SRC_URI[aarch64_rust-nix0.27+env-devel.sha256sum] = "7277ceffd6c8fe13d723cc9ad644461cfb798dacbfc3d0b0609ae24036efc02f"

URI_aarch64_rust-nix0.27+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+event-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+event-devel}"
SRC_URI[aarch64_rust-nix0.27+event-devel.sha256sum] = "7a751eb617de4c8d9590086e09ae9882c6ea1d70624543fb5730ff3d4f988a49"

URI_aarch64_rust-nix0.27+feature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+feature-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+feature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+feature-devel}"
SRC_URI[aarch64_rust-nix0.27+feature-devel.sha256sum] = "49807f5ca5832ca86fd0f98333cf568f22ee90d0c60a968ba0e261ec3944a617"

URI_aarch64_rust-nix0.27+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+fs-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+fs-devel}"
SRC_URI[aarch64_rust-nix0.27+fs-devel.sha256sum] = "c2ce2a6349be373c3fb34fbb5d83f5de0e6893d42f9d4261b7b216f0011d8c06"

URI_aarch64_rust-nix0.27+hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+hostname-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+hostname-devel}"
SRC_URI[aarch64_rust-nix0.27+hostname-devel.sha256sum] = "3d832ba5f87a8e28985c7c376f738f31a885efd2f547cf8d76b319d09b318ec6"

URI_aarch64_rust-nix0.27+inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+inotify-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+inotify-devel}"
SRC_URI[aarch64_rust-nix0.27+inotify-devel.sha256sum] = "d2c63d05872c26e1dbeb2f2b0d2ab3cfc0c6a06e73cc2d8faf8eb5f6846e02c6"

URI_aarch64_rust-nix0.27+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+ioctl-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+ioctl-devel}"
SRC_URI[aarch64_rust-nix0.27+ioctl-devel.sha256sum] = "e263049bc1e7392fd07f03040ec3d1353747792f156b8bf0a9dad0044a60edf2"

URI_aarch64_rust-nix0.27+kmod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+kmod-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+kmod-devel}"
SRC_URI[aarch64_rust-nix0.27+kmod-devel.sha256sum] = "90ce9331accd3dcb9743cab67cce21a253c770732874344a4f68a63d5a75d2f7"

URI_aarch64_rust-nix0.27+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+memoffset-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+memoffset-devel}"
SRC_URI[aarch64_rust-nix0.27+memoffset-devel.sha256sum] = "f036c86ffd791fe507506e1bd9497f3cf98d430f7d08a2ac755f467610e5548e"

URI_aarch64_rust-nix0.27+mman-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+mman-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+mman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+mman-devel}"
SRC_URI[aarch64_rust-nix0.27+mman-devel.sha256sum] = "6ed01ac658f3d2c772185a7afdf63af07efdcc8d307ff3359efb97201ad2c88c"

URI_aarch64_rust-nix0.27+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+mount-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+mount-devel}"
SRC_URI[aarch64_rust-nix0.27+mount-devel.sha256sum] = "857b3c02be9dac33bdcb94eeaa91534d41cc09a206b72ed90104bfa20d16e193"

URI_aarch64_rust-nix0.27+mqueue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+mqueue-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+mqueue-devel}"
SRC_URI[aarch64_rust-nix0.27+mqueue-devel.sha256sum] = "347c5130759af6ba4ace31b2411a84e18c374b55812e3197ed8849661d630253"

URI_aarch64_rust-nix0.27+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+net-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+net-devel}"
SRC_URI[aarch64_rust-nix0.27+net-devel.sha256sum] = "c4b7266bd7395715f70652c9fad765061f2e6e2abbb14dbec3baa446bda44937"

URI_aarch64_rust-nix0.27+personality-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+personality-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+personality-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+personality-devel}"
SRC_URI[aarch64_rust-nix0.27+personality-devel.sha256sum] = "722cca50b69a5086921b497df2fced0ea1f61a8e00602537b5735f538ffda0b9"

URI_aarch64_rust-nix0.27+pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+pin-utils-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+pin-utils-devel}"
SRC_URI[aarch64_rust-nix0.27+pin-utils-devel.sha256sum] = "085237f12bab6727303a7491c5bd7c5fe0383671e30ee54255150dca18524558"

URI_aarch64_rust-nix0.27+poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+poll-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+poll-devel}"
SRC_URI[aarch64_rust-nix0.27+poll-devel.sha256sum] = "03df2cecfa685091382307bf1265bef61451996e847fa3096d9bd5d0ed3de4c8"

URI_aarch64_rust-nix0.27+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+process-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+process-devel}"
SRC_URI[aarch64_rust-nix0.27+process-devel.sha256sum] = "c7bf850db2aef233a0c86009d7095dbc0734518675b3b80c646f31d6bc0f3f1a"

URI_aarch64_rust-nix0.27+pthread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+pthread-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+pthread-devel}"
SRC_URI[aarch64_rust-nix0.27+pthread-devel.sha256sum] = "f88726f3bf43f7e33703cd08dbbf79a10c5852927e0cbb7a880737abb9637f84"

URI_aarch64_rust-nix0.27+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+ptrace-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+ptrace-devel}"
SRC_URI[aarch64_rust-nix0.27+ptrace-devel.sha256sum] = "1008815feb8e8af6d457326c168010fea03cee4411d326cdff92375ba8a40826"

URI_aarch64_rust-nix0.27+quota-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+quota-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+quota-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+quota-devel}"
SRC_URI[aarch64_rust-nix0.27+quota-devel.sha256sum] = "702b2f48935eb0a61c5b38d03a884ba577200aed82fc8ab1b7342ea759779dc5"

URI_aarch64_rust-nix0.27+reboot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+reboot-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+reboot-devel}"
SRC_URI[aarch64_rust-nix0.27+reboot-devel.sha256sum] = "e06afad8747ae5c452c550f890ef6d39da9b4f172012e3fb72ab74ea5f12af3c"

URI_aarch64_rust-nix0.27+resource-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+resource-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+resource-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+resource-devel}"
SRC_URI[aarch64_rust-nix0.27+resource-devel.sha256sum] = "048de70736ba698845fab4cb8077e28b693333ded218fc8e7f34212b77f13851"

URI_aarch64_rust-nix0.27+sched-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+sched-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+sched-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+sched-devel}"
SRC_URI[aarch64_rust-nix0.27+sched-devel.sha256sum] = "a820a967f078d3407cc854274fd1a6507866ca2b07c8ca44f23ea699d415e392"

URI_aarch64_rust-nix0.27+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+signal-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+signal-devel}"
SRC_URI[aarch64_rust-nix0.27+signal-devel.sha256sum] = "cd14b820892761d30f3cde0023097c1b3770e20cf933644ad21740db73611dbd"

URI_aarch64_rust-nix0.27+socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+socket-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+socket-devel}"
SRC_URI[aarch64_rust-nix0.27+socket-devel.sha256sum] = "db0c86d085f8a6355b9e645f856fc7b6285614963d006de78403bd3712662603"

URI_aarch64_rust-nix0.27+term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+term-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+term-devel}"
SRC_URI[aarch64_rust-nix0.27+term-devel.sha256sum] = "cff97f23455c46803abc0acfa46b67a9be141d5504ae38f37c424aa1ca939f05"

URI_aarch64_rust-nix0.27+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+time-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+time-devel}"
SRC_URI[aarch64_rust-nix0.27+time-devel.sha256sum] = "a45aee9539b699fdc754e0ee6a0a1830a16f304c728e83ffad15b788c886f427"

URI_aarch64_rust-nix0.27+ucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+ucontext-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+ucontext-devel}"
SRC_URI[aarch64_rust-nix0.27+ucontext-devel.sha256sum] = "929b22b9727c75af3a8cad27ea3d7d8c8d001e17a22d3c36ba8f23477f284cb8"

URI_aarch64_rust-nix0.27+uio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+uio-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+uio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+uio-devel}"
SRC_URI[aarch64_rust-nix0.27+uio-devel.sha256sum] = "bdf630dd28426c0034d54e45f2d3d272416cdb000795fcaf7e9f0567a77fd697"

URI_aarch64_rust-nix0.27+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+user-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+user-devel}"
SRC_URI[aarch64_rust-nix0.27+user-devel.sha256sum] = "5907f3359adb176dff6f0a03b05014fd40142b4e5421aca66b51a85180e717ef"

URI_aarch64_rust-nix0.27+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27+zerocopy-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27+zerocopy-devel}"
SRC_URI[aarch64_rust-nix0.27+zerocopy-devel.sha256sum] = "95765fc006c02acf5b91c81766d6bd8c0bef346eb7762c0a9006ca98dc9e0991"

URI_aarch64_rust-nix0.27-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix0.27-devel-0.27.1-3.el10_0.noarch.rpm;name=aarch64_rust-nix0.27-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix0.27-devel}"
SRC_URI[aarch64_rust-nix0.27-devel.sha256sum] = "9c87701068bc28ec44a8bb85abbe69ca9b16ef5ff6dd24ae0868754745b6b8ff"

RDEPENDS:rust-nix0.27+acct-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+aio-devel = " \
 cargo \
 rust-nix0.27+pin-utils-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+default-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+dir-devel = " \
 cargo \
 rust-nix0.27+fs-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+env-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+event-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+feature-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+fs-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+hostname-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+inotify-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+ioctl-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+kmod-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+mman-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+mount-devel = " \
 cargo \
 rust-nix0.27+uio-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+mqueue-devel = " \
 cargo \
 rust-nix0.27+fs-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+net-devel = " \
 cargo \
 rust-nix0.27+socket-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+personality-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+pin-utils-devel = " \
 cargo \
 rust-nix0.27-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-nix0.27+poll-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+process-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+pthread-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+ptrace-devel = " \
 cargo \
 rust-nix0.27+process-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+quota-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+reboot-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+resource-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+sched-devel = " \
 cargo \
 rust-nix0.27+process-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+signal-devel = " \
 cargo \
 rust-nix0.27+process-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+socket-devel = " \
 cargo \
 rust-nix0.27+memoffset-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+term-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+time-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+ucontext-devel = " \
 cargo \
 rust-nix0.27+signal-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+uio-devel = " \
 cargo \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+user-devel = " \
 cargo \
 rust-nix0.27+feature-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27+zerocopy-devel = " \
 cargo \
 rust-nix0.27+fs-devel \
 rust-nix0.27+uio-devel \
 rust-nix0.27-devel \
 "
RDEPENDS:rust-nix0.27-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 "
