# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uv"
PV = "0.12.3"
PR = "1.el10_3"
PACKAGES = " \
 python3-uv \
 uv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uv-0.12.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ac746b9c7bbaaa6635ca8e0caa0da287091a86b8042f7c5592a86982b6e21b2"

URI_aarch64_python3-uv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uv-0.12.3-1.el10_3.noarch.rpm;name=aarch64_python3-uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uv}"
SRC_URI[aarch64_python3-uv.sha256sum] = "2fa9a3a0d663a99d251cacc8ab676576e05f822c7da6eeac7817e700078b4e50"

URI_aarch64_uv = "${EPEL_MIRROR}/aarch64/Packages/u/uv-0.12.3-1.el10_3.aarch64.rpm;name=aarch64_uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_uv}"
SRC_URI[aarch64_uv.sha256sum] = "1cec957fc04d8dfbe824676167d4996eb063d7994e8c2e900a25f11c397f47d2"

RDEPENDS:python3-uv = " \
 python3 \
 uv \
 "
RDEPENDS:uv = " \
 glibc \
 jemalloc \
 libgcc \
 libzstd \
 "
