# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fstrm"
PV = "0.6.1"
PR = "12.el10"
PACKAGES = " \
 fstrm \
 fstrm-devel \
 fstrm-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fstrm-0.6.1-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7875f7736ba79d576f8b0e3865ae0fd6dd7355f83cf95b5a42c45a1436368b43"

URI_x86_64_v2_fstrm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fstrm-0.6.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_fstrm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fstrm}"
SRC_URI[x86_64_v2_fstrm.sha256sum] = "b9af1dd3d0f2547214a84e6c5cf57b435968a30e1111b396fcb08ed67241e9f8"

URI_x86_64_v2_fstrm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fstrm-devel-0.6.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_fstrm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fstrm-devel}"
SRC_URI[x86_64_v2_fstrm-devel.sha256sum] = "0644683fed00c810257907a873f587f4b4962b673f2e534d2c1dce85a6638cf0"

URI_x86_64_v2_fstrm-utils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fstrm-utils-0.6.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_fstrm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fstrm-utils}"
SRC_URI[x86_64_v2_fstrm-utils.sha256sum] = "9271da13f44643897df554f93e97d232baf55eb09843c6a17cde7b694b70a7c1"

URI_aarch64_fstrm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fstrm-0.6.1-12.el10.aarch64.rpm;name=aarch64_fstrm;unpack=0"
SRC_URI:append = " ${URI_aarch64_fstrm}"
SRC_URI[aarch64_fstrm.sha256sum] = "f614ed8d76c927638f228a6f58479808c40ed94c9a0f2927db96b1af01f28610"

URI_aarch64_fstrm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fstrm-devel-0.6.1-12.el10.aarch64.rpm;name=aarch64_fstrm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fstrm-devel}"
SRC_URI[aarch64_fstrm-devel.sha256sum] = "53a41f908d8f85774476d9fb52adf2a2df580a445d4d9910f5115f75d8819eb2"

URI_aarch64_fstrm-utils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fstrm-utils-0.6.1-12.el10.aarch64.rpm;name=aarch64_fstrm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_fstrm-utils}"
SRC_URI[aarch64_fstrm-utils.sha256sum] = "6c616e431469b906f0a5a6b22ac08b788fc77ca776b2d9dbe8125eea72ad39a0"

RDEPENDS:fstrm = " \
 glibc \
 "
RDEPENDS:fstrm-devel = " \
 fstrm \
 pkgconf-pkg-config \
 "
RDEPENDS:fstrm-utils = " \
 fstrm \
 glibc \
 libevent \
 "
