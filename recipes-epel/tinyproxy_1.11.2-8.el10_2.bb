# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinyproxy"
PV = "1.11.2"
PR = "8.el10_2"
PACKAGES = " \
 tinyproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tinyproxy-1.11.2-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "656a578db58e9795851dcca479aa5158a4288bcf0b3d2384edcae09172842545"

URI_x86_64_v2_tinyproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyproxy-1.11.2-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyproxy}"
SRC_URI[x86_64_v2_tinyproxy.sha256sum] = "fff5dd788741ee77c155079ed252e42c5d32430ec34e42c02bac41394e80530f"

URI_aarch64_tinyproxy = "${EPEL_MIRROR}/aarch64/Packages/t/tinyproxy-1.11.2-8.el10_2.aarch64.rpm;name=aarch64_tinyproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyproxy}"
SRC_URI[aarch64_tinyproxy.sha256sum] = "8eed64060072fb62bed31acd54153927ea3bb9228f0dbc793453aa3bb3cf8c52"

RDEPENDS:tinyproxy = " \
 bash \
 glibc \
 "
