# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iri-string"
PV = "0.7.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-iri-string+alloc-devel \
 rust-iri-string+default-devel \
 rust-iri-string+memchr-devel \
 rust-iri-string+serde-devel \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-iri-string-0.7.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e8db7184226af5c9907fdfb9bd39fbd1c9d019841f9c04d771905dee187feafa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+alloc-devel-0.7.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string+alloc-devel.sha256sum] = "f515fcd688a988f34199aa556ffb87b1fbc6fd8cd75e8f6ba2827e4d4349bc6d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+default-devel-0.7.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string+default-devel.sha256sum] = "21a4d4a78d0f4529af480d2b355ece0bc19a5ca7e5755827c9e9032e3ec8ed58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+memchr-devel-0.7.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+memchr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string+memchr-devel.sha256sum] = "86e5c42f18d9601f12fba81a4cbbf04384b6dbb9be899f754baf42ebeb33f2ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+serde-devel-0.7.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string+serde-devel.sha256sum] = "2237998f53b2d0ec817c6e864335845ec8f34208273e6737b381bdda2d047cf2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+std-devel-0.7.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string+std-devel.sha256sum] = "38d924118aa255fae6e98ae9afcb993874020e927701f9ec05f113ab9a23a45c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string-devel-0.7.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string-devel;unpack=0"
SRC_URI[x86_64_v2_rust-iri-string-devel.sha256sum] = "25f3d1803929c444d1bec0927f8099d17672ff58d9f1d0ae8749b45d85d0495e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+alloc-devel-0.7.14-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string+alloc-devel.sha256sum] = "a863f55e0c19972b1d9e86b96417df0e9c8ade3d4987f1510fbf6373e470434e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+default-devel-0.7.14-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string+default-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string+default-devel.sha256sum] = "8e2ec45b5d2859eed29a718415c1a4590d1b2c086770e6ddab63576828d11c24"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+memchr-devel-0.7.14-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string+memchr-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string+memchr-devel.sha256sum] = "dc730e6b14cd571f04a7a22b014de1ae8907e964c3210b3ae2eab17646875fd6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+serde-devel-0.7.14-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string+serde-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string+serde-devel.sha256sum] = "5bf80a144b63ff844143469ab3e50365aecd55a8a42886cd596dd261ee3f0a06"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+std-devel-0.7.14-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string+std-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string+std-devel.sha256sum] = "20f4e3b76966b902aef2f0542720e5a3ecc86e61c4b1bab8a6c767b21c871198"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string-devel-0.7.14-1.el10_2.noarch.rpm;name=aarch64_rust-iri-string-devel;unpack=0"
SRC_URI[aarch64_rust-iri-string-devel.sha256sum] = "bbc4282044c672cf221cc057e118f553296812c2523b920c1e09468ac1669ddc"

RDEPENDS:rust-iri-string+alloc-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+default-devel = " \
 cargo \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "
RDEPENDS:rust-iri-string+memchr-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-iri-string+serde-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+std-devel = " \
 cargo \
 rust-iri-string+alloc-devel \
 rust-iri-string-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string-devel = " \
 cargo \
 rust \
 "
