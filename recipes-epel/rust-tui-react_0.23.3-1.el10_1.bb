# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tui-react"
PV = "0.23.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-tui-react+default-devel \
 rust-tui-react-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tui-react-0.23.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6385b66a082085bad687a0e7920c1b450a82673eddcb04aeec4858aa8457abb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tui-react+default-devel-0.23.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tui-react+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tui-react+default-devel.sha256sum] = "56c3f40449959ce10165a2ef403eae4de290da39e3128556dfa1c52e43a7f0a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tui-react-devel-0.23.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tui-react-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tui-react-devel.sha256sum] = "d80339a87194a261c3c68285c51f6ed9098c9472da314efdc38a585fac674657"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tui-react+default-devel-0.23.3-1.el10_1.noarch.rpm;name=aarch64_rust-tui-react+default-devel;unpack=0"
SRC_URI[aarch64_rust-tui-react+default-devel.sha256sum] = "2d3f35c6668724edcf2f2b4a3d0bf74067464f1baafbb243afb52f752638e72d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tui-react-devel-0.23.3-1.el10_1.noarch.rpm;name=aarch64_rust-tui-react-devel;unpack=0"
SRC_URI[aarch64_rust-tui-react-devel.sha256sum] = "10f3b6113f0db40820c98a9812b14fdb8a0ef8a65d488de9b4a0a34ae26b7738"

RDEPENDS:rust-tui-react+default-devel = " \
 cargo \
 rust-tui-react-devel \
 "
RDEPENDS:rust-tui-react-devel = " \
 cargo \
 rust-log+default-devel \
 rust-ratatui0.26-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 "
