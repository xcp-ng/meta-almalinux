# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpgf"
PV = "7.21.7"
PR = "6.el10_0"
PACKAGES = " \
 libpgf \
 libpgf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libpgf-7.21.7-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44431dc41161f70773d7e0f73c993416d60f8d4d6070cefe5fd45552a3c659a8"

URI_x86_64_v2_libpgf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpgf-7.21.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpgf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpgf}"
SRC_URI[x86_64_v2_libpgf.sha256sum] = "d326a65717985f647d0e46a1282b7dc323374c258d68531448dcc895df4cecae"

URI_x86_64_v2_libpgf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpgf-devel-7.21.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpgf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpgf-devel}"
SRC_URI[x86_64_v2_libpgf-devel.sha256sum] = "c5bed140b9b9c05061ae106923b98430a1c7c63d5592bf6394b491f84315ea1c"

URI_aarch64_libpgf = "${EPEL_MIRROR}/aarch64/Packages/l/libpgf-7.21.7-6.el10_0.aarch64.rpm;name=aarch64_libpgf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpgf}"
SRC_URI[aarch64_libpgf.sha256sum] = "b57b4099a8290b4d46826a818b57d5995a3be99f6692f5681fa08e6ded669773"

URI_aarch64_libpgf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libpgf-devel-7.21.7-6.el10_0.aarch64.rpm;name=aarch64_libpgf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpgf-devel}"
SRC_URI[aarch64_libpgf-devel.sha256sum] = "c8b060047863f7ed848121f166a137451bd66d13193dea016e1ae429dda02a8a"

RDEPENDS:libpgf = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libpgf-devel = " \
 libpgf \
 pkgconf-pkg-config \
 "
