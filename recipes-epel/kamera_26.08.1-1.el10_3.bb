# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kamera"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kamera \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kamera-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cfa96478133b41adc299cfa18246cb567a88660234ed36e6433be1dc8831d3b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kamera-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kamera;unpack=0"
SRC_URI[x86_64_v2_kamera.sha256sum] = "0c75bed533f7620c3f6eda2b2be7731a85dd1d67fa1ad364b4ab8be67128d52d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kamera-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kamera;unpack=0"
SRC_URI[aarch64_kamera.sha256sum] = "634ff7e78d65b87a4c80cd767bfdbd6a762d2bb04e453c4c93c8c2061012c972"

RDEPENDS:kamera = " \
 glibc \
 kde-cli-tools \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgphoto2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
