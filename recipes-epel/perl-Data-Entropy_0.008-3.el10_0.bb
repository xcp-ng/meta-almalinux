# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Entropy"
PV = "0.008"
PR = "3.el10_0"
PACKAGES = " \
 perl-Data-Entropy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Entropy-0.008-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbafd0f3074ea1171cd1ac07768d82da875979489853c2dead829099aadaaed0"

URI_x86_64_v2_perl-Data-Entropy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Entropy-0.008-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Entropy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Entropy}"
SRC_URI[x86_64_v2_perl-Data-Entropy.sha256sum] = "1057205cfed17359939b6a5a799eb2f01934fff0aaeb16bd77f361c161649e6c"

URI_aarch64_perl-Data-Entropy = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Entropy-0.008-3.el10_0.noarch.rpm;name=aarch64_perl-Data-Entropy;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Entropy}"
SRC_URI[aarch64_perl-Data-Entropy.sha256sum] = "eb7aab56a368851047e4f4ab6a3808892de564fe34a97f94d98d0d463f9d4238"

RDEPENDS:perl-Data-Entropy = " \
 perl-Carp \
 perl-Crypt-Rijndael \
 perl-Crypt-URandom \
 perl-Data-Entropy \
 perl-Data-Float \
 perl-Errno \
 perl-Exporter \
 perl-HTTP-Lite \
 perl-IO \
 perl-Params-Classify \
 perl-constant \
 perl-libs \
 perl-parent \
 "
