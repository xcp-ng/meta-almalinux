# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmypaint"
PV = "1.6.1"
PR = "21.el10_3"
PACKAGES = " \
 libmypaint \
 libmypaint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmypaint-1.6.1-21.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44c10a2c790210a33fc82eefe6b360a51af4c1f74fb76f60b4cb32b90838cb1b"

URI_x86_64_v2_libmypaint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmypaint-1.6.1-21.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmypaint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmypaint}"
SRC_URI[x86_64_v2_libmypaint.sha256sum] = "63132c95c5e156e8631f9c9385340e10cf228dd62c52339c23bd5b99c33bea44"

URI_x86_64_v2_libmypaint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmypaint-devel-1.6.1-21.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmypaint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmypaint-devel}"
SRC_URI[x86_64_v2_libmypaint-devel.sha256sum] = "6e1a18d63f643ea495567c1b962f3684a9b981bd02ce59d0e36dc138e4c08774"

URI_aarch64_libmypaint = "${EPEL_MIRROR}/aarch64/Packages/l/libmypaint-1.6.1-21.el10_3.aarch64.rpm;name=aarch64_libmypaint;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmypaint}"
SRC_URI[aarch64_libmypaint.sha256sum] = "e8c59afcb80c01b4e74e06a3111ae5ab143de257ffcfd5a572e90a6f593aaa94"

URI_aarch64_libmypaint-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmypaint-devel-1.6.1-21.el10_3.aarch64.rpm;name=aarch64_libmypaint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmypaint-devel}"
SRC_URI[aarch64_libmypaint-devel.sha256sum] = "4c537b32e847c0914fbe129e730b112949589361c24014f464d72563507bd4f8"

RDEPENDS:libmypaint = " \
 glib2 \
 glibc \
 json-c \
 "
RDEPENDS:libmypaint-devel = " \
 glib2-devel \
 json-c-devel \
 libmypaint \
 pkgconf-pkg-config \
 "
