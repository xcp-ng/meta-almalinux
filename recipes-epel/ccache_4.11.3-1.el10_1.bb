# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ccache"
PV = "4.11.3"
PR = "1.el10_1"
PACKAGES = " \
 ccache \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/ccache-4.11.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf91154918901274e1aebefb0a9be6f1f67e13e3ef22b82ae587121835b33253"

URI_x86_64_v2_ccache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ccache-4.11.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ccache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ccache}"
SRC_URI[x86_64_v2_ccache.sha256sum] = "d3094317035b5e501c33f31a4ce71f8cc9d3699a94eddee921dcd39d510541db"

URI_aarch64_ccache = "${EPEL_MIRROR}/aarch64/Packages/c/ccache-4.11.3-1.el10_1.aarch64.rpm;name=aarch64_ccache;unpack=0"
SRC_URI:append = " ${URI_aarch64_ccache}"
SRC_URI[aarch64_ccache.sha256sum] = "3421cbffefea64351e80d2ce64eb0042d98dcc23262a03504cf988305ff34a24"

RDEPENDS:ccache = " \
 bash \
 fmt \
 glibc \
 hiredis \
 libgcc \
 libstdc++ \
 libzstd \
 virtual/coreutils \
 xxhash-libs \
 "
