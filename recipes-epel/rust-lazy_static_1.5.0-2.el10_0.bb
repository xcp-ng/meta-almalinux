# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lazy_static"
PV = "1.5.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-lazy_static+default-devel \
 rust-lazy_static+spin-devel \
 rust-lazy_static+spin_no_std-devel \
 rust-lazy_static-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lazy_static-1.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa186fa59dc189bc0c73ca1372f27453cf861ed9000d7a925754d791dbd87ca5"

URI_x86_64_v2_rust-lazy_static+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lazy_static+default-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lazy_static+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lazy_static+default-devel}"
SRC_URI[x86_64_v2_rust-lazy_static+default-devel.sha256sum] = "b580aff8960c5708bfd8d098e9b0f9ceb4cc823a71e03fd5c869e29660c96b38"

URI_x86_64_v2_rust-lazy_static+spin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lazy_static+spin-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lazy_static+spin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lazy_static+spin-devel}"
SRC_URI[x86_64_v2_rust-lazy_static+spin-devel.sha256sum] = "077fae5664986ccfbe57254c7b237124b0f8c441677ec3a5ce53934709a57645"

URI_x86_64_v2_rust-lazy_static+spin_no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lazy_static+spin_no_std-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lazy_static+spin_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lazy_static+spin_no_std-devel}"
SRC_URI[x86_64_v2_rust-lazy_static+spin_no_std-devel.sha256sum] = "3d0d32cdf195e0836d51b72c9841d9549cf1c026715140f523aa77a2c1fb87e5"

URI_x86_64_v2_rust-lazy_static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lazy_static-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lazy_static-devel}"
SRC_URI[x86_64_v2_rust-lazy_static-devel.sha256sum] = "d7c211ae699450047b095a22393827845b098d55346bf9fff18e0fe1c20261f6"

URI_aarch64_rust-lazy_static+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lazy_static+default-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-lazy_static+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lazy_static+default-devel}"
SRC_URI[aarch64_rust-lazy_static+default-devel.sha256sum] = "886701d68fd36df2da99a65d00b7a4bfb361f124ab10ad909d8e14b840bb60c7"

URI_aarch64_rust-lazy_static+spin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lazy_static+spin-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-lazy_static+spin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lazy_static+spin-devel}"
SRC_URI[aarch64_rust-lazy_static+spin-devel.sha256sum] = "397ef2a1143c35f6c99686bf09cfa6e1033a11d6503abc6a975da7e4461028a6"

URI_aarch64_rust-lazy_static+spin_no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lazy_static+spin_no_std-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-lazy_static+spin_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lazy_static+spin_no_std-devel}"
SRC_URI[aarch64_rust-lazy_static+spin_no_std-devel.sha256sum] = "cd762968abbc16d2b51c6fbcc5d4d6ffacf10e7d8cf71ab2d1ada8c345edd7b3"

URI_aarch64_rust-lazy_static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lazy_static-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lazy_static-devel}"
SRC_URI[aarch64_rust-lazy_static-devel.sha256sum] = "87fd3133431798f35610794c8aec03e450e1af8e002df4d092738dce5111d786"

RDEPENDS:rust-lazy_static+default-devel = " \
 cargo \
 rust-lazy_static-devel \
 "
RDEPENDS:rust-lazy_static+spin-devel = " \
 cargo \
 rust-lazy_static-devel \
 rust-spin0.9+once-devel \
 rust-spin0.9-devel \
 "
RDEPENDS:rust-lazy_static+spin_no_std-devel = " \
 cargo \
 rust-lazy_static+spin-devel \
 rust-lazy_static-devel \
 "
RDEPENDS:rust-lazy_static-devel = " \
 cargo \
 "
