# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "backupninja"
PV = "1.2.2"
PR = "6.el10_0"
PACKAGES = " \
 backupninja \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/backupninja-1.2.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d774d87c4daa91c258f5f841bcb4cf804234fa148aef9c843e2999c72d244956"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/backupninja-1.2.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_backupninja;unpack=0"
SRC_URI[x86_64_v2_backupninja.sha256sum] = "9fd8486c39e62086bc67d5d8994e662f1a829bcfeebe9c96d170a74bfa44ad78"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/backupninja-1.2.2-6.el10_0.noarch.rpm;name=aarch64_backupninja;unpack=0"
SRC_URI[aarch64_backupninja.sha256sum] = "8b19eb1d2e04832d63fe196d395dfaa6ac7165f4103396c284c2c071b5dde79d"

RDEPENDS:backupninja = " \
 bash \
 cronie \
 gawk \
 logrotate \
 rdiff-backup \
 "
