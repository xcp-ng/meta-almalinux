# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argmax"
PV = "0.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-argmax+default-devel \
 rust-argmax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argmax-0.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8d7da4754c7a78ddf96b392ff3b29d4fc3ed37e3ed5eeafec0dbd3d501a6bb5"

URI_x86_64_v2_rust-argmax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argmax+default-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argmax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argmax+default-devel}"
SRC_URI[x86_64_v2_rust-argmax+default-devel.sha256sum] = "abc9bc01af9d3c4473e6d7458d221d5dd0563865c78260a71e74012fa6692fca"

URI_x86_64_v2_rust-argmax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argmax-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argmax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argmax-devel}"
SRC_URI[x86_64_v2_rust-argmax-devel.sha256sum] = "0bc5a383fac62fdba347c1b3b9c9c458c50126742656f1a023719701f0f6dd42"

URI_aarch64_rust-argmax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argmax+default-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-argmax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argmax+default-devel}"
SRC_URI[aarch64_rust-argmax+default-devel.sha256sum] = "3bcae6b477a4c6e44b5b1366b1854b63344b4c90b20d9af19313ea75a19d6a59"

URI_aarch64_rust-argmax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argmax-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-argmax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argmax-devel}"
SRC_URI[aarch64_rust-argmax-devel.sha256sum] = "4a7f9378871c7d7fec3d18c742b45ca41e7f3107106b2ecc3537157f383eb124"

RDEPENDS:rust-argmax+default-devel = " \
 cargo \
 rust-argmax-devel \
 "
RDEPENDS:rust-argmax-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-nix0.30+feature-devel \
 rust-nix0.30-devel \
 rust-once_cell+default-devel \
 "
