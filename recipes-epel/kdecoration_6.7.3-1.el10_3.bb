# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdecoration"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kdecoration \
 kdecoration-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdecoration-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dc91b2d2bf4dc6bef7e863a48f41863b60f5aef39b67a1bfb27b5f372dfa93b"

URI_x86_64_v2_kdecoration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdecoration-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdecoration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdecoration}"
SRC_URI[x86_64_v2_kdecoration.sha256sum] = "f4c9e56f5f90d5c676910a80f6df8d230a184d3679e47d00088b7196afa9b983"

URI_x86_64_v2_kdecoration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdecoration-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdecoration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdecoration-devel}"
SRC_URI[x86_64_v2_kdecoration-devel.sha256sum] = "aa3520e8bd2073d3d41377088f562cd07ef0bfb854d304765b53ceb8cde3b775"

URI_aarch64_kdecoration = "${EPEL_MIRROR}/aarch64/Packages/k/kdecoration-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kdecoration;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdecoration}"
SRC_URI[aarch64_kdecoration.sha256sum] = "569ce84cba92a57d6a7d8aa458f9c4bf2a3cdd6dc387238a7221775a8c9ab43f"

URI_aarch64_kdecoration-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdecoration-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kdecoration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdecoration-devel}"
SRC_URI[aarch64_kdecoration-devel.sha256sum] = "46a58b3b33cd7b77add74d998affd624fd4bd086f49ede58b99158ba19fa9821"

RDEPENDS:kdecoration = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kdecoration-devel = " \
 cmake-filesystem \
 kdecoration \
 "
