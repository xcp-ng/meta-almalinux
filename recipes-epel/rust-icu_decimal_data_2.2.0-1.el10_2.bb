# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_decimal_data"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_decimal_data+default-devel \
 rust-icu_decimal_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_decimal_data-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc9b4834afd5428ff4f04f809a453093ab451e5dc2e11aa5aebf4eb855c1264e"

URI_x86_64_v2_rust-icu_decimal_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal_data+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal_data+default-devel.sha256sum] = "2ae9e09d2fa6d496f464fdc025db6922d84a177ebe2428b5733c37b2a0c5b814"

URI_x86_64_v2_rust-icu_decimal_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal_data-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal_data-devel.sha256sum] = "ae7cbdf73fe8734a4178b2c00af8210757f35bb0a4590a13119274d9b46ecb7e"

URI_aarch64_rust-icu_decimal_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal_data+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_decimal_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal_data+default-devel}"
SRC_URI[aarch64_rust-icu_decimal_data+default-devel.sha256sum] = "29fb6246eefe8dff6565c2c94460ed08de917ddf5e6e6c42fc17535dc1c5c6a2"

URI_aarch64_rust-icu_decimal_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_decimal_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal_data-devel}"
SRC_URI[aarch64_rust-icu_decimal_data-devel.sha256sum] = "a69cdd2fa73dd6f14b0be655c571f209ed120b018e5a147889e491e24a555cb4"

RDEPENDS:rust-icu_decimal_data+default-devel = " \
 cargo \
 rust-icu_decimal_data-devel \
 "
RDEPENDS:rust-icu_decimal_data-devel = " \
 cargo \
 rust \
 "
