# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-writeable"
PV = "0.6.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-writeable+alloc-devel \
 rust-writeable+default-devel \
 rust-writeable+either-devel \
 rust-writeable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-writeable-0.6.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c41d6a8ce8cfbefcc6d837412dd59039504cc1ac57e0026ba27ca9d4dd82aa60"

URI_x86_64_v2_rust-writeable+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+alloc-devel-0.6.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+alloc-devel}"
SRC_URI[x86_64_v2_rust-writeable+alloc-devel.sha256sum] = "68cc79358faf1a4eadeb691858e0590206a2e5a5569e9d05e021bb256068b56f"

URI_x86_64_v2_rust-writeable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+default-devel-0.6.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+default-devel}"
SRC_URI[x86_64_v2_rust-writeable+default-devel.sha256sum] = "fc2708cac01a98958543ddc6baf3ab71c7a652d3e11f6254668726ebfacff635"

URI_x86_64_v2_rust-writeable+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+either-devel-0.6.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+either-devel}"
SRC_URI[x86_64_v2_rust-writeable+either-devel.sha256sum] = "edc1376ec0ef3f615f100130b31a408bfe3bc8824adf2a8cad28c7a562f4a984"

URI_x86_64_v2_rust-writeable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable-devel-0.6.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable-devel}"
SRC_URI[x86_64_v2_rust-writeable-devel.sha256sum] = "542775d71b2a8292567816013a0a9d3d5c8837692bd5fc38109d039769667ab3"

URI_aarch64_rust-writeable+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+alloc-devel-0.6.3-1.el10_3.noarch.rpm;name=aarch64_rust-writeable+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+alloc-devel}"
SRC_URI[aarch64_rust-writeable+alloc-devel.sha256sum] = "95356f7044669473a532b6f0bbe4ee84809d5a65da7201b187d1ea456d44ac30"

URI_aarch64_rust-writeable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+default-devel-0.6.3-1.el10_3.noarch.rpm;name=aarch64_rust-writeable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+default-devel}"
SRC_URI[aarch64_rust-writeable+default-devel.sha256sum] = "b7c0736294093366637dc1aa5b63d857c1d15a7e4278d50c4849fbae5e397734"

URI_aarch64_rust-writeable+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+either-devel-0.6.3-1.el10_3.noarch.rpm;name=aarch64_rust-writeable+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+either-devel}"
SRC_URI[aarch64_rust-writeable+either-devel.sha256sum] = "25a5c666ee79b44d36f7dd4f921224c480fb4fe5f0ac76ab011aa1cc4b85497b"

URI_aarch64_rust-writeable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable-devel-0.6.3-1.el10_3.noarch.rpm;name=aarch64_rust-writeable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable-devel}"
SRC_URI[aarch64_rust-writeable-devel.sha256sum] = "7c3fb03c75b040bb3e860bea5fa8c1f473f86f7f5c4e6b69caf01ed306a7c666"

RDEPENDS:rust-writeable+alloc-devel = " \
 cargo \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable+default-devel = " \
 cargo \
 rust-writeable+alloc-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable+either-devel = " \
 cargo \
 rust-either-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable-devel = " \
 cargo \
 rust \
 "
