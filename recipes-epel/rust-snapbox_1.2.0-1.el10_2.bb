# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snapbox"
PV = "1.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-snapbox+cmd-devel \
 rust-snapbox+color-auto-devel \
 rust-snapbox+color-devel \
 rust-snapbox+debug-devel \
 rust-snapbox+default-devel \
 rust-snapbox+detect-encoding-devel \
 rust-snapbox+diff-devel \
 rust-snapbox+dir-devel \
 rust-snapbox+document-features-devel \
 rust-snapbox+examples-devel \
 rust-snapbox+json-devel \
 rust-snapbox+path-devel \
 rust-snapbox+regex-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox+term-svg-devel \
 rust-snapbox-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snapbox-1.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98f1ef23f81562394f8d69cff4feb93ab216d14d8913b636fb6d654f3c415479"

URI_x86_64_v2_rust-snapbox+cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+cmd-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+cmd-devel}"
SRC_URI[x86_64_v2_rust-snapbox+cmd-devel.sha256sum] = "cfd3047eb4643c750c01fa3c1f25b39d403757961f7ef5c5ed0fd009c725bfae"

URI_x86_64_v2_rust-snapbox+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+color-auto-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+color-auto-devel}"
SRC_URI[x86_64_v2_rust-snapbox+color-auto-devel.sha256sum] = "79990aca915fbdcb1a1a2e1106e69ccbbd4f111483250bd43201bbd14fa594c9"

URI_x86_64_v2_rust-snapbox+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+color-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+color-devel}"
SRC_URI[x86_64_v2_rust-snapbox+color-devel.sha256sum] = "2be0272637f5ab0b788de0facc727cbc0c42ad8f356d407db51e8531e0daa025"

URI_x86_64_v2_rust-snapbox+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+debug-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+debug-devel}"
SRC_URI[x86_64_v2_rust-snapbox+debug-devel.sha256sum] = "0db57e81a83f8ea0355b01266f704e2190fa863458c37a646ddbcb20dcc0d624"

URI_x86_64_v2_rust-snapbox+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+default-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+default-devel}"
SRC_URI[x86_64_v2_rust-snapbox+default-devel.sha256sum] = "a6acca7682cea84d753585ddd3582868db71c99cfdecda7e035840cbf4aebf3d"

URI_x86_64_v2_rust-snapbox+detect-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+detect-encoding-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+detect-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+detect-encoding-devel}"
SRC_URI[x86_64_v2_rust-snapbox+detect-encoding-devel.sha256sum] = "0fdec95d3c2cfc68413c470440c8ef52549e062880574943b59578a9d947ac05"

URI_x86_64_v2_rust-snapbox+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+diff-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+diff-devel}"
SRC_URI[x86_64_v2_rust-snapbox+diff-devel.sha256sum] = "5d6912f8bea1c3c14bca7c18b41102c66a396fdd9126fa6202b62d505bb346a3"

URI_x86_64_v2_rust-snapbox+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+dir-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+dir-devel}"
SRC_URI[x86_64_v2_rust-snapbox+dir-devel.sha256sum] = "0317721f3ee236200396a09646a13a723313b845d02af8f328b35032526f8293"

URI_x86_64_v2_rust-snapbox+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+document-features-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+document-features-devel}"
SRC_URI[x86_64_v2_rust-snapbox+document-features-devel.sha256sum] = "bb126cf5a1948206eff9b4be8a851656a53d7a9fe71e462e7d8f8aea4278dcdd"

URI_x86_64_v2_rust-snapbox+examples-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+examples-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+examples-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+examples-devel}"
SRC_URI[x86_64_v2_rust-snapbox+examples-devel.sha256sum] = "ef780080ea435b4089f374513408db96a79755ca555245b6f1f100effb56a7f9"

URI_x86_64_v2_rust-snapbox+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+json-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+json-devel}"
SRC_URI[x86_64_v2_rust-snapbox+json-devel.sha256sum] = "cd130ea568a2f0a95dfd83829ac2bfde93e20bef622b6d8d8f64c3bbc60fb81e"

URI_x86_64_v2_rust-snapbox+path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+path-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+path-devel}"
SRC_URI[x86_64_v2_rust-snapbox+path-devel.sha256sum] = "312764f9cf52f4f8f460ef35cc3f13ea38b99c595e8a0827bf66c8492d264d80"

URI_x86_64_v2_rust-snapbox+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+regex-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+regex-devel}"
SRC_URI[x86_64_v2_rust-snapbox+regex-devel.sha256sum] = "149ef4bb04803420e92792ca4a8f5ba6434b336ba60a43f89707bc648dc7b906"

URI_x86_64_v2_rust-snapbox+structured-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+structured-data-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+structured-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+structured-data-devel}"
SRC_URI[x86_64_v2_rust-snapbox+structured-data-devel.sha256sum] = "1145089057f863d06bf983a2c74e33d862ed187681191611309e74f9d67b5b10"

URI_x86_64_v2_rust-snapbox+term-svg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+term-svg-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+term-svg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox+term-svg-devel}"
SRC_URI[x86_64_v2_rust-snapbox+term-svg-devel.sha256sum] = "82f36133be38aef64d568597b391c9b081c5e60edb1f6e131768c426b239d82d"

URI_x86_64_v2_rust-snapbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-devel}"
SRC_URI[x86_64_v2_rust-snapbox-devel.sha256sum] = "206f1823158c8e49846a3fa1c17bacd3e489167ea435601cfa20d02d5503e5d2"

URI_aarch64_rust-snapbox+cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+cmd-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+cmd-devel}"
SRC_URI[aarch64_rust-snapbox+cmd-devel.sha256sum] = "582106b871f710f76cfada0d59989a0946b2c2fe34e799252f70a60a25f0a61e"

URI_aarch64_rust-snapbox+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+color-auto-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+color-auto-devel}"
SRC_URI[aarch64_rust-snapbox+color-auto-devel.sha256sum] = "776b716eeb71c15f6f14ef15911e85d347510e6de0c4d0c45f4fd1764e39c1e1"

URI_aarch64_rust-snapbox+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+color-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+color-devel}"
SRC_URI[aarch64_rust-snapbox+color-devel.sha256sum] = "ea07c194b6aa030d9c9de3b2552c9aadb3f5a7533d05c856a6b90f65f748779b"

URI_aarch64_rust-snapbox+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+debug-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+debug-devel}"
SRC_URI[aarch64_rust-snapbox+debug-devel.sha256sum] = "f9c12f0294dd21c00b4d8952a3422be7903c23eab50df49b3195355705c52023"

URI_aarch64_rust-snapbox+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+default-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+default-devel}"
SRC_URI[aarch64_rust-snapbox+default-devel.sha256sum] = "0953014d5272a28cafe965576a9e426614586c09fe919ef236406bd053305ece"

URI_aarch64_rust-snapbox+detect-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+detect-encoding-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+detect-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+detect-encoding-devel}"
SRC_URI[aarch64_rust-snapbox+detect-encoding-devel.sha256sum] = "069230e816b0e27898aaa28401471a10bbb624fcee2eaffe98e10d47000acb95"

URI_aarch64_rust-snapbox+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+diff-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+diff-devel}"
SRC_URI[aarch64_rust-snapbox+diff-devel.sha256sum] = "68e7002d9bcbc325709800c0f48ac27a184a1767cd6a119c33b8911c8c489fee"

URI_aarch64_rust-snapbox+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+dir-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+dir-devel}"
SRC_URI[aarch64_rust-snapbox+dir-devel.sha256sum] = "56c59e9da61642b6ba1efbd38e8017f68c06553f53d006336469b4811f0bcfbf"

URI_aarch64_rust-snapbox+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+document-features-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+document-features-devel}"
SRC_URI[aarch64_rust-snapbox+document-features-devel.sha256sum] = "39d6d80c45f3452087f5f196aad228ca8f6a2cd0ed293a5a00d2e2d1c582e1c7"

URI_aarch64_rust-snapbox+examples-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+examples-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+examples-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+examples-devel}"
SRC_URI[aarch64_rust-snapbox+examples-devel.sha256sum] = "bbf9dc19f990b03f9c2a2b15ca3939ef2dbe48aa6e04615bfe410d798efe1446"

URI_aarch64_rust-snapbox+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+json-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+json-devel}"
SRC_URI[aarch64_rust-snapbox+json-devel.sha256sum] = "615168546fd95c14d4dce5bcb9de090066cbf0ec212c68a0b261d593b6d30350"

URI_aarch64_rust-snapbox+path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+path-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+path-devel}"
SRC_URI[aarch64_rust-snapbox+path-devel.sha256sum] = "9ddc1f92a1d5dfdb3077052653117fd8e9502721f75522fe011242832ed6eab7"

URI_aarch64_rust-snapbox+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+regex-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+regex-devel}"
SRC_URI[aarch64_rust-snapbox+regex-devel.sha256sum] = "835624466ab9f6f4a3292bb14f192f1b6a3d65b21de41bf44e7693e761a1c0f1"

URI_aarch64_rust-snapbox+structured-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+structured-data-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+structured-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+structured-data-devel}"
SRC_URI[aarch64_rust-snapbox+structured-data-devel.sha256sum] = "d68a128b8379a61e0de1d01c387ab92bd4aa1f948ad2273a88b5197175bafa5a"

URI_aarch64_rust-snapbox+term-svg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+term-svg-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox+term-svg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox+term-svg-devel}"
SRC_URI[aarch64_rust-snapbox+term-svg-devel.sha256sum] = "04de9345956fcdfd547c687f3628d89582d77459babe96e17090a2e3a6f123de"

URI_aarch64_rust-snapbox-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-devel}"
SRC_URI[aarch64_rust-snapbox-devel.sha256sum] = "42995923f159c2205acddee4c463fdb5b765ceb5bca8bd2ceb4ac579c6429ebc"

RDEPENDS:rust-snapbox+cmd-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-os_pipe+default-devel \
 rust-snapbox-devel \
 rust-wait-timeout+default-devel \
 "
RDEPENDS:rust-snapbox+color-auto-devel = " \
 cargo \
 rust-snapbox+color-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox-devel \
 rust-snapbox-macros+color-devel \
 "
RDEPENDS:rust-snapbox+debug-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-snapbox-devel \
 rust-snapbox-macros+debug-devel \
 "
RDEPENDS:rust-snapbox+default-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-snapbox+diff-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+detect-encoding-devel = " \
 cargo \
 rust-content_inspector+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+diff-devel = " \
 cargo \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+dir-devel = " \
 cargo \
 rust-dunce+default-devel \
 rust-filetime+default-devel \
 rust-snapbox+detect-encoding-devel \
 rust-snapbox-devel \
 rust-tempfile+default-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-snapbox+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+examples-devel = " \
 cargo \
 rust-escargot+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+json-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+path-devel = " \
 cargo \
 rust-snapbox+dir-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+regex-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+structured-data-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+term-svg-devel = " \
 cargo \
 rust-anstyle-svg+default-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-normalize-line-endings+default-devel \
 rust-snapbox-macros+default-devel \
 "
