# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkscreen"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 libkscreen \
 libkscreen-devel \
 libkscreen-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkscreen-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c83a4e85a0d02de93330fcb41074613585d4ed89f27e07f5893933e18bc368c1"

URI_x86_64_v2_libkscreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkscreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen}"
SRC_URI[x86_64_v2_libkscreen.sha256sum] = "52c7848eb0a5bc999585e013e815382ad9b6e28a9a4155408f2c64b57848de85"

URI_x86_64_v2_libkscreen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkscreen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen-devel}"
SRC_URI[x86_64_v2_libkscreen-devel.sha256sum] = "eea12b3fb9b23651f54c0a5af2a4f1f80961c15b02993abfd10b137750f69181"

URI_x86_64_v2_libkscreen-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-doc-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libkscreen-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen-doc}"
SRC_URI[x86_64_v2_libkscreen-doc.sha256sum] = "d6345cbd81b4a6532a9cc083a18219d6e1aeff89c85531b34a8659289c0f3448"

URI_aarch64_libkscreen = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_libkscreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen}"
SRC_URI[aarch64_libkscreen.sha256sum] = "787a30879d2816d8672e195881dde188fba735d45ffe9519aef8b9140f5ffbc7"

URI_aarch64_libkscreen-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_libkscreen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen-devel}"
SRC_URI[aarch64_libkscreen-devel.sha256sum] = "671cb2a76ef02b12cf24b1571cdd929a51cd36503dad610a5867f9f75c025975"

URI_aarch64_libkscreen-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-doc-6.6.4-1.el10_2.noarch.rpm;name=aarch64_libkscreen-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen-doc}"
SRC_URI[aarch64_libkscreen-doc.sha256sum] = "c51135d0ad5cb822b3195614077e508775851e3654cf810410efdd6a4245fc6c"

RDEPENDS:libkscreen = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkscreen-devel = " \
 cmake-filesystem \
 libkscreen \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:libkscreen-doc = " \
 "
