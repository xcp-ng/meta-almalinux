# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "CGAL"
PV = "6.0.1"
PR = "1.el10_0"
PACKAGES = " \
 CGAL-demos-source \
 CGAL-devel \
 CGAL-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/CGAL-6.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a21dd62ab5079e211d50a26b3290c276751af10f9466cb69eb9ef69ee969ef7"

URI_x86_64_v2_CGAL-demos-source = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGAL-demos-source-6.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_CGAL-demos-source;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGAL-demos-source}"
SRC_URI[x86_64_v2_CGAL-demos-source.sha256sum] = "fa6994909bfdde64ac712bca80d4346d2ae0cb1fa835e1a3610c382e8713095e"

URI_x86_64_v2_CGAL-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGAL-devel-6.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CGAL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGAL-devel}"
SRC_URI[x86_64_v2_CGAL-devel.sha256sum] = "b09832c840af81372ef0a876b4dc07619382b783298afa1805161476e14ad97b"

URI_x86_64_v2_CGAL-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGAL-qt6-devel-6.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CGAL-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGAL-qt6-devel}"
SRC_URI[x86_64_v2_CGAL-qt6-devel.sha256sum] = "6d41e851e99a7dac6776d5fa5c6e2328739f407928b3a4464828a02203f068c9"

URI_aarch64_CGAL-demos-source = "${EPEL_MIRROR}/aarch64/Packages/c/CGAL-demos-source-6.0.1-1.el10_0.noarch.rpm;name=aarch64_CGAL-demos-source;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGAL-demos-source}"
SRC_URI[aarch64_CGAL-demos-source.sha256sum] = "48581848d30ec2c9c0675cefefd081b4378cf1888d7e6d979c695e505eae6c7c"

URI_aarch64_CGAL-devel = "${EPEL_MIRROR}/aarch64/Packages/c/CGAL-devel-6.0.1-1.el10_0.aarch64.rpm;name=aarch64_CGAL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGAL-devel}"
SRC_URI[aarch64_CGAL-devel.sha256sum] = "4c56d74235a36c2d51d20a51f4069412926291d52933711aa2f2eedac2d00acc"

URI_aarch64_CGAL-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/c/CGAL-qt6-devel-6.0.1-1.el10_0.aarch64.rpm;name=aarch64_CGAL-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGAL-qt6-devel}"
SRC_URI[aarch64_CGAL-qt6-devel.sha256sum] = "6b78c0ed4de992741cc33444fe6a71c41ba4fd05ff153a9ace7055f55ca14af5"

RDEPENDS:CGAL-demos-source = " \
 CGAL-devel \
 bash \
 "
RDEPENDS:CGAL-devel = " \
 bash \
 boost-devel \
 cmake \
 cmake-filesystem \
 gmp-devel \
 mpfr-devel \
 "
RDEPENDS:CGAL-qt6-devel = " \
 CGAL-devel \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtsvg-devel \
 qt6-qttools-devel \
 "
