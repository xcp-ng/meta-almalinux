# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nodeenv"
PV = "1.10.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-nodeenv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nodeenv-1.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "955828651f38f544e8ad828cf6df991d5359beb521400667b56c0aaa40fc5005"

URI_x86_64_v2_python3-nodeenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nodeenv-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nodeenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nodeenv}"
SRC_URI[x86_64_v2_python3-nodeenv.sha256sum] = "9aed4b9ff12a38e063f736c1b977142b174de31a657ea017e1f901519693fd72"

URI_aarch64_python3-nodeenv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nodeenv-1.10.0-1.el10_2.noarch.rpm;name=aarch64_python3-nodeenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nodeenv}"
SRC_URI[aarch64_python3-nodeenv.sha256sum] = "59feacf69dc9224068505e7f1c6770ac7112fa13e95abc87a882b2b146680659"

RDEPENDS:python3-nodeenv = " \
 python3 \
 "
