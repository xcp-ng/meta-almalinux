# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sqlite"
PV = "3.46.1"
PR = "5.el10_0"
PACKAGES = " \
 sqlite \
 sqlite-devel \
 sqlite-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sqlite-3.46.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a64cc31499652d782498f3ef135b26fc5b4cca9ca1e27da6718ce87430f1ffec"

URI_x86_64_v2_sqlite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sqlite-3.46.1-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlite}"
SRC_URI[x86_64_v2_sqlite.sha256sum] = "8e38f713e6693cd4af5b3a8929dfd97a8f0b11c5bf55e8aadaa0295d140ca114"

URI_x86_64_v2_sqlite-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sqlite-devel-3.46.1-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlite-devel}"
SRC_URI[x86_64_v2_sqlite-devel.sha256sum] = "5389c8bf0479552adc7a5773a9a9b984170e90c810c1a38de2da6a3d76293f39"

URI_x86_64_v2_sqlite-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sqlite-libs-3.46.1-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_sqlite-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlite-libs}"
SRC_URI[x86_64_v2_sqlite-libs.sha256sum] = "845acc568ab94b4843d7c481d3f3e2301174aedb1533a52fe2b8235c7f0ad50c"

URI_aarch64_sqlite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sqlite-3.46.1-5.el10_0.aarch64.rpm;name=aarch64_sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlite}"
SRC_URI[aarch64_sqlite.sha256sum] = "0191e2e239e92599fe4c3c0a199033f15d4c0abc70a82fb7b1e1ada3b121fa10"

URI_aarch64_sqlite-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sqlite-devel-3.46.1-5.el10_0.aarch64.rpm;name=aarch64_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlite-devel}"
SRC_URI[aarch64_sqlite-devel.sha256sum] = "039ab5b065d1ab063f067a42ebb3f028a3ca3e2c9e7390749dff15d778cce179"

URI_aarch64_sqlite-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sqlite-libs-3.46.1-5.el10_0.aarch64.rpm;name=aarch64_sqlite-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlite-libs}"
SRC_URI[aarch64_sqlite-libs.sha256sum] = "fb9e4ec956ec7010e07fd3ade5cce9ee0b8e921ac488333c0bdad3d0b2cadd74"

RDEPENDS:sqlite = " \
 glibc \
 readline \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:sqlite-devel = " \
 pkgconf-pkg-config \
 sqlite \
 sqlite-libs \
 "
RDEPENDS:sqlite-libs = " \
 glibc \
 zlib-ng-compat \
 "
