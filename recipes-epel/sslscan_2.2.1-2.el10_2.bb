# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sslscan"
PV = "2.2.1"
PR = "2.el10_2"
PACKAGES = " \
 sslscan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sslscan-2.2.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a230712110d5be9f39247158e62b353a7cf40755a7f2e7506fb607d52591d424"

URI_x86_64_v2_sslscan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sslscan-2.2.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sslscan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sslscan}"
SRC_URI[x86_64_v2_sslscan.sha256sum] = "4254671fe5b5d20dc1c663d638628209f1ea16bf6214d8328b6e6e18f11b8493"

URI_aarch64_sslscan = "${EPEL_MIRROR}/aarch64/Packages/s/sslscan-2.2.1-2.el10_2.aarch64.rpm;name=aarch64_sslscan;unpack=0"
SRC_URI:append = " ${URI_aarch64_sslscan}"
SRC_URI[aarch64_sslscan.sha256sum] = "cb131f2380574d95c6f79480e017fe404ed25002ec87fb74e4b9b68a5ea065a7"

RDEPENDS:sslscan = " \
 glibc \
 zlib-ng-compat \
 "
