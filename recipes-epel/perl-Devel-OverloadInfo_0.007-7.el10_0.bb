# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-OverloadInfo"
PV = "0.007"
PR = "7.el10_0"
PACKAGES = " \
 perl-Devel-OverloadInfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-OverloadInfo-0.007-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd1254b902b91a880fbf97faac1d3be80bfc99d9f7fae378cedf4ba977efb59f"

URI_x86_64_v2_perl-Devel-OverloadInfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-OverloadInfo-0.007-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-OverloadInfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-OverloadInfo}"
SRC_URI[x86_64_v2_perl-Devel-OverloadInfo.sha256sum] = "9cb5a8ed93e669e5e3262f17c1339458daa2d7f1f326dfa65e442a721c0e95fb"

URI_aarch64_perl-Devel-OverloadInfo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-OverloadInfo-0.007-7.el10_0.noarch.rpm;name=aarch64_perl-Devel-OverloadInfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-OverloadInfo}"
SRC_URI[aarch64_perl-Devel-OverloadInfo.sha256sum] = "8ac8d5e42edc6349bc697451aaea79d5123d94f2d6d842e77920ce78556f7db2"

RDEPENDS:perl-Devel-OverloadInfo = " \
 perl-Exporter \
 perl-MRO-Compat \
 perl-Package-Stash \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 "
