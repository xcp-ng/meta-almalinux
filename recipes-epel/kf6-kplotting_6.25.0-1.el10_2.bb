# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kplotting"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kplotting \
 kf6-kplotting-devel \
 kf6-kplotting-doc \
 kf6-kplotting-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kplotting-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a318549c8e18d637bba1d0371a706523196006f2e716f89f700b6124a7f9cc51"

URI_x86_64_v2_kf6-kplotting = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kplotting;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting}"
SRC_URI[x86_64_v2_kf6-kplotting.sha256sum] = "838e09b395edd728de42188bdfd8f262c5649aec45dd2a05fdf235893c32e125"

URI_x86_64_v2_kf6-kplotting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kplotting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-devel}"
SRC_URI[x86_64_v2_kf6-kplotting-devel.sha256sum] = "24ac155fa3c08a764b776f3fe667c4afaf949fd1e1b7eff341232316c2f97118"

URI_x86_64_v2_kf6-kplotting-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kplotting-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-doc}"
SRC_URI[x86_64_v2_kf6-kplotting-doc.sha256sum] = "a90cdbf0edd06d9f9dadf682924cb908befc5a20d9fcadbfe1490bcd06c1d57d"

URI_x86_64_v2_kf6-kplotting-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kplotting-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-html}"
SRC_URI[x86_64_v2_kf6-kplotting-html.sha256sum] = "c765650827175b9d3f66aa3668b15c2973c71258d726a41bcab5fdbdfc0510cf"

URI_aarch64_kf6-kplotting = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kplotting;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting}"
SRC_URI[aarch64_kf6-kplotting.sha256sum] = "65ae5e721253fb95aed416e10fb251a34c13fbc0261d5553ce88a93fc514bb37"

URI_aarch64_kf6-kplotting-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kplotting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-devel}"
SRC_URI[aarch64_kf6-kplotting-devel.sha256sum] = "e292723bfa78782bd54b5c1142b81f9e3a75b23bd5108dc4637388467ecf2dc3"

URI_aarch64_kf6-kplotting-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kplotting-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-doc}"
SRC_URI[aarch64_kf6-kplotting-doc.sha256sum] = "1b5dfdfe5cbdc33f3c352acc0938fcdc6211ffd016b2069cb8dc8c4e371a252b"

URI_aarch64_kf6-kplotting-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kplotting-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-html}"
SRC_URI[aarch64_kf6-kplotting-html.sha256sum] = "ec80c4820529d4037a09afcda2c954264cc378af917aecf38ca649e8eb8fc760"

RDEPENDS:kf6-kplotting = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kplotting-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kplotting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kplotting-doc = " \
 "
RDEPENDS:kf6-kplotting-html = " \
 "
