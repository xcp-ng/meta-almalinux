# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hspec-discover"
PV = "2.11.9"
PR = "1.el10_0"
PACKAGES = " \
 ghc-hspec-discover \
 ghc-hspec-discover-devel \
 ghc-hspec-discover-doc \
 ghc-hspec-discover-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hspec-discover-2.11.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f0a993fdc3cda940a2aafe19f9da46c6712a285e05a63a5f0d208259d77a127"

URI_x86_64_v2_ghc-hspec-discover = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-discover-2.11.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-discover;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-discover}"
SRC_URI[x86_64_v2_ghc-hspec-discover.sha256sum] = "8538ef7f7c4d208d0b70f5351f982289eaebff2c6e08cc5476f76afce7255d5c"

URI_x86_64_v2_ghc-hspec-discover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-discover-devel-2.11.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-discover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-discover-devel}"
SRC_URI[x86_64_v2_ghc-hspec-discover-devel.sha256sum] = "0b4d7b02be02f6cc489632ffac670edaeae6d875fead08968427f1df500d4b81"

URI_x86_64_v2_ghc-hspec-discover-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-discover-doc-2.11.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hspec-discover-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-discover-doc}"
SRC_URI[x86_64_v2_ghc-hspec-discover-doc.sha256sum] = "99707d48b7b7840041da75f15e2ba6885aed64f0ced606e67a74686aa767b73e"

URI_x86_64_v2_ghc-hspec-discover-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-discover-prof-2.11.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-discover-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-discover-prof}"
SRC_URI[x86_64_v2_ghc-hspec-discover-prof.sha256sum] = "62915f149de8dfd7c001fa3a7a3a3a9294e7f93c8f383a25dfe53372b656d615"

URI_aarch64_ghc-hspec-discover = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-discover-2.11.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-discover;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-discover}"
SRC_URI[aarch64_ghc-hspec-discover.sha256sum] = "16d01b948f1e0b7ee2ad9b15971756ccbde1befd68491e4700bd2033d6131eb8"

URI_aarch64_ghc-hspec-discover-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-discover-devel-2.11.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-discover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-discover-devel}"
SRC_URI[aarch64_ghc-hspec-discover-devel.sha256sum] = "a6758e23bf1a35ad1f5e8b249b8b3458d1264f33bb1ccfbdc1912ca9a2e18323"

URI_aarch64_ghc-hspec-discover-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-discover-doc-2.11.9-1.el10_0.noarch.rpm;name=aarch64_ghc-hspec-discover-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-discover-doc}"
SRC_URI[aarch64_ghc-hspec-discover-doc.sha256sum] = "d18f3e3876290502558ee53d343aad053992d4e20b3074898c58db3e8829ab09"

URI_aarch64_ghc-hspec-discover-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-discover-prof-2.11.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-discover-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-discover-prof}"
SRC_URI[aarch64_ghc-hspec-discover-prof.sha256sum] = "1e2a9564573460d05b814c9c83c0fcc61db09f83e572bfb7d2e464d762997f6c"

RDEPENDS:ghc-hspec-discover = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hspec-discover-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-hspec-discover \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-hspec-discover-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hspec-discover-prof = " \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-hspec-discover-devel \
 "
