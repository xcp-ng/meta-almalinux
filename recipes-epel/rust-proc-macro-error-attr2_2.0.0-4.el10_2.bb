# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-error-attr2"
PV = "2.0.0"
PR = "4.el10_2"
PACKAGES = " \
 rust-proc-macro-error-attr2+default-devel \
 rust-proc-macro-error-attr2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-error-attr2-2.0.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c7565f510b6638b85affe35491c5a12e745f2e66dc9d86f159fd420f299644d"

URI_x86_64_v2_rust-proc-macro-error-attr2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error-attr2+default-devel-2.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error-attr2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error-attr2+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error-attr2+default-devel.sha256sum] = "780e4e1778082b91a62b4e3db799fcfc05ed162ba83082f71321763d330fc6d3"

URI_x86_64_v2_rust-proc-macro-error-attr2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error-attr2-devel-2.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error-attr2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-error-attr2-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-error-attr2-devel.sha256sum] = "092637febf53acbdee6dca9bed80db72a56bda71c300d43a18841faddf611a7f"

URI_aarch64_rust-proc-macro-error-attr2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error-attr2+default-devel-2.0.0-4.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-error-attr2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error-attr2+default-devel}"
SRC_URI[aarch64_rust-proc-macro-error-attr2+default-devel.sha256sum] = "2e94047e611ed03db1ea9128c6a10f28d291803fac56b83505b0e7724f26d88d"

URI_aarch64_rust-proc-macro-error-attr2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error-attr2-devel-2.0.0-4.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-error-attr2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-error-attr2-devel}"
SRC_URI[aarch64_rust-proc-macro-error-attr2-devel.sha256sum] = "67d566a87033ffc7b2b221257324afebefcea951f8bd87d0de4bfd5c5b7a5972"

RDEPENDS:rust-proc-macro-error-attr2+default-devel = " \
 cargo \
 rust-proc-macro-error-attr2-devel \
 "
RDEPENDS:rust-proc-macro-error-attr2-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
