# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-s-cargot"
PV = "0.1.6.0"
PR = "3.el10_0"
PACKAGES = " \
 ghc-s-cargot \
 ghc-s-cargot-devel \
 ghc-s-cargot-doc \
 ghc-s-cargot-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-s-cargot-0.1.6.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "621451bcc6359d2d6d5063ef2c5a34117b3a8258217ed2bb56782e36c8fbccc5"

URI_x86_64_v2_ghc-s-cargot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-s-cargot-0.1.6.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-s-cargot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-s-cargot}"
SRC_URI[x86_64_v2_ghc-s-cargot.sha256sum] = "5b3ac2619597a78734f13bc2d997b021ebe03efa08e2e013549b632d2dacbf01"

URI_x86_64_v2_ghc-s-cargot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-s-cargot-devel-0.1.6.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-s-cargot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-s-cargot-devel}"
SRC_URI[x86_64_v2_ghc-s-cargot-devel.sha256sum] = "f1eaf312ab623c6c1be4b00a1cf9a7796bdb4d2266a996f96496e64ea6453232"

URI_x86_64_v2_ghc-s-cargot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-s-cargot-doc-0.1.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-s-cargot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-s-cargot-doc}"
SRC_URI[x86_64_v2_ghc-s-cargot-doc.sha256sum] = "013e7f1d49b667359435390ea091915e4424b3e89d6da84ccce02d91a79e5c4b"

URI_x86_64_v2_ghc-s-cargot-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-s-cargot-prof-0.1.6.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-s-cargot-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-s-cargot-prof}"
SRC_URI[x86_64_v2_ghc-s-cargot-prof.sha256sum] = "ba6c498eb66f8d45ead56d054dbac27c5c8cb93c03e860aa19b6ac8c9d53e5f0"

URI_aarch64_ghc-s-cargot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-s-cargot-0.1.6.0-3.el10_0.aarch64.rpm;name=aarch64_ghc-s-cargot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-s-cargot}"
SRC_URI[aarch64_ghc-s-cargot.sha256sum] = "93d6253055aa847c8efe0a23c4583a68aa980f64c531f92e6d8345cdb38c21c1"

URI_aarch64_ghc-s-cargot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-s-cargot-devel-0.1.6.0-3.el10_0.aarch64.rpm;name=aarch64_ghc-s-cargot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-s-cargot-devel}"
SRC_URI[aarch64_ghc-s-cargot-devel.sha256sum] = "c84b53fd406c7b77888a46f5c517c9216e9cea52415b209cbd2a902c8ff8d0b3"

URI_aarch64_ghc-s-cargot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-s-cargot-doc-0.1.6.0-3.el10_0.noarch.rpm;name=aarch64_ghc-s-cargot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-s-cargot-doc}"
SRC_URI[aarch64_ghc-s-cargot-doc.sha256sum] = "951440fece4fe1d68279b98afde710e7b221bf61096d15bbd484369ae32befeb"

URI_aarch64_ghc-s-cargot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-s-cargot-prof-0.1.6.0-3.el10_0.aarch64.rpm;name=aarch64_ghc-s-cargot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-s-cargot-prof}"
SRC_URI[aarch64_ghc-s-cargot-prof.sha256sum] = "c785b4ec9fa7024171230c8ea2c677f190c8fce4c03f94f67ea8699d919aa1cf"

RDEPENDS:ghc-s-cargot = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-s-cargot-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-parsec-devel \
 ghc-s-cargot \
 ghc-text-devel \
 "
RDEPENDS:ghc-s-cargot-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-s-cargot-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-parsec-prof \
 ghc-s-cargot-devel \
 ghc-text-prof \
 "
