# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kglobalaccel"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kglobalaccel \
 kf6-kglobalaccel-devel \
 kf6-kglobalaccel-doc \
 kf6-kglobalaccel-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kglobalaccel-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ae69fe21c56abd1877e790e53a4cc536dfce2e2441c021a0153421a4133efda"

URI_x86_64_v2_kf6-kglobalaccel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kglobalaccel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel}"
SRC_URI[x86_64_v2_kf6-kglobalaccel.sha256sum] = "6edc30e00e991b6e570cf147aa0c7df8c8e89e7fee482fd730a19bde1b36c9af"

URI_x86_64_v2_kf6-kglobalaccel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kglobalaccel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-devel}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-devel.sha256sum] = "3c6ad5d0d6d929d8f1fab81037cc0c98993d8c459045f828eeff7d27faf6465b"

URI_x86_64_v2_kf6-kglobalaccel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kglobalaccel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-doc}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-doc.sha256sum] = "1c0acbe4b85a7b972410b21651e95704415840fd89c2549cb73fbd8ec976a29f"

URI_x86_64_v2_kf6-kglobalaccel-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kglobalaccel-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-html}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-html.sha256sum] = "7ebd433c8ae5d6d9104391f73cabe2e9654c70a9dfec8f517fd8cb4ff50f7735"

URI_aarch64_kf6-kglobalaccel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kglobalaccel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel}"
SRC_URI[aarch64_kf6-kglobalaccel.sha256sum] = "8ad5427aed826b3bfe55450893b82a093d1d98b1e170f2ff402499e859241546"

URI_aarch64_kf6-kglobalaccel-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kglobalaccel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-devel}"
SRC_URI[aarch64_kf6-kglobalaccel-devel.sha256sum] = "cdf43b901cfbcba8724a2b6c5ff1477faa1e61903fe09eff8771a416eca98c1a"

URI_aarch64_kf6-kglobalaccel-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kglobalaccel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-doc}"
SRC_URI[aarch64_kf6-kglobalaccel-doc.sha256sum] = "7b549148cecfc6719286e69f16b6f1b66c4a5325ba51805b5cbf7757c135a9f1"

URI_aarch64_kf6-kglobalaccel-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kglobalaccel-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-html}"
SRC_URI[aarch64_kf6-kglobalaccel-html.sha256sum] = "38d240f485a4e02c47374edb0ea3b2a778b6142303f06d833e3af5516f88db25"

RDEPENDS:kf6-kglobalaccel = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kglobalaccel-devel = " \
 cmake-filesystem \
 kf6-kglobalaccel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kglobalaccel-doc = " \
 "
RDEPENDS:kf6-kglobalaccel-html = " \
 "
