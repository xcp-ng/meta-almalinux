# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Heap"
PV = "0.80"
PR = "49.el10_3"
PACKAGES = " \
 perl-Heap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Heap-0.80-49.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf1cbb73e6f61201c0a253896339b6bccb4d4e65b971074400e60c12d06ad1eb"

URI_x86_64_v2_perl-Heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Heap-0.80-49.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Heap}"
SRC_URI[x86_64_v2_perl-Heap.sha256sum] = "a9f5c7b1550db92d20bedd6931b21dbc0321900cf7ea907ef692651ccb0c4551"

URI_aarch64_perl-Heap = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Heap-0.80-49.el10_3.noarch.rpm;name=aarch64_perl-Heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Heap}"
SRC_URI[aarch64_perl-Heap.sha256sum] = "dc810bd0e70164c3e619e8264bb8f483ae9e285aa95b326b92eb59b5cbe3b8f3"

RDEPENDS:perl-Heap = " \
 perl-Exporter \
 perl-Heap \
 perl-libs \
 perl-vars \
 "
