# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fdupes"
PE = "1"
PV = "2.4.0"
PR = "1.el10_1"
PACKAGES = " \
 fdupes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fdupes-2.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5975ae765fa61c5d12a2f32146b7afc5621d49f6b5a96d882d686f5d8104f96b"

URI_x86_64_v2_fdupes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fdupes-2.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fdupes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdupes}"
SRC_URI[x86_64_v2_fdupes.sha256sum] = "16445e0d7404a77e3b62031320889d884ea0a60943122ab8c2e2292a176cb489"

URI_aarch64_fdupes = "${EPEL_MIRROR}/aarch64/Packages/f/fdupes-2.4.0-1.el10_1.aarch64.rpm;name=aarch64_fdupes;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdupes}"
SRC_URI[aarch64_fdupes.sha256sum] = "138758e8ba901fc0602c37644b5884fe3c55b23500de0512cd4af4193d1002f0"

RDEPENDS:fdupes = " \
 glibc \
 ncurses-libs \
 pcre2-utf32 \
 sqlite-libs \
 "
