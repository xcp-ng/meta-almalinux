# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-insta"
PV = "1.48.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-insta+_cargo_insta_internal-devel \
 rust-insta+clap-devel \
 rust-insta+colors-devel \
 rust-insta+console-devel \
 rust-insta+csv-devel \
 rust-insta+default-devel \
 rust-insta+filters-devel \
 rust-insta+glob-devel \
 rust-insta+globset-devel \
 rust-insta+json-devel \
 rust-insta+pest-devel \
 rust-insta+pest_derive-devel \
 rust-insta+redactions-devel \
 rust-insta+regex-devel \
 rust-insta+ron-devel \
 rust-insta+serde-devel \
 rust-insta+strip-ansi-escapes-devel \
 rust-insta+toml-devel \
 rust-insta+walkdir-devel \
 rust-insta+yaml-devel \
 rust-insta-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-insta-1.48.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a0d12e4bc65ec890d80e629bdbf88085ba4ccbc0fc4afeb1b3f0951945bb852a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+_cargo_insta_internal-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+_cargo_insta_internal-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+_cargo_insta_internal-devel.sha256sum] = "5eb6d0221fcb82827000d33f1687b74ae40066d9c9631c15657465d1ab28500d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+clap-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+clap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+clap-devel.sha256sum] = "db1a6d1175caf13ef7128988acac8f653aca5c2307d9e8ecefe8ad98fbf11cbc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+colors-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+colors-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+colors-devel.sha256sum] = "c5c2545dbe020061376b2e91715f5044beccfa68d38fd42443a751ad7fe209d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+console-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+console-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+console-devel.sha256sum] = "dcdd7a10f954ec48c0c93079cae37aa2f4a6acb4d7e655303c356e584ee39599"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+csv-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+csv-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+csv-devel.sha256sum] = "4658b340565a78abe75d3223505cc643a3437cfbd4dcc13e1d4b324616153210"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+default-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+default-devel.sha256sum] = "0c612dc69e46ebd5af3a5153a58e2a08dbb9733af3705fd0c6f0de09d0ac654c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+filters-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+filters-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+filters-devel.sha256sum] = "296923ae320f63b40af0309ea603a995eceafb92526db75012f69dbe309b56b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+glob-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+glob-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+glob-devel.sha256sum] = "4d051fb55ecfba90e0c46a1c08b0903aead0798579cad94448c06fcfa57780e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+globset-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+globset-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+globset-devel.sha256sum] = "e86af86ccc65340a2d95aef93225cdd2adbdff4716c2d9102b22749494432c0d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+json-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+json-devel.sha256sum] = "c42e7d577e11089d650cab4e819679c6619700b759d943720ea9c4d1c17333e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+pest-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+pest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+pest-devel.sha256sum] = "98a9d088e25173f3da5f52b5ebfb2db12d3af5afc0caa0e997eea3865908ad3d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+pest_derive-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+pest_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+pest_derive-devel.sha256sum] = "c82f9437aa7cd557cf5a06cda0c608f3008e998ffd892537a0bb0ebacac81929"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+redactions-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+redactions-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+redactions-devel.sha256sum] = "eddb6691ec55742469a1585c116b0c17c06d94ca3d0de070bc81d088ce85fed3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+regex-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+regex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+regex-devel.sha256sum] = "a4039f51e74a5f5d7f4af1e6e63b58347933a079f9709da218ce678f559ec041"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+ron-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+ron-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+ron-devel.sha256sum] = "9f8e10046de8f5c811d0949a352dccd39df57470210313744b6f42d0d485e896"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+serde-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+serde-devel.sha256sum] = "73fab017336034eadfe28b1c0b8f850bf42c6f3a61d2796d118aa22c061a4778"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+strip-ansi-escapes-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+strip-ansi-escapes-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+strip-ansi-escapes-devel.sha256sum] = "4a625be7f0dcbacb662c13d61fa0dcd2ab9bb5f8b4d95ac983c78d08c328a007"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+toml-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+toml-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+toml-devel.sha256sum] = "13d8d993d6d88b20c04d4fb3b8f73bee36a6ab478e5bcc0b161913bfd00da871"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+walkdir-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+walkdir-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+walkdir-devel.sha256sum] = "d93096cbd0cf58ef6752ed46a2dced2d8cc71bdd2bbfaf24eac1b30d39b8d028"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+yaml-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+yaml-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+yaml-devel.sha256sum] = "d9c2f29a1644704dcca68deb664c21ec705410e6e870b86f63e1ab978cca9a86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta-devel-1.48.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta-devel.sha256sum] = "4aaeec84d946d3e60b38ff1c7bdcd372f711bcf4cd084fecee3cdf88b272b791"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+_cargo_insta_internal-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+_cargo_insta_internal-devel;unpack=0"
SRC_URI[aarch64_rust-insta+_cargo_insta_internal-devel.sha256sum] = "1e3ade9dfea2fb2b4ae0c2878637a9864e0053b0cf33ca61f4b6ce7efbad2e21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+clap-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+clap-devel;unpack=0"
SRC_URI[aarch64_rust-insta+clap-devel.sha256sum] = "1e575784223b374f9bcd2473cfee41fe08f49d31e11e7a77f0cecc1c6bc8f4ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+colors-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+colors-devel;unpack=0"
SRC_URI[aarch64_rust-insta+colors-devel.sha256sum] = "b772f90e23b96904da2db570484ec70dd4db153d63fee27b709c46ee3a191e82"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+console-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+console-devel;unpack=0"
SRC_URI[aarch64_rust-insta+console-devel.sha256sum] = "d1e8bb5a60746e73d5d99b002569b6a3a485b9870a5fc7b5c420cae1c9bb3206"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+csv-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+csv-devel;unpack=0"
SRC_URI[aarch64_rust-insta+csv-devel.sha256sum] = "8f27a654bc1bff701f2d99a794669d687149aecd92faa8fa058cf73d3f64ecc6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+default-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+default-devel;unpack=0"
SRC_URI[aarch64_rust-insta+default-devel.sha256sum] = "fa3b3778ed6710be3704aeef7e4f48ffa9a56915b046a3bdf49f7e449ac7c7f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+filters-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+filters-devel;unpack=0"
SRC_URI[aarch64_rust-insta+filters-devel.sha256sum] = "dfb6b9b2f943c20595922da85aa87154931fdebb028724f6a26b072b5d8c332b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+glob-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+glob-devel;unpack=0"
SRC_URI[aarch64_rust-insta+glob-devel.sha256sum] = "32be6580f7b08a9a3690a54dd7d5d311e82094bc5abc40c36eee19c7a412b7c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+globset-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+globset-devel;unpack=0"
SRC_URI[aarch64_rust-insta+globset-devel.sha256sum] = "da35b3be6a16c617f92bc4db2384af0dd4d4b812ed1b76bfd2427e71f70e44ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+json-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+json-devel;unpack=0"
SRC_URI[aarch64_rust-insta+json-devel.sha256sum] = "4f7724ffeb58e45b61229c24922566fb71b2824e25a595dcb2b663f97632d7f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+pest-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+pest-devel;unpack=0"
SRC_URI[aarch64_rust-insta+pest-devel.sha256sum] = "2e37f5976fe44e2e607090d55abf0f18a7f22ccc12b8c9ad093a8aa4acdbcee4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+pest_derive-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+pest_derive-devel;unpack=0"
SRC_URI[aarch64_rust-insta+pest_derive-devel.sha256sum] = "2290b35d250da277d1a09c0f660275cca7c73d01c7a26b57e23120c4357b3080"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+redactions-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+redactions-devel;unpack=0"
SRC_URI[aarch64_rust-insta+redactions-devel.sha256sum] = "b9de27cf63c72fb6d0278c71ac5c1036b2f21800c886050e8a5291d3e8186e4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+regex-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+regex-devel;unpack=0"
SRC_URI[aarch64_rust-insta+regex-devel.sha256sum] = "c96fa0ae7b9270192630138d2f56ad03d6e0d5664b07e03d19c20775b2ecf3fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+ron-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+ron-devel;unpack=0"
SRC_URI[aarch64_rust-insta+ron-devel.sha256sum] = "2cd1ea32ee19ef8c9acc9c3e9038cacbeb2726ef649faf3d8f257212231985f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+serde-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+serde-devel;unpack=0"
SRC_URI[aarch64_rust-insta+serde-devel.sha256sum] = "fadd4cb857c5189919410e9c101d6f8d087a8764e6b48a23382ba93d30c9941f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+strip-ansi-escapes-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+strip-ansi-escapes-devel;unpack=0"
SRC_URI[aarch64_rust-insta+strip-ansi-escapes-devel.sha256sum] = "b0de5429305765a60a36efad53a3b279adbb0571c3a078c4fbedc42e55fff6fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+toml-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+toml-devel;unpack=0"
SRC_URI[aarch64_rust-insta+toml-devel.sha256sum] = "9b364ebe8ef15d5eb1c246dc9e2f4e5911e8de58aeaac2f915aae30158ca43ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+walkdir-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+walkdir-devel;unpack=0"
SRC_URI[aarch64_rust-insta+walkdir-devel.sha256sum] = "0d14bcb98bf9eee804c9c93415243b9a7a3b306f2ff4c5ccb6a0dfdb94c4d28c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+yaml-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta+yaml-devel;unpack=0"
SRC_URI[aarch64_rust-insta+yaml-devel.sha256sum] = "ea4f171ca467f93b9cb777f2f434022217cab995a261c6b1549ab55ae44ded5a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta-devel-1.48.0-1.el10_3.noarch.rpm;name=aarch64_rust-insta-devel;unpack=0"
SRC_URI[aarch64_rust-insta-devel.sha256sum] = "1f12025318a528b7738e6bfa692ee4c7cfa999805ec38f3fd5edab95b0cc5382"

RDEPENDS:rust-insta+_cargo_insta_internal-devel = " \
 cargo \
 rust-insta+clap-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+clap-devel = " \
 cargo \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+colors-devel = " \
 cargo \
 rust-insta+console-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+console-devel = " \
 cargo \
 rust-console+std-devel \
 rust-console-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+csv-devel = " \
 cargo \
 rust-csv+default-devel \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+default-devel = " \
 cargo \
 rust-insta+colors-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+filters-devel = " \
 cargo \
 rust-insta+regex-devel \
 rust-insta+strip-ansi-escapes-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+glob-devel = " \
 cargo \
 rust-insta+globset-devel \
 rust-insta+walkdir-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+globset-devel = " \
 cargo \
 rust-globset+default-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+json-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+pest-devel = " \
 cargo \
 rust-insta-devel \
 rust-pest+default-devel \
 "
RDEPENDS:rust-insta+pest_derive-devel = " \
 cargo \
 rust-insta-devel \
 rust-pest_derive+default-devel \
 "
RDEPENDS:rust-insta+redactions-devel = " \
 cargo \
 rust-insta+pest-devel \
 rust-insta+pest_derive-devel \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+regex-devel = " \
 cargo \
 rust-insta-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-insta+ron-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 rust-ron+default-devel \
 "
RDEPENDS:rust-insta+serde-devel = " \
 cargo \
 rust-insta-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-insta+strip-ansi-escapes-devel = " \
 cargo \
 rust-insta-devel \
 rust-strip-ansi-escapes+default-devel \
 "
RDEPENDS:rust-insta+toml-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 rust-toml_edit+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit+serde-devel \
 rust-toml_writer+default-devel \
 "
RDEPENDS:rust-insta+walkdir-devel = " \
 cargo \
 rust-insta-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-insta+yaml-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta-devel = " \
 cargo \
 rust \
 rust-once_cell+default-devel \
 rust-similar2+default-devel \
 rust-similar2+inline-devel \
 rust-tempfile+default-devel \
 "
