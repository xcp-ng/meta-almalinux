# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdiamond"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kdiamond \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdiamond-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7efbda364d5be9a2def9e4b4afa7862869f1965f57d6a50e55e9660c70fef81e"

URI_x86_64_v2_kdiamond = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdiamond-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdiamond;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdiamond}"
SRC_URI[x86_64_v2_kdiamond.sha256sum] = "9ec5161049d45f3136607a5d1e35ffa22e9bab83e2383bf17b5a72a20a5dada3"

URI_aarch64_kdiamond = "${EPEL_MIRROR}/aarch64/Packages/k/kdiamond-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kdiamond;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdiamond}"
SRC_URI[aarch64_kdiamond.sha256sum] = "ebde3d2361482b2c96b2667c147599ab2a02bad19054246f51133f33d6e616cd"

RDEPENDS:kdiamond = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
