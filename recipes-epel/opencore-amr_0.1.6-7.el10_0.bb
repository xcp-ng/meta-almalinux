# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencore-amr"
PV = "0.1.6"
PR = "7.el10_0"
PACKAGES = " \
 opencore-amr \
 opencore-amr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opencore-amr-0.1.6-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ade2575e9cefc9b184b097c9854a44a39175d6d2e85c72c451d2f4af673d248f"

URI_x86_64_v2_opencore-amr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencore-amr-0.1.6-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencore-amr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencore-amr}"
SRC_URI[x86_64_v2_opencore-amr.sha256sum] = "74974b74ec210bab1870865ee9d994d70914cb5e96c166957b4aa2cd73e2f474"

URI_x86_64_v2_opencore-amr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencore-amr-devel-0.1.6-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencore-amr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencore-amr-devel}"
SRC_URI[x86_64_v2_opencore-amr-devel.sha256sum] = "743a92eb6c3d7b09d02e55bf805c1255c2440d16406c6695b8f8b592e74fb4ca"

URI_aarch64_opencore-amr = "${EPEL_MIRROR}/aarch64/Packages/o/opencore-amr-0.1.6-7.el10_0.aarch64.rpm;name=aarch64_opencore-amr;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencore-amr}"
SRC_URI[aarch64_opencore-amr.sha256sum] = "fbaa3cb7246a87130e8db8bdddb901de9f9a28643efb19e719018b5081f7bab6"

URI_aarch64_opencore-amr-devel = "${EPEL_MIRROR}/aarch64/Packages/o/opencore-amr-devel-0.1.6-7.el10_0.aarch64.rpm;name=aarch64_opencore-amr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencore-amr-devel}"
SRC_URI[aarch64_opencore-amr-devel.sha256sum] = "d8e310b3f7786a7bd1db82b7f0591aa0943b6f9e1d7200854a58f52e425a3971"

RDEPENDS:opencore-amr = " \
 glibc \
 "
RDEPENDS:opencore-amr-devel = " \
 opencore-amr \
 pkgconf-pkg-config \
 "
