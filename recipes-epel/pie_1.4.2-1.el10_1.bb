# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pie"
PV = "1.4.2"
PR = "1.el10_1"
PACKAGES = " \
 pie \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pie-1.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9539f43e6aca888e43ca2d9c44e2556acaf9b3d59d0eda2e388db845542ed1f"

URI_x86_64_v2_pie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pie-1.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pie}"
SRC_URI[x86_64_v2_pie.sha256sum] = "0599f1fe2a33690f89e207b448e0a31365e605528253d62129974af7458d63ed"

URI_aarch64_pie = "${EPEL_MIRROR}/aarch64/Packages/p/pie-1.4.2-1.el10_1.noarch.rpm;name=aarch64_pie;unpack=0"
SRC_URI:append = " ${URI_aarch64_pie}"
SRC_URI[aarch64_pie.sha256sum] = "31a7b55416850171d6ab5e167364910be8626fdeadad2a73d7b6d46e333fad18"

RDEPENDS:pie = " \
 bash \
 ca-certificates \
 php-cli \
 php-common \
 php-intl \
 php-mbstring \
 php-pecl-zip \
 php-process \
 php-xml \
 "
