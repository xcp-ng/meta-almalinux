# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zcfan"
PV = "1.4.0"
PR = "3.el10_1"
PACKAGES:x86_64_v2 = " \
 zcfan \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/z/zcfan-1.4.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72fd67fe6f7c1c34ea82fee64d4717749622ca0c5a3f3fd5b9bd687181280f74"

URI_x86_64_v2_zcfan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zcfan-1.4.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zcfan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zcfan}"
SRC_URI[x86_64_v2_zcfan.sha256sum] = "a4d2a1842d379689f4c557139676274e969003111e443a80bd4931ef75b3c96d"

RDEPENDS:zcfan = " \
 bash \
 glibc \
 "
