# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-bitarray"
PV = "3.10.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-bitarray \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-bitarray-3.10.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa9f314b71e804302a264f516274f2aacb75030f7eecceae1aeee5ac8d5aebae"

URI_x86_64_v2_python3-bitarray = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bitarray-3.10.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-bitarray;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bitarray}"
SRC_URI[x86_64_v2_python3-bitarray.sha256sum] = "cde111a405c7913df456ccfc1df212c3d8f4f66e24557179b0cce4e31ed2cae1"

URI_aarch64_python3-bitarray = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bitarray-3.10.1-1.el10_3.aarch64.rpm;name=aarch64_python3-bitarray;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bitarray}"
SRC_URI[aarch64_python3-bitarray.sha256sum] = "b2bf76b682a838d5c6335f9932ff841f3674ef6618a6b1041cd0ea505c9b8882"

RDEPENDS:python3-bitarray = " \
 glibc \
 python3 \
 "
