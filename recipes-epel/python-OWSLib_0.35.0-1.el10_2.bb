# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-OWSLib"
PV = "0.35.0"
PR = "1.el10_2"
PACKAGES = " \
 python-OWSLib-doc \
 python3-OWSLib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-OWSLib-0.35.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f2b83c2595c4b842cf14d47bef6fda9abf449a51dbeaf8e1c978b4c004527dc"

URI_x86_64_v2_python-OWSLib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-OWSLib-doc-0.35.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-OWSLib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-OWSLib-doc}"
SRC_URI[x86_64_v2_python-OWSLib-doc.sha256sum] = "d13a573a499c59851915cc06d4542b765a14438f79a9a96b23ad2c8a3dba11ef"

URI_x86_64_v2_python3-OWSLib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-OWSLib-0.35.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-OWSLib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-OWSLib}"
SRC_URI[x86_64_v2_python3-OWSLib.sha256sum] = "e49d628d15af3f1e2fb6fd58937f8cbe67f171cedef0c659f8560c9a8d32c111"

URI_aarch64_python-OWSLib-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-OWSLib-doc-0.35.0-1.el10_2.noarch.rpm;name=aarch64_python-OWSLib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-OWSLib-doc}"
SRC_URI[aarch64_python-OWSLib-doc.sha256sum] = "0b40b499e30841bc2d84d8c56231bf1761db2d63f1d1e6226571b4f55ded863b"

URI_aarch64_python3-OWSLib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-OWSLib-0.35.0-1.el10_2.noarch.rpm;name=aarch64_python3-OWSLib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-OWSLib}"
SRC_URI[aarch64_python3-OWSLib.sha256sum] = "e126aab1c572893270da351dbd4a2cdaec45fd0ca13249524ad822baf76934ea"

RDEPENDS:python-OWSLib-doc = " \
 "
RDEPENDS:python3-OWSLib = " \
 python3 \
 python3-dateutil \
 python3-lxml \
 python3-pyyaml \
 python3-requests \
 "
