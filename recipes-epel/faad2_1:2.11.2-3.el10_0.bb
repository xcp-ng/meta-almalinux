# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "faad2"
PE = "1"
PV = "2.11.2"
PR = "3.el10_0"
PACKAGES = " \
 faad2 \
 faad2-devel \
 faad2-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/faad2-2.11.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0333785349c18c3d1bb49ba3fda28850ceb0e6c9ed7b9613ccf29109dc4ba26f"

URI_x86_64_v2_faad2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/faad2-2.11.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_faad2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_faad2}"
SRC_URI[x86_64_v2_faad2.sha256sum] = "55858a3dd2a8d26a9f57038387ca66d6444b9c0854053aa8abdfa80770c30b43"

URI_x86_64_v2_faad2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/faad2-devel-2.11.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_faad2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_faad2-devel}"
SRC_URI[x86_64_v2_faad2-devel.sha256sum] = "9477aea372c7ab918a6c92f8a7b7fe21ea75c50586dc51a812f1ae4a31fd6b04"

URI_x86_64_v2_faad2-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/faad2-libs-2.11.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_faad2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_faad2-libs}"
SRC_URI[x86_64_v2_faad2-libs.sha256sum] = "7bc3a15bc09552d15851bfddcb08174dca17483be5b5763e3c1ef9f8adf87f0f"

URI_aarch64_faad2 = "${EPEL_MIRROR}/aarch64/Packages/f/faad2-2.11.2-3.el10_0.aarch64.rpm;name=aarch64_faad2;unpack=0"
SRC_URI:append = " ${URI_aarch64_faad2}"
SRC_URI[aarch64_faad2.sha256sum] = "cd3db491026c1622791481e8ba8c72d726507289a68532898bf56a526009eb84"

URI_aarch64_faad2-devel = "${EPEL_MIRROR}/aarch64/Packages/f/faad2-devel-2.11.2-3.el10_0.aarch64.rpm;name=aarch64_faad2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_faad2-devel}"
SRC_URI[aarch64_faad2-devel.sha256sum] = "6024201ab3a60e5a7ce37befe7b87790519e604691c460a78d8babd7e23900d2"

URI_aarch64_faad2-libs = "${EPEL_MIRROR}/aarch64/Packages/f/faad2-libs-2.11.2-3.el10_0.aarch64.rpm;name=aarch64_faad2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_faad2-libs}"
SRC_URI[aarch64_faad2-libs.sha256sum] = "dd7740eaaf14423a079dc06f4c3e1b5509a56324494450ea2c56739c60293c10"

RDEPENDS:faad2 = " \
 faad2-libs \
 glibc \
 "
RDEPENDS:faad2-devel = " \
 faad2-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:faad2-libs = " \
 glibc \
 "
