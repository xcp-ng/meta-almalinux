# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-schema"
PV = "0.7.7"
PR = "1.el10_1"
PACKAGES = " \
 python3-schema \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-schema-0.7.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "791aedbbdd303dc3701385d2d31cfe1c3d2e8eb1de303213b313df8dbb123734"

URI_x86_64_v2_python3-schema = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-schema-0.7.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-schema;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-schema}"
SRC_URI[x86_64_v2_python3-schema.sha256sum] = "a7ce6721b3a2132ef9322c9ae5acfb06ded9a21e4fc450d463112327052a385a"

URI_aarch64_python3-schema = "${EPEL_MIRROR}/aarch64/Packages/p/python3-schema-0.7.7-1.el10_1.noarch.rpm;name=aarch64_python3-schema;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-schema}"
SRC_URI[aarch64_python3-schema.sha256sum] = "67db9a432da6ca6f0ed26561f71b277bc2a5fe5cd3d833bfb8b07ca1929e7e13"

RDEPENDS:python3-schema = " \
 python3 \
 "
