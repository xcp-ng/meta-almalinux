# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum0.7"
PV = "0.7.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-axum0.7+default-devel \
 rust-axum0.7+form-devel \
 rust-axum0.7+http1-devel \
 rust-axum0.7+http2-devel \
 rust-axum0.7+json-devel \
 rust-axum0.7+macros-devel \
 rust-axum0.7+matched-path-devel \
 rust-axum0.7+multipart-devel \
 rust-axum0.7+original-uri-devel \
 rust-axum0.7+query-devel \
 rust-axum0.7+tokio-devel \
 rust-axum0.7+tower-http-devel \
 rust-axum0.7+tower-log-devel \
 rust-axum0.7+tracing-devel \
 rust-axum0.7+ws-devel \
 rust-axum0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum0.7-0.7.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c66435694fc15a8946bb824e39b4ea1e5c4f6726579d1432f0fc44172ee7732"

URI_x86_64_v2_rust-axum0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+default-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+default-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+default-devel.sha256sum] = "d0a13b4de760680e0aa6f4571333534c8232f57c68ea9765d722da3b81cccbcd"

URI_x86_64_v2_rust-axum0.7+form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+form-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+form-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+form-devel.sha256sum] = "5cd38ce2cd8335d281ffb773a7d9fcddaa575a1464ed042a8ea4a5d209b0f39b"

URI_x86_64_v2_rust-axum0.7+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+http1-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+http1-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+http1-devel.sha256sum] = "a951d007896ca4f6744145bfc7a7f5dd612d3da5d9231bfdc3ae37ca7477d27f"

URI_x86_64_v2_rust-axum0.7+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+http2-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+http2-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+http2-devel.sha256sum] = "758068753327dff55626b53187660679490beb8c3e3569879a1e33100e6e892a"

URI_x86_64_v2_rust-axum0.7+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+json-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+json-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+json-devel.sha256sum] = "cb6ba175a49d03b339ea135845854f26a663c1ec14782bb29f3ed5c6458789da"

URI_x86_64_v2_rust-axum0.7+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+macros-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+macros-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+macros-devel.sha256sum] = "1b6110458ed12059749b13ca8b3b1dc2c4b47f38cf09d75b6123d084075df16e"

URI_x86_64_v2_rust-axum0.7+matched-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+matched-path-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+matched-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+matched-path-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+matched-path-devel.sha256sum] = "a14b04a8a31c4372c3350c2d1fac8e6047b763c081a0b6dc7783329bcdcc549a"

URI_x86_64_v2_rust-axum0.7+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+multipart-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+multipart-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+multipart-devel.sha256sum] = "b70b6e5c9e821b7bcb4ee6c3f4d30d611eb1e0e97bb15d376f7c79fac32c5235"

URI_x86_64_v2_rust-axum0.7+original-uri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+original-uri-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+original-uri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+original-uri-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+original-uri-devel.sha256sum] = "70d0fb19cb8b6b2626c90d115c35b8a36c84bceb6480c3517cab1c810798dc32"

URI_x86_64_v2_rust-axum0.7+query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+query-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+query-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+query-devel.sha256sum] = "ef4ba20606596130a08242903e02775967e1cc1320b470bb2fb796a81e529dd7"

URI_x86_64_v2_rust-axum0.7+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+tokio-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+tokio-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+tokio-devel.sha256sum] = "77fe225b970c71b2030f2bc7e6edd350316af6334ea13a8ffe3819d317f6bb00"

URI_x86_64_v2_rust-axum0.7+tower-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+tower-http-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+tower-http-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+tower-http-devel.sha256sum] = "16c41aa4a71b31db060cf52c3cf798afcb538a518df278867136ab39a85a06a0"

URI_x86_64_v2_rust-axum0.7+tower-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+tower-log-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+tower-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+tower-log-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+tower-log-devel.sha256sum] = "c9bd145ce4604bcbf303589cde22fcb4c1a365723eee08c85386f04f334de3d7"

URI_x86_64_v2_rust-axum0.7+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+tracing-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+tracing-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+tracing-devel.sha256sum] = "de9f1d2f272817f98a277a82beec5d7ce756bfdeabbcac07418afb75c5263e58"

URI_x86_64_v2_rust-axum0.7+ws-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7+ws-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7+ws-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7+ws-devel}"
SRC_URI[x86_64_v2_rust-axum0.7+ws-devel.sha256sum] = "31c1e07731e80a49937d1118a14a09f37ca5cc0bc03ba92811a344b8bc5cd86a"

URI_x86_64_v2_rust-axum0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum0.7-devel-0.7.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum0.7-devel}"
SRC_URI[x86_64_v2_rust-axum0.7-devel.sha256sum] = "bc4662bfd5ff98f05476caa51309d2f949a1e86001ba5560ca1dea25ca39bdcf"

URI_aarch64_rust-axum0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+default-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+default-devel}"
SRC_URI[aarch64_rust-axum0.7+default-devel.sha256sum] = "0cf065398690aebb414e337b704472f871471f99c29f97130ec576160a5fb3d2"

URI_aarch64_rust-axum0.7+form-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+form-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+form-devel}"
SRC_URI[aarch64_rust-axum0.7+form-devel.sha256sum] = "2b91d2ab506a9b9253513bddad894682c756b47af4c376d256cd613e57ffb032"

URI_aarch64_rust-axum0.7+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+http1-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+http1-devel}"
SRC_URI[aarch64_rust-axum0.7+http1-devel.sha256sum] = "184ca236993192b49b1055e1524d5811b291490727b5e15749681b3be553452e"

URI_aarch64_rust-axum0.7+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+http2-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+http2-devel}"
SRC_URI[aarch64_rust-axum0.7+http2-devel.sha256sum] = "8450f5821dc52e669d6d52e6d511fa2274a321e3d968729fa3df40745985bc5b"

URI_aarch64_rust-axum0.7+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+json-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+json-devel}"
SRC_URI[aarch64_rust-axum0.7+json-devel.sha256sum] = "bd1235b444b801645bb2c2f8a078c7102199fb448bccd45e0c7b2b4ef52dc3f1"

URI_aarch64_rust-axum0.7+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+macros-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+macros-devel}"
SRC_URI[aarch64_rust-axum0.7+macros-devel.sha256sum] = "f02b23444b35d5cbce809e37caa5f68904435fbf3ecf5d10cd8365de49cbe380"

URI_aarch64_rust-axum0.7+matched-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+matched-path-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+matched-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+matched-path-devel}"
SRC_URI[aarch64_rust-axum0.7+matched-path-devel.sha256sum] = "c9df44124c7a585dbea19eb7ea88c9def342225353a63a129b5de8ff24a03c01"

URI_aarch64_rust-axum0.7+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+multipart-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+multipart-devel}"
SRC_URI[aarch64_rust-axum0.7+multipart-devel.sha256sum] = "c842c0c56669febac02055c1ed7518b7de14235d5f17452e0694c1d71e5f4cd0"

URI_aarch64_rust-axum0.7+original-uri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+original-uri-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+original-uri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+original-uri-devel}"
SRC_URI[aarch64_rust-axum0.7+original-uri-devel.sha256sum] = "bbd3f3d76a4831f6d930308afd98e7ff6ed7f8f9ba6b29cde2e28e651becab21"

URI_aarch64_rust-axum0.7+query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+query-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+query-devel}"
SRC_URI[aarch64_rust-axum0.7+query-devel.sha256sum] = "ac2eecff23fc3be1356629e31e274bc9a4eda6a99686d94b6be95bd7b892f9ce"

URI_aarch64_rust-axum0.7+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+tokio-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+tokio-devel}"
SRC_URI[aarch64_rust-axum0.7+tokio-devel.sha256sum] = "6f804dcd52446e91192173a1b318ec912d0c7f16eaaacb588a5804c7085f5589"

URI_aarch64_rust-axum0.7+tower-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+tower-http-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+tower-http-devel}"
SRC_URI[aarch64_rust-axum0.7+tower-http-devel.sha256sum] = "efc903ff46d29af94c995c98b373f45ea3039a5c2916a267f876601dcdb6bf2a"

URI_aarch64_rust-axum0.7+tower-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+tower-log-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+tower-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+tower-log-devel}"
SRC_URI[aarch64_rust-axum0.7+tower-log-devel.sha256sum] = "1fedd799b1d15a24b09335ca2356c2f3f1152cd8cdfd68a24c15bac2c5fbb1d5"

URI_aarch64_rust-axum0.7+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+tracing-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+tracing-devel}"
SRC_URI[aarch64_rust-axum0.7+tracing-devel.sha256sum] = "e5ef43fe18beecdea329a98392d16836e6e2a27163a8c73da51cfab2b432dde2"

URI_aarch64_rust-axum0.7+ws-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7+ws-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7+ws-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7+ws-devel}"
SRC_URI[aarch64_rust-axum0.7+ws-devel.sha256sum] = "7bc6acb6090f37e39fa20b668b3f854946cf638075aa8bf346da7f013caf4277"

URI_aarch64_rust-axum0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum0.7-devel-0.7.9-1.el10_2.noarch.rpm;name=aarch64_rust-axum0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum0.7-devel}"
SRC_URI[aarch64_rust-axum0.7-devel.sha256sum] = "faae4efce57a9b3c96f8b07a28b8abd33fb1da9173029f652f3ece81ff66a44d"

RDEPENDS:rust-axum0.7+default-devel = " \
 cargo \
 rust-axum0.7+form-devel \
 rust-axum0.7+http1-devel \
 rust-axum0.7+json-devel \
 rust-axum0.7+matched-path-devel \
 rust-axum0.7+original-uri-devel \
 rust-axum0.7+query-devel \
 rust-axum0.7+tokio-devel \
 rust-axum0.7+tower-log-devel \
 rust-axum0.7+tracing-devel \
 rust-axum0.7-devel \
 "
RDEPENDS:rust-axum0.7+form-devel = " \
 cargo \
 rust-axum0.7-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-axum0.7+http1-devel = " \
 cargo \
 rust-axum0.7-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 "
RDEPENDS:rust-axum0.7+http2-devel = " \
 cargo \
 rust-axum0.7-devel \
 rust-hyper+default-devel \
 rust-hyper+http2-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 "
RDEPENDS:rust-axum0.7+json-devel = " \
 cargo \
 rust-axum0.7-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-serde_path_to_error+default-devel \
 "
RDEPENDS:rust-axum0.7+macros-devel = " \
 cargo \
 rust-axum-macros0.4+default-devel \
 rust-axum0.7-devel \
 "
RDEPENDS:rust-axum0.7+matched-path-devel = " \
 cargo \
 rust-axum0.7-devel \
 "
RDEPENDS:rust-axum0.7+multipart-devel = " \
 cargo \
 rust-axum0.7-devel \
 rust-multer+default-devel \
 "
RDEPENDS:rust-axum0.7+original-uri-devel = " \
 cargo \
 rust-axum0.7-devel \
 "
RDEPENDS:rust-axum0.7+query-devel = " \
 cargo \
 rust-axum0.7-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-axum0.7+tokio-devel = " \
 cargo \
 rust-axum0.7-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-tokio+default-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 rust-tower+make-devel \
 "
RDEPENDS:rust-axum0.7+tower-http-devel = " \
 cargo \
 rust-axum0.7-devel \
 rust-tower-http+add-extension-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+default-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+util-devel \
 rust-tower-http+validate-request-devel \
 "
RDEPENDS:rust-axum0.7+tower-log-devel = " \
 cargo \
 rust-axum0.7-devel \
 rust-tower+log-devel \
 "
RDEPENDS:rust-axum0.7+tracing-devel = " \
 cargo \
 rust-axum-core0.4+tracing-devel \
 rust-axum0.7-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-axum0.7+ws-devel = " \
 cargo \
 rust-axum0.7+tokio-devel \
 rust-axum0.7-devel \
 rust-base64+default-devel \
 rust-hyper+default-devel \
 rust-sha1+default-devel \
 rust-tokio-tungstenite0.23+default-devel \
 "
RDEPENDS:rust-axum0.7-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-axum-core0.4+default-devel \
 rust-bytes+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-itoa+default-devel \
 rust-matchit0.7+default-devel \
 rust-memchr+default-devel \
 rust-mime+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-rustversion+default-devel \
 rust-serde+default-devel \
 rust-sync_wrapper+default-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
