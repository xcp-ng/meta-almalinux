# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perftest"
PV = "24.10.0.0.66"
PR = "1.el10"
PACKAGES = " \
 perftest \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/perftest-24.10.0.0.66-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9618c10216b5af2834741f499f9adba41a0d3d13ee1468efe6f62f5c517db628"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/perftest-24.10.0.0.66-1.el10.x86_64_v2.rpm;name=x86_64_v2_perftest;unpack=0"
SRC_URI[x86_64_v2_perftest.sha256sum] = "dee09c0c37effa484fd760211103b915e9e9f1166261cb832c3c78183a04c070"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/perftest-24.10.0.0.66-1.el10.aarch64.rpm;name=aarch64_perftest;unpack=0"
SRC_URI[aarch64_perftest.sha256sum] = "e89f3359f07d5d3579f20af9ae519b91bd12741fd1ff3398d05440343e3789c6"

RDEPENDS:perftest = " \
 glibc \
 libibumad \
 libibverbs \
 librdmacm \
 pciutils-libs \
 "
