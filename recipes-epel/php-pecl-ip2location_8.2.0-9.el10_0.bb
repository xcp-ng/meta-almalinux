# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-ip2location"
PV = "8.2.0"
PR = "9.el10_0"
PACKAGES = " \
 php-pecl-ip2location \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-ip2location-8.2.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8701e3e165d5b0c81ae8dc3e67d86b030729a8e4ef846422c845d5839e9c1902"

URI_x86_64_v2_php-pecl-ip2location = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-ip2location-8.2.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-ip2location;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-ip2location}"
SRC_URI[x86_64_v2_php-pecl-ip2location.sha256sum] = "009333418f638b265fefeced8a828fce6beb2c372c867c73afc248f6dfacd9aa"

URI_aarch64_php-pecl-ip2location = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-ip2location-8.2.0-9.el10_0.aarch64.rpm;name=aarch64_php-pecl-ip2location;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-ip2location}"
SRC_URI[aarch64_php-pecl-ip2location.sha256sum] = "f2d9808bea5c327633bd3cb9a59cb4b9d56e1c630c5d499e66f863eedb0b1c6e"

RDEPENDS:php-pecl-ip2location = " \
 IP2Location-libs \
 glibc \
 php-common \
 "
