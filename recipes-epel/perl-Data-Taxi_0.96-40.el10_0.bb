# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Taxi"
PV = "0.96"
PR = "40.el10_0"
PACKAGES = " \
 perl-Data-Taxi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Taxi-0.96-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fa77c1ebf754912500d371ee86d0c607d6983530ae801e4fd667b23a4e59db4"

URI_x86_64_v2_perl-Data-Taxi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Taxi-0.96-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Taxi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Taxi}"
SRC_URI[x86_64_v2_perl-Data-Taxi.sha256sum] = "015d9423d27cd2608f015964c3a44f1abb77f86281fcf067230f776a3488c15e"

URI_aarch64_perl-Data-Taxi = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Taxi-0.96-40.el10_0.noarch.rpm;name=aarch64_perl-Data-Taxi;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Taxi}"
SRC_URI[aarch64_perl-Data-Taxi.sha256sum] = "11e11b525e81291c48f1465fa4c862115735aae4f83e20ef03a1b3954f3f32d8"

RDEPENDS:perl-Data-Taxi = " \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-vars \
 "
