# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chromium"
PV = "133.0.6943.98"
PR = "1.el10_0"
PACKAGES = " \
 chromedriver \
 chromium \
 chromium-common \
 chromium-headless \
 chromium-qt5-ui \
 chromium-qt6-ui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/chromium-133.0.6943.98-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a9298e83569bd8b29abf7a618f75c24637fc3756685561c7bb1dfb3d139d583"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - chromium: libavcodec.so.61()(64bit)
# - chromium: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - chromium: libavformat.so.61()(64bit)
# - chromium: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - chromium: libavutil.so.59()(64bit)
# - chromium: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_chromedriver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromedriver-133.0.6943.98-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromedriver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromedriver}"
SRC_URI[x86_64_v2_chromedriver.sha256sum] = "b7defabb0d79675f377f657723537b0e62d442f843f40958e3f241c7d96bb4a2"

URI_x86_64_v2_chromium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-133.0.6943.98-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromium}"
SRC_URI[x86_64_v2_chromium.sha256sum] = "e67ccab166b4a787c80ae20ba9344bfa960f3a0354c2820698ea85378bbef28e"

URI_x86_64_v2_chromium-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-common-133.0.6943.98-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromium-common}"
SRC_URI[x86_64_v2_chromium-common.sha256sum] = "40fc4e63986869e7d6b9200e25e7690830ebda443ed5f918fea9aba50e3d1fa3"

URI_x86_64_v2_chromium-headless = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-headless-133.0.6943.98-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromium-headless}"
SRC_URI[x86_64_v2_chromium-headless.sha256sum] = "96487c953cf97eb4b04785eb4b771e39176d8cc1944e5098222779923bce7bcd"

URI_x86_64_v2_chromium-qt5-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-qt5-ui-133.0.6943.98-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-qt5-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromium-qt5-ui}"
SRC_URI[x86_64_v2_chromium-qt5-ui.sha256sum] = "d4902c74e3a1591d5678fe22bb95a7ed298436f590d4685150d0fbee848804bf"

URI_x86_64_v2_chromium-qt6-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chromium-qt6-ui-133.0.6943.98-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chromium-qt6-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chromium-qt6-ui}"
SRC_URI[x86_64_v2_chromium-qt6-ui.sha256sum] = "f5b52d050cfb10061ea6f3b84cb7954e646cf8e37184eaccc6d26703a050974c"

URI_aarch64_chromedriver = "${EPEL_MIRROR}/aarch64/Packages/c/chromedriver-133.0.6943.98-1.el10_0.aarch64.rpm;name=aarch64_chromedriver;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromedriver}"
SRC_URI[aarch64_chromedriver.sha256sum] = "75aa32388598d3ff9e5c3ab8d44f92c2b619bc26a48d0f92dfb057015068f23d"

URI_aarch64_chromium = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-133.0.6943.98-1.el10_0.aarch64.rpm;name=aarch64_chromium;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium}"
SRC_URI[aarch64_chromium.sha256sum] = "9ea86710dc623593249b5390e188c93d7a50effa4e792bd6bce0535f2da49c3f"

URI_aarch64_chromium-common = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-common-133.0.6943.98-1.el10_0.aarch64.rpm;name=aarch64_chromium-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-common}"
SRC_URI[aarch64_chromium-common.sha256sum] = "e2a9f349908c5090ac4753973b975c929de5f11403a971b0b6e7d24dfcab6397"

URI_aarch64_chromium-headless = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-headless-133.0.6943.98-1.el10_0.aarch64.rpm;name=aarch64_chromium-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-headless}"
SRC_URI[aarch64_chromium-headless.sha256sum] = "e88dacfb4be69666cbc4fea75e30b7c24c013379b0dc3d432286b2ac60722167"

URI_aarch64_chromium-qt5-ui = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt5-ui-133.0.6943.98-1.el10_0.aarch64.rpm;name=aarch64_chromium-qt5-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-qt5-ui}"
SRC_URI[aarch64_chromium-qt5-ui.sha256sum] = "6114190fcb7ca38564266743ec5c75f82fc58063d4e5e5abfdad573ca7ff94a7"

URI_aarch64_chromium-qt6-ui = "${EPEL_MIRROR}/aarch64/Packages/c/chromium-qt6-ui-133.0.6943.98-1.el10_0.aarch64.rpm;name=aarch64_chromium-qt6-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_chromium-qt6-ui}"
SRC_URI[aarch64_chromium-qt6-ui.sha256sum] = "3ca1c90fcfb51d2a57a33c1a9fb6690e2996fa3c93336a6c42c1174c551ae029"

RDEPENDS:chromedriver = " \
 chromium-common \
 double-conversion \
 glib2 \
 glibc \
 libbrotli \
 libgcc \
 libxcb \
 libzstd \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:chromium:x86_64_v2 = " \
 alsa-lib \
 at-spi2-atk \
 at-spi2-core \
 atk \
 bash \
 cairo \
 chromium-common \
 cups-libs \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 lcms2 \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libbrotli \
 libcanberra-gtk3 \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libpng \
 libusb1 \
 libwebp \
 libxcb \
 libxkbcommon \
 libxml2 \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-mdns \
 nss-util \
 openjpeg2 \
 opus \
 pango \
 pipewire-libs \
 policycoreutils \
 policycoreutils-python-utils \
 systemd-libs \
"
RDEPENDS:chromium:aarch64 = " \
 alsa-lib \
 at-spi2-atk \
 at-spi2-core \
 atk \
 bash \
 cairo \
 chromium-common \
 cups-libs \
 dbus-libs \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 lcms2 \
 libX11 \
 libXNVCtrl \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbrotli \
 libcanberra-gtk3 \
 libdav1d \
 libdrm \
 libffi \
 libgcc \
 libjpeg-turbo \
 libpng \
 libusb1 \
 libwebp \
 libxcb \
 libxkbcommon \
 libxml2 \
 libxslt \
 libzstd \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-mdns \
 nss-util \
 openjpeg2 \
 opus \
 pango \
 pipewire-libs \
 policycoreutils \
 policycoreutils-python-utils \
 systemd-libs \
"
RDEPENDS:chromium-common = " \
 glibc \
 libX11 \
 libXNVCtrl \
 libdrm \
 libgcc \
 libxcb \
 "
RDEPENDS:chromium-headless = " \
 chromium-common \
 double-conversion \
 expat \
 flac-libs \
 fontconfig \
 freetype \
 glibc \
 harfbuzz \
 libbrotli \
 libdav1d \
 libgcc \
 libjpeg-turbo \
 libpng \
 libwebp \
 libxml2 \
 libxslt \
 libzstd \
 nspr \
 nss \
 nss-util \
 opus \
 "
RDEPENDS:chromium-qt5-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:chromium-qt6-ui = " \
 chromium \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
