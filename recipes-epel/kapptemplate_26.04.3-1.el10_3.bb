# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kapptemplate"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kapptemplate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kapptemplate-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d59c549afe67478a1fd4eb15e882d53575b0b5de8c60ba0aeac20ff49a5ab09d"

URI_x86_64_v2_kapptemplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kapptemplate-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kapptemplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kapptemplate}"
SRC_URI[x86_64_v2_kapptemplate.sha256sum] = "68ec25df034c732e4a8e775823627af0a5d91b4e6141d00f4193031acb0f8ae5"

URI_aarch64_kapptemplate = "${EPEL_MIRROR}/aarch64/Packages/k/kapptemplate-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kapptemplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_kapptemplate}"
SRC_URI[aarch64_kapptemplate.sha256sum] = "030393343d7c5310e2be9f458ec129283d0e8ba1f5c3f41036e38782ae1ef821"

RDEPENDS:kapptemplate = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
