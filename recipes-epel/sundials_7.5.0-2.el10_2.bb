# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sundials"
PV = "7.5.0"
PR = "2.el10_2"
PACKAGES = " \
 sundials \
 sundials-devel \
 sundials-doc \
 sundials-mpich \
 sundials-mpich-devel \
 sundials-openmpi \
 sundials-openmpi-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sundials-7.5.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f3ab380d9112370f3baf056facd2ec9eb3e741e3f77501914dd5e914970b85f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sundials-7.5.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sundials;unpack=0"
SRC_URI[x86_64_v2_sundials.sha256sum] = "01934b4ffb482ae83a0fc501dd5b53f3716da2a2cbba89c7a754ae98c1dd296a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sundials-devel-7.5.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sundials-devel;unpack=0"
SRC_URI[x86_64_v2_sundials-devel.sha256sum] = "8601ad42a696ce5475cb3ed917804c41d287528f31e509accf4ce9f55dcf588b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sundials-doc-7.5.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sundials-doc;unpack=0"
SRC_URI[x86_64_v2_sundials-doc.sha256sum] = "4c2dab37d1653b3561b3eef08f3cd9b43d484385a63c565cb1947e54fe21727e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sundials-mpich-7.5.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sundials-mpich;unpack=0"
SRC_URI[x86_64_v2_sundials-mpich.sha256sum] = "dfed0d74a1ac02f335a46c02d6a1001ba42c9a7387b006cbe1c1e8609f1f5064"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sundials-mpich-devel-7.5.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sundials-mpich-devel;unpack=0"
SRC_URI[x86_64_v2_sundials-mpich-devel.sha256sum] = "ec96c7d8fb0368aea824018a7a155d78407222ff00f238b1f09287456d7bad68"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sundials-openmpi-7.5.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sundials-openmpi;unpack=0"
SRC_URI[x86_64_v2_sundials-openmpi.sha256sum] = "aa91891c68eafc0406209b08efb4de82364301b0264495d77b3668aa1a259135"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sundials-openmpi-devel-7.5.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sundials-openmpi-devel;unpack=0"
SRC_URI[x86_64_v2_sundials-openmpi-devel.sha256sum] = "369010ef18a31ce5cdc33370f308d08452ffd7b5650beb6366d5baf5e58ddcca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sundials-7.5.0-2.el10_2.aarch64.rpm;name=aarch64_sundials;unpack=0"
SRC_URI[aarch64_sundials.sha256sum] = "42cde28fef4d0b8b97e6ff4e2442cd4552e185e255cff7e85e987a918e46188b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sundials-devel-7.5.0-2.el10_2.aarch64.rpm;name=aarch64_sundials-devel;unpack=0"
SRC_URI[aarch64_sundials-devel.sha256sum] = "73613e2938e1393a8c5a1c9df95d4cc4091a31e4517d8cf9a0d6615acf10d7f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sundials-doc-7.5.0-2.el10_2.noarch.rpm;name=aarch64_sundials-doc;unpack=0"
SRC_URI[aarch64_sundials-doc.sha256sum] = "e3abcefed0d3b4ebe83dfe2c19a984fd5c48d5cf366839d856846a7cdc0d4fd9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sundials-mpich-7.5.0-2.el10_2.aarch64.rpm;name=aarch64_sundials-mpich;unpack=0"
SRC_URI[aarch64_sundials-mpich.sha256sum] = "00215d61e6f8bff7181c288e8c9ee499e8f42e32e385432cd7f4e428121bb56d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sundials-mpich-devel-7.5.0-2.el10_2.aarch64.rpm;name=aarch64_sundials-mpich-devel;unpack=0"
SRC_URI[aarch64_sundials-mpich-devel.sha256sum] = "8955349368113d51e723b9ef59a2d0bef6e09e1778ecf02dfc4f5446f83ebea2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sundials-openmpi-7.5.0-2.el10_2.aarch64.rpm;name=aarch64_sundials-openmpi;unpack=0"
SRC_URI[aarch64_sundials-openmpi.sha256sum] = "15fdf0b48da42739f27eb196ea4fda7c0bfdb6093073ff7e507315817ccabeec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sundials-openmpi-devel-7.5.0-2.el10_2.aarch64.rpm;name=aarch64_sundials-openmpi-devel;unpack=0"
SRC_URI[aarch64_sundials-openmpi-devel.sha256sum] = "db5f501f62323a1a7dd2bfb275a06b9ec8c7405c2c221ff7e6e4b9cd354b12f3"

RDEPENDS:sundials = " \
 SuperLUMT64-double \
 glibc \
 libgomp \
 suitesparse \
 suitesparse64 \
 "
RDEPENDS:sundials-devel = " \
 cmake-filesystem \
 sundials \
 "
RDEPENDS:sundials-doc = " \
 "
RDEPENDS:sundials-mpich = " \
 SuperLUMT64-double \
 glibc \
 hypre-mpich \
 libgomp \
 mpich \
 petsc-mpich \
 suitesparse \
 suitesparse64 \
 "
RDEPENDS:sundials-mpich-devel = " \
 sundials-mpich \
 "
RDEPENDS:sundials-openmpi = " \
 SuperLUMT64-double \
 glibc \
 hypre-openmpi \
 libgomp \
 openmpi \
 petsc-openmpi \
 suitesparse \
 suitesparse64 \
 "
RDEPENDS:sundials-openmpi-devel = " \
 sundials-openmpi \
 "
