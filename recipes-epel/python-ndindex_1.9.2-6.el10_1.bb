# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ndindex"
PV = "1.9.2"
PR = "6.el10_1"
PACKAGES = " \
 python3-ndindex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ndindex-1.9.2-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f2347a27c9ac9095767d0a00f662e44e040340e275876108bb4ba5e3e202ea2"

URI_x86_64_v2_python3-ndindex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ndindex-1.9.2-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-ndindex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ndindex}"
SRC_URI[x86_64_v2_python3-ndindex.sha256sum] = "aad8adc54db0f34dfcde0866abcd6941b3423da721adcf9897475871d66cc1bd"

URI_aarch64_python3-ndindex = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ndindex-1.9.2-6.el10_1.aarch64.rpm;name=aarch64_python3-ndindex;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ndindex}"
SRC_URI[aarch64_python3-ndindex.sha256sum] = "ebfd056f49d73fb01657cc89bdd8677adbcb6abf589c5eff7f49161b39c6aac3"

RDEPENDS:python3-ndindex = " \
 glibc \
 python3 \
 python3-numpy \
 "
