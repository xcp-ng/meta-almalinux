# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-nr"
PV = "0.20091030"
PR = "32.el10"
PACKAGES = " \
 hunspell-nr \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-nr-0.20091030-32.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52a10fe7b66d80225750ab8daa15eceee7f363736d61572648da0a095d780c67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-nr-0.20091030-32.el10.noarch.rpm;name=x86_64_v2_hunspell-nr;unpack=0"
SRC_URI[x86_64_v2_hunspell-nr.sha256sum] = "c28f7781ec6ae79bd626cd4abe1b2ece7ce985a9a552867897b070d9b98c26a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-nr-0.20091030-32.el10.noarch.rpm;name=aarch64_hunspell-nr;unpack=0"
SRC_URI[aarch64_hunspell-nr.sha256sum] = "c28f7781ec6ae79bd626cd4abe1b2ece7ce985a9a552867897b070d9b98c26a8"

RDEPENDS:hunspell-nr = " \
 hunspell \
 "
