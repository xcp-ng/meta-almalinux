# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "procps-ng"
PV = "4.0.4"
PR = "11.el10"
PACKAGES = " \
 procps-ng \
 procps-ng-devel \
 procps-ng-i18n \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/procps-ng-4.0.4-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "168829cba4d6ef51db6fbfa7571365499dc8c2f19fbeefd996294c00c7f6122e"

URI_x86_64_v2_procps-ng = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/procps-ng-4.0.4-11.el10.x86_64_v2.rpm;name=x86_64_v2_procps-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procps-ng}"
SRC_URI[x86_64_v2_procps-ng.sha256sum] = "04769a2893fb25d6581f182d33105f75cc85d8797d168fd97f9cb51942fe696f"

URI_x86_64_v2_procps-ng-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/procps-ng-devel-4.0.4-11.el10.x86_64_v2.rpm;name=x86_64_v2_procps-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procps-ng-devel}"
SRC_URI[x86_64_v2_procps-ng-devel.sha256sum] = "1995dbe0024a9dd12e1dbaeb0cdfec4f7eff73827c5182ea14241b20680269d5"

URI_x86_64_v2_procps-ng-i18n = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/procps-ng-i18n-4.0.4-11.el10.noarch.rpm;name=x86_64_v2_procps-ng-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procps-ng-i18n}"
SRC_URI[x86_64_v2_procps-ng-i18n.sha256sum] = "a7b466ac9d7bcf319c284d785bf3df2855c0f55661e12f91c7f86639941c4d86"

URI_aarch64_procps-ng = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/procps-ng-4.0.4-11.el10.aarch64.rpm;name=aarch64_procps-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_procps-ng}"
SRC_URI[aarch64_procps-ng.sha256sum] = "e669a99e1fd96177464a92225ba760f818cdb6915ec899d15036df3bc9bdd792"

URI_aarch64_procps-ng-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/procps-ng-devel-4.0.4-11.el10.aarch64.rpm;name=aarch64_procps-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_procps-ng-devel}"
SRC_URI[aarch64_procps-ng-devel.sha256sum] = "56830510ba30cd8c3e334119fe9362965785780175d28b10b7c6e8696a9e0704"

URI_aarch64_procps-ng-i18n = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/procps-ng-i18n-4.0.4-11.el10.noarch.rpm;name=aarch64_procps-ng-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_procps-ng-i18n}"
SRC_URI[aarch64_procps-ng-i18n.sha256sum] = "a7b466ac9d7bcf319c284d785bf3df2855c0f55661e12f91c7f86639941c4d86"

RDEPENDS:procps-ng = " \
 glibc \
 ncurses-libs \
 systemd-libs \
 "
RDEPENDS:procps-ng-devel = " \
 pkgconf-pkg-config \
 procps-ng \
 "
RDEPENDS:procps-ng-i18n = " \
 procps-ng \
 "
