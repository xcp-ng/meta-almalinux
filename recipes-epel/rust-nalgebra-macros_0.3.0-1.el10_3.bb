# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nalgebra-macros"
PV = "0.3.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-nalgebra-macros+default-devel \
 rust-nalgebra-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nalgebra-macros-0.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ada766f21373f69f74ac0b65879ea984d10f39badbf7267a0b7379711d7d633"

URI_x86_64_v2_rust-nalgebra-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra-macros+default-devel-0.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra-macros+default-devel}"
SRC_URI[x86_64_v2_rust-nalgebra-macros+default-devel.sha256sum] = "a8b9d98d09b34b51164d5e39dfd2ae4056fa68a1a77ef38a7024fcc0c9f547c5"

URI_x86_64_v2_rust-nalgebra-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra-macros-devel-0.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra-macros-devel}"
SRC_URI[x86_64_v2_rust-nalgebra-macros-devel.sha256sum] = "7184a345bb8e89106a08fcb65711ad1a1c20d3f267915bcc17cf8b83da9b1eee"

URI_aarch64_rust-nalgebra-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra-macros+default-devel-0.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra-macros+default-devel}"
SRC_URI[aarch64_rust-nalgebra-macros+default-devel.sha256sum] = "9f443a4be2d3d063315d0f185d44d320fdec7df57440d969c86a3545651492fb"

URI_aarch64_rust-nalgebra-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra-macros-devel-0.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-nalgebra-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra-macros-devel}"
SRC_URI[aarch64_rust-nalgebra-macros-devel.sha256sum] = "ec88c1e58c90e16317a55671a7d42c6e037b9534ea5fd2702a2992194a96feb2"

RDEPENDS:rust-nalgebra-macros+default-devel = " \
 cargo \
 rust-nalgebra-macros-devel \
 "
RDEPENDS:rust-nalgebra-macros-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
