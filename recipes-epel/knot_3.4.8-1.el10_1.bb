# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knot"
PV = "3.4.8"
PR = "1.el10_1"
PACKAGES = " \
 knot \
 knot-devel \
 knot-dnssecutils \
 knot-doc \
 knot-exporter \
 knot-libs \
 knot-module-dnstap \
 knot-module-geoip \
 knot-utils \
 python3-libknot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knot-3.4.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "451cf4fa80aaceaeb6e8497fff9a914b6761a519a86447f1fa5e7117055f7b80"

URI_x86_64_v2_knot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-3.4.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot}"
SRC_URI[x86_64_v2_knot.sha256sum] = "93bae8d66a78e9289a2185f59da9da8dac87c6122e3106ae6e3704552d1dfd69"

URI_x86_64_v2_knot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-devel-3.4.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-devel}"
SRC_URI[x86_64_v2_knot-devel.sha256sum] = "263d322c221f8cdf6fce08fb444fe5812272fcdf6b5dde253bd32fd13ba389f7"

URI_x86_64_v2_knot-dnssecutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-dnssecutils-3.4.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-dnssecutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-dnssecutils}"
SRC_URI[x86_64_v2_knot-dnssecutils.sha256sum] = "398004d6889ec0a17ccc3737659876979ce65d502e08ef319cb22572d83423ae"

URI_x86_64_v2_knot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-doc-3.4.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_knot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-doc}"
SRC_URI[x86_64_v2_knot-doc.sha256sum] = "96113e472396613d7131a7be98a69c535829fd935c11d4aa3cf69a2a42447f31"

URI_x86_64_v2_knot-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-exporter-3.4.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_knot-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-exporter}"
SRC_URI[x86_64_v2_knot-exporter.sha256sum] = "cb3cb74a49cd3a813d80d4c3b63b99a5cc20043c9ed7d53e5418b95fef961cb7"

URI_x86_64_v2_knot-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-libs-3.4.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-libs}"
SRC_URI[x86_64_v2_knot-libs.sha256sum] = "fc162739f3a8ed7bb6b91cb95fdf6a9a710638d259e87d0a7360e2ba58df6a87"

URI_x86_64_v2_knot-module-dnstap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-module-dnstap-3.4.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-module-dnstap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-module-dnstap}"
SRC_URI[x86_64_v2_knot-module-dnstap.sha256sum] = "2837d183d32b5b63b4271aef15bc1311032dd01b12126aec8e2a8091164c29d1"

URI_x86_64_v2_knot-module-geoip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-module-geoip-3.4.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-module-geoip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-module-geoip}"
SRC_URI[x86_64_v2_knot-module-geoip.sha256sum] = "948edb5c3bb79782fd224bb2aaa71c69795ecf56f0653a5061d72dfae69ada50"

URI_x86_64_v2_knot-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-utils-3.4.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-utils}"
SRC_URI[x86_64_v2_knot-utils.sha256sum] = "01116aa821f6b39706c735a0d463f43a0af822fc071693e418f51d08653d5d9a"

URI_x86_64_v2_python3-libknot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libknot-3.4.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-libknot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libknot}"
SRC_URI[x86_64_v2_python3-libknot.sha256sum] = "d97e66d53be0e60bdc63332430b5e559915669cb5a565743145cb202c8b10223"

URI_aarch64_knot = "${EPEL_MIRROR}/aarch64/Packages/k/knot-3.4.8-1.el10_1.aarch64.rpm;name=aarch64_knot;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot}"
SRC_URI[aarch64_knot.sha256sum] = "9a70f9e6dfbe98a4fe2ce819ae1db1e6e17841e94d486cd12c31169ca384bec3"

URI_aarch64_knot-devel = "${EPEL_MIRROR}/aarch64/Packages/k/knot-devel-3.4.8-1.el10_1.aarch64.rpm;name=aarch64_knot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-devel}"
SRC_URI[aarch64_knot-devel.sha256sum] = "7b962c3eba69641f0b63ac4270cba522c08e68d51573e5ec486c1ed3f2cc482b"

URI_aarch64_knot-dnssecutils = "${EPEL_MIRROR}/aarch64/Packages/k/knot-dnssecutils-3.4.8-1.el10_1.aarch64.rpm;name=aarch64_knot-dnssecutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-dnssecutils}"
SRC_URI[aarch64_knot-dnssecutils.sha256sum] = "2147ad0ecb655c04bcd1ff801c10c7d9aeab6647adf9ff2e345edc8beebc7849"

URI_aarch64_knot-doc = "${EPEL_MIRROR}/aarch64/Packages/k/knot-doc-3.4.8-1.el10_1.noarch.rpm;name=aarch64_knot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-doc}"
SRC_URI[aarch64_knot-doc.sha256sum] = "fe638369e8f02681dd1b6246a5569e54aee2fe8ae5a589dd7775460b6fbf4c6f"

URI_aarch64_knot-exporter = "${EPEL_MIRROR}/aarch64/Packages/k/knot-exporter-3.4.8-1.el10_1.noarch.rpm;name=aarch64_knot-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-exporter}"
SRC_URI[aarch64_knot-exporter.sha256sum] = "53af5e279dbe3ffbc43aecc1b1621b3098f87ab0a6a1028edf38676ed3aa7c90"

URI_aarch64_knot-libs = "${EPEL_MIRROR}/aarch64/Packages/k/knot-libs-3.4.8-1.el10_1.aarch64.rpm;name=aarch64_knot-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-libs}"
SRC_URI[aarch64_knot-libs.sha256sum] = "3c46c5234b115dc178edfd2e8601c9b0486a7cded74d88e040a96371a3662e0b"

URI_aarch64_knot-module-dnstap = "${EPEL_MIRROR}/aarch64/Packages/k/knot-module-dnstap-3.4.8-1.el10_1.aarch64.rpm;name=aarch64_knot-module-dnstap;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-module-dnstap}"
SRC_URI[aarch64_knot-module-dnstap.sha256sum] = "c45ce980747ecb257a3d4dd48cd6fe41d76667658373303a37c585a02035dd89"

URI_aarch64_knot-module-geoip = "${EPEL_MIRROR}/aarch64/Packages/k/knot-module-geoip-3.4.8-1.el10_1.aarch64.rpm;name=aarch64_knot-module-geoip;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-module-geoip}"
SRC_URI[aarch64_knot-module-geoip.sha256sum] = "807ce84de92a248c5b21ebbaeb9054d56c2ffa6781dda497c082ace639fc5f1e"

URI_aarch64_knot-utils = "${EPEL_MIRROR}/aarch64/Packages/k/knot-utils-3.4.8-1.el10_1.aarch64.rpm;name=aarch64_knot-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-utils}"
SRC_URI[aarch64_knot-utils.sha256sum] = "0a6eeddf00853a0f6604e31c1ec58ce6d1e55f7691f3c649edbfa75825fec77b"

URI_aarch64_python3-libknot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libknot-3.4.8-1.el10_1.noarch.rpm;name=aarch64_python3-libknot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libknot}"
SRC_URI[aarch64_python3-libknot.sha256sum] = "4f983a2f364efd3027b7cb47684d5fa324bfba3602e5229ec8ffedea08470696"

RDEPENDS:knot = " \
 bash \
 glibc \
 gnutls \
 knot-libs \
 libcap-ng \
 libedit \
 libgcc \
 lmdb-libs \
 systemd \
 systemd-libs \
 userspace-rcu \
 util-linux \
 "
RDEPENDS:knot-devel = " \
 gnutls-devel \
 knot-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:knot-dnssecutils = " \
 glibc \
 knot-libs \
 libgcc \
 lmdb-libs \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:knot-doc = " \
 "
RDEPENDS:knot-exporter = " \
 knot-libs \
 python3 \
 python3-libknot \
 python3-prometheus_client \
 python3-psutil \
 "
RDEPENDS:knot-libs = " \
 glibc \
 gnutls \
 libbpf \
 libgcc \
 libxdp \
 lmdb-libs \
 "
RDEPENDS:knot-module-dnstap = " \
 fstrm \
 glibc \
 knot \
 protobuf-c \
 "
RDEPENDS:knot-module-geoip = " \
 glibc \
 knot \
 libgcc \
 libmaxminddb \
 "
RDEPENDS:knot-utils = " \
 fstrm \
 glibc \
 gnutls \
 knot-libs \
 libedit \
 libgcc \
 libidn2 \
 libmnl \
 libnghttp2 \
 protobuf-c \
 "
RDEPENDS:python3-libknot = " \
 knot-libs \
 python3 \
 "
