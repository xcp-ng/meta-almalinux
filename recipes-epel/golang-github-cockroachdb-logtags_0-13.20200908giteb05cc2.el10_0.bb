# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-cockroachdb-logtags"
PV = "0"
PR = "13.20200908giteb05cc2.el10_0"
PACKAGES = " \
 golang-github-cockroachdb-logtags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-cockroachdb-logtags-0-13.20200908giteb05cc2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88567d759b027c34b492e3254fc18f9b05f2667693b5cab20730da8782696983"

URI_aarch64_golang-github-cockroachdb-logtags-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-cockroachdb-logtags-devel-0-13.20200908giteb05cc2.el10_0.noarch.rpm;name=aarch64_golang-github-cockroachdb-logtags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cockroachdb-logtags-devel}"
SRC_URI[aarch64_golang-github-cockroachdb-logtags-devel.sha256sum] = "93fa1fd66c8313e6662429bd88446984183fea32b60593f9adb062a9da04c85d"

RDEPENDS:golang-github-cockroachdb-logtags-devel = " \
 go-filesystem \
 "
