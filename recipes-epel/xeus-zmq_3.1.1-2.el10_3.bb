# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xeus-zmq"
PV = "3.1.1"
PR = "2.el10_3"
PACKAGES = " \
 xeus-zmq \
 xeus-zmq-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/x/xeus-zmq-3.1.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5514c2b9a7b83ce66217559606c39437c112bed9d1f19139ac544fa49aef8a56"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeus-zmq-3.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeus-zmq;unpack=0"
SRC_URI[x86_64_v2_xeus-zmq.sha256sum] = "de3a95d16ebbb57872da5a2936ce228201fc743cbca99676a04b7e3ed2cabeb8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeus-zmq-devel-3.1.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeus-zmq-devel;unpack=0"
SRC_URI[x86_64_v2_xeus-zmq-devel.sha256sum] = "01893a9a48179a8fe69cffb3dffbad1e7519e1df9e8ee103a3b8f207f6521ae1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xeus-zmq-3.1.1-2.el10_3.aarch64.rpm;name=aarch64_xeus-zmq;unpack=0"
SRC_URI[aarch64_xeus-zmq.sha256sum] = "f1bde5918d62d4b8f4f4a54e1f4da0722ea93606ecd4d4fbf6b27fde59299a3e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xeus-zmq-devel-3.1.1-2.el10_3.aarch64.rpm;name=aarch64_xeus-zmq-devel;unpack=0"
SRC_URI[aarch64_xeus-zmq-devel.sha256sum] = "bd3391f67a01279f5a8adacd93ccc3245ea4ad77900b6789dcabbfd6212a3a3a"

RDEPENDS:xeus-zmq = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 xeus \
 zeromq \
 "
RDEPENDS:xeus-zmq-devel = " \
 cmake-filesystem \
 xeus-zmq \
 "
