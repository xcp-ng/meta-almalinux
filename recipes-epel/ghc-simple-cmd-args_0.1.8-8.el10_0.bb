# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-simple-cmd-args"
PV = "0.1.8"
PR = "8.el10_0"
PACKAGES = " \
 ghc-simple-cmd-args \
 ghc-simple-cmd-args-devel \
 ghc-simple-cmd-args-doc \
 ghc-simple-cmd-args-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-simple-cmd-args-0.1.8-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f28f6c6ec664212654825d35c545cd7ac6a9b689ed5a51137daf045e05fc3a11"

URI_x86_64_v2_ghc-simple-cmd-args = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cmd-args-0.1.8-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cmd-args;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cmd-args}"
SRC_URI[x86_64_v2_ghc-simple-cmd-args.sha256sum] = "455f5f4fab66a8db8da86d4da63c63547ba404b973788e232a9d79899e0a2020"

URI_x86_64_v2_ghc-simple-cmd-args-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cmd-args-devel-0.1.8-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cmd-args-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cmd-args-devel}"
SRC_URI[x86_64_v2_ghc-simple-cmd-args-devel.sha256sum] = "ab877e837787ac16e3b5c9006fe8ce6eda5adc3b4933cb12abb7f37fbb1abd43"

URI_x86_64_v2_ghc-simple-cmd-args-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cmd-args-doc-0.1.8-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-simple-cmd-args-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cmd-args-doc}"
SRC_URI[x86_64_v2_ghc-simple-cmd-args-doc.sha256sum] = "232a25149992fd4457df9909f1f6afdc41b676adb83135ce02238fde85001ab0"

URI_x86_64_v2_ghc-simple-cmd-args-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cmd-args-prof-0.1.8-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cmd-args-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cmd-args-prof}"
SRC_URI[x86_64_v2_ghc-simple-cmd-args-prof.sha256sum] = "3e3d5b8e1b971c99a8fefea90bda5559f36f05fe780c0879446a4bcf43d6bd3a"

URI_aarch64_ghc-simple-cmd-args = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cmd-args-0.1.8-8.el10_0.aarch64.rpm;name=aarch64_ghc-simple-cmd-args;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cmd-args}"
SRC_URI[aarch64_ghc-simple-cmd-args.sha256sum] = "df3a158d2ef50dcfb7531a55e3d89b9a24a8262310fb2f3ce3039447682ae01d"

URI_aarch64_ghc-simple-cmd-args-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cmd-args-devel-0.1.8-8.el10_0.aarch64.rpm;name=aarch64_ghc-simple-cmd-args-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cmd-args-devel}"
SRC_URI[aarch64_ghc-simple-cmd-args-devel.sha256sum] = "3859239645bda695ee26567be608fcbaab43f76674ccc60ef54fea1cdc5da594"

URI_aarch64_ghc-simple-cmd-args-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cmd-args-doc-0.1.8-8.el10_0.noarch.rpm;name=aarch64_ghc-simple-cmd-args-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cmd-args-doc}"
SRC_URI[aarch64_ghc-simple-cmd-args-doc.sha256sum] = "89d839f4248a257010a572169ffefa66d011bb5a89204f4162a1b7d7f0ebe557"

URI_aarch64_ghc-simple-cmd-args-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cmd-args-prof-0.1.8-8.el10_0.aarch64.rpm;name=aarch64_ghc-simple-cmd-args-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cmd-args-prof}"
SRC_URI[aarch64_ghc-simple-cmd-args-prof.sha256sum] = "473e1c39c05c882a0fd1d785d538f320ab41f43829ebf6208ab1a77464035d0a"

RDEPENDS:ghc-simple-cmd-args = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-optparse-applicative \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-simple-cmd-args-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-optparse-applicative-devel \
 ghc-simple-cmd-args \
 "
RDEPENDS:ghc-simple-cmd-args-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-simple-cmd-args-prof = " \
 ghc-base-prof \
 ghc-optparse-applicative-prof \
 ghc-simple-cmd-args-devel \
 "
