# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nvtop"
PV = "3.1.0"
PR = "2.el10_0"
PACKAGES = " \
 nvtop \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nvtop-3.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "94d2863385d9667af9f4b075ec93d80ed0a25a9022a70d730e8c849d52fec530"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nvtop-3.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nvtop;unpack=0"
SRC_URI[x86_64_v2_nvtop.sha256sum] = "6bcda900c57e519e8ea8ad9f530969c7df2a7686a97e7d510ff64e481b315263"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nvtop-3.1.0-2.el10_0.aarch64.rpm;name=aarch64_nvtop;unpack=0"
SRC_URI[aarch64_nvtop.sha256sum] = "c72aa891761ac29411bd0b442573aee4a5639074fb8a80b029713420bb034bfd"

RDEPENDS:nvtop = " \
 glibc \
 hicolor-icon-theme \
 ncurses-libs \
 systemd-libs \
 "
