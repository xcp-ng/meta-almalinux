# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-cursor"
PV = "0.31.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-wayland-cursor+default-devel \
 rust-wayland-cursor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-cursor-0.31.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdf9a17bea50d50a5f495ab034c373f9400409411e87e81727a48cc93566ad7e"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-wayland-cursor-devel: (crate(xcursor/default) >= 0.3.1 with crate(xcursor/default) < 0.4.0~)

URI_x86_64_v2_rust-wayland-cursor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-cursor+default-devel-0.31.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-cursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-cursor+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-cursor+default-devel.sha256sum] = "32efac9803aedf678066f795398728e90600dc458c63f494ad9094e1594ec6a5"

URI_x86_64_v2_rust-wayland-cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-cursor-devel-0.31.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-cursor-devel}"
SRC_URI[x86_64_v2_rust-wayland-cursor-devel.sha256sum] = "9892988bd1db6db091aed262c9710454e285460fca4f4f469bb63dd811e1fa64"

URI_aarch64_rust-wayland-cursor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-cursor+default-devel-0.31.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-cursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-cursor+default-devel}"
SRC_URI[aarch64_rust-wayland-cursor+default-devel.sha256sum] = "fccce73e8cb8c364d559ad8cbf54e29718bdbe6027330301475c3e6c8d2f41c3"

URI_aarch64_rust-wayland-cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-cursor-devel-0.31.12-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-cursor-devel}"
SRC_URI[aarch64_rust-wayland-cursor-devel.sha256sum] = "904112beaee58a3b829dfccf0d7108ad41a44a1ec61eecda62495ab355813e30"

RDEPENDS:rust-wayland-cursor+default-devel = " \
 cargo \
 rust-wayland-cursor-devel \
 "
RDEPENDS:rust-wayland-cursor-devel:x86_64_v2 = " \
 cargo \
 rust \
 rust-rustix+default-devel \
 rust-rustix+shm-devel \
 rust-wayland-client+default-devel \
"
RDEPENDS:rust-wayland-cursor-devel:aarch64 = " \
 cargo \
 rust \
 rust-rustix+default-devel \
 rust-rustix+shm-devel \
 rust-wayland-client+default-devel \
 rust-xcursor+default-devel \
"
