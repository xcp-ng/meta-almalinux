# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glslang"
PV = "16.0.0"
PR = "1.el10"
PACKAGES = " \
 glslang \
 glslang-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/glslang-16.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcf5951eb797005b5e88a787f7d0f107c4f589a10a4573ec7ce0b4207e6ee94a"

URI_x86_64_v2_glslang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glslang-16.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_glslang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glslang}"
SRC_URI[x86_64_v2_glslang.sha256sum] = "c6fcb31e5773b0d24cdc3374f92d0c662ebe783275431ece1bb290c232bc9267"

URI_x86_64_v2_glslang-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glslang-devel-16.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_glslang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glslang-devel}"
SRC_URI[x86_64_v2_glslang-devel.sha256sum] = "68c039f105062c5bd402fb1700be5677ba817b19e285b29facfea6a8313067ed"

URI_aarch64_glslang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glslang-16.0.0-1.el10.aarch64.rpm;name=aarch64_glslang;unpack=0"
SRC_URI:append = " ${URI_aarch64_glslang}"
SRC_URI[aarch64_glslang.sha256sum] = "1fe5495438e4b0ff5c4fb6a09a737e1a6754814687743405c648572fe04b3654"

URI_aarch64_glslang-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glslang-devel-16.0.0-1.el10.aarch64.rpm;name=aarch64_glslang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glslang-devel}"
SRC_URI[aarch64_glslang-devel.sha256sum] = "5b58f71f07079b305809f210350c17b9dccf823ebd78f418a3943a32b2e81d57"

RDEPENDS:glslang = " \
 glibc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:glslang-devel = " \
 cmake-filesystem \
 glslang \
 pkgconf-pkg-config \
 "
