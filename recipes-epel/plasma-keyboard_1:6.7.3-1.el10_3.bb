# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-keyboard"
PE = "1"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kcm-plasma-keyboard \
 plasma-keyboard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-keyboard-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fc341ca6187106b5fa27b222cc95f096bb28da6fdac528435db2df444ee5107"

URI_x86_64_v2_kcm-plasma-keyboard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcm-plasma-keyboard-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcm-plasma-keyboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcm-plasma-keyboard}"
SRC_URI[x86_64_v2_kcm-plasma-keyboard.sha256sum] = "3e9bf8414cb72314490d711175ba742681b9ba0d9ad517f445c8ecdd5968cd75"

URI_x86_64_v2_plasma-keyboard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-keyboard-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-keyboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-keyboard}"
SRC_URI[x86_64_v2_plasma-keyboard.sha256sum] = "52d53a7e7b5c59279f6f6355d98f7db2cdd51f9449195727cd6dde2e70dbb56a"

URI_aarch64_kcm-plasma-keyboard = "${EPEL_MIRROR}/aarch64/Packages/k/kcm-plasma-keyboard-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kcm-plasma-keyboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcm-plasma-keyboard}"
SRC_URI[aarch64_kcm-plasma-keyboard.sha256sum] = "7f9d9e833cdfac299a2d45ec97f3536604bc10f16a264b099d0ce12c3b4b6abe"

URI_aarch64_plasma-keyboard = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-keyboard-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-keyboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-keyboard}"
SRC_URI[aarch64_plasma-keyboard.sha256sum] = "309f52f808787b3c10d5a4f02c08e858a954d6512292c0cf53175ddee3df54b4"

RDEPENDS:kcm-plasma-keyboard = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 libstdc++ \
 plasma-keyboard \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-keyboard = " \
 glibc \
 kcm-plasma-keyboard \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 libstdc++ \
 libwayland-client \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtvirtualkeyboard \
 "
