# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iproute"
PV = "6.17.0"
PR = "2.el10"
PACKAGES = " \
 iproute \
 iproute-devel \
 iproute-tc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iproute-6.17.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7852d31251238dc9dfb337598f6ab0b562777b8252dea571d550cc674c3611e9"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - iproute-tc: libcap.so.2()(64bit)
# - iproute: libcap.so.2()(64bit)

URI_x86_64_v2_iproute = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iproute-6.17.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iproute;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iproute}"
SRC_URI[x86_64_v2_iproute.sha256sum] = "9baa9a6609d6c8c6459337e53dd0f049f8788e8cf7951bad0964ef484c924b43"

URI_x86_64_v2_iproute-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/iproute-devel-6.17.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iproute-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iproute-devel}"
SRC_URI[x86_64_v2_iproute-devel.sha256sum] = "c959441e46917343ff8319869834b5b99105eeb4b780ba9f3aa04fe4a883c50b"

URI_x86_64_v2_iproute-tc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iproute-tc-6.17.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iproute-tc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iproute-tc}"
SRC_URI[x86_64_v2_iproute-tc.sha256sum] = "80604b5f3154cd3c909e51298cbc02779eddffb7e5429e84f91a7e992d9b9e75"

URI_aarch64_iproute = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iproute-6.17.0-2.el10.aarch64.rpm;name=aarch64_iproute;unpack=0"
SRC_URI:append = " ${URI_aarch64_iproute}"
SRC_URI[aarch64_iproute.sha256sum] = "e368b2e820a30f13f09cea4304c1510e9f937644329574b534fa797c5ac59511"

URI_aarch64_iproute-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/iproute-devel-6.17.0-2.el10.aarch64.rpm;name=aarch64_iproute-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iproute-devel}"
SRC_URI[aarch64_iproute-devel.sha256sum] = "11bb57a1997f14d5334d77cf49e3306e0321cef874c06b14bab6cb62de16a68e"

URI_aarch64_iproute-tc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iproute-tc-6.17.0-2.el10.aarch64.rpm;name=aarch64_iproute-tc;unpack=0"
SRC_URI:append = " ${URI_aarch64_iproute-tc}"
SRC_URI[aarch64_iproute-tc.sha256sum] = "9aef1b321d22d32c1262ada87f8101a18c3b5d8bd8f02957b89d80a79ebdbd12"

RDEPENDS:iproute:x86_64_v2 = " \
 bash \
 elfutils-libelf \
 glibc \
 libbpf \
 libcap \
 libmnl \
 libselinux \
 psmisc \
"
RDEPENDS:iproute:aarch64 = " \
 bash \
 elfutils-libelf \
 glibc \
 libbpf \
 libmnl \
 libselinux \
 psmisc \
"
RDEPENDS:iproute-devel = " \
 iproute \
 "
RDEPENDS:iproute-tc:x86_64_v2 = " \
 elfutils-libelf \
 glibc \
 iproute \
 iptables-libs \
 libbpf \
 libcap \
 libmnl \
"
RDEPENDS:iproute-tc:aarch64 = " \
 elfutils-libelf \
 glibc \
 iproute \
 iptables-libs \
 libbpf \
 libmnl \
"
