# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kompare"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kompare \
 kompare-devel \
 kompare-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kompare-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0a89a320affebf4bc4212a2e480024560a9c60653802fef0236456275f232e7"

URI_x86_64_v2_kompare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare}"
SRC_URI[x86_64_v2_kompare.sha256sum] = "bdbfea4c4b10b6b0ee9665ac28bc8213a2e09bf603a6b9c6331b81af57a3a6c5"

URI_x86_64_v2_kompare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare-devel}"
SRC_URI[x86_64_v2_kompare-devel.sha256sum] = "797434c615789ac8337a6d7df30d71aa88634fd189c71a55726c9f7b338c1825"

URI_x86_64_v2_kompare-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare-libs}"
SRC_URI[x86_64_v2_kompare-libs.sha256sum] = "25c3ab5c2bdd552591f492507a3dacd7dffbc404390e371827ec0a4fec128f91"

URI_aarch64_kompare = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kompare;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare}"
SRC_URI[aarch64_kompare.sha256sum] = "89836265bf879151c30ae27f0ffb6758a09857e0ed05383338d807308febd15b"

URI_aarch64_kompare-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kompare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare-devel}"
SRC_URI[aarch64_kompare-devel.sha256sum] = "c6dc81728aa84e9dad9263052c90cef4b0e913414dcdbcfbbaf466a13d0743a2"

URI_aarch64_kompare-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kompare-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare-libs}"
SRC_URI[aarch64_kompare-libs.sha256sum] = "faaa484c8779f57f357dbab4edf15c88cc5e9176b56ecadb021811550a4ed067"

RDEPENDS:kompare = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kompare-libs \
 libkomparediff2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kompare-devel = " \
 kompare-libs \
 qt6-qtbase-devel \
 "
RDEPENDS:kompare-libs = " \
 glibc \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkomparediff2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
