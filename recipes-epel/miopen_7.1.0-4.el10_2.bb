# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "miopen"
PV = "7.1.0"
PR = "4.el10_2"
PACKAGES:x86_64_v2 = " \
 miopen \
 miopen-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/miopen-7.1.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8529edc24d1dd6de2e17301892c811bdf8ccb6807f349ab9256781f38838199e"

URI_x86_64_v2_miopen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/miopen-7.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_miopen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_miopen}"
SRC_URI[x86_64_v2_miopen.sha256sum] = "f3849142798b6f2bb3c2dcf2ecb9b16b71be68ecef983f9dd54634eaad8b9420"

URI_x86_64_v2_miopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/miopen-devel-7.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_miopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_miopen-devel}"
SRC_URI[x86_64_v2_miopen-devel.sha256sum] = "3075fa921a049a516aacac261fa0c559a1d6289125d9bda72f1a95fc1fbe53fa"

RDEPENDS:miopen = " \
 bash \
 boost-filesystem \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocm-comgr \
 rocm-hip \
 rocm-hip-devel \
 rocrand-devel \
 roctracer \
 sqlite-libs \
 "
RDEPENDS:miopen-devel = " \
 cmake-filesystem \
 miopen \
 "
