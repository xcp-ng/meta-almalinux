# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awf-gtk2"
PV = "4.2.0"
PR = "1.el10_3"
PACKAGES = " \
 awf-gtk2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/awf-gtk2-4.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab7e1daf11ba61a3c6d97a8d9cd1f132d337e49aa4a5d7d550799b3ebb5bec5f"

URI_x86_64_v2_awf-gtk2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/awf-gtk2-4.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_awf-gtk2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awf-gtk2}"
SRC_URI[x86_64_v2_awf-gtk2.sha256sum] = "33d7df6cf546499eb71a88ae5e9c3963be1e5bcd3098c131213e9b7c2dfcb2fb"

URI_aarch64_awf-gtk2 = "${EPEL_MIRROR}/aarch64/Packages/a/awf-gtk2-4.2.0-1.el10_3.aarch64.rpm;name=aarch64_awf-gtk2;unpack=0"
SRC_URI:append = " ${URI_aarch64_awf-gtk2}"
SRC_URI[aarch64_awf-gtk2.sha256sum] = "3bde99e3f8a08d89ee64f5a2756837b38399b64080cda8e699944824a4b2366a"

RDEPENDS:awf-gtk2 = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 hicolor-icon-theme \
 libnotify \
 pango \
 "
