# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Compress-Lzma"
PV = "2.206"
PR = "7.el10"
PACKAGES = " \
 perl-IO-Compress-Lzma \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-IO-Compress-Lzma-2.206-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48ab023cc87f98fa1698f5fe4ad97fc08efbc0d9793b5352be7b6b397f07a567"

URI_x86_64_v2_perl-IO-Compress-Lzma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IO-Compress-Lzma-2.206-7.el10.noarch.rpm;name=x86_64_v2_perl-IO-Compress-Lzma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Compress-Lzma}"
SRC_URI[x86_64_v2_perl-IO-Compress-Lzma.sha256sum] = "3725eac2e36c4cae267727ebded71b64ed6b8753796dfea00daa2fae710aaa83"

URI_aarch64_perl-IO-Compress-Lzma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IO-Compress-Lzma-2.206-7.el10.noarch.rpm;name=aarch64_perl-IO-Compress-Lzma;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Compress-Lzma}"
SRC_URI[aarch64_perl-IO-Compress-Lzma.sha256sum] = "3725eac2e36c4cae267727ebded71b64ed6b8753796dfea00daa2fae710aaa83"

RDEPENDS:perl-IO-Compress-Lzma = " \
 perl-Compress-Raw-Lzma \
 perl-Compress-Raw-Zlib \
 perl-Exporter \
 perl-IO-Compress \
 perl-IO-Compress-Lzma \
 perl-constant \
 perl-libs \
 "
