# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crash-gcore-command"
PV = "1.6.4"
PR = "8.el10_0.1"
PACKAGES = " \
 crash-gcore-command \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crash-gcore-command-1.6.4-8.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f9f8d394f81e3db2d11b6661b2928a8500b9d90ac0f4c7dfdbffa34db18657f"

URI_x86_64_v2_crash-gcore-command = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crash-gcore-command-1.6.4-8.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_crash-gcore-command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crash-gcore-command}"
SRC_URI[x86_64_v2_crash-gcore-command.sha256sum] = "a1d174ce13a2a9ac71f536455b2ff97168c7befa78626d5fce627b3dd09e0ac0"

URI_aarch64_crash-gcore-command = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crash-gcore-command-1.6.4-8.el10_0.1.aarch64.rpm;name=aarch64_crash-gcore-command;unpack=0"
SRC_URI:append = " ${URI_aarch64_crash-gcore-command}"
SRC_URI[aarch64_crash-gcore-command.sha256sum] = "02a980fb0cbd4f308c65578cc43543f34854768a77c79d5d96a521555b5a2ceb"

RDEPENDS:crash-gcore-command = " \
 crash \
 glibc \
 "
