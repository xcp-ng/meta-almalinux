# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv0.7"
PV = "0.7.45"
PR = "1.el10_0"
PACKAGES = " \
 rust-rkyv0.7+alloc-devel \
 rust-rkyv0.7+arbitrary_enum_discriminant-devel \
 rust-rkyv0.7+archive_be-devel \
 rust-rkyv0.7+archive_le-devel \
 rust-rkyv0.7+arrayvec-devel \
 rust-rkyv0.7+bytecheck-devel \
 rust-rkyv0.7+copy-devel \
 rust-rkyv0.7+copy_unsafe-devel \
 rust-rkyv0.7+default-devel \
 rust-rkyv0.7+hashbrown-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+size_16-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+size_64-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7+strict-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv0.7-0.7.45-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f082b0d177e376d38f967408a66cb78611224b13767ba217a9482f63be7ba6c4"

URI_x86_64_v2_rust-rkyv0.7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+alloc-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+alloc-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+alloc-devel.sha256sum] = "103d940cadf4104845598490fd440dd93dae6f002dbdce98465222cd37482ae8"

URI_x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+arbitrary_enum_discriminant-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel.sha256sum] = "e38e4640323b6a468902b4db04394a77281a11d0ef45008623196bf59835712d"

URI_x86_64_v2_rust-rkyv0.7+archive_be-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+archive_be-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+archive_be-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+archive_be-devel.sha256sum] = "b46912e0e7ff0a59d795f32f2c792e1ab86dea8b3171664411938f4cfcfcffce"

URI_x86_64_v2_rust-rkyv0.7+archive_le-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+archive_le-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+archive_le-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+archive_le-devel.sha256sum] = "1f69037698e81e1b7cc08a064b4cfd9452c1d27abfeafad2cdbfa18a990bd26e"

URI_x86_64_v2_rust-rkyv0.7+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+arrayvec-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+arrayvec-devel.sha256sum] = "c38c644a873eebc0f4c927c1bb1154fd927a94b3eb83021ae7432d5d49e6fb17"

URI_x86_64_v2_rust-rkyv0.7+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+bytecheck-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+bytecheck-devel.sha256sum] = "8e831a985f4bf51490e3fba5136f88b493a7da7ab5f36dbc95ccef17f3e11712"

URI_x86_64_v2_rust-rkyv0.7+copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+copy-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+copy-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+copy-devel.sha256sum] = "73eb329f81b52e494ce697f759ae08da58c27032cea198454f461978103b7e1d"

URI_x86_64_v2_rust-rkyv0.7+copy_unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+copy_unsafe-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+copy_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+copy_unsafe-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+copy_unsafe-devel.sha256sum] = "e9e20af27863f508cec4366806ecc97344e4574a29f41cbbd6c04c6773c0dbf8"

URI_x86_64_v2_rust-rkyv0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+default-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+default-devel.sha256sum] = "37d794ec2dbb7603c962aba5c1de1741982c3d09cdfd92d6a9d5859da2eac7f1"

URI_x86_64_v2_rust-rkyv0.7+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+hashbrown-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+hashbrown-devel.sha256sum] = "bb7141fdc4e51fba6fb8ca9bcf38584a3c6c70a45650c17d3e381e415352226a"

URI_x86_64_v2_rust-rkyv0.7+rend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+rend-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+rend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+rend-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+rend-devel.sha256sum] = "92f902e6c070efa34cf4c1fad2b28f65abca02d74948df61e86056d3a89ebc4a"

URI_x86_64_v2_rust-rkyv0.7+size_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+size_16-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+size_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+size_16-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+size_16-devel.sha256sum] = "2d757e3f2383775ed994b10963303e9123582b84332582d59bccea7a3424c3eb"

URI_x86_64_v2_rust-rkyv0.7+size_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+size_32-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+size_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+size_32-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+size_32-devel.sha256sum] = "bc1061ebfe20f99dc2414a7f657d00d6113b56eb888cb893b384e5d564167f5a"

URI_x86_64_v2_rust-rkyv0.7+size_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+size_64-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+size_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+size_64-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+size_64-devel.sha256sum] = "aabddb68e18f50f7d1156cc42fd79725011b14a0fc00930e37604edeaebfa540"

URI_x86_64_v2_rust-rkyv0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+std-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+std-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+std-devel.sha256sum] = "9da9c2ea296d08fc6473d0aaff4ee4c7f01b76929d36122aa1a4575cc4efb0c8"

URI_x86_64_v2_rust-rkyv0.7+strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+strict-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+strict-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+strict-devel.sha256sum] = "debc13ea1cb153b680011f7a04a034f18a4abcb988ebb20b15ab8c40c2e0cc5f"

URI_x86_64_v2_rust-rkyv0.7+validation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+validation-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+validation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+validation-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+validation-devel.sha256sum] = "fad0bd562d946c8e22e922676a563ed93f4194c1e950222f1643afe4778aa2e0"

URI_x86_64_v2_rust-rkyv0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7-devel.sha256sum] = "d86965d0b8a558541fdd6269b3a3b234c2df8c4c9dbae138471b7c7736a96df8"

URI_aarch64_rust-rkyv0.7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+alloc-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+alloc-devel}"
SRC_URI[aarch64_rust-rkyv0.7+alloc-devel.sha256sum] = "70832be638173fb282533f2efe9baebb533fb5c0a45444e5477beed0f344132c"

URI_aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+arbitrary_enum_discriminant-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel.sha256sum] = "a6905cc11edc459de3c81b473f5d554c7e4938bbaa37716f69cb3caf7ddcac0f"

URI_aarch64_rust-rkyv0.7+archive_be-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+archive_be-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+archive_be-devel}"
SRC_URI[aarch64_rust-rkyv0.7+archive_be-devel.sha256sum] = "97bc6c3d7761c0e8e911b1abf1117e5a4d8b358d29e6be935e84592e96c128b3"

URI_aarch64_rust-rkyv0.7+archive_le-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+archive_le-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+archive_le-devel}"
SRC_URI[aarch64_rust-rkyv0.7+archive_le-devel.sha256sum] = "b992955972602f25863352348a77b6e9ba07ee0d159dcee2c009cd53504406e8"

URI_aarch64_rust-rkyv0.7+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+arrayvec-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+arrayvec-devel}"
SRC_URI[aarch64_rust-rkyv0.7+arrayvec-devel.sha256sum] = "78d1ddfdcc117ea96ec1127fdd1a80f76b190bac418478ef486e2e0705d9cf7f"

URI_aarch64_rust-rkyv0.7+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+bytecheck-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv0.7+bytecheck-devel.sha256sum] = "1f758274148049c962c2aa569fe4f9c8e59010bd3001220f3e4e1ba6066894bd"

URI_aarch64_rust-rkyv0.7+copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+copy-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+copy-devel}"
SRC_URI[aarch64_rust-rkyv0.7+copy-devel.sha256sum] = "2da40d1663a6b5e03dfa22ed3b9954fc343a5f22b41c1879f5099721504b61ca"

URI_aarch64_rust-rkyv0.7+copy_unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+copy_unsafe-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+copy_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+copy_unsafe-devel}"
SRC_URI[aarch64_rust-rkyv0.7+copy_unsafe-devel.sha256sum] = "ab6ff02b178faec19d70dd9da2b0258ed540d216a58f8b109cf194a7b0b3b2dd"

URI_aarch64_rust-rkyv0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+default-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+default-devel}"
SRC_URI[aarch64_rust-rkyv0.7+default-devel.sha256sum] = "86746ff16d25379d6e5972e50327eb6d958f94c3866526c2c921f79690bd40a9"

URI_aarch64_rust-rkyv0.7+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+hashbrown-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+hashbrown-devel}"
SRC_URI[aarch64_rust-rkyv0.7+hashbrown-devel.sha256sum] = "13c0b2675ab75015248b6d19973185879c38423fefdcc12be8261586bf6b2407"

URI_aarch64_rust-rkyv0.7+rend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+rend-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+rend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+rend-devel}"
SRC_URI[aarch64_rust-rkyv0.7+rend-devel.sha256sum] = "9c5c0fbb8bda1afe05f699d53be122199e791b89c4e80c3248bc58e0ed86811c"

URI_aarch64_rust-rkyv0.7+size_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+size_16-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+size_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+size_16-devel}"
SRC_URI[aarch64_rust-rkyv0.7+size_16-devel.sha256sum] = "1c93f845866b3f4817519adabec7e3b18afee7327bad1d7d0f5a7b2393b70c19"

URI_aarch64_rust-rkyv0.7+size_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+size_32-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+size_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+size_32-devel}"
SRC_URI[aarch64_rust-rkyv0.7+size_32-devel.sha256sum] = "17a02c3855b3979d0e7f26343568105005ee495f0aca6e20d5a8ecef8f1793c7"

URI_aarch64_rust-rkyv0.7+size_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+size_64-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+size_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+size_64-devel}"
SRC_URI[aarch64_rust-rkyv0.7+size_64-devel.sha256sum] = "7e7b096a37efff44acfa444d436191ede5177ea54cfca28a0733dd847218aeb2"

URI_aarch64_rust-rkyv0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+std-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+std-devel}"
SRC_URI[aarch64_rust-rkyv0.7+std-devel.sha256sum] = "54e90ddf3203e8bac446f190d81a0d0d150794cf2c9c83530834d490e8bdcfec"

URI_aarch64_rust-rkyv0.7+strict-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+strict-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+strict-devel}"
SRC_URI[aarch64_rust-rkyv0.7+strict-devel.sha256sum] = "edc56d704f1e14e4c89098e73fa063ae63d3f66238a97f1ea2de340605a0280a"

URI_aarch64_rust-rkyv0.7+validation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+validation-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7+validation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+validation-devel}"
SRC_URI[aarch64_rust-rkyv0.7+validation-devel.sha256sum] = "397b5386d30b5745c73b35bbbc484e66ac0f40e91b71a4f328239b96c2258ae1"

URI_aarch64_rust-rkyv0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7-devel}"
SRC_URI[aarch64_rust-rkyv0.7-devel.sha256sum] = "1c762d1def6728292d8d71c5afbbd34dc0d0ce41aa47f872a4bdc6e755df45e0"

RDEPENDS:rust-rkyv0.7+alloc-devel = " \
 cargo \
 rust-rkyv0.7+hashbrown-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+arbitrary_enum_discriminant-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel \
 "
RDEPENDS:rust-rkyv0.7+archive_be-devel = " \
 cargo \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+archive_be-devel \
 "
RDEPENDS:rust-rkyv0.7+archive_le-devel = " \
 cargo \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+archive_le-devel \
 "
RDEPENDS:rust-rkyv0.7+arrayvec-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+bytecheck-devel = " \
 cargo \
 rust-bytecheck0.6-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+copy-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+copy-devel \
 "
RDEPENDS:rust-rkyv0.7+copy_unsafe-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+default-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.14+default-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+rend-devel = " \
 cargo \
 rust-rend0.4-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+size_16-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+size_32-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+size_64-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+std-devel = " \
 cargo \
 rust-bytecheck0.6+std-devel \
 rust-bytecheck0.6-devel \
 rust-ptr_meta0.1+std-devel \
 rust-rend0.4+std-devel \
 rust-rend0.4-devel \
 rust-rkyv0.7+alloc-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+strict-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+strict-devel \
 "
RDEPENDS:rust-rkyv0.7+validation-devel = " \
 cargo \
 rust-rend0.4+validation-devel \
 rust-rend0.4-devel \
 rust-rkyv0.7+alloc-devel \
 rust-rkyv0.7+bytecheck-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7-devel = " \
 cargo \
 rust-ptr_meta0.1-devel \
 rust-rkyv_derive0.7+default-devel \
 rust-seahash+default-devel \
 "
