# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-float-cmp"
PV = "0.10.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-float-cmp+default-devel \
 rust-float-cmp+num-traits-devel \
 rust-float-cmp+ratio-devel \
 rust-float-cmp+std-devel \
 rust-float-cmp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-float-cmp-0.10.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22b23ae060634f2acadeb7ef43d8cfb7683e7e82f4ddccc7151c8a502ef044b6"

URI_x86_64_v2_rust-float-cmp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-cmp+default-devel-0.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-cmp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-cmp+default-devel}"
SRC_URI[x86_64_v2_rust-float-cmp+default-devel.sha256sum] = "2273f39ae6adb0020866bffc13f0e86778c269986830763946e9ced41f03fefe"

URI_x86_64_v2_rust-float-cmp+num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-cmp+num-traits-devel-0.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-cmp+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-cmp+num-traits-devel}"
SRC_URI[x86_64_v2_rust-float-cmp+num-traits-devel.sha256sum] = "03b9f0d81ea47a656542b1b3f1e15d16e3ff836b275c5dea8d6a7e7592ddf658"

URI_x86_64_v2_rust-float-cmp+ratio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-cmp+ratio-devel-0.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-cmp+ratio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-cmp+ratio-devel}"
SRC_URI[x86_64_v2_rust-float-cmp+ratio-devel.sha256sum] = "1460acf18d82ac083727bf3e7e1800c5729aba433e72510e74933ffff1c2d041"

URI_x86_64_v2_rust-float-cmp+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-cmp+std-devel-0.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-cmp+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-cmp+std-devel}"
SRC_URI[x86_64_v2_rust-float-cmp+std-devel.sha256sum] = "26bd439313cd040860304475dada2fc3252c8c6fb4f388d1cef91bd1c02cdd6e"

URI_x86_64_v2_rust-float-cmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-cmp-devel-0.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-cmp-devel}"
SRC_URI[x86_64_v2_rust-float-cmp-devel.sha256sum] = "87ddbf4f5c2fb71055cd696a5ba31debdcdf00cc3c56089e82a6149e9f112598"

URI_aarch64_rust-float-cmp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-cmp+default-devel-0.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-float-cmp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-cmp+default-devel}"
SRC_URI[aarch64_rust-float-cmp+default-devel.sha256sum] = "3b01e58b0d5e267ca822f0c9beaa78085779f3efc8d827036311f0877cc2d554"

URI_aarch64_rust-float-cmp+num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-cmp+num-traits-devel-0.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-float-cmp+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-cmp+num-traits-devel}"
SRC_URI[aarch64_rust-float-cmp+num-traits-devel.sha256sum] = "8c9a71a3e29f99d2e75f195496681aa0b68c950a130a3108e5a566daee206d3e"

URI_aarch64_rust-float-cmp+ratio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-cmp+ratio-devel-0.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-float-cmp+ratio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-cmp+ratio-devel}"
SRC_URI[aarch64_rust-float-cmp+ratio-devel.sha256sum] = "4f59ee8541f4667847f875f47e66abbb27f591a02bcb77e0d37c1e1597faec41"

URI_aarch64_rust-float-cmp+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-cmp+std-devel-0.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-float-cmp+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-cmp+std-devel}"
SRC_URI[aarch64_rust-float-cmp+std-devel.sha256sum] = "cf803e74c0238cdc237ed418478029db1b41fea66b261927ff6e6c1e59bc935d"

URI_aarch64_rust-float-cmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-cmp-devel-0.10.0-1.el10_0.noarch.rpm;name=aarch64_rust-float-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-cmp-devel}"
SRC_URI[aarch64_rust-float-cmp-devel.sha256sum] = "8d5fd07ca44946ed2be8e7e7202250e88ef2ed9784910f02b2247f0ccffc4a7a"

RDEPENDS:rust-float-cmp+default-devel = " \
 cargo \
 rust-float-cmp+ratio-devel \
 rust-float-cmp-devel \
 "
RDEPENDS:rust-float-cmp+num-traits-devel = " \
 cargo \
 rust-float-cmp-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-float-cmp+ratio-devel = " \
 cargo \
 rust-float-cmp+num-traits-devel \
 rust-float-cmp-devel \
 "
RDEPENDS:rust-float-cmp+std-devel = " \
 cargo \
 rust-float-cmp-devel \
 "
RDEPENDS:rust-float-cmp-devel = " \
 cargo \
 "
