# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bpfilter"
PV = "0.6.0"
PR = "1.el10_1"
PACKAGES = " \
 bpfilter \
 bpfilter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bpfilter-0.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5aafb48a415949422d07bd7f212c41a764e39d391844d07b9f98da1e42955258"

URI_x86_64_v2_bpfilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bpfilter-0.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bpfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpfilter}"
SRC_URI[x86_64_v2_bpfilter.sha256sum] = "a9e523bab2a9047212b61192c10be18c3aec73f3df4a0fdba3299ffcf6d7d3a7"

URI_x86_64_v2_bpfilter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bpfilter-devel-0.6.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bpfilter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpfilter-devel}"
SRC_URI[x86_64_v2_bpfilter-devel.sha256sum] = "c416bf4ee01967e3ddb8b977a04cd43239735e56b00f3bd5e1f3caf8472c2eb2"

URI_aarch64_bpfilter = "${EPEL_MIRROR}/aarch64/Packages/b/bpfilter-0.6.0-1.el10_1.aarch64.rpm;name=aarch64_bpfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpfilter}"
SRC_URI[aarch64_bpfilter.sha256sum] = "719fe15cc71bb9c762f6e3aaca2d815738f10686f51b0964f03722ba79e36853"

URI_aarch64_bpfilter-devel = "${EPEL_MIRROR}/aarch64/Packages/b/bpfilter-devel-0.6.0-1.el10_1.aarch64.rpm;name=aarch64_bpfilter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpfilter-devel}"
SRC_URI[aarch64_bpfilter-devel.sha256sum] = "a433a7adbe3b9b6de54796deb1a1a034a876e49fefc12c1b583d6f6a126d1c27"

RDEPENDS:bpfilter = " \
 bash \
 glibc \
 libbpf \
 libgcc \
 "
RDEPENDS:bpfilter-devel = " \
 bpfilter \
 pkgconf-pkg-config \
 "
