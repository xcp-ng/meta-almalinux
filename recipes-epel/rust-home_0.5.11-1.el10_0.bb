# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-home"
PV = "0.5.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-home+default-devel \
 rust-home-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-home-0.5.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3bc4731a059c400888d9b59919a2c7deb33d9752c9971f345e8d7f5c06a31f05"

URI_x86_64_v2_rust-home+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-home+default-devel-0.5.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-home+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-home+default-devel}"
SRC_URI[x86_64_v2_rust-home+default-devel.sha256sum] = "3059bd1ac5b52027faa94c68945f321f61092781ec2a59899e47ce893f80c7cc"

URI_x86_64_v2_rust-home-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-home-devel-0.5.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-home-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-home-devel}"
SRC_URI[x86_64_v2_rust-home-devel.sha256sum] = "943d71dad015f850139d886d059c51b550f1a0db57a68a41ab993328236cf82a"

URI_aarch64_rust-home+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-home+default-devel-0.5.11-1.el10_0.noarch.rpm;name=aarch64_rust-home+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-home+default-devel}"
SRC_URI[aarch64_rust-home+default-devel.sha256sum] = "f9bc64c1fc4bdb373eaf1e924689cfb85dc0d91f713a9468ba8c19dfb979d852"

URI_aarch64_rust-home-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-home-devel-0.5.11-1.el10_0.noarch.rpm;name=aarch64_rust-home-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-home-devel}"
SRC_URI[aarch64_rust-home-devel.sha256sum] = "96a5db006951720578304b03146c7c528a6599cb6364e9f5edc70f3019cd4f08"

RDEPENDS:rust-home+default-devel = " \
 cargo \
 rust-home-devel \
 "
RDEPENDS:rust-home-devel = " \
 cargo \
 rust \
 "
