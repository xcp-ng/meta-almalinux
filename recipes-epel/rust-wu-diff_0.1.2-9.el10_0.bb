# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wu-diff"
PV = "0.1.2"
PR = "9.el10_0"
PACKAGES = " \
 rust-wu-diff+default-devel \
 rust-wu-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wu-diff-0.1.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df044c8f0a66856f4653b1bdba87e88ac92dc1cbe1113cf351309c0c899f8ec0"

URI_x86_64_v2_rust-wu-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wu-diff+default-devel-0.1.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wu-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wu-diff+default-devel}"
SRC_URI[x86_64_v2_rust-wu-diff+default-devel.sha256sum] = "2f5c4d7966c3ac626000d42f79db2f0e58cf929dda8c32a6b44c7fe962888ee8"

URI_x86_64_v2_rust-wu-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wu-diff-devel-0.1.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wu-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wu-diff-devel}"
SRC_URI[x86_64_v2_rust-wu-diff-devel.sha256sum] = "1628ae1f9f5fdb907cbbc589366c276e15fa19bb08e1fc930bf023dcc898bede"

URI_aarch64_rust-wu-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wu-diff+default-devel-0.1.2-9.el10_0.noarch.rpm;name=aarch64_rust-wu-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wu-diff+default-devel}"
SRC_URI[aarch64_rust-wu-diff+default-devel.sha256sum] = "5ebb5d47e4edee3402c42782616c43c3ec6147961dc3431a34b6618cea3de4ce"

URI_aarch64_rust-wu-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wu-diff-devel-0.1.2-9.el10_0.noarch.rpm;name=aarch64_rust-wu-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wu-diff-devel}"
SRC_URI[aarch64_rust-wu-diff-devel.sha256sum] = "2a6c90b0c02250dd49caacca7ee65601c97e5ad55ce67d287c1601654c0c970e"

RDEPENDS:rust-wu-diff+default-devel = " \
 cargo \
 rust-wu-diff-devel \
 "
RDEPENDS:rust-wu-diff-devel = " \
 cargo \
 "
