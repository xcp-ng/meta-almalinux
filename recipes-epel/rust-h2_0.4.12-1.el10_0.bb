# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-h2"
PV = "0.4.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-h2+default-devel \
 rust-h2+stream-devel \
 rust-h2+unstable-devel \
 rust-h2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-h2-0.4.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1992d38063f8ae8e014c7c3866dcdb7cce5e10070e7e666a53320bf84a11fd0"

URI_x86_64_v2_rust-h2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+default-devel-0.4.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+default-devel}"
SRC_URI[x86_64_v2_rust-h2+default-devel.sha256sum] = "fd4394c8fa6a6ee69bdb343a9a08ba9e94a0b20a9c33d82df38de16c2c0dcf92"

URI_x86_64_v2_rust-h2+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+stream-devel-0.4.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+stream-devel}"
SRC_URI[x86_64_v2_rust-h2+stream-devel.sha256sum] = "33f19cfdf3f5115352d0d16db84de2401799bf6101bf745ec4fda2ec10cec1d4"

URI_x86_64_v2_rust-h2+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+unstable-devel-0.4.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+unstable-devel}"
SRC_URI[x86_64_v2_rust-h2+unstable-devel.sha256sum] = "e85428c900d0ceea31cc4e2c017631e034926d7bf587a543bbfc2524656f8a71"

URI_x86_64_v2_rust-h2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2-devel-0.4.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2-devel}"
SRC_URI[x86_64_v2_rust-h2-devel.sha256sum] = "b42771d4ca4fd51c8736c5b54d354478d0a86bd0e01cd729c43162b1684db03f"

URI_aarch64_rust-h2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+default-devel-0.4.12-1.el10_0.noarch.rpm;name=aarch64_rust-h2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+default-devel}"
SRC_URI[aarch64_rust-h2+default-devel.sha256sum] = "d847616ed590200744ef4d89619f9c75601120ade78f4e32193cc314cef97625"

URI_aarch64_rust-h2+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+stream-devel-0.4.12-1.el10_0.noarch.rpm;name=aarch64_rust-h2+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+stream-devel}"
SRC_URI[aarch64_rust-h2+stream-devel.sha256sum] = "c69b5666221e004ce69a9d1b39a29cf63fc14a55791c8d902275068134b2857c"

URI_aarch64_rust-h2+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+unstable-devel-0.4.12-1.el10_0.noarch.rpm;name=aarch64_rust-h2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+unstable-devel}"
SRC_URI[aarch64_rust-h2+unstable-devel.sha256sum] = "324621f9289b2b9d6995b0fa920180f806cdeeca90cf1a226242dcf4083514c0"

URI_aarch64_rust-h2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2-devel-0.4.12-1.el10_0.noarch.rpm;name=aarch64_rust-h2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2-devel}"
SRC_URI[aarch64_rust-h2-devel.sha256sum] = "89897888ac1650df8676043c4878ebb0e6be5af97f88cae86d1671c04721a874"

RDEPENDS:rust-h2+default-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+stream-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+unstable-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2-devel = " \
 cargo \
 rust \
 rust-atomic-waker+default-devel \
 rust-bytes+default-devel \
 rust-fnv+default-devel \
 rust-futures-core-devel \
 rust-futures-sink-devel \
 rust-http+default-devel \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-slab+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
