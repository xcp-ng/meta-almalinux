# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook"
PV = "0.4.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-signal-hook+cc-devel \
 rust-signal-hook+channel-devel \
 rust-signal-hook+default-devel \
 rust-signal-hook+extended-siginfo-devel \
 rust-signal-hook+extended-siginfo-raw-devel \
 rust-signal-hook+iterator-devel \
 rust-signal-hook-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook-0.4.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c813a284450bd9f526f073224d5ad3da497802525e7c19679228613f665d2e5"

URI_x86_64_v2_rust-signal-hook+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+cc-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+cc-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+cc-devel.sha256sum] = "84d2efe34b0abbc80c3e27d07d859289210f35f4ebecdecb680c339ee6b4f7cc"

URI_x86_64_v2_rust-signal-hook+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+channel-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+channel-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+channel-devel.sha256sum] = "11e37ea80e356fc48cf7f6706f256713403aacb94e9927d2dd58af3c07238f8a"

URI_x86_64_v2_rust-signal-hook+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+default-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+default-devel.sha256sum] = "e0f309c45c939320c6a8a3b80d068c41dbc060d5a8f64ecc8d0f86f9bb6a629f"

URI_x86_64_v2_rust-signal-hook+extended-siginfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+extended-siginfo-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+extended-siginfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+extended-siginfo-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+extended-siginfo-devel.sha256sum] = "964745b86b47e825a8431430130c67852e4c083f55900c05ddcd444f72c10e48"

URI_x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+extended-siginfo-raw-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel.sha256sum] = "117e4a26cebe7882489bd444c1dec1fd413f0576a796b1919786b485bd88fd49"

URI_x86_64_v2_rust-signal-hook+iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+iterator-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+iterator-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+iterator-devel.sha256sum] = "5c9462a87b6fff27ce9ec821c44dd34e2d0d994c56c0962d9b6730415fa29c02"

URI_x86_64_v2_rust-signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-devel.sha256sum] = "106faa461acd9bd8da4957bfd3d3256efeedf1257685bf96edf6a9f2b4d9886e"

URI_aarch64_rust-signal-hook+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+cc-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+cc-devel}"
SRC_URI[aarch64_rust-signal-hook+cc-devel.sha256sum] = "acceda1b5459150b38c20f521c3edf664f49e0b2b6efe93a02f239035e422517"

URI_aarch64_rust-signal-hook+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+channel-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+channel-devel}"
SRC_URI[aarch64_rust-signal-hook+channel-devel.sha256sum] = "544f15fdfff1be32f64d13946d3d0e30974a3319cd35188ba30bd1a4b33e27c1"

URI_aarch64_rust-signal-hook+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+default-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+default-devel}"
SRC_URI[aarch64_rust-signal-hook+default-devel.sha256sum] = "4fc03377b680ef28b1ca9a526f3212a4e50b855581afa165cf4fffef2ed15fd5"

URI_aarch64_rust-signal-hook+extended-siginfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+extended-siginfo-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook+extended-siginfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+extended-siginfo-devel}"
SRC_URI[aarch64_rust-signal-hook+extended-siginfo-devel.sha256sum] = "1b2c9893cc6f04e7d5c08873ec6309610971a8947d658cdb6828b65342355dd3"

URI_aarch64_rust-signal-hook+extended-siginfo-raw-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+extended-siginfo-raw-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook+extended-siginfo-raw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+extended-siginfo-raw-devel}"
SRC_URI[aarch64_rust-signal-hook+extended-siginfo-raw-devel.sha256sum] = "764d4cbb4e26f9f5ef38e5ead4c341573e6c39619b7a1e8cae56894a00efd8be"

URI_aarch64_rust-signal-hook+iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+iterator-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook+iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+iterator-devel}"
SRC_URI[aarch64_rust-signal-hook+iterator-devel.sha256sum] = "64427f79f7a178d2ac97ca5f4d00df6248fd5b3a15afebc73373fa16013a0391"

URI_aarch64_rust-signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-devel}"
SRC_URI[aarch64_rust-signal-hook-devel.sha256sum] = "d5c6fba55dec067af5aac31a7e03d3a49b12e4d8b274f549056fcc6ee80b2305"

RDEPENDS:rust-signal-hook+cc-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+channel-devel = " \
 cargo \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+default-devel = " \
 cargo \
 rust-signal-hook+channel-devel \
 rust-signal-hook+iterator-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+extended-siginfo-devel = " \
 cargo \
 rust-signal-hook+channel-devel \
 rust-signal-hook+extended-siginfo-raw-devel \
 rust-signal-hook+iterator-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+extended-siginfo-raw-devel = " \
 cargo \
 rust-signal-hook+cc-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+iterator-devel = " \
 cargo \
 rust-signal-hook+channel-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-signal-hook-registry+default-devel \
 "
