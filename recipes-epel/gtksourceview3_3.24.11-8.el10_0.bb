# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtksourceview3"
PV = "3.24.11"
PR = "8.el10_0"
PACKAGES = " \
 gtksourceview3 \
 gtksourceview3-devel \
 gtksourceview3-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtksourceview3-3.24.11-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0916947687b1ecf4c5a7a4b430f29da571114f2eee8e14bfd24486c3089e062c"

URI_x86_64_v2_gtksourceview3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtksourceview3-3.24.11-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtksourceview3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtksourceview3}"
SRC_URI[x86_64_v2_gtksourceview3.sha256sum] = "63ed0ca8205801acac47f8e6676006f0789fdb35e4ea97b46db97010611f4f54"

URI_x86_64_v2_gtksourceview3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtksourceview3-devel-3.24.11-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtksourceview3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtksourceview3-devel}"
SRC_URI[x86_64_v2_gtksourceview3-devel.sha256sum] = "4274ada43d996d9fd89288528d3e94aca524e7e20655dcd1779a416b95193e38"

URI_x86_64_v2_gtksourceview3-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtksourceview3-tests-3.24.11-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtksourceview3-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtksourceview3-tests}"
SRC_URI[x86_64_v2_gtksourceview3-tests.sha256sum] = "ce279955c3601105878c6ddbdc68c842dbd090d198b773f0d38605396f1e21b1"

URI_aarch64_gtksourceview3 = "${EPEL_MIRROR}/aarch64/Packages/g/gtksourceview3-3.24.11-8.el10_0.aarch64.rpm;name=aarch64_gtksourceview3;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtksourceview3}"
SRC_URI[aarch64_gtksourceview3.sha256sum] = "09171c79e41ac7c240c63852e701ab8f92a60375253a093cfc3e0ec8091b878f"

URI_aarch64_gtksourceview3-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gtksourceview3-devel-3.24.11-8.el10_0.aarch64.rpm;name=aarch64_gtksourceview3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtksourceview3-devel}"
SRC_URI[aarch64_gtksourceview3-devel.sha256sum] = "ad90d9a5029de858bffe3345e851620aaa68fa16de84332dab8dfbd99bb42660"

URI_aarch64_gtksourceview3-tests = "${EPEL_MIRROR}/aarch64/Packages/g/gtksourceview3-tests-3.24.11-8.el10_0.aarch64.rpm;name=aarch64_gtksourceview3-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtksourceview3-tests}"
SRC_URI[aarch64_gtksourceview3-tests.sha256sum] = "2a1944f31ac88a745e68c4f3cb8338f99ad876c3ff18ef5345d66b1d3b158efa"

RDEPENDS:gtksourceview3 = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libxml2 \
 pango \
 "
RDEPENDS:gtksourceview3-devel = " \
 glib2-devel \
 gtk3-devel \
 gtksourceview3 \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gtksourceview3-tests = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 gtksourceview3 \
 libxml2 \
 pango \
 "
