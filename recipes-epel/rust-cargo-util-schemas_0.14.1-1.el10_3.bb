# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-util-schemas"
PV = "0.14.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo-util-schemas+default-devel \
 rust-cargo-util-schemas-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-util-schemas-0.14.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "be9f72bdeb3b104050c049816a4ca4c3f821b1dceee4a060a3bf56e2dba9ccae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-schemas+default-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-schemas+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-util-schemas+default-devel.sha256sum] = "cb5707ad7ebe9baf2e96ca6687529bc8f85b3f9959b4049e5bc274c662559a7f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-schemas-devel-0.14.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-schemas-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-util-schemas-devel.sha256sum] = "720789c68d91096a6f05d8705be85a4a8599b615df418ea10889a76c9796cda7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-schemas+default-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-util-schemas+default-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-util-schemas+default-devel.sha256sum] = "7d5bb07cb174c071933428a0f6c950a8bdf1cd7538d844441b5e80bfa522350d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-schemas-devel-0.14.1-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-util-schemas-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-util-schemas-devel.sha256sum] = "0660cedb7dd1cd71d788e3d09afc2e4c6d296116634cdaf4dfca511a2b7423bd"

RDEPENDS:rust-cargo-util-schemas+default-devel = " \
 cargo \
 rust-cargo-util-schemas-devel \
 "
RDEPENDS:rust-cargo-util-schemas-devel = " \
 cargo \
 rust \
 rust-jiff+serde-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde-untagged+default-devel \
 rust-serde-value+default-devel \
 rust-thiserror+default-devel \
 rust-toml+serde-devel \
 rust-toml-devel \
 rust-unicode-ident+default-devel \
 rust-url+default-devel \
 "
