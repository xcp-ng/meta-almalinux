# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-characters"
PV = "46.0"
PR = "3.el10"
PACKAGES = " \
 gnome-characters \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-characters-46.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0233206e32bc021273a4487bb8bfb39a029df29d0646f56ff4e40f7a758f43ce"

URI_x86_64_v2_gnome-characters = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-characters-46.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-characters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-characters}"
SRC_URI[x86_64_v2_gnome-characters.sha256sum] = "aa2205eb23fbff44f5879663143dd69b89975c5460150d5a35f71c214fab9ebb"

URI_aarch64_gnome-characters = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-characters-46.0-3.el10.aarch64.rpm;name=aarch64_gnome-characters;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-characters}"
SRC_URI[aarch64_gnome-characters.sha256sum] = "00780a5cfe88352b269f64118122d0ddad9261166a84edcc7fdc47bf8c68c2e7"

RDEPENDS:gnome-characters = " \
 gjs \
 glib2 \
 glibc \
 gnome-desktop4 \
 gtk4 \
 libadwaita \
 "
