# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bsf"
PV = "2.4.0"
PR = "54.el10"
PACKAGES = " \
 bsf \
 bsf-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bsf-2.4.0-54.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72a2a727a1b20ac9f9a47f98b73fe3ae094dda3c0f6fea4db33d8133a24bb161"

URI_x86_64_v2_bsf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bsf-2.4.0-54.el10.noarch.rpm;name=x86_64_v2_bsf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bsf}"
SRC_URI[x86_64_v2_bsf.sha256sum] = "f1464931d2c8ed054b3e2a494a792c348dff3e150c1171bfc4bec0671bb3c861"

URI_x86_64_v2_bsf-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bsf-javadoc-2.4.0-54.el10.noarch.rpm;name=x86_64_v2_bsf-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bsf-javadoc}"
SRC_URI[x86_64_v2_bsf-javadoc.sha256sum] = "fe272f191db4170f4e57a66ad81f572f170f682ab76ae3e842ff95c1167e341d"

URI_aarch64_bsf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bsf-2.4.0-54.el10.noarch.rpm;name=aarch64_bsf;unpack=0"
SRC_URI:append = " ${URI_aarch64_bsf}"
SRC_URI[aarch64_bsf.sha256sum] = "f1464931d2c8ed054b3e2a494a792c348dff3e150c1171bfc4bec0671bb3c861"

URI_aarch64_bsf-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bsf-javadoc-2.4.0-54.el10.noarch.rpm;name=aarch64_bsf-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bsf-javadoc}"
SRC_URI[aarch64_bsf-javadoc.sha256sum] = "fe272f191db4170f4e57a66ad81f572f170f682ab76ae3e842ff95c1167e341d"

RDEPENDS:bsf = " \
 apache-commons-logging \
 javapackages-filesystem \
 "
RDEPENDS:bsf-javadoc = " \
 javapackages-filesystem \
 "
