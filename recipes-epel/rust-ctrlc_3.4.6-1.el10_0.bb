# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ctrlc"
PV = "3.4.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-ctrlc+default-devel \
 rust-ctrlc+termination-devel \
 rust-ctrlc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ctrlc-3.4.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3204b2ef50720b973cb6c710363b63837c1e03f29f65db5683e6026a8edf2e4e"

URI_x86_64_v2_rust-ctrlc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctrlc+default-devel-3.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctrlc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctrlc+default-devel}"
SRC_URI[x86_64_v2_rust-ctrlc+default-devel.sha256sum] = "26bc86d45c1c535d14a35740559214d01a82c3252b40f2140e3b17923e5e163a"

URI_x86_64_v2_rust-ctrlc+termination-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctrlc+termination-devel-3.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctrlc+termination-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctrlc+termination-devel}"
SRC_URI[x86_64_v2_rust-ctrlc+termination-devel.sha256sum] = "9aa47d7305ed029b25d2fc5300ee7743650d00568bdebf071c324fc85f1e5fc0"

URI_x86_64_v2_rust-ctrlc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctrlc-devel-3.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctrlc-devel}"
SRC_URI[x86_64_v2_rust-ctrlc-devel.sha256sum] = "9650d87b77d2507fcba366a7957b7dcc6de293b971d5151909bc264cbb1ad222"

URI_aarch64_rust-ctrlc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctrlc+default-devel-3.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-ctrlc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctrlc+default-devel}"
SRC_URI[aarch64_rust-ctrlc+default-devel.sha256sum] = "0c3bbac8ea7057d0d3dba0d6e8f257c8cb946b4ecfe65abe3c242262e332b719"

URI_aarch64_rust-ctrlc+termination-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctrlc+termination-devel-3.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-ctrlc+termination-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctrlc+termination-devel}"
SRC_URI[aarch64_rust-ctrlc+termination-devel.sha256sum] = "3bb7064acf4de49108bce4b8dad12d8ac2f72d997a461a813f2418c42c7e189c"

URI_aarch64_rust-ctrlc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctrlc-devel-3.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctrlc-devel}"
SRC_URI[aarch64_rust-ctrlc-devel.sha256sum] = "1545aac4126ad2f3ce6bc3e61279dea61e06abad5b1de8de5265715e539c78b2"

RDEPENDS:rust-ctrlc+default-devel = " \
 cargo \
 rust-ctrlc-devel \
 "
RDEPENDS:rust-ctrlc+termination-devel = " \
 cargo \
 rust-ctrlc-devel \
 "
RDEPENDS:rust-ctrlc-devel = " \
 cargo \
 rust \
 rust-nix+fs-devel \
 rust-nix+signal-devel \
 rust-nix-devel \
 "
