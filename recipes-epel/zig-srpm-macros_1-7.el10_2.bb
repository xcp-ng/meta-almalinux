# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zig-srpm-macros"
PV = "1"
PR = "7.el10_2"
PACKAGES = " \
 zig-srpm-macros \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/z/zig-srpm-macros-1-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f916cbc912e4b97566653a7ef7b84a51e6d9337d3664fd1c02184ccfd5912b8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zig-srpm-macros-1-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_zig-srpm-macros;unpack=0"
SRC_URI[x86_64_v2_zig-srpm-macros.sha256sum] = "491ad33c42d28ff104697e9dc3cff1cad344bda5522bf2d8186674e732cd038b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zig-srpm-macros-1-7.el10_2.noarch.rpm;name=aarch64_zig-srpm-macros;unpack=0"
SRC_URI[aarch64_zig-srpm-macros.sha256sum] = "ebb26ef5d5922eba672d77f26f194c70831265529131b760bbf011bda89fb138"

RDEPENDS:zig-srpm-macros = " \
 rpm \
 "
