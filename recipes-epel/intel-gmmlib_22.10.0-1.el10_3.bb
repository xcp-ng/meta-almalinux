# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-gmmlib"
PV = "22.10.0"
PR = "1.el10_3"
PACKAGES = " \
 intel-gmmlib \
 intel-gmmlib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-gmmlib-22.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbb0852f1a52a4cb421dc4737bc467fd1c6063ddfd102e3750d5064a25b66154"

URI_x86_64_v2_intel-gmmlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-22.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gmmlib}"
SRC_URI[x86_64_v2_intel-gmmlib.sha256sum] = "c308fe2ba4455a94ea5cc0d70d160de2c8f85b27a14dc0e58bdd3b07ebf2b51c"

URI_x86_64_v2_intel-gmmlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-devel-22.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gmmlib-devel}"
SRC_URI[x86_64_v2_intel-gmmlib-devel.sha256sum] = "961e25cd00f91425bceaa0ae918aae34bfe80e1795aa150dd14a28cb6f7202d5"

URI_aarch64_intel-gmmlib = "${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-22.10.0-1.el10_3.aarch64.rpm;name=aarch64_intel-gmmlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gmmlib}"
SRC_URI[aarch64_intel-gmmlib.sha256sum] = "85f2f2083de5ef61f67ee5d51317f6edbcfb3ce8e8a7696ac320bad9b612fdf9"

URI_aarch64_intel-gmmlib-devel = "${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-devel-22.10.0-1.el10_3.aarch64.rpm;name=aarch64_intel-gmmlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gmmlib-devel}"
SRC_URI[aarch64_intel-gmmlib-devel.sha256sum] = "3b48c8994b2feb92bbe2d3f558d36d9a01409bbee8268d7d385084a406cb4150"

RDEPENDS:intel-gmmlib = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-gmmlib-devel = " \
 intel-gmmlib \
 pkgconf-pkg-config \
 "
