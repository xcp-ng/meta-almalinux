# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cpuinfo"
PV = "24.09.26"
PR = "1.git1e83a2f.el10_1.1"
PACKAGES = " \
 cpuinfo \
 cpuinfo-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cpuinfo-24.09.26-1.git1e83a2f.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b864fa2f5adfbcbb1de0f67f41dc35fa364664f6d9a7f263a2cf557c2a49ceb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpuinfo-24.09.26-1.git1e83a2f.el10_1.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_cpuinfo;unpack=0"
SRC_URI[x86_64_v2_cpuinfo.sha256sum] = "783a08f929a15c627f8a531ce4f29c268de453192879174d857d3d0ff6af31f5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cpuinfo-devel-24.09.26-1.git1e83a2f.el10_1.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_cpuinfo-devel;unpack=0"
SRC_URI[x86_64_v2_cpuinfo-devel.sha256sum] = "e5bc6487403973cc3eb7a1e772096ce8d31e19d53450a45aa9343f8df92ca039"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cpuinfo-24.09.26-1.git1e83a2f.el10_1.1.aarch64.rpm;name=aarch64_cpuinfo;unpack=0"
SRC_URI[aarch64_cpuinfo.sha256sum] = "309370c3dd23841bffc69d2f42103e9091b044d462ef287df121908d04114f2f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cpuinfo-devel-24.09.26-1.git1e83a2f.el10_1.1.aarch64.rpm;name=aarch64_cpuinfo-devel;unpack=0"
SRC_URI[aarch64_cpuinfo-devel.sha256sum] = "4e756cc1caf017fe7e1f2934390681cfb9d0f9494144dfb2f286f3d7af6cca4b"

RDEPENDS:cpuinfo = " \
 glibc \
 "
RDEPENDS:cpuinfo-devel = " \
 cpuinfo \
 pkgconf-pkg-config \
 "
