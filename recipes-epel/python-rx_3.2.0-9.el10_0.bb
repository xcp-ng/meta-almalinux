# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rx"
PV = "3.2.0"
PR = "9.el10_0"
PACKAGES = " \
 python3-rx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rx-3.2.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87e72fda61b421c731b5458a4f16f126b549465076f2f32be7e2c4743bd5089f"

URI_x86_64_v2_python3-rx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rx-3.2.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rx}"
SRC_URI[x86_64_v2_python3-rx.sha256sum] = "7c1ec97fe5c9948b93209f762079454168640f5683029040d616208935d038f3"

URI_aarch64_python3-rx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rx-3.2.0-9.el10_0.noarch.rpm;name=aarch64_python3-rx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rx}"
SRC_URI[aarch64_python3-rx.sha256sum] = "7c9934a7d87eb14f60cd18c1aa7f81b9ad2f4c46c9c115d281506cf26b2ffc68"

RDEPENDS:python3-rx = " \
 python3 \
 "
