# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wordpress"
PV = "6.9.4"
PR = "1.el10_1"
PACKAGES = " \
 wordpress \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wordpress-6.9.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1436fbd95725bae7314412f57b9f4cd6e69e67865a3593a455d1729f262a161"

URI_x86_64_v2_wordpress = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wordpress-6.9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_wordpress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wordpress}"
SRC_URI[x86_64_v2_wordpress.sha256sum] = "b4b4799040c0f8fbc48e3a0451af107448bfa5a0e9b2c785e649fd06ccb395a3"

URI_aarch64_wordpress = "${EPEL_MIRROR}/aarch64/Packages/w/wordpress-6.9.4-1.el10_1.noarch.rpm;name=aarch64_wordpress;unpack=0"
SRC_URI:append = " ${URI_aarch64_wordpress}"
SRC_URI[aarch64_wordpress.sha256sum] = "6cda64fd106f6b9c720e91e2d4c1c7965a7ba0f07b4a0f6fd72ba0e18dc6cb11"

RDEPENDS:wordpress = " \
 ca-certificates \
 httpd \
 httpd-filesystem \
 nginx-filesystem \
 php-common \
 php-fpm \
 php-gd \
 php-intl \
 php-mbstring \
 php-mysqlnd \
 php-pecl-zip \
 php-sodium \
 php-xml \
 virtual/webserver \
 "
