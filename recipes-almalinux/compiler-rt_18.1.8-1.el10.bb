# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "compiler-rt"
PV = "18.1.8"
PR = "1.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/compiler-rt-18.1.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa5897f7353295c6633af62372ad7611653a583d3de83ea52b4394f6db7f04f1"

