# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpublictransport"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kpublictransport \
 kpublictransport-devel \
 kpublictransport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpublictransport-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5179a68232056e06375b1c1041253715d475cff12d040cdc37d13dafb10c03fb"

URI_x86_64_v2_kpublictransport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpublictransport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport}"
SRC_URI[x86_64_v2_kpublictransport.sha256sum] = "472b4d0965a8a31421f599edad28348ef4efcbc2700c890da5e45bcc95110480"

URI_x86_64_v2_kpublictransport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpublictransport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport-devel}"
SRC_URI[x86_64_v2_kpublictransport-devel.sha256sum] = "f67d351949c148c456adf759731bf4ce8556a4e8b47e66899361956fef0e7aa5"

URI_x86_64_v2_kpublictransport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kpublictransport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport-doc}"
SRC_URI[x86_64_v2_kpublictransport-doc.sha256sum] = "96a9f19a65d90e493d6506b16eaf12ab8dc7f0145f0c810e6e2a92669a7c6a0d"

URI_aarch64_kpublictransport = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kpublictransport;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport}"
SRC_URI[aarch64_kpublictransport.sha256sum] = "78ccb570b6ea394a5eb2ac621e694e017563a0d9bcf811a02ddb12f3bbee4876"

URI_aarch64_kpublictransport-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kpublictransport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport-devel}"
SRC_URI[aarch64_kpublictransport-devel.sha256sum] = "e1b3af544f28cc2a3d95855b27defa770b6185b12f6cdf6d3fe4a47ec171c4d1"

URI_aarch64_kpublictransport-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kpublictransport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport-doc}"
SRC_URI[aarch64_kpublictransport-doc.sha256sum] = "a37364b7e00ad54a74cb7600462bb69739edd529adc4ba26fe07c85dcadb80a9"

RDEPENDS:kpublictransport = " \
 glibc \
 kf6-ki18n \
 kf6-networkmanager-qt \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:kpublictransport-devel = " \
 cmake-filesystem \
 kpublictransport \
 "
RDEPENDS:kpublictransport-doc = " \
 "
