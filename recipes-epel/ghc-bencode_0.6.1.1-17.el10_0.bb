# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-bencode"
PV = "0.6.1.1"
PR = "17.el10_0"
PACKAGES = " \
 ghc-bencode \
 ghc-bencode-devel \
 ghc-bencode-doc \
 ghc-bencode-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-bencode-0.6.1.1-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54d93f08f06b7cfcca947d210a9c18189a63cf13cf09611c34fd8de53b0998b5"

URI_x86_64_v2_ghc-bencode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bencode-0.6.1.1-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bencode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bencode}"
SRC_URI[x86_64_v2_ghc-bencode.sha256sum] = "d2599255cf47ecb857c57005091996a2039c43c46f91400fdf314c283a1ec676"

URI_x86_64_v2_ghc-bencode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bencode-devel-0.6.1.1-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bencode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bencode-devel}"
SRC_URI[x86_64_v2_ghc-bencode-devel.sha256sum] = "d0733ac6389fdc0747b190c4d22a2b69ef5b4648b08324e36eb4b340a70c12b7"

URI_x86_64_v2_ghc-bencode-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bencode-doc-0.6.1.1-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-bencode-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bencode-doc}"
SRC_URI[x86_64_v2_ghc-bencode-doc.sha256sum] = "f9d779a456e9395bdbd25179cf9f807b76978421e0d56afae89d20a5aff45dfb"

URI_x86_64_v2_ghc-bencode-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bencode-prof-0.6.1.1-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bencode-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bencode-prof}"
SRC_URI[x86_64_v2_ghc-bencode-prof.sha256sum] = "6e365ee4c978b9e997c2c65ee6d98906c504344ab7fb7f346fe3106a7d6af88a"

URI_aarch64_ghc-bencode = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bencode-0.6.1.1-17.el10_0.aarch64.rpm;name=aarch64_ghc-bencode;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bencode}"
SRC_URI[aarch64_ghc-bencode.sha256sum] = "7760e89981b3f8ad1064fc1caa9fbdc6ea10731765c9d2ee720753df1c55bfd8"

URI_aarch64_ghc-bencode-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bencode-devel-0.6.1.1-17.el10_0.aarch64.rpm;name=aarch64_ghc-bencode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bencode-devel}"
SRC_URI[aarch64_ghc-bencode-devel.sha256sum] = "ad20f4ee99d0450ca50a5fe62fe7e7e6413ade6217f5ac87ef876979973668ed"

URI_aarch64_ghc-bencode-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bencode-doc-0.6.1.1-17.el10_0.noarch.rpm;name=aarch64_ghc-bencode-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bencode-doc}"
SRC_URI[aarch64_ghc-bencode-doc.sha256sum] = "82c8010a1c856144fe9724edca0e75475abe3e6538018f6ff8c9f52b1c5d4505"

URI_aarch64_ghc-bencode-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bencode-prof-0.6.1.1-17.el10_0.aarch64.rpm;name=aarch64_ghc-bencode-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bencode-prof}"
SRC_URI[aarch64_ghc-bencode-prof.sha256sum] = "4bf86931eed8fbec4d12497cac3eeb909c5d4ed82c892a3e3e51a04a826919de"

RDEPENDS:ghc-bencode = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-transformers-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-bencode-devel = " \
 ghc-base-devel \
 ghc-bencode \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-parsec-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-bencode-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-bencode-prof = " \
 ghc-base-prof \
 ghc-bencode-devel \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-parsec-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 "
