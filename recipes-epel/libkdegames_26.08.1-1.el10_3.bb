# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdegames"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libkdegames \
 libkdegames-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkdegames-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d38c3e40c4265d537bc2f0215558b035a4fbe0460ebb90b90ddaa641778e866"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdegames-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdegames;unpack=0"
SRC_URI[x86_64_v2_libkdegames.sha256sum] = "5f0a40dc6ac71169ccab904b5cf9d164d9cced57dca9b7e8d012e9d4d6303963"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdegames-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdegames-devel;unpack=0"
SRC_URI[x86_64_v2_libkdegames-devel.sha256sum] = "70c8049a34f60f427f172d7331b3f0b6198fa28e68a588f455a08dd6b082fa13"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkdegames-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkdegames;unpack=0"
SRC_URI[aarch64_libkdegames.sha256sum] = "2d3d9019faeae4a32dbbff2c9367efaaee9f102299f88fb06ffbcddb7099e2fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkdegames-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libkdegames-devel;unpack=0"
SRC_URI[aarch64_libkdegames-devel.sha256sum] = "ef703e158a18661f0b4a42895c4009d404008ed4b070df95a69ba8e72fb6e342"

RDEPENDS:libkdegames = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdnssd \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libsndfile \
 libstdc++ \
 openal-soft \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:libkdegames-devel = " \
 cmake-filesystem \
 kf6-kcompletion-devel \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-ki18n-devel \
 kf6-kwidgetsaddons-devel \
 libkdegames \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
