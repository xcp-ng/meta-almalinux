# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "slirp4netns"
PV = "1.3.3"
PR = "1.el10"
PACKAGES = " \
 slirp4netns \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/slirp4netns-1.3.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e656fb0f5ed14926eee9932b427847d4b16fb79cbef4312150aa9b1ced85f89a"

URI_x86_64_v2_slirp4netns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/slirp4netns-1.3.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_slirp4netns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slirp4netns}"
SRC_URI[x86_64_v2_slirp4netns.sha256sum] = "7f7db76ca0dab553c34e44d9149c94c39be0d5b80f34d250c7447313454522a6"

URI_aarch64_slirp4netns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/slirp4netns-1.3.3-1.el10.aarch64.rpm;name=aarch64_slirp4netns;unpack=0"
SRC_URI:append = " ${URI_aarch64_slirp4netns}"
SRC_URI[aarch64_slirp4netns.sha256sum] = "4d795bae1a9353189abbbe30f923e531dcea79967b1540b27ce6271b65a981fe"

RDEPENDS:slirp4netns = " \
 glib2 \
 glibc \
 libseccomp \
 libslirp \
 "
