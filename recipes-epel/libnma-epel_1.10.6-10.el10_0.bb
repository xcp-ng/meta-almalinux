# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnma-epel"
PV = "1.10.6"
PR = "10.el10_0"
PACKAGES = " \
 libnma-gtk4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libnma-epel-1.10.6-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf7275af3552e65791c7ad00349b259f9375c1cdc40a68903a1257396e438a6a"

URI_x86_64_v2_libnma-gtk4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnma-gtk4-devel-1.10.6-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnma-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnma-gtk4-devel}"
SRC_URI[x86_64_v2_libnma-gtk4-devel.sha256sum] = "4a1d952ce01c54585b30d99721f47ff32c076d7807e4eebe36a2a519fb716e41"

URI_aarch64_libnma-gtk4-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libnma-gtk4-devel-1.10.6-10.el10_0.aarch64.rpm;name=aarch64_libnma-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnma-gtk4-devel}"
SRC_URI[aarch64_libnma-gtk4-devel.sha256sum] = "1d248936a9c39a5ea7665148a4756b1e3f9f48dd873826f8ef5b604d24900e12"

RDEPENDS:libnma-gtk4-devel = " \
 NetworkManager-libnm-devel \
 gtk4-devel \
 libnma-gtk4 \
 pkgconf-pkg-config \
 "
