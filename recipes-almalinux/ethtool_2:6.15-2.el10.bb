# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ethtool"
PE = "2"
PV = "6.15"
PR = "2.el10"
PACKAGES = " \
 ethtool \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ethtool-6.15-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6cc76a6230a69c0bd41ba8bf79a7473c17fb76eb20c04e916438c484158592da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ethtool-6.15-2.el10.x86_64_v2.rpm;name=x86_64_v2_ethtool;unpack=0"
SRC_URI[x86_64_v2_ethtool.sha256sum] = "2e3e3ea6ad2d83e454226e0ffdf05357a3e44541d3314723da6f1ba0f9f4cbaa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ethtool-6.15-2.el10.aarch64.rpm;name=aarch64_ethtool;unpack=0"
SRC_URI[aarch64_ethtool.sha256sum] = "d1fce11fd89088ec73552e3c66fdfe980faf6eb910ebc83b42a30776b29d5d3f"

RDEPENDS:ethtool = " \
 glibc \
 libmnl \
 "
