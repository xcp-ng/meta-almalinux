# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-catkin_pkg"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 python-catkin_pkg-doc \
 python3-catkin_pkg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-catkin_pkg-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32482cc60de65810b46f991c3ab0178b2ed32b5ae501ad53af2de631b13b6e9b"

URI_x86_64_v2_python-catkin_pkg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-catkin_pkg-doc-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-catkin_pkg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-catkin_pkg-doc}"
SRC_URI[x86_64_v2_python-catkin_pkg-doc.sha256sum] = "ff2f4df91435a3aeecf2e9585310eb8c216bb28266387af5123544e04d1c9693"

URI_x86_64_v2_python3-catkin_pkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-catkin_pkg-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-catkin_pkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-catkin_pkg}"
SRC_URI[x86_64_v2_python3-catkin_pkg.sha256sum] = "60a5aa0e9f304e772132a9390bf8e78370496ef0f07f21f1fcf2219d0ef064b1"

URI_aarch64_python-catkin_pkg-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-catkin_pkg-doc-1.1.0-1.el10_2.noarch.rpm;name=aarch64_python-catkin_pkg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-catkin_pkg-doc}"
SRC_URI[aarch64_python-catkin_pkg-doc.sha256sum] = "29da4c8963793365ed25d2440418429dbc94ff7028a3dde9cb03721fa69caca2"

URI_aarch64_python3-catkin_pkg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-catkin_pkg-1.1.0-1.el10_2.noarch.rpm;name=aarch64_python3-catkin_pkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-catkin_pkg}"
SRC_URI[aarch64_python3-catkin_pkg.sha256sum] = "e2dd8d29d69eba2cf15ca520ddb707f04ae4002433f66bd742bf28b40f420361"

RDEPENDS:python-catkin_pkg-doc = " \
 "
RDEPENDS:python3-catkin_pkg = " \
 python3 \
 python3-dateutil \
 python3-docutils \
 python3-packaging \
 python3-pyparsing \
 python3-setuptools \
 "
