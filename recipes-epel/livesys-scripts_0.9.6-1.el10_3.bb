# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "livesys-scripts"
PV = "0.9.6"
PR = "1.el10_3"
PACKAGES = " \
 livesys-scripts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/livesys-scripts-0.9.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bba617a049890e80e2a9783b7053c62d63a89b1486fd5616c46ed5c170cfdbeb"

URI_x86_64_v2_livesys-scripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/livesys-scripts-0.9.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_livesys-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_livesys-scripts}"
SRC_URI[x86_64_v2_livesys-scripts.sha256sum] = "f1c47e2cf899a35f839c6b0cc24b70a30d6474faac8c147e3618f12845ef04cb"

URI_aarch64_livesys-scripts = "${EPEL_MIRROR}/aarch64/Packages/l/livesys-scripts-0.9.6-1.el10_3.noarch.rpm;name=aarch64_livesys-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_livesys-scripts}"
SRC_URI[aarch64_livesys-scripts.sha256sum] = "b1ae4a2dbe9b664097d9db656f2e6c4aeb4d17e3d38bb5ca5e171f4b0db810aa"

RDEPENDS:livesys-scripts = " \
 bash \
 "
