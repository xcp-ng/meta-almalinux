# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdeplasma-addons"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 kate-krunner-plugin \
 kdeplasma-addons \
 kdeplasma-addons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdeplasma-addons-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ec0d5b7ace4fefadffd5b0ef3d155270dab31482c6665ca0fc591490e078da7"

URI_x86_64_v2_kate-krunner-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-krunner-plugin-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-krunner-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate-krunner-plugin}"
SRC_URI[x86_64_v2_kate-krunner-plugin.sha256sum] = "49c5e38619604e6e1180646721258dcafc655fffaee490f4d69c36a59faf58fb"

URI_x86_64_v2_kdeplasma-addons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeplasma-addons-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeplasma-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeplasma-addons}"
SRC_URI[x86_64_v2_kdeplasma-addons.sha256sum] = "c04b8bf5f19a3a0e94d7431dad3e827f85f1d64795425eacccf460b533b55023"

URI_x86_64_v2_kdeplasma-addons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeplasma-addons-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeplasma-addons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeplasma-addons-devel}"
SRC_URI[x86_64_v2_kdeplasma-addons-devel.sha256sum] = "d83df62cb97da266148e1b11052de0922e9020f7e71cd610fdcc355e85bc7d28"

URI_aarch64_kate-krunner-plugin = "${EPEL_MIRROR}/aarch64/Packages/k/kate-krunner-plugin-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kate-krunner-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate-krunner-plugin}"
SRC_URI[aarch64_kate-krunner-plugin.sha256sum] = "a53c64883e8b96c40e0b8121cd8924ec53ec576d859d5eae04931cf5bd983002"

URI_aarch64_kdeplasma-addons = "${EPEL_MIRROR}/aarch64/Packages/k/kdeplasma-addons-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kdeplasma-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeplasma-addons}"
SRC_URI[aarch64_kdeplasma-addons.sha256sum] = "81e0624f4c2b9b296d280f9a6542ec2330afdc2083fc3c414a3551f1fb1496fe"

URI_aarch64_kdeplasma-addons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdeplasma-addons-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kdeplasma-addons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeplasma-addons-devel}"
SRC_URI[aarch64_kdeplasma-addons-devel.sha256sum] = "4e9988634bdec4a1a152ff253ba5d284c34e15dea22cd8aa2bd3994a27f7287a"

RDEPENDS:kate-krunner-plugin = " \
 glibc \
 kate \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-krunner \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kdeplasma-addons = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-kunitconversion \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libicu \
 libplasma \
 libstdc++ \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 qt6-qtwebengine \
 "
RDEPENDS:kdeplasma-addons-devel = " \
 cmake-filesystem \
 kdeplasma-addons \
 kf6-kcoreaddons-devel \
 qt6-qtbase-devel \
 "
