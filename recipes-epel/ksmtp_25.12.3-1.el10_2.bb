# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksmtp"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ksmtp \
 ksmtp-devel \
 ksmtp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksmtp-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d1b21e4151234863e465acd9f3fcfbdc6704eb168b7afc5df78d2f6e1bd216c"

URI_x86_64_v2_ksmtp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksmtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp}"
SRC_URI[x86_64_v2_ksmtp.sha256sum] = "0b1539cba61e4e12f088d6689545797d6587315dcd802d225cf067006c5cdfbb"

URI_x86_64_v2_ksmtp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksmtp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp-devel}"
SRC_URI[x86_64_v2_ksmtp-devel.sha256sum] = "3f0811cc7d1c040fe1a84ab45a35a062e566ae24c2b26a284869d56acd1a42f9"

URI_x86_64_v2_ksmtp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ksmtp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp-doc}"
SRC_URI[x86_64_v2_ksmtp-doc.sha256sum] = "3d9596df2ee9c6a2993185394f1adddeaa5d9f08af392ce62fa64143d1cda70c"

URI_aarch64_ksmtp = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ksmtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp}"
SRC_URI[aarch64_ksmtp.sha256sum] = "70bb6a75ae13ff2ad1fc73fbf673ff57a845837c335b84e7c33743c688aaed23"

URI_aarch64_ksmtp-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ksmtp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp-devel}"
SRC_URI[aarch64_ksmtp-devel.sha256sum] = "7082b03f1bdc2b433c5cdc87ce655e9f0021cd8faf7d09c65220a3c789682a89"

URI_aarch64_ksmtp-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_ksmtp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp-doc}"
SRC_URI[aarch64_ksmtp-doc.sha256sum] = "0f0a2f776eefae43336a6c252442eab47491a3bae35770738477792d98c98938"

RDEPENDS:ksmtp = " \
 cyrus-sasl-lib \
 cyrus-sasl-plain \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:ksmtp-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kmime-devel \
 ksmtp \
 "
RDEPENDS:ksmtp-doc = " \
 "
