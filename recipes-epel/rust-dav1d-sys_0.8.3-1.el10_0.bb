# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dav1d-sys"
PV = "0.8.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-dav1d-sys+default-devel \
 rust-dav1d-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dav1d-sys-0.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ec84f5b9bd7003bfd259f29af25cf60a68607dbcd2d475b93dc053700629324"

URI_x86_64_v2_rust-dav1d-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dav1d-sys+default-devel-0.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dav1d-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dav1d-sys+default-devel}"
SRC_URI[x86_64_v2_rust-dav1d-sys+default-devel.sha256sum] = "eb4371286dc5259d04b10f1f7bac44c2252e4b08cf672b215fe6aacd66215921"

URI_x86_64_v2_rust-dav1d-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dav1d-sys-devel-0.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dav1d-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dav1d-sys-devel}"
SRC_URI[x86_64_v2_rust-dav1d-sys-devel.sha256sum] = "e578d21b74f0adbf80731f32c4260e212e42dfd08f34b6c5041ab31679e6b8e0"

URI_aarch64_rust-dav1d-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dav1d-sys+default-devel-0.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-dav1d-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dav1d-sys+default-devel}"
SRC_URI[aarch64_rust-dav1d-sys+default-devel.sha256sum] = "4a12a988ff1c3fdea53aa58954df24689e120290637ad012c34a03d56b29d310"

URI_aarch64_rust-dav1d-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dav1d-sys-devel-0.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-dav1d-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dav1d-sys-devel}"
SRC_URI[aarch64_rust-dav1d-sys-devel.sha256sum] = "5f30e278d6ccb9f181077270625e5a6210a316bf18878f1b271afd7a34eb50a0"

RDEPENDS:rust-dav1d-sys+default-devel = " \
 cargo \
 rust-dav1d-sys-devel \
 "
RDEPENDS:rust-dav1d-sys-devel = " \
 cargo \
 libdav1d-devel \
 rust \
 rust-libc+default-devel \
 rust-system-deps+default-devel \
 "
