# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-terminaltables3"
PV = "4.0.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-terminaltables3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-terminaltables3-4.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9489aedeb5aa0237f012f916a5a8cacb6ef6433f54dd09376168d58bd329c7fb"

URI_x86_64_v2_python3-terminaltables3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-terminaltables3-4.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-terminaltables3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-terminaltables3}"
SRC_URI[x86_64_v2_python3-terminaltables3.sha256sum] = "b9890e1437f21d910a7e8fa6b5299f01b18f9529e581ba9013eae286be07b356"

URI_aarch64_python3-terminaltables3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-terminaltables3-4.0.0-1.el10_2.noarch.rpm;name=aarch64_python3-terminaltables3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-terminaltables3}"
SRC_URI[aarch64_python3-terminaltables3.sha256sum] = "3a8e07517419a952b5f8ac287cd30df133dc16971ec2a9583f911eb0ad0c49b7"

RDEPENDS:python3-terminaltables3 = " \
 python3 \
 "
