# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-rustls"
PV = "0.26.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-tokio-rustls+default-devel \
 rust-tokio-rustls+early-data-devel \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-rustls-0.26.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80264b59bc28a78a34917a79b7f376e73e2ed676072bc6840b17cf42ded10bb9"

URI_x86_64_v2_rust-tokio-rustls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+default-devel-0.26.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+default-devel.sha256sum] = "9905de9599b4a4da7d805076f6f109093256f8cb375af336d50883dad6849f13"

URI_x86_64_v2_rust-tokio-rustls+early-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+early-data-devel-0.26.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+early-data-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+early-data-devel.sha256sum] = "1390616660a04d68404a987ef454dabc4e20a4e14a97bfa38bcd7cb106a4430e"

URI_x86_64_v2_rust-tokio-rustls+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+logging-devel-0.26.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+logging-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+logging-devel.sha256sum] = "58bbb860e6c65f1988e24d1f1fd4dadc781cf435322253be9ca5ae126aeb4aa3"

URI_x86_64_v2_rust-tokio-rustls+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+ring-devel-0.26.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+ring-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+ring-devel.sha256sum] = "2f79bbe868a999ae049ff66fe7948f3614f4bd7af6023640b6917a72989b67cd"

URI_x86_64_v2_rust-tokio-rustls+tls12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+tls12-devel-0.26.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+tls12-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+tls12-devel.sha256sum] = "9312c0934067c14ce4d8ec8f51cc7bac7b3c2bd54953e4430e52004bbf8e8074"

URI_x86_64_v2_rust-tokio-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls-devel-0.26.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls-devel.sha256sum] = "8d4554ceed9042b4b1e3472cb0b9b9141bf97cf6c98dfe62aa7076e5e3889dd0"

URI_aarch64_rust-tokio-rustls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+default-devel-0.26.2-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+default-devel}"
SRC_URI[aarch64_rust-tokio-rustls+default-devel.sha256sum] = "f9ef94f78eb7e7451bc8b91fc74ff9ae715c6ff6df69dcdf161f5bc8b7c14033"

URI_aarch64_rust-tokio-rustls+early-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+early-data-devel-0.26.2-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+early-data-devel}"
SRC_URI[aarch64_rust-tokio-rustls+early-data-devel.sha256sum] = "03868bd63d1efb8d55c89ab22e9a4b93274dc19267b70b0e2baecdc2545a5762"

URI_aarch64_rust-tokio-rustls+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+logging-devel-0.26.2-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+logging-devel}"
SRC_URI[aarch64_rust-tokio-rustls+logging-devel.sha256sum] = "a32ac75f728a4807d5145269cf779f03b3916a2ddd93ddb41b94e93afc5d832c"

URI_aarch64_rust-tokio-rustls+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+ring-devel-0.26.2-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+ring-devel}"
SRC_URI[aarch64_rust-tokio-rustls+ring-devel.sha256sum] = "61d449798e615906dc4d514826d3300861850dffd4ec5124eb648b03afe1fa79"

URI_aarch64_rust-tokio-rustls+tls12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+tls12-devel-0.26.2-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+tls12-devel}"
SRC_URI[aarch64_rust-tokio-rustls+tls12-devel.sha256sum] = "f7d2df8d69aded893e6f01f1d3bd3b9362daa528b824db76c83a5348c4ba49a3"

URI_aarch64_rust-tokio-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls-devel-0.26.2-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls-devel}"
SRC_URI[aarch64_rust-tokio-rustls-devel.sha256sum] = "c7c2bc39c16c789d587ce6a49c1572fe3d96f23406e5cedb9caaeea7c3d077e7"

RDEPENDS:rust-tokio-rustls+default-devel = " \
 cargo \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+early-data-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+logging-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+ring-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+tls12-devel = " \
 cargo \
 rust-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls-devel = " \
 cargo \
 rust \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tokio+default-devel \
 "
