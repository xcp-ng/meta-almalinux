# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bat"
PV = "0.24.0"
PR = "11.el10_0"
PACKAGES = " \
 bat \
 rust-bat+application-devel \
 rust-bat+bugreport-devel \
 rust-bat+build-assets-devel \
 rust-bat+clap-devel \
 rust-bat+default-devel \
 rust-bat+etcetera-devel \
 rust-bat+git-devel \
 rust-bat+git2-devel \
 rust-bat+grep-cli-devel \
 rust-bat+minimal-application-devel \
 rust-bat+paging-devel \
 rust-bat+regex-devel \
 rust-bat+regex-fancy-devel \
 rust-bat+regex-onig-devel \
 rust-bat+shell-words-devel \
 rust-bat+walkdir-devel \
 rust-bat+wild-devel \
 rust-bat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bat-0.24.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f2f39576e08af0d246aa0edfe54880ba17e3988c7c7a1beac02f1a5739067dc"

URI_x86_64_v2_bat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bat-0.24.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bat}"
SRC_URI[x86_64_v2_bat.sha256sum] = "dfbba23a92a71b4faa089ac6aec9e1485fcc2011a1feaae68dd54d658c4481f1"

URI_x86_64_v2_rust-bat+application-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+application-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+application-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+application-devel}"
SRC_URI[x86_64_v2_rust-bat+application-devel.sha256sum] = "7251c4609b4e7b40f7012c47a2208b99243563cf2701756148c63068c076db1a"

URI_x86_64_v2_rust-bat+bugreport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+bugreport-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+bugreport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+bugreport-devel}"
SRC_URI[x86_64_v2_rust-bat+bugreport-devel.sha256sum] = "ebf942c2f4f1bad1dc4cfc9d90539b4125c6d6dd633d6d62b9c6af863b697705"

URI_x86_64_v2_rust-bat+build-assets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+build-assets-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+build-assets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+build-assets-devel}"
SRC_URI[x86_64_v2_rust-bat+build-assets-devel.sha256sum] = "8f8d121d3893abe1859486614893a467d13161f567a29a23f7cd6d2d1537dc4b"

URI_x86_64_v2_rust-bat+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+clap-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+clap-devel}"
SRC_URI[x86_64_v2_rust-bat+clap-devel.sha256sum] = "b3d3b2567465182a9622a42d345c006442327035b76fbf4cf638a7ca9d42104d"

URI_x86_64_v2_rust-bat+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+default-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+default-devel}"
SRC_URI[x86_64_v2_rust-bat+default-devel.sha256sum] = "af54552fff54137833789aaaa3b6ff9b480d27b542f11179e3d2fa4f6463548b"

URI_x86_64_v2_rust-bat+etcetera-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+etcetera-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+etcetera-devel}"
SRC_URI[x86_64_v2_rust-bat+etcetera-devel.sha256sum] = "49cd13d534ff0ddc9ed553acfe7af7dfdfa730f753f3d7c05b96240ed5cb26cb"

URI_x86_64_v2_rust-bat+git-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+git-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+git-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+git-devel}"
SRC_URI[x86_64_v2_rust-bat+git-devel.sha256sum] = "d9a9609cbcad31cf6b49b046b92e926bd0488c93fd93b045586670a711290eae"

URI_x86_64_v2_rust-bat+git2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+git2-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+git2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+git2-devel}"
SRC_URI[x86_64_v2_rust-bat+git2-devel.sha256sum] = "d974f003150f1143b0047cb5cfdd0e0f2a8f4b0cd42a375a19ee230252bacf0b"

URI_x86_64_v2_rust-bat+grep-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+grep-cli-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+grep-cli-devel}"
SRC_URI[x86_64_v2_rust-bat+grep-cli-devel.sha256sum] = "935b6389b29324d981451b0d51684495b3a21efffefe2e0d156dcfe8d907dcb4"

URI_x86_64_v2_rust-bat+minimal-application-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+minimal-application-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+minimal-application-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+minimal-application-devel}"
SRC_URI[x86_64_v2_rust-bat+minimal-application-devel.sha256sum] = "1f4c4fecee5cb53646395de74b2b2619887752e7326e5a5173da8490be205c4a"

URI_x86_64_v2_rust-bat+paging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+paging-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+paging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+paging-devel}"
SRC_URI[x86_64_v2_rust-bat+paging-devel.sha256sum] = "5c34d83f3da69213a3c7c971d053a78286333e80a308b9124aac5f913baf5744"

URI_x86_64_v2_rust-bat+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+regex-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+regex-devel}"
SRC_URI[x86_64_v2_rust-bat+regex-devel.sha256sum] = "9bca3b5571d026e9d397b86db06a77f0355f2a009410d03d200ea4cd03f5e68a"

URI_x86_64_v2_rust-bat+regex-fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+regex-fancy-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+regex-fancy-devel}"
SRC_URI[x86_64_v2_rust-bat+regex-fancy-devel.sha256sum] = "f160f70e49d931d0e8a35496bfb2f305005d0ea6499b816d6cfdd6eb08da84d3"

URI_x86_64_v2_rust-bat+regex-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+regex-onig-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+regex-onig-devel}"
SRC_URI[x86_64_v2_rust-bat+regex-onig-devel.sha256sum] = "ee28b5c86632d06a19a93d839f78843d7350d623fcfcc287c757f2d2b0195866"

URI_x86_64_v2_rust-bat+shell-words-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+shell-words-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+shell-words-devel}"
SRC_URI[x86_64_v2_rust-bat+shell-words-devel.sha256sum] = "19b8ecd650ca33976840e5fe0001f0b310a50f6add65f07ef0bdb6f43d18dede"

URI_x86_64_v2_rust-bat+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+walkdir-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+walkdir-devel}"
SRC_URI[x86_64_v2_rust-bat+walkdir-devel.sha256sum] = "e3adce4162f4ecd6bb2d91a414b6817dcc05e00916e178a97dd40b7c5b78ffce"

URI_x86_64_v2_rust-bat+wild-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat+wild-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat+wild-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat+wild-devel}"
SRC_URI[x86_64_v2_rust-bat+wild-devel.sha256sum] = "e382de2dd114a712acd251c545c4d6e009eb31e000147f69a971309459f752b3"

URI_x86_64_v2_rust-bat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bat-devel-0.24.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bat-devel}"
SRC_URI[x86_64_v2_rust-bat-devel.sha256sum] = "5395b18944caef744a20562e04625bac69804c622fea730c5fa18de9de170c1e"

URI_aarch64_bat = "${EPEL_MIRROR}/aarch64/Packages/b/bat-0.24.0-11.el10_0.aarch64.rpm;name=aarch64_bat;unpack=0"
SRC_URI:append = " ${URI_aarch64_bat}"
SRC_URI[aarch64_bat.sha256sum] = "72438f1419c0563cc342a5639264f1fc20df4e52e83f1743ec94875885840c40"

URI_aarch64_rust-bat+application-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+application-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+application-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+application-devel}"
SRC_URI[aarch64_rust-bat+application-devel.sha256sum] = "a535956d227cb0dc45dfecb6a631856b160ca11423d3fc26af1a4f07188a1240"

URI_aarch64_rust-bat+bugreport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+bugreport-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+bugreport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+bugreport-devel}"
SRC_URI[aarch64_rust-bat+bugreport-devel.sha256sum] = "7955a35822791f9158b9ac4872559a46f3576bb0c82e855962178d1d35367287"

URI_aarch64_rust-bat+build-assets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+build-assets-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+build-assets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+build-assets-devel}"
SRC_URI[aarch64_rust-bat+build-assets-devel.sha256sum] = "2af68241d074a6d9a9ea466509931d4b0bd5f5361b92c3b564247bf3fc284faf"

URI_aarch64_rust-bat+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+clap-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+clap-devel}"
SRC_URI[aarch64_rust-bat+clap-devel.sha256sum] = "eeff475298f542f945e66ce73783bfc8b9e3904f4a1460220b84bed221a348e1"

URI_aarch64_rust-bat+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+default-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+default-devel}"
SRC_URI[aarch64_rust-bat+default-devel.sha256sum] = "ef10980a880f1c6cae04fda51bb32f9ba82809c24a849d44d948afd4b4ce6f6b"

URI_aarch64_rust-bat+etcetera-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+etcetera-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+etcetera-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+etcetera-devel}"
SRC_URI[aarch64_rust-bat+etcetera-devel.sha256sum] = "09dc24de95658b62b697b6274a6f996f27cfc9e733f8d7945335417a63b4d4d5"

URI_aarch64_rust-bat+git-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+git-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+git-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+git-devel}"
SRC_URI[aarch64_rust-bat+git-devel.sha256sum] = "9c6643db6477f8004117a1d0abefd24651c76e217e24554afc12cfb5c9b28782"

URI_aarch64_rust-bat+git2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+git2-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+git2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+git2-devel}"
SRC_URI[aarch64_rust-bat+git2-devel.sha256sum] = "dc058f0b052ae22f51ca5d1a04c0a96b29736b6724375498e71153a56fd799b2"

URI_aarch64_rust-bat+grep-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+grep-cli-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+grep-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+grep-cli-devel}"
SRC_URI[aarch64_rust-bat+grep-cli-devel.sha256sum] = "269669ae529932f6a52933fef7d3506cc754f5949bc585f2dc7db3fdfb4c5878"

URI_aarch64_rust-bat+minimal-application-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+minimal-application-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+minimal-application-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+minimal-application-devel}"
SRC_URI[aarch64_rust-bat+minimal-application-devel.sha256sum] = "3e628345555e8427508e4cc4d44fa638ff7b62eaca87f6d567fb01061b0b24d5"

URI_aarch64_rust-bat+paging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+paging-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+paging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+paging-devel}"
SRC_URI[aarch64_rust-bat+paging-devel.sha256sum] = "3df551ffc1eedcf7fe8ed643567d48f283c0157eb0069806395bc5076419083e"

URI_aarch64_rust-bat+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+regex-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+regex-devel}"
SRC_URI[aarch64_rust-bat+regex-devel.sha256sum] = "7837073628f965f57eac49d4827f0a180b8af2d00d7dcafe5154f7854e03e98c"

URI_aarch64_rust-bat+regex-fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+regex-fancy-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+regex-fancy-devel}"
SRC_URI[aarch64_rust-bat+regex-fancy-devel.sha256sum] = "3bdee82a59ff9e18868d973f8df5bf148ac3c6f248626951feff73c9e4d140f5"

URI_aarch64_rust-bat+regex-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+regex-onig-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+regex-onig-devel}"
SRC_URI[aarch64_rust-bat+regex-onig-devel.sha256sum] = "642e84476ec8643ede1fc01e59d0e84fa85ac828aa15032d0690847b752f7d21"

URI_aarch64_rust-bat+shell-words-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+shell-words-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+shell-words-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+shell-words-devel}"
SRC_URI[aarch64_rust-bat+shell-words-devel.sha256sum] = "8ac6baac11869ace57eb8518587c20ecd81ad93ebbebb8fd0b51b248e05592f2"

URI_aarch64_rust-bat+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+walkdir-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+walkdir-devel}"
SRC_URI[aarch64_rust-bat+walkdir-devel.sha256sum] = "8c27d13ec9b5cef1a91eceffe4f60173dfe19bcef2c6124e694b46b12599b339"

URI_aarch64_rust-bat+wild-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat+wild-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat+wild-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat+wild-devel}"
SRC_URI[aarch64_rust-bat+wild-devel.sha256sum] = "4553e75b2fb0f1232eff53bd01bc547c74b4cd21b101a96cbf3cc04bed7a346f"

URI_aarch64_rust-bat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bat-devel-0.24.0-11.el10_0.noarch.rpm;name=aarch64_rust-bat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bat-devel}"
SRC_URI[aarch64_rust-bat-devel.sha256sum] = "6af19bdf69a5f79d47fca05ec469ce705dd8197d228c4c5fb0c89ec75be67e0f"

RDEPENDS:bat = " \
 glibc \
 libgcc \
 oniguruma \
 zlib-ng-compat \
 "
RDEPENDS:rust-bat+application-devel = " \
 cargo \
 rust-bat+bugreport-devel \
 rust-bat+build-assets-devel \
 rust-bat+git-devel \
 rust-bat+minimal-application-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+bugreport-devel = " \
 cargo \
 rust-bat-devel \
 rust-bugreport+default-devel \
 "
RDEPENDS:rust-bat+build-assets-devel = " \
 cargo \
 rust-bat+regex-devel \
 rust-bat+walkdir-devel \
 rust-bat-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+yaml-load-devel \
 "
RDEPENDS:rust-bat+clap-devel = " \
 cargo \
 rust-bat-devel \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 "
RDEPENDS:rust-bat+default-devel = " \
 cargo \
 rust-bat+application-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+etcetera-devel = " \
 cargo \
 rust-bat-devel \
 rust-etcetera+default-devel \
 "
RDEPENDS:rust-bat+git-devel = " \
 cargo \
 rust-bat+git2-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+git2-devel = " \
 cargo \
 rust-bat-devel \
 rust-git2-devel \
 "
RDEPENDS:rust-bat+grep-cli-devel = " \
 cargo \
 rust-bat-devel \
 rust-grep-cli+default-devel \
 "
RDEPENDS:rust-bat+minimal-application-devel = " \
 cargo \
 rust-bat+clap-devel \
 rust-bat+etcetera-devel \
 rust-bat+paging-devel \
 rust-bat+regex-onig-devel \
 rust-bat+wild-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+paging-devel = " \
 cargo \
 rust-bat+grep-cli-devel \
 rust-bat+shell-words-devel \
 rust-bat-devel \
 "
RDEPENDS:rust-bat+regex-devel = " \
 cargo \
 rust-bat-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-bat+regex-fancy-devel = " \
 cargo \
 rust-bat-devel \
 rust-syntect+regex-fancy-devel \
 "
RDEPENDS:rust-bat+regex-onig-devel = " \
 cargo \
 rust-bat-devel \
 rust-syntect+regex-onig-devel \
 "
RDEPENDS:rust-bat+shell-words-devel = " \
 cargo \
 rust-bat-devel \
 rust-shell-words+default-devel \
 "
RDEPENDS:rust-bat+walkdir-devel = " \
 cargo \
 rust-bat-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-bat+wild-devel = " \
 cargo \
 rust-bat-devel \
 rust-wild+default-devel \
 "
RDEPENDS:rust-bat-devel = " \
 bash \
 cargo \
 python3 \
 rust \
 rust-ansi_colours+default-devel \
 rust-bincode+default-devel \
 rust-bytesize+default-devel \
 rust-clircle+default-devel \
 rust-console+default-devel \
 rust-content_inspector+default-devel \
 rust-encoding_rs+default-devel \
 rust-flate2+default-devel \
 rust-globset+default-devel \
 rust-nu-ansi-term+default-devel \
 rust-once_cell+default-devel \
 rust-path-absolutize+default-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_yaml+default-devel \
 rust-syntect+parsing-devel \
 rust-syntect-devel \
 rust-thiserror1+default-devel \
 rust-unicode-width0.1+default-devel \
 "
