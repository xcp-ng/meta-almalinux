# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-send_wrapper"
PV = "0.6.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-send_wrapper+default-devel \
 rust-send_wrapper+futures-core-devel \
 rust-send_wrapper+futures-devel \
 rust-send_wrapper-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-send_wrapper-0.6.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92562de856828d0f23d710a9000ffa23c94be5431d10307db9b57e8d0b58ce87"

URI_x86_64_v2_rust-send_wrapper+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-send_wrapper+default-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-send_wrapper+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-send_wrapper+default-devel}"
SRC_URI[x86_64_v2_rust-send_wrapper+default-devel.sha256sum] = "f2fe9ae8a70169e9aedcc95257a6d347883c77a6aaf2a6f316ba8f84f7f12828"

URI_x86_64_v2_rust-send_wrapper+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-send_wrapper+futures-core-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-send_wrapper+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-send_wrapper+futures-core-devel}"
SRC_URI[x86_64_v2_rust-send_wrapper+futures-core-devel.sha256sum] = "f2884b225ad6841dce4a852c6983d4396665aecb7381d3301d2fea540661e1bd"

URI_x86_64_v2_rust-send_wrapper+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-send_wrapper+futures-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-send_wrapper+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-send_wrapper+futures-devel}"
SRC_URI[x86_64_v2_rust-send_wrapper+futures-devel.sha256sum] = "b8d1d6ca1340d3b4c944d16cefa669ec414e67c78d47402967728571700ece93"

URI_x86_64_v2_rust-send_wrapper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-send_wrapper-devel-0.6.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-send_wrapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-send_wrapper-devel}"
SRC_URI[x86_64_v2_rust-send_wrapper-devel.sha256sum] = "015fd9d874bcdb3d0f2d0d2e93a60b7c81aa1a31cf4e828b1cf3b98cc1ed872f"

URI_aarch64_rust-send_wrapper+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-send_wrapper+default-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-send_wrapper+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-send_wrapper+default-devel}"
SRC_URI[aarch64_rust-send_wrapper+default-devel.sha256sum] = "cd5d041568209ea25fa5707c3b2679b3c27347c708b9c871b9620d39cefff6c5"

URI_aarch64_rust-send_wrapper+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-send_wrapper+futures-core-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-send_wrapper+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-send_wrapper+futures-core-devel}"
SRC_URI[aarch64_rust-send_wrapper+futures-core-devel.sha256sum] = "e256b4f7cdd98b1831bf2c1ed4ad352b0808a7d09d5d22df83eba24b4d96d23a"

URI_aarch64_rust-send_wrapper+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-send_wrapper+futures-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-send_wrapper+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-send_wrapper+futures-devel}"
SRC_URI[aarch64_rust-send_wrapper+futures-devel.sha256sum] = "a0a7d76e4b5cef451c19518904d6cf4aa7c063e2fbd567f7440d48a6a6fb52be"

URI_aarch64_rust-send_wrapper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-send_wrapper-devel-0.6.0-3.el10_0.noarch.rpm;name=aarch64_rust-send_wrapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-send_wrapper-devel}"
SRC_URI[aarch64_rust-send_wrapper-devel.sha256sum] = "9510def3ffcb944f5546f677ac1dc6c3f15b2ab861f6313a37dd41e1560e2731"

RDEPENDS:rust-send_wrapper+default-devel = " \
 cargo \
 rust-send_wrapper-devel \
 "
RDEPENDS:rust-send_wrapper+futures-core-devel = " \
 cargo \
 rust-futures-core+default-devel \
 rust-send_wrapper-devel \
 "
RDEPENDS:rust-send_wrapper+futures-devel = " \
 cargo \
 rust-send_wrapper+futures-core-devel \
 rust-send_wrapper-devel \
 "
RDEPENDS:rust-send_wrapper-devel = " \
 cargo \
 "
