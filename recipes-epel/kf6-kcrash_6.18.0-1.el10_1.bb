# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcrash"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kcrash \
 kf6-kcrash-devel \
 kf6-kcrash-doc \
 kf6-kcrash-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcrash-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d41b7bebf1c5c9bfd64d3a9587e1dc575e74a08f3dc9a9d405459748265a9528"

URI_x86_64_v2_kf6-kcrash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcrash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash}"
SRC_URI[x86_64_v2_kf6-kcrash.sha256sum] = "9d1312470592ea07a2a6d9bb953c6c68edde72f5e8ffd58bab99bc17a5debafb"

URI_x86_64_v2_kf6-kcrash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcrash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-devel}"
SRC_URI[x86_64_v2_kf6-kcrash-devel.sha256sum] = "0cbf9226ef6cd56d67057fe8a55c66875c2f0f31a77ac535837d493990618e52"

URI_x86_64_v2_kf6-kcrash-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcrash-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-doc}"
SRC_URI[x86_64_v2_kf6-kcrash-doc.sha256sum] = "6a416c13b99ac34dda5ea13edeb628af99878491c444bce1357bc380a473dec0"

URI_x86_64_v2_kf6-kcrash-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcrash-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-html}"
SRC_URI[x86_64_v2_kf6-kcrash-html.sha256sum] = "aca08828e210cdb58bb6b5ec77349d062e06fa7c92721649d44e19f619977664"

URI_aarch64_kf6-kcrash = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcrash;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash}"
SRC_URI[aarch64_kf6-kcrash.sha256sum] = "8428ab43d94275037aced5b243d7098c8dbc573fbc419f0c1646dc3ae2465c93"

URI_aarch64_kf6-kcrash-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcrash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-devel}"
SRC_URI[aarch64_kf6-kcrash-devel.sha256sum] = "c2d09a7aa03fa0f47d784f2e5e0d04104527eb14f83a4050113a3af26eb94260"

URI_aarch64_kf6-kcrash-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcrash-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-doc}"
SRC_URI[aarch64_kf6-kcrash-doc.sha256sum] = "04202cfadfb465b9fbdea5011381bf862452a9d9e1d360e26b64dd8343b426ab"

URI_aarch64_kf6-kcrash-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcrash-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-html}"
SRC_URI[aarch64_kf6-kcrash-html.sha256sum] = "2eff52c42c3fbb42838b4e5d90345597b7fa785c2640f659d78e0754f0c9b08b"

RDEPENDS:kf6-kcrash = " \
 glibc \
 kf6-kcoreaddons \
 libX11 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcrash-devel = " \
 cmake-filesystem \
 kf6-kcrash \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcrash-doc = " \
 "
RDEPENDS:kf6-kcrash-html = " \
 "
