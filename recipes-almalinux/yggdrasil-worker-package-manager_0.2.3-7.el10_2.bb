# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yggdrasil-worker-package-manager"
PV = "0.2.3"
PR = "7.el10_2"
PACKAGES = " \
 yggdrasil-worker-package-manager \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yggdrasil-worker-package-manager-0.2.3-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50dbdaba90ced61f4823aca9d3f6d5c266c4ace07672c9f7c7d342376a7dfab3"

URI_x86_64_v2_yggdrasil-worker-package-manager = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yggdrasil-worker-package-manager-0.2.3-7.el10_2.x86_64_v2.rpm;name=x86_64_v2_yggdrasil-worker-package-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil-worker-package-manager}"
SRC_URI[x86_64_v2_yggdrasil-worker-package-manager.sha256sum] = "664a020789d16be0523501bbf4b65a7ce1c6d7642fb5dc4b1f431b75a193a50f"

URI_aarch64_yggdrasil-worker-package-manager = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yggdrasil-worker-package-manager-0.2.3-7.el10_2.aarch64.rpm;name=aarch64_yggdrasil-worker-package-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil-worker-package-manager}"
SRC_URI[aarch64_yggdrasil-worker-package-manager.sha256sum] = "93b32b03617c0d712b9154c331853fb7b32cae09733a5d8d65213ee20de34a6c"

RDEPENDS:yggdrasil-worker-package-manager = " \
 bash \
 glibc \
 "
