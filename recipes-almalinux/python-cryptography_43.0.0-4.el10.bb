# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cryptography"
PV = "43.0.0"
PR = "4.el10"
PACKAGES = " \
 python3-cryptography \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-cryptography-43.0.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c209ee414e0157c9485e3bd7c6f6ffab6738306bac31fd9c49efa1f9133708e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-cryptography-43.0.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3-cryptography;unpack=0"
SRC_URI[x86_64_v2_python3-cryptography.sha256sum] = "c01cc165739e1d759271178fe0ae81a6abd592d6d1ec64422cfc1d3584724c71"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-cryptography-43.0.0-4.el10.aarch64.rpm;name=aarch64_python3-cryptography;unpack=0"
SRC_URI[aarch64_python3-cryptography.sha256sum] = "c3b7b86bf1942cc07fe61ba00d91a7f59349f8ea6e0bff05e21c60d58201de0a"

RDEPENDS:python3-cryptography = " \
 glibc \
 libgcc \
 openssl-libs \
 python3 \
 python3-cffi \
 "
