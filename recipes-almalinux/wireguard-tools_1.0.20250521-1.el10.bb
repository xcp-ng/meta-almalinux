# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wireguard-tools"
PV = "1.0.20250521"
PR = "1.el10"
PACKAGES = " \
 wireguard-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wireguard-tools-1.0.20250521-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc27231badacd50b6f23b61d41ae8c367dd43380222d8dc6fc9a6367648b9fe9"

URI_x86_64_v2_wireguard-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireguard-tools-1.0.20250521-1.el10.x86_64_v2.rpm;name=x86_64_v2_wireguard-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireguard-tools}"
SRC_URI[x86_64_v2_wireguard-tools.sha256sum] = "489d404ac06973f4a0613d5ad7d6c87f25c01d103db367f9fdba9a05413ddf3f"

URI_aarch64_wireguard-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireguard-tools-1.0.20250521-1.el10.aarch64.rpm;name=aarch64_wireguard-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireguard-tools}"
SRC_URI[aarch64_wireguard-tools.sha256sum] = "50f3db0bf8b5511662a2764711f31e8b8a63413a7775c80e181a17bc0d4f205a"

RDEPENDS:wireguard-tools = " \
 bash \
 glibc \
 systemd \
 systemd-resolved \
 "
