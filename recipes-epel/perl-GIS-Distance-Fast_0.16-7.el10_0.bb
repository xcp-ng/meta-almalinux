# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GIS-Distance-Fast"
PV = "0.16"
PR = "7.el10_0"
PACKAGES = " \
 perl-GIS-Distance-Fast \
 perl-GIS-Distance-Fast-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GIS-Distance-Fast-0.16-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fe86e8d68a2e56a746509bd3a9eaf42045f96855ae16a1f2c78ae5f42a205ea"

URI_x86_64_v2_perl-GIS-Distance-Fast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GIS-Distance-Fast-0.16-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-GIS-Distance-Fast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GIS-Distance-Fast}"
SRC_URI[x86_64_v2_perl-GIS-Distance-Fast.sha256sum] = "c35b521e49e989fe7ccbf86e05e8e3aa33d85df1d21ef1a9c377022836236f4c"

URI_x86_64_v2_perl-GIS-Distance-Fast-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GIS-Distance-Fast-tests-0.16-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GIS-Distance-Fast-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GIS-Distance-Fast-tests}"
SRC_URI[x86_64_v2_perl-GIS-Distance-Fast-tests.sha256sum] = "68a0d095bcc56c77cfd0ddc71eb8c375c745bef9cb1f664d3188cc61c57e46ef"

URI_aarch64_perl-GIS-Distance-Fast = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GIS-Distance-Fast-0.16-7.el10_0.aarch64.rpm;name=aarch64_perl-GIS-Distance-Fast;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GIS-Distance-Fast}"
SRC_URI[aarch64_perl-GIS-Distance-Fast.sha256sum] = "5a8e88dbe679f9b0812088ea950d2a88b63ec5233fac9286a5df45133662be54"

URI_aarch64_perl-GIS-Distance-Fast-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GIS-Distance-Fast-tests-0.16-7.el10_0.noarch.rpm;name=aarch64_perl-GIS-Distance-Fast-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GIS-Distance-Fast-tests}"
SRC_URI[aarch64_perl-GIS-Distance-Fast-tests.sha256sum] = "2eb27b1af7e18b21e7bf60e04751786ccd9592068a27ec3a0209a02a716588ef"

RDEPENDS:perl-GIS-Distance-Fast = " \
 glibc \
 perl-GIS-Distance \
 perl-GIS-Distance-Fast \
 perl-libs \
 perl-namespace-clean \
 perl-parent \
 perl-strictures \
 "
RDEPENDS:perl-GIS-Distance-Fast-tests = " \
 bash \
 perl-GIS-Distance \
 perl-GIS-Distance-Fast \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-interpreter \
 perl-libs \
 perl-strictures \
 "
