# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-xauth"
PE = "1"
PV = "1.1.2"
PR = "8.el10"
PACKAGES = " \
 xorg-x11-xauth \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xorg-x11-xauth-1.1.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de29acde2c99d9f583f7a909560f64f5a8f7bd0374532388712d194617b7aecb"

URI_x86_64_v2_xorg-x11-xauth = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xorg-x11-xauth-1.1.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-xauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-xauth}"
SRC_URI[x86_64_v2_xorg-x11-xauth.sha256sum] = "c777b6b73d7b0676eabebe7b2da3cadf908ebca79a011cf4494507dcb1f9c969"

URI_aarch64_xorg-x11-xauth = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xorg-x11-xauth-1.1.2-8.el10.aarch64.rpm;name=aarch64_xorg-x11-xauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-xauth}"
SRC_URI[aarch64_xorg-x11-xauth.sha256sum] = "d6e740691a21352cf6f997c2475e251392463fa46b4ea4bc090c5c6c6bce6c1b"

RDEPENDS:xorg-x11-xauth = " \
 glibc \
 libX11 \
 libXau \
 libXext \
 libXmu \
 "
