# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-fuse"
PV = "5.1.1"
PR = "3.el10_3"
PACKAGES = " \
 kio-fuse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-fuse-5.1.1-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2a72f23422e45198670b659abe07f209c32ebba2fad9f0161257ed9b3533d3a"

URI_x86_64_v2_kio-fuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-fuse-5.1.1-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-fuse}"
SRC_URI[x86_64_v2_kio-fuse.sha256sum] = "036271a8ffb45194243f94094bdd01660a5197bdfe5fe92db0528584706f3e2f"

URI_aarch64_kio-fuse = "${EPEL_MIRROR}/aarch64/Packages/k/kio-fuse-5.1.1-3.el10_3.aarch64.rpm;name=aarch64_kio-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-fuse}"
SRC_URI[aarch64_kio-fuse.sha256sum] = "dafab38187138e4dc1ec7d08d8ff81a49b7ac1652c9be8606a7229be3a65f004"

RDEPENDS:kio-fuse = " \
 dbus-common \
 fuse3-libs \
 glibc \
 kf6-kcoreaddons \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 systemd \
 "
