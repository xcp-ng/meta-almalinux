# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-NetAddr-IP"
PV = "4.079"
PR = "30.el10_0"
PACKAGES = " \
 perl-NetAddr-IP \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-NetAddr-IP-4.079-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "51bc862794287558eb269cf12a50068b8eff0a37ba92b6aeb0ca7e928853e327"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-NetAddr-IP-4.079-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-NetAddr-IP;unpack=0"
SRC_URI[x86_64_v2_perl-NetAddr-IP.sha256sum] = "cdff06112cc0c22402a8aaf0a0abff91776db520cc2c347bedb7fa307ee45fb7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-NetAddr-IP-4.079-30.el10_0.aarch64.rpm;name=aarch64_perl-NetAddr-IP;unpack=0"
SRC_URI[aarch64_perl-NetAddr-IP.sha256sum] = "35453fea85e7da5b565e1ba960f26a4de61b65c223c54297f8bffdb01d72c681"

RDEPENDS:perl-NetAddr-IP = " \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-Math-BigInt \
 perl-NetAddr-IP \
 perl-Socket \
 perl-libs \
 perl-overload \
 perl-vars \
 "
