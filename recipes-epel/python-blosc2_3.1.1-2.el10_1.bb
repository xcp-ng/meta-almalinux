# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-blosc2"
PV = "3.1.1"
PR = "2.el10_1"
PACKAGES = " \
 python3-blosc2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-blosc2-3.1.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fe667132ff03cd4f4dafeb0c90ac2a00f2cb085cf703d8375a6275ae2497301"

URI_x86_64_v2_python3-blosc2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-blosc2-3.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-blosc2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-blosc2}"
SRC_URI[x86_64_v2_python3-blosc2.sha256sum] = "b03bf32d6b4384f525368e587fd649e2114d76ebac4c582627fcc97e17d19d11"

URI_aarch64_python3-blosc2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-blosc2-3.1.1-2.el10_1.aarch64.rpm;name=aarch64_python3-blosc2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-blosc2}"
SRC_URI[aarch64_python3-blosc2.sha256sum] = "d7b4dcb1e4bc9fe5f984d81af428e7343121d3786d4604cd12a9fbd459cad15c"

RDEPENDS:python3-blosc2 = " \
 blosc2 \
 glibc \
 python3 \
 python3-cpuinfo \
 python3-httpx \
 python3-msgpack \
 python3-ndindex \
 python3-numexpr \
 python3-numpy \
 python3-platformdirs \
 "
