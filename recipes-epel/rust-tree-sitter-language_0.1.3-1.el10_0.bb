# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-language"
PV = "0.1.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-language+default-devel \
 rust-tree-sitter-language-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-language-0.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc12953174e52982e48fbf24eb317fe72578b172839d5bc815a0c0913c89cbc5"

URI_x86_64_v2_rust-tree-sitter-language+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-language+default-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-language+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-language+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-language+default-devel.sha256sum] = "57e9ff6c4e28c58085e9cd1446d88dc55cb83291e41c5d7c3aad3f2296e57f62"

URI_x86_64_v2_rust-tree-sitter-language-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-language-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-language-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-language-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-language-devel.sha256sum] = "350f3d74a60d18d356d736de73964427bc7a19589b6225dd079f6370574fc568"

URI_aarch64_rust-tree-sitter-language+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-language+default-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-language+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-language+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-language+default-devel.sha256sum] = "6d2b72bfa89dd864f930648323e30f4934b2d9f7292422c0f1d22a5f6c1cafed"

URI_aarch64_rust-tree-sitter-language-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-language-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-language-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-language-devel}"
SRC_URI[aarch64_rust-tree-sitter-language-devel.sha256sum] = "4d235f242fb0c6cb775ac829a1781401a1d5d294dea3e810be18a6e59388baf4"

RDEPENDS:rust-tree-sitter-language+default-devel = " \
 cargo \
 rust-tree-sitter-language-devel \
 "
RDEPENDS:rust-tree-sitter-language-devel = " \
 cargo \
 rust \
 "
