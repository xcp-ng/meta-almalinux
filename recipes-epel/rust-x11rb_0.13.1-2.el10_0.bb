# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-x11rb"
PV = "0.13.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-x11rb+all-extensions-devel \
 rust-x11rb+allow-unsafe-code-devel \
 rust-x11rb+as-raw-xcb-connection-devel \
 rust-x11rb+composite-devel \
 rust-x11rb+cursor-devel \
 rust-x11rb+damage-devel \
 rust-x11rb+dbe-devel \
 rust-x11rb+default-devel \
 rust-x11rb+dl-libxcb-devel \
 rust-x11rb+dpms-devel \
 rust-x11rb+dri2-devel \
 rust-x11rb+dri3-devel \
 rust-x11rb+extra-traits-devel \
 rust-x11rb+glx-devel \
 rust-x11rb+image-devel \
 rust-x11rb+libc-devel \
 rust-x11rb+libloading-devel \
 rust-x11rb+once_cell-devel \
 rust-x11rb+present-devel \
 rust-x11rb+randr-devel \
 rust-x11rb+record-devel \
 rust-x11rb+render-devel \
 rust-x11rb+request-parsing-devel \
 rust-x11rb+res-devel \
 rust-x11rb+resource_manager-devel \
 rust-x11rb+screensaver-devel \
 rust-x11rb+shape-devel \
 rust-x11rb+shm-devel \
 rust-x11rb+sync-devel \
 rust-x11rb+tracing-devel \
 rust-x11rb+xevie-devel \
 rust-x11rb+xf86dri-devel \
 rust-x11rb+xf86vidmode-devel \
 rust-x11rb+xfixes-devel \
 rust-x11rb+xinerama-devel \
 rust-x11rb+xinput-devel \
 rust-x11rb+xkb-devel \
 rust-x11rb+xprint-devel \
 rust-x11rb+xselinux-devel \
 rust-x11rb+xtest-devel \
 rust-x11rb+xv-devel \
 rust-x11rb+xvmc-devel \
 rust-x11rb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-x11rb-0.13.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31c8560ca1801980292e53610bfcbb338d0b336b07fcb74b202bf04a16748137"

URI_x86_64_v2_rust-x11rb+all-extensions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+all-extensions-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+all-extensions-devel}"
SRC_URI[x86_64_v2_rust-x11rb+all-extensions-devel.sha256sum] = "e4f09692f027b67184d118cfae3643668390423143453c8e2e0293e0bd604833"

URI_x86_64_v2_rust-x11rb+allow-unsafe-code-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+allow-unsafe-code-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+allow-unsafe-code-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+allow-unsafe-code-devel}"
SRC_URI[x86_64_v2_rust-x11rb+allow-unsafe-code-devel.sha256sum] = "c2243f2cf273c4f90d5f2c6865d8beb38e0bd69a173e6520bc759ac4f40371fe"

URI_x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+as-raw-xcb-connection-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel}"
SRC_URI[x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel.sha256sum] = "d11edad6e0d15e986e96e5ec8e47d3fae25ff10034aac57b5087eaa8fdfa16af"

URI_x86_64_v2_rust-x11rb+composite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+composite-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+composite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+composite-devel}"
SRC_URI[x86_64_v2_rust-x11rb+composite-devel.sha256sum] = "4a7fae9286987c40765b9e65b0364927d4a05446f1c60b7433e243b5209047ec"

URI_x86_64_v2_rust-x11rb+cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+cursor-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+cursor-devel}"
SRC_URI[x86_64_v2_rust-x11rb+cursor-devel.sha256sum] = "b66af673366cde3f3026ce14934466ccd8c2a32e52ec528cd506db5ce26c9e41"

URI_x86_64_v2_rust-x11rb+damage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+damage-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+damage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+damage-devel}"
SRC_URI[x86_64_v2_rust-x11rb+damage-devel.sha256sum] = "0e13ae743af2703313ea7c92b8664c82ac9fb5ce1448f306e8070e507c4acb27"

URI_x86_64_v2_rust-x11rb+dbe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dbe-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dbe-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dbe-devel.sha256sum] = "b97b1c65e9a26fa12fccbac60c35c7258f55b3630228c568d28d21320512bc38"

URI_x86_64_v2_rust-x11rb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+default-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+default-devel}"
SRC_URI[x86_64_v2_rust-x11rb+default-devel.sha256sum] = "5b28379e7130078d453c2bfc15a085cc40ddf9ba93a2b2b2a241197c04908983"

URI_x86_64_v2_rust-x11rb+dl-libxcb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dl-libxcb-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dl-libxcb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dl-libxcb-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dl-libxcb-devel.sha256sum] = "79710fe439fd185a1e7dc530f8bb7c716181a750776291eb460925cb7d5ad7a3"

URI_x86_64_v2_rust-x11rb+dpms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dpms-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dpms-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dpms-devel.sha256sum] = "25ad9464f9b312a3773207a22e8bcf73ab170eeb84d58fb37fc3c17739806360"

URI_x86_64_v2_rust-x11rb+dri2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dri2-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dri2-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dri2-devel.sha256sum] = "0ed797a7cc4b84b4578a5a9b3d815c5dbd813ba261ed30f4e7ed086354faaea1"

URI_x86_64_v2_rust-x11rb+dri3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dri3-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dri3-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dri3-devel.sha256sum] = "ad73559906a76c2b5fcea45dc8b9d592938c381722604478af53413806b2de25"

URI_x86_64_v2_rust-x11rb+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+extra-traits-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-x11rb+extra-traits-devel.sha256sum] = "0b5fcd0bf043d7d36c931ff479e2fe893305549ef426ba50498a206c4f9a1aee"

URI_x86_64_v2_rust-x11rb+glx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+glx-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+glx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+glx-devel}"
SRC_URI[x86_64_v2_rust-x11rb+glx-devel.sha256sum] = "03ad643c8e8f4cc1d4fafad4428abdf267c8215442c1ca207b3162ad9367ff80"

URI_x86_64_v2_rust-x11rb+image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+image-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+image-devel}"
SRC_URI[x86_64_v2_rust-x11rb+image-devel.sha256sum] = "5b1e2d1174b23b4948e40a5b71bdb6df36f7223e0ec6cdf7d2252b4e2a36e399"

URI_x86_64_v2_rust-x11rb+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+libc-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+libc-devel}"
SRC_URI[x86_64_v2_rust-x11rb+libc-devel.sha256sum] = "5e8f66a1a87ac72bee040709b96831b61caf79c8ce03b10b22fa7c4ad0766291"

URI_x86_64_v2_rust-x11rb+libloading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+libloading-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+libloading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+libloading-devel}"
SRC_URI[x86_64_v2_rust-x11rb+libloading-devel.sha256sum] = "2ac98751dfa54ee6644b8be96334aad08af48cf7d7fc51f2a87981890d465201"

URI_x86_64_v2_rust-x11rb+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+once_cell-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+once_cell-devel}"
SRC_URI[x86_64_v2_rust-x11rb+once_cell-devel.sha256sum] = "a0a9278b6cace5bb5ee5b34baf839e63f9a67d34ee09c0e1d865cad80a541b94"

URI_x86_64_v2_rust-x11rb+present-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+present-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+present-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+present-devel}"
SRC_URI[x86_64_v2_rust-x11rb+present-devel.sha256sum] = "29dbf18130b9e03294d14ce7f702585151bfdba99cc1ecf7d5210d4a006868ce"

URI_x86_64_v2_rust-x11rb+randr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+randr-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+randr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+randr-devel}"
SRC_URI[x86_64_v2_rust-x11rb+randr-devel.sha256sum] = "b81365136e6627f23f5334aaaa59abbefe8847636ec0ad0a6880d1d6b76fa9bc"

URI_x86_64_v2_rust-x11rb+record-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+record-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+record-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+record-devel}"
SRC_URI[x86_64_v2_rust-x11rb+record-devel.sha256sum] = "4237d5177b4e49748589a320b4843c26210bd3fe9ef1982712ae262c1ee57b6c"

URI_x86_64_v2_rust-x11rb+render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+render-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+render-devel}"
SRC_URI[x86_64_v2_rust-x11rb+render-devel.sha256sum] = "65141ff7ff15b90c1a15c81662daa3a26f1ad3323fb1b5f153540b4d06907f30"

URI_x86_64_v2_rust-x11rb+request-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+request-parsing-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+request-parsing-devel}"
SRC_URI[x86_64_v2_rust-x11rb+request-parsing-devel.sha256sum] = "7fe666c0c31197bdedf83094d7058a4a148446538d1ad5bce7e27ae92a65c8a7"

URI_x86_64_v2_rust-x11rb+res-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+res-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+res-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+res-devel}"
SRC_URI[x86_64_v2_rust-x11rb+res-devel.sha256sum] = "799287e4698a0e32278ff0798e445a04a9ac075b07bc547758d09ffb6688f769"

URI_x86_64_v2_rust-x11rb+resource_manager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+resource_manager-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+resource_manager-devel}"
SRC_URI[x86_64_v2_rust-x11rb+resource_manager-devel.sha256sum] = "32d5ae5ee2412a984ad00174a86d19ee2f5ed4e17a71d8296e1a0f9b9d9fdf0c"

URI_x86_64_v2_rust-x11rb+screensaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+screensaver-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+screensaver-devel}"
SRC_URI[x86_64_v2_rust-x11rb+screensaver-devel.sha256sum] = "fa3546c40472018818a53c0ad102b49a98adc1a49f474beb610cf23601054854"

URI_x86_64_v2_rust-x11rb+shape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+shape-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+shape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+shape-devel}"
SRC_URI[x86_64_v2_rust-x11rb+shape-devel.sha256sum] = "cbcc406967fd873dd62caa1f34f22975fbad5c77452c30e25ccc9cdd0318753b"

URI_x86_64_v2_rust-x11rb+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+shm-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+shm-devel}"
SRC_URI[x86_64_v2_rust-x11rb+shm-devel.sha256sum] = "f5c6e25518e4e456390b316adb447235c0f93920a1074dc614aeb975353c1ccd"

URI_x86_64_v2_rust-x11rb+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+sync-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+sync-devel}"
SRC_URI[x86_64_v2_rust-x11rb+sync-devel.sha256sum] = "10ab41cfa7be432e88c44eb5d1145c03dbc441acde098a19199d3b8de54f076b"

URI_x86_64_v2_rust-x11rb+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+tracing-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+tracing-devel}"
SRC_URI[x86_64_v2_rust-x11rb+tracing-devel.sha256sum] = "3dfcc89416bd0e0ef8710ef1131cd7cac786544da68fc76d224c0577c7f7d213"

URI_x86_64_v2_rust-x11rb+xevie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xevie-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xevie-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xevie-devel.sha256sum] = "8b600e95fe9c34f6e268191bd543681c7a5a52394f2a1bcbc6558d9dcb44c983"

URI_x86_64_v2_rust-x11rb+xf86dri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xf86dri-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xf86dri-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xf86dri-devel.sha256sum] = "934f8ecf8a47218c19e309db646679e82ac31910c50088622139d1c12349a4da"

URI_x86_64_v2_rust-x11rb+xf86vidmode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xf86vidmode-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xf86vidmode-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xf86vidmode-devel.sha256sum] = "cdde11a447917400a80767cbd235d56afe0302f423e0655d34ae5677716fd934"

URI_x86_64_v2_rust-x11rb+xfixes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xfixes-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xfixes-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xfixes-devel.sha256sum] = "cff3b4733d6a8af7b67c8172175a5ff73840f43dd166d90379d659c077d81168"

URI_x86_64_v2_rust-x11rb+xinerama-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xinerama-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xinerama-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xinerama-devel.sha256sum] = "67bcd7cf8ac11c7191547b95abb3b8d1d72c6d3e2d14b9927c2522b6941374cb"

URI_x86_64_v2_rust-x11rb+xinput-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xinput-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xinput-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xinput-devel.sha256sum] = "ef7fbf262e0093b3ad9cd65508f57aed8b349f291d7f7e79408a85f394174652"

URI_x86_64_v2_rust-x11rb+xkb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xkb-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xkb-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xkb-devel.sha256sum] = "2f391a360366691936df089362e0d7105f101f969cb9217b458c7f47af083964"

URI_x86_64_v2_rust-x11rb+xprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xprint-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xprint-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xprint-devel.sha256sum] = "851bcbbc0fa11c7fc4e369b16aeca791333f842b396044975f08ffbc6dee349f"

URI_x86_64_v2_rust-x11rb+xselinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xselinux-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xselinux-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xselinux-devel.sha256sum] = "9a58d41d5116b83c7329395ea8debae57e2dbf45e0d88fb48016ad8d6881a0ee"

URI_x86_64_v2_rust-x11rb+xtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xtest-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xtest-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xtest-devel.sha256sum] = "0b115dd8756a9522ff162a8c1ade5a51b0d37f2013e8b027da17ea929f2d013a"

URI_x86_64_v2_rust-x11rb+xv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xv-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xv-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xv-devel.sha256sum] = "947bcb2e533a25de08aee764552935d1599aa778295026a800167a77271b6f2f"

URI_x86_64_v2_rust-x11rb+xvmc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xvmc-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xvmc-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xvmc-devel.sha256sum] = "63b18f10ec716da651de18fb17c85b003152b0e9e27db8eaac2dab50435fb208"

URI_x86_64_v2_rust-x11rb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-devel-0.13.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-devel}"
SRC_URI[x86_64_v2_rust-x11rb-devel.sha256sum] = "afe5d5fa674a2ac4a16d62b1431757122e0fbdf2f6d07542fbd84996e8ecd455"

URI_aarch64_rust-x11rb+all-extensions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+all-extensions-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+all-extensions-devel}"
SRC_URI[aarch64_rust-x11rb+all-extensions-devel.sha256sum] = "7d77261a52aeb1347b3cb0cc43a233b6b5d0135932f180069f5fbb8c4da97cb5"

URI_aarch64_rust-x11rb+allow-unsafe-code-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+allow-unsafe-code-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+allow-unsafe-code-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+allow-unsafe-code-devel}"
SRC_URI[aarch64_rust-x11rb+allow-unsafe-code-devel.sha256sum] = "1e61b6ca986fea91e62598050b61b0e1ba8f0f7014b20b92aa7f9c729bf8c7cb"

URI_aarch64_rust-x11rb+as-raw-xcb-connection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+as-raw-xcb-connection-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+as-raw-xcb-connection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+as-raw-xcb-connection-devel}"
SRC_URI[aarch64_rust-x11rb+as-raw-xcb-connection-devel.sha256sum] = "7d04fc0171ca994be4237f08f1b6e5939d803730667e0888959ca590a41c7ca5"

URI_aarch64_rust-x11rb+composite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+composite-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+composite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+composite-devel}"
SRC_URI[aarch64_rust-x11rb+composite-devel.sha256sum] = "b8fa16ba3240e9166e4f9066db5986490abf38e41de3d03a3ed542e91571da72"

URI_aarch64_rust-x11rb+cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+cursor-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+cursor-devel}"
SRC_URI[aarch64_rust-x11rb+cursor-devel.sha256sum] = "2e13a09ff70cdb404ab2097adb737e41c257f1039aa7bcec7073540e87128ea0"

URI_aarch64_rust-x11rb+damage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+damage-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+damage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+damage-devel}"
SRC_URI[aarch64_rust-x11rb+damage-devel.sha256sum] = "ced6510bca3b670725d641591aad7bdf392884cc795a25bc6d84317f04f5721a"

URI_aarch64_rust-x11rb+dbe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dbe-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dbe-devel}"
SRC_URI[aarch64_rust-x11rb+dbe-devel.sha256sum] = "e8a781b7d2852305a4e25860a0c1a3880d59e5d4514c049808d6b33aaa5e809e"

URI_aarch64_rust-x11rb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+default-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+default-devel}"
SRC_URI[aarch64_rust-x11rb+default-devel.sha256sum] = "3d3332f99ae9ee57c3a8af08e24cb08084549b17b0572f4f1cd6954784444d2d"

URI_aarch64_rust-x11rb+dl-libxcb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dl-libxcb-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+dl-libxcb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dl-libxcb-devel}"
SRC_URI[aarch64_rust-x11rb+dl-libxcb-devel.sha256sum] = "6159010dde9c89298087ee4202b7b4513e88c7e1295551b9a25dca2154eb00cd"

URI_aarch64_rust-x11rb+dpms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dpms-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dpms-devel}"
SRC_URI[aarch64_rust-x11rb+dpms-devel.sha256sum] = "b060847c27f55fb85b05846b8ffe7621db8fe395ba240355a574687d5deaef9f"

URI_aarch64_rust-x11rb+dri2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dri2-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dri2-devel}"
SRC_URI[aarch64_rust-x11rb+dri2-devel.sha256sum] = "a3e2623f736847e0b93e96aacc7b94310d685cde29c639724c0e2d98f8dd160f"

URI_aarch64_rust-x11rb+dri3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dri3-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dri3-devel}"
SRC_URI[aarch64_rust-x11rb+dri3-devel.sha256sum] = "4a19c3167bce507b2b698dfc2cb81f9012cfcb53743e7fccd992917ec5cfefbd"

URI_aarch64_rust-x11rb+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+extra-traits-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+extra-traits-devel}"
SRC_URI[aarch64_rust-x11rb+extra-traits-devel.sha256sum] = "840aa247d5f9a913cf93424c697a2ed0522b32b2a584bc0b04b95757d65f15f5"

URI_aarch64_rust-x11rb+glx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+glx-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+glx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+glx-devel}"
SRC_URI[aarch64_rust-x11rb+glx-devel.sha256sum] = "ae165dce28794964a0e728da24164821d37002fd6d281324a56aa1faac47e117"

URI_aarch64_rust-x11rb+image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+image-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+image-devel}"
SRC_URI[aarch64_rust-x11rb+image-devel.sha256sum] = "4e3db4283ae3eeb83210d52a16c40c115777d6c8063c3527d768b8d56428ed9a"

URI_aarch64_rust-x11rb+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+libc-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+libc-devel}"
SRC_URI[aarch64_rust-x11rb+libc-devel.sha256sum] = "6dda7662a90d377827e881f70e8cb5b1a599d362814a923ffb72bbc50183a1b2"

URI_aarch64_rust-x11rb+libloading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+libloading-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+libloading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+libloading-devel}"
SRC_URI[aarch64_rust-x11rb+libloading-devel.sha256sum] = "72baa7ed3fe8334e4e11191e2eb2bb25173a60129c5c73b2b661f5a5b48ef15f"

URI_aarch64_rust-x11rb+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+once_cell-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+once_cell-devel}"
SRC_URI[aarch64_rust-x11rb+once_cell-devel.sha256sum] = "2998164020378f4751f5648cb96bad6262949d3e4b1a08b0f10ff8bb34a4cc76"

URI_aarch64_rust-x11rb+present-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+present-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+present-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+present-devel}"
SRC_URI[aarch64_rust-x11rb+present-devel.sha256sum] = "342c83aadde5fd73e316361e9a76e974b6fa4ecb7acdc7d877d6be052765679c"

URI_aarch64_rust-x11rb+randr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+randr-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+randr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+randr-devel}"
SRC_URI[aarch64_rust-x11rb+randr-devel.sha256sum] = "ba21d35290e540ea79d8b292a0f2033cedf0129cf8f803e3a1adf07cae3de981"

URI_aarch64_rust-x11rb+record-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+record-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+record-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+record-devel}"
SRC_URI[aarch64_rust-x11rb+record-devel.sha256sum] = "30995b6c48148de9d6b4f2c4f3eee2464fb451c37eeb0b9f4dc802bb85957def"

URI_aarch64_rust-x11rb+render-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+render-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+render-devel}"
SRC_URI[aarch64_rust-x11rb+render-devel.sha256sum] = "1860034dab024ab9ea65d6cb579477bd6b61821c0d3a17188a19e98d993956f1"

URI_aarch64_rust-x11rb+request-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+request-parsing-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+request-parsing-devel}"
SRC_URI[aarch64_rust-x11rb+request-parsing-devel.sha256sum] = "6cefcc17e49665f78de89bdab8ec033aedcf958b3ab233c26fb6bc08bb34420b"

URI_aarch64_rust-x11rb+res-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+res-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+res-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+res-devel}"
SRC_URI[aarch64_rust-x11rb+res-devel.sha256sum] = "8e3781b35dc922bf65acf4f30cfa612fc660683b70a46aff52b2ccbbe79a5ff9"

URI_aarch64_rust-x11rb+resource_manager-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+resource_manager-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+resource_manager-devel}"
SRC_URI[aarch64_rust-x11rb+resource_manager-devel.sha256sum] = "c2afe8bb12ce6e236bf89bf637b92a3d9ac9f076dd684d098a472463e722fb5a"

URI_aarch64_rust-x11rb+screensaver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+screensaver-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+screensaver-devel}"
SRC_URI[aarch64_rust-x11rb+screensaver-devel.sha256sum] = "0dfc64bb5882e78cfaf3e4b49d04be4fead71d19ebb26a102602f25219f58e2f"

URI_aarch64_rust-x11rb+shape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+shape-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+shape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+shape-devel}"
SRC_URI[aarch64_rust-x11rb+shape-devel.sha256sum] = "148074cba021c91fdb48d8b711e10ac95c0ef599fc59ddd2167376da2562a687"

URI_aarch64_rust-x11rb+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+shm-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+shm-devel}"
SRC_URI[aarch64_rust-x11rb+shm-devel.sha256sum] = "fe0c267eae72fafcf60ddcd7f8c65710f574bd7d808c1e4a6dcbd232720c2ee1"

URI_aarch64_rust-x11rb+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+sync-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+sync-devel}"
SRC_URI[aarch64_rust-x11rb+sync-devel.sha256sum] = "6045da4fe97376410458c32917fb69fc9ec867891e9181f310863797fc5fbf0a"

URI_aarch64_rust-x11rb+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+tracing-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+tracing-devel}"
SRC_URI[aarch64_rust-x11rb+tracing-devel.sha256sum] = "e0b82f92e27a177b0ccd20dc721d8d0b6f24bd0833a14743b32863c50ea2147f"

URI_aarch64_rust-x11rb+xevie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xevie-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xevie-devel}"
SRC_URI[aarch64_rust-x11rb+xevie-devel.sha256sum] = "4e06fc688aadf0f581bcafd4c06226618637b5b7319b9c167b4a4773008e25be"

URI_aarch64_rust-x11rb+xf86dri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xf86dri-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xf86dri-devel}"
SRC_URI[aarch64_rust-x11rb+xf86dri-devel.sha256sum] = "72f52b9d67a83f6842ae4cd2214e22fca952685bd258ea88cec477629093efcb"

URI_aarch64_rust-x11rb+xf86vidmode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xf86vidmode-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xf86vidmode-devel}"
SRC_URI[aarch64_rust-x11rb+xf86vidmode-devel.sha256sum] = "0f643f18ff4523ef1bf3d43d430d7054379827d2b9f633fdb85194607f7ed3d1"

URI_aarch64_rust-x11rb+xfixes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xfixes-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xfixes-devel}"
SRC_URI[aarch64_rust-x11rb+xfixes-devel.sha256sum] = "e14938bef289afae5b62c2645dc1662d065f265fc4e6f7f6cc695ffc137c35cd"

URI_aarch64_rust-x11rb+xinerama-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xinerama-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xinerama-devel}"
SRC_URI[aarch64_rust-x11rb+xinerama-devel.sha256sum] = "0f3ada3c76064e9b510bb6e8231834023b0051c4bdd457f5c861e8abb0a93832"

URI_aarch64_rust-x11rb+xinput-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xinput-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xinput-devel}"
SRC_URI[aarch64_rust-x11rb+xinput-devel.sha256sum] = "6ddaa9240a75f5158cf2cfb36bbaa9d37914d7cdcae33493f80ab10f79d50374"

URI_aarch64_rust-x11rb+xkb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xkb-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xkb-devel}"
SRC_URI[aarch64_rust-x11rb+xkb-devel.sha256sum] = "f3826d143a160135c5351a544056d7f0558aaea17c186ea9f6c9c3553e8198b2"

URI_aarch64_rust-x11rb+xprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xprint-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xprint-devel}"
SRC_URI[aarch64_rust-x11rb+xprint-devel.sha256sum] = "8ecaa96f19a309c632a48ac909893eaf7493dc82756c1ca5fce5293f9c22e6b6"

URI_aarch64_rust-x11rb+xselinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xselinux-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xselinux-devel}"
SRC_URI[aarch64_rust-x11rb+xselinux-devel.sha256sum] = "5f6314501d9fed7dd8a706cbb1ad50d441b70daa706caed948d8d25f6a5d22d8"

URI_aarch64_rust-x11rb+xtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xtest-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xtest-devel}"
SRC_URI[aarch64_rust-x11rb+xtest-devel.sha256sum] = "0e01e288fb456bee975cd84083da967316b08ab818b99f158b7e56546dce7451"

URI_aarch64_rust-x11rb+xv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xv-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xv-devel}"
SRC_URI[aarch64_rust-x11rb+xv-devel.sha256sum] = "765591f545fb8cd2694819e37bea31fdcaef573b3220648750d2d031417701d3"

URI_aarch64_rust-x11rb+xvmc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xvmc-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xvmc-devel}"
SRC_URI[aarch64_rust-x11rb+xvmc-devel.sha256sum] = "8670537d6a85400868c2228e546c89e8c7d06990c86a87c738fced49030ea9fd"

URI_aarch64_rust-x11rb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-devel-0.13.1-2.el10_0.noarch.rpm;name=aarch64_rust-x11rb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-devel}"
SRC_URI[aarch64_rust-x11rb-devel.sha256sum] = "aeb0428a07a9f24dbd780bc8c64773a63e89cb69d84f67dc52ce762ab731a6bb"

RDEPENDS:rust-x11rb+all-extensions-devel = " \
 cargo \
 rust-x11rb+composite-devel \
 rust-x11rb+damage-devel \
 rust-x11rb+dbe-devel \
 rust-x11rb+dpms-devel \
 rust-x11rb+dri2-devel \
 rust-x11rb+dri3-devel \
 rust-x11rb+glx-devel \
 rust-x11rb+present-devel \
 rust-x11rb+randr-devel \
 rust-x11rb+record-devel \
 rust-x11rb+render-devel \
 rust-x11rb+res-devel \
 rust-x11rb+screensaver-devel \
 rust-x11rb+shape-devel \
 rust-x11rb+shm-devel \
 rust-x11rb+sync-devel \
 rust-x11rb+xevie-devel \
 rust-x11rb+xf86dri-devel \
 rust-x11rb+xf86vidmode-devel \
 rust-x11rb+xfixes-devel \
 rust-x11rb+xinerama-devel \
 rust-x11rb+xinput-devel \
 rust-x11rb+xkb-devel \
 rust-x11rb+xprint-devel \
 rust-x11rb+xselinux-devel \
 rust-x11rb+xtest-devel \
 rust-x11rb+xv-devel \
 rust-x11rb+xvmc-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+all-extensions-devel \
 "
RDEPENDS:rust-x11rb+allow-unsafe-code-devel = " \
 cargo \
 rust-x11rb+as-raw-xcb-connection-devel \
 rust-x11rb+libc-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+as-raw-xcb-connection-devel = " \
 cargo \
 rust-as-raw-xcb-connection+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+composite-devel = " \
 cargo \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+composite-devel \
 "
RDEPENDS:rust-x11rb+cursor-devel = " \
 cargo \
 rust-x11rb+render-devel \
 rust-x11rb+resource_manager-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+damage-devel = " \
 cargo \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+damage-devel \
 "
RDEPENDS:rust-x11rb+dbe-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dbe-devel \
 "
RDEPENDS:rust-x11rb+default-devel = " \
 cargo \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+dl-libxcb-devel = " \
 cargo \
 rust-x11rb+allow-unsafe-code-devel \
 rust-x11rb+libloading-devel \
 rust-x11rb+once_cell-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+dpms-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dpms-devel \
 "
RDEPENDS:rust-x11rb+dri2-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dri2-devel \
 "
RDEPENDS:rust-x11rb+dri3-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dri3-devel \
 "
RDEPENDS:rust-x11rb+extra-traits-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+extra-traits-devel \
 "
RDEPENDS:rust-x11rb+glx-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+glx-devel \
 "
RDEPENDS:rust-x11rb+image-devel = " \
 cargo \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+libloading-devel = " \
 cargo \
 rust-libloading+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+present-devel = " \
 cargo \
 rust-x11rb+randr-devel \
 rust-x11rb+sync-devel \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+present-devel \
 "
RDEPENDS:rust-x11rb+randr-devel = " \
 cargo \
 rust-x11rb+render-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+randr-devel \
 "
RDEPENDS:rust-x11rb+record-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+record-devel \
 "
RDEPENDS:rust-x11rb+render-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+render-devel \
 "
RDEPENDS:rust-x11rb+request-parsing-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+request-parsing-devel \
 "
RDEPENDS:rust-x11rb+res-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+res-devel \
 "
RDEPENDS:rust-x11rb+resource_manager-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+resource_manager-devel \
 "
RDEPENDS:rust-x11rb+screensaver-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+screensaver-devel \
 "
RDEPENDS:rust-x11rb+shape-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+shape-devel \
 "
RDEPENDS:rust-x11rb+shm-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+shm-devel \
 "
RDEPENDS:rust-x11rb+sync-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+sync-devel \
 "
RDEPENDS:rust-x11rb+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+xevie-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xevie-devel \
 "
RDEPENDS:rust-x11rb+xf86dri-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xf86dri-devel \
 "
RDEPENDS:rust-x11rb+xf86vidmode-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xf86vidmode-devel \
 "
RDEPENDS:rust-x11rb+xfixes-devel = " \
 cargo \
 rust-x11rb+render-devel \
 rust-x11rb+shape-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xfixes-devel \
 "
RDEPENDS:rust-x11rb+xinerama-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xinerama-devel \
 "
RDEPENDS:rust-x11rb+xinput-devel = " \
 cargo \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xinput-devel \
 "
RDEPENDS:rust-x11rb+xkb-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xkb-devel \
 "
RDEPENDS:rust-x11rb+xprint-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xprint-devel \
 "
RDEPENDS:rust-x11rb+xselinux-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xselinux-devel \
 "
RDEPENDS:rust-x11rb+xtest-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xtest-devel \
 "
RDEPENDS:rust-x11rb+xv-devel = " \
 cargo \
 rust-x11rb+shm-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xv-devel \
 "
RDEPENDS:rust-x11rb+xvmc-devel = " \
 cargo \
 rust-x11rb+xv-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xvmc-devel \
 "
RDEPENDS:rust-x11rb-devel = " \
 cargo \
 rust \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+std-devel \
 rust-rustix+system-devel \
 rust-rustix-devel \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol-devel \
 "
