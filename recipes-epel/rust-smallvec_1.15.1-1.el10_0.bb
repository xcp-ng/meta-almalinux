# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smallvec"
PV = "1.15.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-smallvec+arbitrary-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+debugger_visualizer-devel \
 rust-smallvec+default-devel \
 rust-smallvec+drain_filter-devel \
 rust-smallvec+drain_keep_rest-devel \
 rust-smallvec+may_dangle-devel \
 rust-smallvec+serde-devel \
 rust-smallvec+specialization-devel \
 rust-smallvec+union-devel \
 rust-smallvec+write-devel \
 rust-smallvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smallvec-1.15.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1229bc8d14f11a13f371e9579e64e66228de44dc71b12db76b49b83205dea9ea"

URI_x86_64_v2_rust-smallvec+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+arbitrary-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-smallvec+arbitrary-devel.sha256sum] = "5af082d9d77652f326ea3bf2e9db3bf71a4997c91511d0e1520b476228e7864d"

URI_x86_64_v2_rust-smallvec+const_generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+const_generics-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+const_generics-devel}"
SRC_URI[x86_64_v2_rust-smallvec+const_generics-devel.sha256sum] = "60a338b3f9e818191edb8426f17aba72f35262002753ac86e27ad92e65ed312d"

URI_x86_64_v2_rust-smallvec+const_new-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+const_new-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+const_new-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+const_new-devel}"
SRC_URI[x86_64_v2_rust-smallvec+const_new-devel.sha256sum] = "bd039babf1f5f3e8fdebd6126f638e1396385272a142c803839f10dca59747ae"

URI_x86_64_v2_rust-smallvec+debugger_visualizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+debugger_visualizer-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+debugger_visualizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+debugger_visualizer-devel}"
SRC_URI[x86_64_v2_rust-smallvec+debugger_visualizer-devel.sha256sum] = "ab18e782c8ef8dd7fe061e0647869c408db6cc5e647f9a0135794aab54d61aeb"

URI_x86_64_v2_rust-smallvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+default-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+default-devel}"
SRC_URI[x86_64_v2_rust-smallvec+default-devel.sha256sum] = "8d783f0603a0fab48137c4533fdf84c5b2381815383de36843a12d8074b2cb06"

URI_x86_64_v2_rust-smallvec+drain_filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+drain_filter-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+drain_filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+drain_filter-devel}"
SRC_URI[x86_64_v2_rust-smallvec+drain_filter-devel.sha256sum] = "7526545bdd0ef5371ead6d063dc408147c4b3ea9c214b0b368d37736b326231a"

URI_x86_64_v2_rust-smallvec+drain_keep_rest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+drain_keep_rest-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+drain_keep_rest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+drain_keep_rest-devel}"
SRC_URI[x86_64_v2_rust-smallvec+drain_keep_rest-devel.sha256sum] = "ce8ddbd0f3d74cf3d842b06e0c7a6348b3a791621327884c8af993faeb9439c6"

URI_x86_64_v2_rust-smallvec+may_dangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+may_dangle-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+may_dangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+may_dangle-devel}"
SRC_URI[x86_64_v2_rust-smallvec+may_dangle-devel.sha256sum] = "a0d1a1b47da87fc21620d2b0676fcfb4d467fd666295f4b3a7c5274c2842d067"

URI_x86_64_v2_rust-smallvec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+serde-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+serde-devel}"
SRC_URI[x86_64_v2_rust-smallvec+serde-devel.sha256sum] = "b29b8aefb7709536754aea0a776eb7a04c4437d26852db4920f5d136270a2838"

URI_x86_64_v2_rust-smallvec+specialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+specialization-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+specialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+specialization-devel}"
SRC_URI[x86_64_v2_rust-smallvec+specialization-devel.sha256sum] = "0438b862c2d567bba62cd3eb5dc5e882ac1672eedfc1deee450eae26d0841b0f"

URI_x86_64_v2_rust-smallvec+union-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+union-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+union-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+union-devel}"
SRC_URI[x86_64_v2_rust-smallvec+union-devel.sha256sum] = "a1d80a59bae7448f6e0d78f45ef2ebca68cafedf2ae61c13693ecd61369e5311"

URI_x86_64_v2_rust-smallvec+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+write-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec+write-devel}"
SRC_URI[x86_64_v2_rust-smallvec+write-devel.sha256sum] = "894f2c355331efd8e195dc4d4794ffa294921c5985a66132b205177d68d4bd28"

URI_x86_64_v2_rust-smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec-devel-1.15.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallvec-devel}"
SRC_URI[x86_64_v2_rust-smallvec-devel.sha256sum] = "0310e43c3dc14ff785db30c9b5eda317acf1bd441d3f56cbbbdfeb9257e432c1"

URI_aarch64_rust-smallvec+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+arbitrary-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+arbitrary-devel}"
SRC_URI[aarch64_rust-smallvec+arbitrary-devel.sha256sum] = "f82b083f342545204037a584ab7933688b8911efb1955b4cd89a161e82c1c286"

URI_aarch64_rust-smallvec+const_generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+const_generics-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+const_generics-devel}"
SRC_URI[aarch64_rust-smallvec+const_generics-devel.sha256sum] = "31e2afa02d3da95ae9668b780e08894d9fe02740ad487175243be0d735fe0cb9"

URI_aarch64_rust-smallvec+const_new-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+const_new-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+const_new-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+const_new-devel}"
SRC_URI[aarch64_rust-smallvec+const_new-devel.sha256sum] = "d0c9d9e5e998cf62dbd728e76bd5685e4c578d1eda750e8831a319fd67ec1153"

URI_aarch64_rust-smallvec+debugger_visualizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+debugger_visualizer-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+debugger_visualizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+debugger_visualizer-devel}"
SRC_URI[aarch64_rust-smallvec+debugger_visualizer-devel.sha256sum] = "9fb8e99c5e9b791ffd93f9f74e39fdb6d54a4e5715b28000e2acddd5748ac128"

URI_aarch64_rust-smallvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+default-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+default-devel}"
SRC_URI[aarch64_rust-smallvec+default-devel.sha256sum] = "516b044e5c814f6250fe0579b338a5013c255733e75dbd07e645721a30a13a56"

URI_aarch64_rust-smallvec+drain_filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+drain_filter-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+drain_filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+drain_filter-devel}"
SRC_URI[aarch64_rust-smallvec+drain_filter-devel.sha256sum] = "b9f570811bbc1f2f18ecd79b99bac482243e3f225eb3ae8608226fc7c4f2115f"

URI_aarch64_rust-smallvec+drain_keep_rest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+drain_keep_rest-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+drain_keep_rest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+drain_keep_rest-devel}"
SRC_URI[aarch64_rust-smallvec+drain_keep_rest-devel.sha256sum] = "1855b869af2b0a019908fa6e756cbaf50dcc69a73f71bcb12589876601f88b75"

URI_aarch64_rust-smallvec+may_dangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+may_dangle-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+may_dangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+may_dangle-devel}"
SRC_URI[aarch64_rust-smallvec+may_dangle-devel.sha256sum] = "b366226926402619dc77ea7773217b96285bd4ec039567240d8f461b0d4b3c94"

URI_aarch64_rust-smallvec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+serde-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+serde-devel}"
SRC_URI[aarch64_rust-smallvec+serde-devel.sha256sum] = "ba1e9c86cec35c74d278fa13bee432687914591abffc9550bee240cf07613950"

URI_aarch64_rust-smallvec+specialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+specialization-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+specialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+specialization-devel}"
SRC_URI[aarch64_rust-smallvec+specialization-devel.sha256sum] = "dc6a46136a428eeec8f0d3f5c5bec9d276771be52a98c0112ba17b045c28ea97"

URI_aarch64_rust-smallvec+union-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+union-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+union-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+union-devel}"
SRC_URI[aarch64_rust-smallvec+union-devel.sha256sum] = "3a6f78d5edd1f5b8773cb152a9225141a16f2e722ba8f3b468e526958f2c1fe2"

URI_aarch64_rust-smallvec+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+write-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec+write-devel}"
SRC_URI[aarch64_rust-smallvec+write-devel.sha256sum] = "26dec55a44f5a6dc47fa4fa3a10e87db96a6929c875072ff6ec6fd710ca9f99f"

URI_aarch64_rust-smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec-devel-1.15.1-1.el10_0.noarch.rpm;name=aarch64_rust-smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallvec-devel}"
SRC_URI[aarch64_rust-smallvec-devel.sha256sum] = "a1a25f084a80d44fb70221115798de4b6899871a5a2335d19ce26b9e8443de41"

RDEPENDS:rust-smallvec+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+const_generics-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+const_new-devel = " \
 cargo \
 rust-smallvec+const_generics-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+debugger_visualizer-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+default-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+drain_filter-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+drain_keep_rest-devel = " \
 cargo \
 rust-smallvec+drain_filter-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+may_dangle-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+specialization-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+union-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+write-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec-devel = " \
 cargo \
 "
