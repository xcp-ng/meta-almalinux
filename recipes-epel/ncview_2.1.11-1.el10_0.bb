# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncview"
PV = "2.1.11"
PR = "1.el10_0"
PACKAGES = " \
 ncview \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ncview-2.1.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e86ab7715b53cf2fc9ac76454b0ca6af0b8a38ea7cbf04837969a037a06e1e2"

URI_x86_64_v2_ncview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ncview-2.1.11-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ncview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncview}"
SRC_URI[x86_64_v2_ncview.sha256sum] = "d66a7b9b185bb60f6dd28df9cc2b3a8a6697858f08f31000a1e197ce8378b346"

URI_aarch64_ncview = "${EPEL_MIRROR}/aarch64/Packages/n/ncview-2.1.11-1.el10_0.aarch64.rpm;name=aarch64_ncview;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncview}"
SRC_URI[aarch64_ncview.sha256sum] = "9289a5714317e54d91436be8b1b2052f0269cc58022d92e8bae793ddfd844c84"

RDEPENDS:ncview = " \
 expat \
 glibc \
 libICE \
 libSM \
 libX11 \
 libXaw \
 libXt \
 libpng \
 netcdf \
 udunits2 \
 "
