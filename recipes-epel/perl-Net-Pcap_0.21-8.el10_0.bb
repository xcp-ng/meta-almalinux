# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-Pcap"
PV = "0.21"
PR = "8.el10_0"
PACKAGES = " \
 perl-Net-Pcap \
 perl-Net-Pcap-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-Pcap-0.21-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40d655112c47441e3726212622139503674c7faa28e1399ce22acae2e13c8f10"

URI_x86_64_v2_perl-Net-Pcap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-Pcap-0.21-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Net-Pcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Pcap}"
SRC_URI[x86_64_v2_perl-Net-Pcap.sha256sum] = "1eb2d1c426a7b094c0a34c31517e1e1522b8a198ba62b7378d8008cae7cac739"

URI_x86_64_v2_perl-Net-Pcap-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-Pcap-tests-0.21-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Net-Pcap-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Pcap-tests}"
SRC_URI[x86_64_v2_perl-Net-Pcap-tests.sha256sum] = "b3744f7adcedc0cd598282f1d31fa631f1f5103babcac152aee8e6f3f2125c37"

URI_aarch64_perl-Net-Pcap = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-Pcap-0.21-8.el10_0.aarch64.rpm;name=aarch64_perl-Net-Pcap;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Pcap}"
SRC_URI[aarch64_perl-Net-Pcap.sha256sum] = "031d1a0800c1def4499a3f94663cafcbfcf650b9eff34eca8986ec25cdb4f7f3"

URI_aarch64_perl-Net-Pcap-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-Pcap-tests-0.21-8.el10_0.aarch64.rpm;name=aarch64_perl-Net-Pcap-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Pcap-tests}"
SRC_URI[aarch64_perl-Net-Pcap-tests.sha256sum] = "6c70ef6c08f6c2a63ddef261fa0f929e3257ec667eb4efe2d015b10120aca0fa"

RDEPENDS:perl-Net-Pcap = " \
 glibc \
 libpcap \
 perl-Carp \
 perl-Exporter \
 perl-Net-Pcap \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-Net-Pcap-tests = " \
 bash \
 perl-English \
 perl-ExtUtils-MakeMaker \
 perl-Net-Pcap \
 perl-PathTools \
 perl-Socket \
 perl-Test-Exception \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
