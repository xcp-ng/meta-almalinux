# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksquares"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 ksquares \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksquares-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df487f8c4f1c54ee57d836fc53d4ed2b72792a1598420c2722afffa64c26ce46"

URI_x86_64_v2_ksquares = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksquares-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksquares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksquares}"
SRC_URI[x86_64_v2_ksquares.sha256sum] = "22bab176069baafcb83582e7ef1eada0a94005fbd2d723801b27296384908069"

URI_aarch64_ksquares = "${EPEL_MIRROR}/aarch64/Packages/k/ksquares-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_ksquares;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksquares}"
SRC_URI[aarch64_ksquares.sha256sum] = "6de9809c2b0696fda9476a849c46fbad3dd9e975117a2cd058a795507376d57a"

RDEPENDS:ksquares = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
