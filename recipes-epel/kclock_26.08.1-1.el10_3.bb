# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kclock"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kclock \
 kclock-plasma-applet \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kclock-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dfc9d83e23bd0e1d737134ba8a11d7380c404ac5af65c9ca062a2cb886a301c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kclock-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kclock;unpack=0"
SRC_URI[x86_64_v2_kclock.sha256sum] = "3aedf1ff75a0d7f2e0a7cceaec20759fd97e5b7a3a911714139b5fa0899fb0a9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kclock-plasma-applet-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kclock-plasma-applet;unpack=0"
SRC_URI[x86_64_v2_kclock-plasma-applet.sha256sum] = "af9c06853f0e7d3f7b60b9c20f0fb89ac5918e95a7484a831cf4e3c890d1dab7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kclock-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kclock;unpack=0"
SRC_URI[aarch64_kclock.sha256sum] = "c07a1c6d85447e617d8426bde5e543b715c01d935a968c75bf60fe0c8ad00105"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kclock-plasma-applet-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kclock-plasma-applet;unpack=0"
SRC_URI[aarch64_kclock-plasma-applet.sha256sum] = "0720df2b840ca915cfeb17560ba955a5ed189e703ecd4e01cc221656257b5b81"

RDEPENDS:kclock = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 kf6-kwindowsystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:kclock-plasma-applet = " \
 glibc \
 kclock \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-kservice \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 "
