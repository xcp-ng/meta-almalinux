# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-platform-verifier"
PV = "0.5.3"
PR = "2.el10_1"
PACKAGES = " \
 rust-rustls-platform-verifier+base64-devel \
 rust-rustls-platform-verifier+cert-logging-devel \
 rust-rustls-platform-verifier+dbg-devel \
 rust-rustls-platform-verifier+default-devel \
 rust-rustls-platform-verifier+ffi-testing-devel \
 rust-rustls-platform-verifier-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-platform-verifier-0.5.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "066f456ff33e6a7adf7f0cfeed9dda49ab77a3196b276c6e1632f0d422ce3f3c"

URI_x86_64_v2_rust-rustls-platform-verifier+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+base64-devel-0.5.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+base64-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+base64-devel.sha256sum] = "0147ba472b315bf320557b83637ee1dce0ad5ae5a1ad90d3a8e6440c8c1bdcb8"

URI_x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+cert-logging-devel-0.5.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+cert-logging-devel.sha256sum] = "5bbe67ee4b61cbd4e170a25b8d2d314bc769afa94734d6322ddd3681f22f9784"

URI_x86_64_v2_rust-rustls-platform-verifier+dbg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+dbg-devel-0.5.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+dbg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+dbg-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+dbg-devel.sha256sum] = "6df4597b82ea33489a0797e2943b09b1d4bf43cd0bcfb9f7da9c74141e6201d8"

URI_x86_64_v2_rust-rustls-platform-verifier+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+default-devel-0.5.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+default-devel.sha256sum] = "f6620a00ec8e31d3fb3fe0b8bd82fb308beeb17b2dc96081fc690605472cb78c"

URI_x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier+ffi-testing-devel-0.5.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier+ffi-testing-devel.sha256sum] = "87e8e8d3623416be0ce0635a8863890d111a13857f1b67dad5dbf5690bd79567"

URI_x86_64_v2_rust-rustls-platform-verifier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier-devel-0.5.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier-devel.sha256sum] = "087b39bc0b30068a17597ac6c720b766c608f912b24633d7c55d273b1a77a42a"

URI_aarch64_rust-rustls-platform-verifier+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+base64-devel-0.5.3-2.el10_1.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+base64-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+base64-devel.sha256sum] = "7476afb50111cb7433e1975c979a54355b149d20b93459030cd4eb716b519784"

URI_aarch64_rust-rustls-platform-verifier+cert-logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+cert-logging-devel-0.5.3-2.el10_1.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+cert-logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+cert-logging-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+cert-logging-devel.sha256sum] = "73c59d4bdddd898a09027070c69d44eff9491f66de3b2ec6b3424ca43d1194e5"

URI_aarch64_rust-rustls-platform-verifier+dbg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+dbg-devel-0.5.3-2.el10_1.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+dbg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+dbg-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+dbg-devel.sha256sum] = "a8be60706a9a9767b3aebf58dd83c6a650cd53d360a9dea0de73d302453366f9"

URI_aarch64_rust-rustls-platform-verifier+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+default-devel-0.5.3-2.el10_1.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+default-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+default-devel.sha256sum] = "34720ee4e4cc9a798a470a8786edeeda275c245d4149dce916ce657fd067fe1b"

URI_aarch64_rust-rustls-platform-verifier+ffi-testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier+ffi-testing-devel-0.5.3-2.el10_1.noarch.rpm;name=aarch64_rust-rustls-platform-verifier+ffi-testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier+ffi-testing-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier+ffi-testing-devel.sha256sum] = "768fba2bc2cf96a9973a1700bc484c3d556bcdb420984d86bc671f4f0a814199"

URI_aarch64_rust-rustls-platform-verifier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier-devel-0.5.3-2.el10_1.noarch.rpm;name=aarch64_rust-rustls-platform-verifier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier-devel.sha256sum] = "b6f4e617edf4d2ec70fd2fec02dfbd50b0e23a0f5f70642348733733cbab5c1c"

RDEPENDS:rust-rustls-platform-verifier+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+cert-logging-devel = " \
 cargo \
 rust-rustls-platform-verifier+base64-devel \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+dbg-devel = " \
 cargo \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+default-devel = " \
 cargo \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier+ffi-testing-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-rustls-platform-verifier-devel \
 "
RDEPENDS:rust-rustls-platform-verifier-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-once_cell+default-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-rustls-native-certs+default-devel \
 rust-rustls-webpki-devel \
 "
