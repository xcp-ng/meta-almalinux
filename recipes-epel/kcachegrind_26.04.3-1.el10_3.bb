# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcachegrind"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kcachegrind \
 kcachegrind-converters \
 qcachegrind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcachegrind-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed84a17eac76814ab6c6148fa4fa8a3337fb8a8cecc08161966870ac5f5b6b60"

URI_x86_64_v2_kcachegrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcachegrind-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcachegrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcachegrind}"
SRC_URI[x86_64_v2_kcachegrind.sha256sum] = "f97c81c78dc50b5b2f98489e18b923b5443633ae2bd1871d00ab2c3055eb698f"

URI_x86_64_v2_kcachegrind-converters = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcachegrind-converters-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcachegrind-converters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcachegrind-converters}"
SRC_URI[x86_64_v2_kcachegrind-converters.sha256sum] = "d1a27c102f24661f1ed62d202543bcfb86b62c717f8d6d24142d2318d57a847a"

URI_x86_64_v2_qcachegrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcachegrind-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcachegrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcachegrind}"
SRC_URI[x86_64_v2_qcachegrind.sha256sum] = "e61638b40c5390233e7df7d20a8e1576a1c1fa36fe994a8b9afdfe2367f180f5"

URI_aarch64_kcachegrind = "${EPEL_MIRROR}/aarch64/Packages/k/kcachegrind-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kcachegrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcachegrind}"
SRC_URI[aarch64_kcachegrind.sha256sum] = "16a7fc5f477738158adde366e1ff6f551f6902668f9fac425d05a1d943e91525"

URI_aarch64_kcachegrind-converters = "${EPEL_MIRROR}/aarch64/Packages/k/kcachegrind-converters-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kcachegrind-converters;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcachegrind-converters}"
SRC_URI[aarch64_kcachegrind-converters.sha256sum] = "acddd9e0b9ff0dec5ce3207058733f297d54a310132d81ad45667fd4c5473a2d"

URI_aarch64_qcachegrind = "${EPEL_MIRROR}/aarch64/Packages/q/qcachegrind-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_qcachegrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcachegrind}"
SRC_URI[aarch64_qcachegrind.sha256sum] = "7271287e629891b9821a0397d8f22d5f9a19b0855d84a6140136d125ec407c9d"

RDEPENDS:kcachegrind = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcachegrind-converters = " \
 kcachegrind \
 perl-Getopt-Std \
 perl-IO \
 perl-interpreter \
 perl-libs \
 python3 \
 virtual//usr/bin/php \
 "
RDEPENDS:qcachegrind = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
