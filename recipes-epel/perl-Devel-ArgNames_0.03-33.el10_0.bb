# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-ArgNames"
PV = "0.03"
PR = "33.el10_0"
PACKAGES = " \
 perl-Devel-ArgNames \
 perl-Devel-ArgNames-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-ArgNames-0.03-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44c2c4e6ef1f575b6be95465b4f78d40c7cdff1dbf5c0105fd4245c9c6886427"

URI_x86_64_v2_perl-Devel-ArgNames = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-ArgNames-0.03-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-ArgNames;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-ArgNames}"
SRC_URI[x86_64_v2_perl-Devel-ArgNames.sha256sum] = "da7fbce2261a92f03078aee2cc4e8e183c2dbc61a02ee2850830dc1ae847846a"

URI_x86_64_v2_perl-Devel-ArgNames-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-ArgNames-tests-0.03-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-ArgNames-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-ArgNames-tests}"
SRC_URI[x86_64_v2_perl-Devel-ArgNames-tests.sha256sum] = "ab88a37e179fc20e80b75d27f0e3313c3d680abf362dd345444e03113e8edf6a"

URI_aarch64_perl-Devel-ArgNames = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-ArgNames-0.03-33.el10_0.noarch.rpm;name=aarch64_perl-Devel-ArgNames;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-ArgNames}"
SRC_URI[aarch64_perl-Devel-ArgNames.sha256sum] = "28d6b7dcee2eee7bf3e07bdbe50081692c4938cb89f34e7ed73071af756c5e65"

URI_aarch64_perl-Devel-ArgNames-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-ArgNames-tests-0.03-33.el10_0.noarch.rpm;name=aarch64_perl-Devel-ArgNames-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-ArgNames-tests}"
SRC_URI[aarch64_perl-Devel-ArgNames-tests.sha256sum] = "e5c69129c400aebc2c787e4fe89738e8f33b59731194f31d1d01613e461d381f"

RDEPENDS:perl-Devel-ArgNames = " \
 perl-Exporter \
 perl-PadWalker \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Devel-ArgNames-tests = " \
 bash \
 perl-Devel-ArgNames \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-libs \
 "
