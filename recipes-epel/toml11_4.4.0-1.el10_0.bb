# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "toml11"
PV = "4.4.0"
PR = "1.el10_0"
PACKAGES = " \
 toml11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/toml11-4.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1826617f0a6257b4a6369cf556bb395e90959af6936465d39645e74da0b81fa"

URI_x86_64_v2_toml11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/toml11-devel-4.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_toml11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_toml11-devel}"
SRC_URI[x86_64_v2_toml11-devel.sha256sum] = "35b3480b538d7648d248ec4b88c20bb1ed1f233a5b8e271d8a6f33236107f485"

URI_aarch64_toml11-devel = "${EPEL_MIRROR}/aarch64/Packages/t/toml11-devel-4.4.0-1.el10_0.aarch64.rpm;name=aarch64_toml11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_toml11-devel}"
SRC_URI[aarch64_toml11-devel.sha256sum] = "7688bc3634d3b626fe6dc27dc8d7ad7c1dd454807dbb7c92b2489adec7c98da1"

RDEPENDS:toml11-devel = " \
 cmake-filesystem \
 "
