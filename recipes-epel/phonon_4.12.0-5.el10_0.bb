# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "phonon"
PV = "4.12.0"
PR = "5.el10_0"
PACKAGES = " \
 phonon-common \
 phonon-qt6 \
 phonon-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/phonon-4.12.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c541f355e992a1d9111099c6cea6b173e948995af3bde736f61638bd4a124c77"

URI_x86_64_v2_phonon-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/phonon-common-4.12.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_phonon-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_phonon-common}"
SRC_URI[x86_64_v2_phonon-common.sha256sum] = "8c5bfad60049c2196522139bc5bd780ad0937ce4fdcc509237ca800682ad3edb"

URI_x86_64_v2_phonon-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/phonon-qt6-4.12.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_phonon-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_phonon-qt6}"
SRC_URI[x86_64_v2_phonon-qt6.sha256sum] = "be5f7965f12e7f27885a5836459fc051cddf8fc280dffb267702b34965159414"

URI_x86_64_v2_phonon-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/phonon-qt6-devel-4.12.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_phonon-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_phonon-qt6-devel}"
SRC_URI[x86_64_v2_phonon-qt6-devel.sha256sum] = "ce71a3395c72f0f803601554e46d494069bacebd6b62e8e1491a600687145920"

URI_aarch64_phonon-common = "${EPEL_MIRROR}/aarch64/Packages/p/phonon-common-4.12.0-5.el10_0.noarch.rpm;name=aarch64_phonon-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_phonon-common}"
SRC_URI[aarch64_phonon-common.sha256sum] = "8454ec7bc563c5ed9dd23b09c5e1c837e09eba7444a408b6ca66b063772eed2c"

URI_aarch64_phonon-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/phonon-qt6-4.12.0-5.el10_0.aarch64.rpm;name=aarch64_phonon-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_phonon-qt6}"
SRC_URI[aarch64_phonon-qt6.sha256sum] = "735ab8ea4d404b89c8e9c27c5248a7920ab3feb5a0f62129ce8927475a05061a"

URI_aarch64_phonon-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/phonon-qt6-devel-4.12.0-5.el10_0.aarch64.rpm;name=aarch64_phonon-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_phonon-qt6-devel}"
SRC_URI[aarch64_phonon-qt6-devel.sha256sum] = "cfe4d1a5982c8dc3ba10ba51610073cb00f96f8b5b78205ee1105df8311071ce"

RDEPENDS:phonon-common = " \
 "
RDEPENDS:phonon-qt6 = " \
 glibc \
 libstdc++ \
 phonon-common \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-designer \
 "
RDEPENDS:phonon-qt6-devel = " \
 cmake-filesystem \
 phonon-qt6 \
 pkgconf-pkg-config \
 "
