# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-msal"
PV = "1.33.0"
PR = "3.el10_2"
PACKAGES = " \
 python3-msal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-msal-1.33.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea986bee8c06fc9f1da0e4bdabc80cdae2845258238039a9aca9ff4770f4dd8c"

URI_x86_64_v2_python3-msal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-msal-1.33.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-msal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-msal}"
SRC_URI[x86_64_v2_python3-msal.sha256sum] = "7227f46359d79bf27eb7298942ff5d8996de8497066696bdfb0b84bda2479c59"

URI_aarch64_python3-msal = "${EPEL_MIRROR}/aarch64/Packages/p/python3-msal-1.33.0-3.el10_2.noarch.rpm;name=aarch64_python3-msal;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-msal}"
SRC_URI[aarch64_python3-msal.sha256sum] = "a506a4ea0f17a46165cf70952bfb9bb20077b14242c6e0ea5e69c2a6b20dea0b"

RDEPENDS:python3-msal = " \
 python3 \
 python3-cryptography \
 python3-jwt \
 python3-jwt+crypto \
 python3-requests \
 "
