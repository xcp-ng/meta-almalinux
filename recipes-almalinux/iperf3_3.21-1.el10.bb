# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iperf3"
PV = "3.21"
PR = "1.el10"
PACKAGES = " \
 iperf3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/iperf3-3.21-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e66f867e7a649ad291ab6e43ba445d16cde19d4f00cb716096e3fd982696e5d6"

URI_x86_64_v2_iperf3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iperf3-3.21-1.el10.x86_64_v2.rpm;name=x86_64_v2_iperf3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iperf3}"
SRC_URI[x86_64_v2_iperf3.sha256sum] = "b09ae78e61593d8817cd99b673ec6661fce428a9bb9ebd371853cf4de7ab2669"

URI_aarch64_iperf3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iperf3-3.21-1.el10.aarch64.rpm;name=aarch64_iperf3;unpack=0"
SRC_URI:append = " ${URI_aarch64_iperf3}"
SRC_URI[aarch64_iperf3.sha256sum] = "b145f97e0787c70517e00b11f1e88b4d750153cff0533407bf69e57e24cb57c3"

RDEPENDS:iperf3 = " \
 glibc \
 lksctp-tools \
 openssl-libs \
 "
