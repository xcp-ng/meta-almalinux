# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsdist"
PV = "2.0.7"
PR = "1.el10_2"
PACKAGES = " \
 dnsdist \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnsdist-2.0.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f5e8b05346632c2818a938a40e164df541e5f1ee68622126a49389631e642c0"

URI_x86_64_v2_dnsdist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnsdist-2.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnsdist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsdist}"
SRC_URI[x86_64_v2_dnsdist.sha256sum] = "baf12f6d90f0b52225e1540f7c1728e183ef487a70b47abeb5c7417424aa48ce"

URI_aarch64_dnsdist = "${EPEL_MIRROR}/aarch64/Packages/d/dnsdist-2.0.7-1.el10_2.aarch64.rpm;name=aarch64_dnsdist;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsdist}"
SRC_URI[aarch64_dnsdist.sha256sum] = "0d2d203a3554f5ba4f50d449f0e12677d4ad220f2268c8350cf9c9b652c97018"

RDEPENDS:dnsdist = " \
 bash \
 fstrm \
 glibc \
 libcap \
 libedit \
 libgcc \
 libnghttp2 \
 libsodium \
 libstdc++ \
 lmdb-libs \
 luajit \
 openssl-libs \
 re2 \
 shadow-utils \
 systemd \
 systemd-libs \
 tinycdb \
 "
