# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pythia8"
PV = "8.3.17"
PR = "2.el10_1"
PACKAGES = " \
 pythia8 \
 pythia8-data \
 pythia8-devel \
 pythia8-doc \
 pythia8-examples \
 pythia8-hepmc3 \
 pythia8-lhapdf \
 python3-pythia8 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pythia8-8.3.17-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fc686f65ca0721ede20afb25f1651183dbd6d8c369e92022d553fa5a90e868f"

URI_x86_64_v2_pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-8.3.17-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8}"
SRC_URI[x86_64_v2_pythia8.sha256sum] = "88ff6a03f6c4055735b9beca0b5fd47c0784632eb33729ad43ac873fa0e5051b"

URI_x86_64_v2_pythia8-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-data-8.3.17-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-data}"
SRC_URI[x86_64_v2_pythia8-data.sha256sum] = "da13beeb4da4a6c32a8faa9fa421524181f41def165516e630b5350845dfd8de"

URI_x86_64_v2_pythia8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-devel-8.3.17-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-devel}"
SRC_URI[x86_64_v2_pythia8-devel.sha256sum] = "9853f5aacf55cdd9580e1fbf07e82d13f31c89d922a3277aacfe381e9fe5261c"

URI_x86_64_v2_pythia8-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-doc-8.3.17-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-doc}"
SRC_URI[x86_64_v2_pythia8-doc.sha256sum] = "56bdb9c29f18ad679357160774bf73a9d1a6d2fef0451d9f406922bf1c88f65d"

URI_x86_64_v2_pythia8-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-examples-8.3.17-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-examples}"
SRC_URI[x86_64_v2_pythia8-examples.sha256sum] = "e56abc3bb2abba8937a89883e5a6a695ba1a370ce0615ff5018edbb2ffd06bba"

URI_x86_64_v2_pythia8-hepmc3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-hepmc3-8.3.17-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-hepmc3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-hepmc3}"
SRC_URI[x86_64_v2_pythia8-hepmc3.sha256sum] = "c2de1ff2fc3378262d9074cd5cac6b9e938475e9a1d5b23c52e837c18678cb27"

URI_x86_64_v2_pythia8-lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-lhapdf-8.3.17-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-lhapdf}"
SRC_URI[x86_64_v2_pythia8-lhapdf.sha256sum] = "faaba7a96f1c27651c5ec1fa2d2c48c1c03ae3f00e785ac798ee5fa8ac013870"

URI_x86_64_v2_python3-pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pythia8-8.3.17-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pythia8}"
SRC_URI[x86_64_v2_python3-pythia8.sha256sum] = "b5db309bc39dcdedbd44c76f570230e988ab619a9cca814a8feab360fa532ffe"

URI_aarch64_pythia8 = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-8.3.17-2.el10_1.aarch64.rpm;name=aarch64_pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8}"
SRC_URI[aarch64_pythia8.sha256sum] = "18716907dc89154447a3cfef38eb602a7d6caee9b6682e37b061ca90f60b034d"

URI_aarch64_pythia8-data = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-data-8.3.17-2.el10_1.noarch.rpm;name=aarch64_pythia8-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-data}"
SRC_URI[aarch64_pythia8-data.sha256sum] = "de195004a5738a241d3c92008aff44dbd894f531e8cc1ce113197d70f4bdd1f7"

URI_aarch64_pythia8-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-devel-8.3.17-2.el10_1.aarch64.rpm;name=aarch64_pythia8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-devel}"
SRC_URI[aarch64_pythia8-devel.sha256sum] = "9c3c20c7dbb443ad51942aa36cfa0e89afa6db2229d22a52c1eff765548ba9bd"

URI_aarch64_pythia8-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-doc-8.3.17-2.el10_1.noarch.rpm;name=aarch64_pythia8-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-doc}"
SRC_URI[aarch64_pythia8-doc.sha256sum] = "2c6b7982491f2082d9289615e2dc319db341fb26a708fd5212fcc3672ced2f56"

URI_aarch64_pythia8-examples = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-examples-8.3.17-2.el10_1.noarch.rpm;name=aarch64_pythia8-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-examples}"
SRC_URI[aarch64_pythia8-examples.sha256sum] = "62bca17c6a12a50dc334d3d7511eb7be1e35db778f6526c0234ab2e185f39024"

URI_aarch64_pythia8-hepmc3 = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-hepmc3-8.3.17-2.el10_1.aarch64.rpm;name=aarch64_pythia8-hepmc3;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-hepmc3}"
SRC_URI[aarch64_pythia8-hepmc3.sha256sum] = "141f6101e2cabbb81549123ee9029530447668f038bb633189db7a246c3aa8bd"

URI_aarch64_pythia8-lhapdf = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-lhapdf-8.3.17-2.el10_1.aarch64.rpm;name=aarch64_pythia8-lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-lhapdf}"
SRC_URI[aarch64_pythia8-lhapdf.sha256sum] = "b95596cb8d1cf48aad6566578120aa5e91f83df7655eb5da5cda8fe0e71a40ec"

URI_aarch64_python3-pythia8 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pythia8-8.3.17-2.el10_1.aarch64.rpm;name=aarch64_python3-pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pythia8}"
SRC_URI[aarch64_python3-pythia8.sha256sum] = "c71c4bcbd33b0e4ccdc554b824192a2e58ba7d1e4c4c6fb44925c15d6c11df1a"

RDEPENDS:pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8-data \
 zlib-ng-compat \
 "
RDEPENDS:pythia8-data = " \
 "
RDEPENDS:pythia8-devel = " \
 pythia8 \
 "
RDEPENDS:pythia8-doc = " \
 "
RDEPENDS:pythia8-examples = " \
 "
RDEPENDS:pythia8-hepmc3 = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 "
RDEPENDS:pythia8-lhapdf = " \
 glibc \
 lhapdf \
 libgcc \
 libstdc++ \
 pythia8 \
 "
RDEPENDS:python3-pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 python3 \
 "
