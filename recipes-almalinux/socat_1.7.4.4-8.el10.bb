# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "socat"
PV = "1.7.4.4"
PR = "8.el10"
PACKAGES = " \
 socat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/socat-1.7.4.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b9e21f09e5aef00419686e76a44f1efc52b6168aa41e12c27633489a120deb3"

URI_x86_64_v2_socat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/socat-1.7.4.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_socat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_socat}"
SRC_URI[x86_64_v2_socat.sha256sum] = "37529e8a17531d225b80ac14a66ee5dab8d9b92d24bc5ed282cbd1179d00776f"

URI_aarch64_socat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/socat-1.7.4.4-8.el10.aarch64.rpm;name=aarch64_socat;unpack=0"
SRC_URI:append = " ${URI_aarch64_socat}"
SRC_URI[aarch64_socat.sha256sum] = "4a92a80192dac638210344d00d3c153c52afc1265257809439217b614ce4306a"

RDEPENDS:socat = " \
 glibc \
 openssl-libs \
 readline \
 "
