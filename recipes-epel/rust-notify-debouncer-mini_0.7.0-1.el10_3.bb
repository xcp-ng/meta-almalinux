# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-notify-debouncer-mini"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-notify-debouncer-mini+crossbeam-channel-devel \
 rust-notify-debouncer-mini+default-devel \
 rust-notify-debouncer-mini+flume-devel \
 rust-notify-debouncer-mini+serde-devel \
 rust-notify-debouncer-mini+serialization-compat-6-devel \
 rust-notify-debouncer-mini-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-notify-debouncer-mini-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56f5bc4910bce83c539253d4765af9fa5f1aa5943ba6e77d80cca39bb239300d"

URI_x86_64_v2_rust-notify-debouncer-mini+crossbeam-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-debouncer-mini+crossbeam-channel-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-debouncer-mini+crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-debouncer-mini+crossbeam-channel-devel}"
SRC_URI[x86_64_v2_rust-notify-debouncer-mini+crossbeam-channel-devel.sha256sum] = "f3f64f9c4aba3298f3603dc8cbaac824ed2b27824dd41842a1e6b6ea041bb52c"

URI_x86_64_v2_rust-notify-debouncer-mini+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-debouncer-mini+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-debouncer-mini+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-debouncer-mini+default-devel}"
SRC_URI[x86_64_v2_rust-notify-debouncer-mini+default-devel.sha256sum] = "2dfb0232857e74250a1384ec3abc01153361f321dcc6c40e477b7860e9105393"

URI_x86_64_v2_rust-notify-debouncer-mini+flume-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-debouncer-mini+flume-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-debouncer-mini+flume-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-debouncer-mini+flume-devel}"
SRC_URI[x86_64_v2_rust-notify-debouncer-mini+flume-devel.sha256sum] = "41798fb62b6c7a04c8288b1b77584cb24b430a4f57e50f6b8ec05d6b0b69aa58"

URI_x86_64_v2_rust-notify-debouncer-mini+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-debouncer-mini+serde-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-debouncer-mini+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-debouncer-mini+serde-devel}"
SRC_URI[x86_64_v2_rust-notify-debouncer-mini+serde-devel.sha256sum] = "458b85e4d7caffea304f79f0f10c29bab3e71e42abd6374eac0f819e6e07406b"

URI_x86_64_v2_rust-notify-debouncer-mini+serialization-compat-6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-debouncer-mini+serialization-compat-6-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-debouncer-mini+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-debouncer-mini+serialization-compat-6-devel}"
SRC_URI[x86_64_v2_rust-notify-debouncer-mini+serialization-compat-6-devel.sha256sum] = "ba04c6fe8c875a673a71c3fef1e23d71e72a003c2c7906d0af8fceb321f9fb16"

URI_x86_64_v2_rust-notify-debouncer-mini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-debouncer-mini-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-debouncer-mini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-debouncer-mini-devel}"
SRC_URI[x86_64_v2_rust-notify-debouncer-mini-devel.sha256sum] = "59d002e0fc414c1040de409a1fb2d38d9e01281182e6bf2b57e81db9304a6554"

URI_aarch64_rust-notify-debouncer-mini+crossbeam-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-debouncer-mini+crossbeam-channel-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-notify-debouncer-mini+crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-debouncer-mini+crossbeam-channel-devel}"
SRC_URI[aarch64_rust-notify-debouncer-mini+crossbeam-channel-devel.sha256sum] = "cee1220ab22ec4bf59db7f7c7e6d1992a39298852b361b4aeda50f616682992d"

URI_aarch64_rust-notify-debouncer-mini+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-debouncer-mini+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-notify-debouncer-mini+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-debouncer-mini+default-devel}"
SRC_URI[aarch64_rust-notify-debouncer-mini+default-devel.sha256sum] = "4fd9882ce5731e38f46a96ea46d1ddc5def29fb184181a5103dcb68ce0319c01"

URI_aarch64_rust-notify-debouncer-mini+flume-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-debouncer-mini+flume-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-notify-debouncer-mini+flume-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-debouncer-mini+flume-devel}"
SRC_URI[aarch64_rust-notify-debouncer-mini+flume-devel.sha256sum] = "2b5f0f4adc5be066c58f454e370195985ed5933aadb2f4515f57c04b6a494f32"

URI_aarch64_rust-notify-debouncer-mini+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-debouncer-mini+serde-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-notify-debouncer-mini+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-debouncer-mini+serde-devel}"
SRC_URI[aarch64_rust-notify-debouncer-mini+serde-devel.sha256sum] = "fe76e244f6190095f287724b3a282b1c32e58200b477e6e9f2c78b96840cb8df"

URI_aarch64_rust-notify-debouncer-mini+serialization-compat-6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-debouncer-mini+serialization-compat-6-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-notify-debouncer-mini+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-debouncer-mini+serialization-compat-6-devel}"
SRC_URI[aarch64_rust-notify-debouncer-mini+serialization-compat-6-devel.sha256sum] = "7550410bc8a044f6b5ba5b76c1b0afeaec329d799f78a35ac9e5227eb230e848"

URI_aarch64_rust-notify-debouncer-mini-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-debouncer-mini-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-notify-debouncer-mini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-debouncer-mini-devel}"
SRC_URI[aarch64_rust-notify-debouncer-mini-devel.sha256sum] = "cbfdf5dc71db9f9516bbcbe6fc37db2a95650279940eb02e98b3bba2379098b4"

RDEPENDS:rust-notify-debouncer-mini+crossbeam-channel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-notify+crossbeam-channel-devel \
 rust-notify-debouncer-mini-devel \
 "
RDEPENDS:rust-notify-debouncer-mini+default-devel = " \
 cargo \
 rust-notify-debouncer-mini-devel \
 "
RDEPENDS:rust-notify-debouncer-mini+flume-devel = " \
 cargo \
 rust-flume+default-devel \
 rust-notify+flume-devel \
 rust-notify-debouncer-mini-devel \
 "
RDEPENDS:rust-notify-debouncer-mini+serde-devel = " \
 cargo \
 rust-notify-debouncer-mini-devel \
 rust-notify-types+serde-devel \
 "
RDEPENDS:rust-notify-debouncer-mini+serialization-compat-6-devel = " \
 cargo \
 rust-notify+serialization-compat-6-devel \
 rust-notify-debouncer-mini-devel \
 "
RDEPENDS:rust-notify-debouncer-mini-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-notify+default-devel \
 rust-notify-types+default-devel \
 rust-tempfile+default-devel \
 "
