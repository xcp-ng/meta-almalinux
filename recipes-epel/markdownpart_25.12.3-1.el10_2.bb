# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "markdownpart"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 markdownpart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/markdownpart-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f95a8833d34d158339ebfdc42cfc6f872d55696ad610abd2ec2ca4cf1513561"

URI_x86_64_v2_markdownpart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/markdownpart-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_markdownpart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_markdownpart}"
SRC_URI[x86_64_v2_markdownpart.sha256sum] = "33782e40e305143033499434f5261d13ce30258af28e6f048530e07ab1ef909e"

URI_aarch64_markdownpart = "${EPEL_MIRROR}/aarch64/Packages/m/markdownpart-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_markdownpart;unpack=0"
SRC_URI:append = " ${URI_aarch64_markdownpart}"
SRC_URI[aarch64_markdownpart.sha256sum] = "750fa0496b1c85539a3b03a1466e8da5b7398fe9c2f8aeda3c6b38b10697467e"

RDEPENDS:markdownpart = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kparts \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
