# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire"
PV = "1.4.11"
PR = "1.el10_2"
PACKAGES = " \
 pipewire \
 pipewire-alsa \
 pipewire-devel \
 pipewire-gstreamer \
 pipewire-jack-audio-connection-kit \
 pipewire-jack-audio-connection-kit-devel \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pipewire-module-x11 \
 pipewire-plugin-libcamera \
 pipewire-pulseaudio \
 pipewire-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pipewire-1.4.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "821c090f99c516d910ab3aba71ca7ad54562662cf22ff1f428d91259d7f9cac6"

URI_x86_64_v2_pipewire = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire}"
SRC_URI[x86_64_v2_pipewire.sha256sum] = "1f73ed78b5c1f93f94d8cb805f41996461e55e81148ea22211239ef3a546f515"

URI_x86_64_v2_pipewire-alsa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-alsa-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-alsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-alsa}"
SRC_URI[x86_64_v2_pipewire-alsa.sha256sum] = "e90a5a9ec2eb180011ea06c77e822a9bf09a20fbbe81221a94f4bc1d27033083"

URI_x86_64_v2_pipewire-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-devel-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-devel}"
SRC_URI[x86_64_v2_pipewire-devel.sha256sum] = "02b3fa726cee7c29c43069a732a649d304f71104221578119be0d661d2d4fbfd"

URI_x86_64_v2_pipewire-gstreamer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-gstreamer-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-gstreamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-gstreamer}"
SRC_URI[x86_64_v2_pipewire-gstreamer.sha256sum] = "fd499ec8568962857c6e8b6b8af7b1e2c1d296ca005c0fc449814c520869b664"

URI_x86_64_v2_pipewire-jack-audio-connection-kit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit.sha256sum] = "75ad185157b3d1ca3027a893133b13bbcafc10fe11aef25a2192cda5d2fb9b63"

URI_x86_64_v2_pipewire-jack-audio-connection-kit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-devel-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit-devel}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-devel.sha256sum] = "74fd965bbc1fc863822a129b222878461a1283d9b726ac473a931443893f8282"

URI_x86_64_v2_pipewire-jack-audio-connection-kit-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-libs-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit-libs}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-libs.sha256sum] = "8b42ee6e6e1c97645aeb77ce9d986328087a0a81f135de963127f05806956652"

URI_x86_64_v2_pipewire-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-libs-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-libs}"
SRC_URI[x86_64_v2_pipewire-libs.sha256sum] = "7f0a9e39c0ac85910fa155e3d8cbf311f1c401926361a58dbaea97689d493368"

URI_x86_64_v2_pipewire-module-x11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-module-x11-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-module-x11}"
SRC_URI[x86_64_v2_pipewire-module-x11.sha256sum] = "50b6aff64f9f3cbccf2cd4a836ae59d5b5bae2ef1bd382cecbc0b9f584019731"

URI_x86_64_v2_pipewire-plugin-libcamera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-plugin-libcamera-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-plugin-libcamera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-plugin-libcamera}"
SRC_URI[x86_64_v2_pipewire-plugin-libcamera.sha256sum] = "702bea68c4ba94c322c6719697d9c097cbb919c9e36dfb22974fc74e347209ed"

URI_x86_64_v2_pipewire-pulseaudio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-pulseaudio-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-pulseaudio}"
SRC_URI[x86_64_v2_pipewire-pulseaudio.sha256sum] = "052f9edf2a721e6ee382f0932a9ef832c10e2531912487e3e234759251b3e176"

URI_x86_64_v2_pipewire-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-utils-1.4.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_pipewire-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-utils}"
SRC_URI[x86_64_v2_pipewire-utils.sha256sum] = "3c4c9209372f5219cbd448204547f4c31677f73365e835da0477ec1e454369da"

URI_aarch64_pipewire = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire}"
SRC_URI[aarch64_pipewire.sha256sum] = "0dc9b5cc9ea822117b24f942ec9189b7f67e8085c014f5fb1b0d3e715241766e"

URI_aarch64_pipewire-alsa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-alsa-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-alsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-alsa}"
SRC_URI[aarch64_pipewire-alsa.sha256sum] = "705f7177d361c933d43500dfc5d1e3cbcf9b4edc6f82eda46096f4591aa566b5"

URI_aarch64_pipewire-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-devel-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-devel}"
SRC_URI[aarch64_pipewire-devel.sha256sum] = "8385ff93a9a41afceb6020f6fb44d5def57b1023b0aec75636ff5ca5a90ae1e8"

URI_aarch64_pipewire-gstreamer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-gstreamer-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-gstreamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-gstreamer}"
SRC_URI[aarch64_pipewire-gstreamer.sha256sum] = "49b85cb148a65f0e92afd9d6f614157ed33f4ae0fb7963dfdef936d533964678"

URI_aarch64_pipewire-jack-audio-connection-kit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit.sha256sum] = "a45e1db88281f38a9089d8aed533247ddd389c408fe79c86e986b6f20e1e6d71"

URI_aarch64_pipewire-jack-audio-connection-kit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-devel-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit-devel}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-devel.sha256sum] = "a1a7265fcc8b9098d427164db71c68d96998dc05a03022b235e2bb0b38b08474"

URI_aarch64_pipewire-jack-audio-connection-kit-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-libs-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit-libs}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-libs.sha256sum] = "0ee1059e7d2b728e03707593ec097ef19b998546b4bf00bfc6509c36c5afe07e"

URI_aarch64_pipewire-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-libs-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-libs}"
SRC_URI[aarch64_pipewire-libs.sha256sum] = "453d185758d99cb30e724a2b99052851807965a352b5f86201bb7a962e923be3"

URI_aarch64_pipewire-module-x11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-module-x11-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-module-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-module-x11}"
SRC_URI[aarch64_pipewire-module-x11.sha256sum] = "5c98c9c9ff0930bfe2ae2bd9138fcfe5f745b93b77d7bb689aaa3a7906ed1ab9"

URI_aarch64_pipewire-plugin-libcamera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-plugin-libcamera-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-plugin-libcamera;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-plugin-libcamera}"
SRC_URI[aarch64_pipewire-plugin-libcamera.sha256sum] = "bcbf5206ca29c74b3b47f856ffa794610b78360e9088843abb550001509e67bb"

URI_aarch64_pipewire-pulseaudio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-pulseaudio-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-pulseaudio}"
SRC_URI[aarch64_pipewire-pulseaudio.sha256sum] = "e655c0b4d7c71800f5c5b995bacf889eac6aed79fa3400f410a452ce5ba70430"

URI_aarch64_pipewire-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-utils-1.4.11-1.el10_2.aarch64.rpm;name=aarch64_pipewire-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-utils}"
SRC_URI[aarch64_pipewire-utils.sha256sum] = "239c55aba3ec022c058803a2521e087b9ca69f9c0f8c0e1d14d870038b5a2a14"

RDEPENDS:pipewire = " \
 bash \
 glibc \
 pipewire-libs \
 rtkit \
 systemd \
 wireplumber \
 "
RDEPENDS:pipewire-alsa = " \
 alsa-lib \
 glibc \
 pipewire-libs \
 "
RDEPENDS:pipewire-devel = " \
 pipewire-devel \
 pipewire-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 pipewire-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit = " \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-devel = " \
 pipewire-jack-audio-connection-kit-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-libs = " \
 bash \
 glibc \
 pipewire-jack-audio-connection-kit \
 pipewire-libs \
 "
RDEPENDS:pipewire-libs = " \
 alsa-lib \
 avahi-libs \
 bluez-libs \
 dbus-libs \
 fdk-aac-free \
 fftw-libs-single \
 glib2 \
 glibc \
 libgcc \
 liblc3 \
 libldac \
 libsbc \
 libselinux \
 libsndfile \
 libstdc++ \
 libusb1 \
 openssl-libs \
 opus \
 pulseaudio-libs \
 systemd-libs \
 webrtc-audio-processing \
 "
RDEPENDS:pipewire-module-x11 = " \
 glibc \
 libX11 \
 libXfixes \
 libcanberra \
 pipewire-libs \
 "
RDEPENDS:pipewire-plugin-libcamera = " \
 glibc \
 libcamera \
 libdrm \
 libgcc \
 libstdc++ \
 pipewire-libs \
 "
RDEPENDS:pipewire-pulseaudio = " \
 avahi-libs \
 bash \
 dbus-libs \
 glib2 \
 glibc \
 libgcc \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:pipewire-utils = " \
 alsa-lib \
 dbus-libs \
 glibc \
 libgcc \
 libsndfile \
 ncurses-libs \
 pipewire \
 pipewire-libs \
 readline \
 "
