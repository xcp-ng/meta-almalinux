# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-socksio"
PV = "1.0.0"
PR = "15.el10_0"
PACKAGES = " \
 python3-socksio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-socksio-1.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bdbbd5b5233b3153f7ac11f08e44bc2c54cd8ca2a2dd01fddbd55856d5eaa42"

URI_x86_64_v2_python3-socksio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-socksio-1.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-socksio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-socksio}"
SRC_URI[x86_64_v2_python3-socksio.sha256sum] = "324a6b8c4642fbb814a2c54c0cf3aef79563db14e27dea893f4367e0632cf20c"

URI_aarch64_python3-socksio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-socksio-1.0.0-15.el10_0.noarch.rpm;name=aarch64_python3-socksio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-socksio}"
SRC_URI[aarch64_python3-socksio.sha256sum] = "38b13fd448a9a2762d3382b5f199df781de4bc76c11fe28f569d7f1f0060fbe6"

RDEPENDS:python3-socksio = " \
 python3 \
 "
