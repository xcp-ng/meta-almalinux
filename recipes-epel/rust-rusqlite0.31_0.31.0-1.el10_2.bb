# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusqlite0.31"
PV = "0.31.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rusqlite0.31+array-devel \
 rust-rusqlite0.31+backup-devel \
 rust-rusqlite0.31+blob-devel \
 rust-rusqlite0.31+buildtime_bindgen-devel \
 rust-rusqlite0.31+chrono-devel \
 rust-rusqlite0.31+collation-devel \
 rust-rusqlite0.31+column_decltype-devel \
 rust-rusqlite0.31+csv-devel \
 rust-rusqlite0.31+csvtab-devel \
 rust-rusqlite0.31+default-devel \
 rust-rusqlite0.31+extra_check-devel \
 rust-rusqlite0.31+functions-devel \
 rust-rusqlite0.31+hooks-devel \
 rust-rusqlite0.31+i128_blob-devel \
 rust-rusqlite0.31+limits-devel \
 rust-rusqlite0.31+load_extension-devel \
 rust-rusqlite0.31+modern-full-devel \
 rust-rusqlite0.31+modern_sqlite-devel \
 rust-rusqlite0.31+release_memory-devel \
 rust-rusqlite0.31+serde_json-devel \
 rust-rusqlite0.31+serialize-devel \
 rust-rusqlite0.31+series-devel \
 rust-rusqlite0.31+session-devel \
 rust-rusqlite0.31+time-devel \
 rust-rusqlite0.31+trace-devel \
 rust-rusqlite0.31+unlock_notify-devel \
 rust-rusqlite0.31+url-devel \
 rust-rusqlite0.31+uuid-devel \
 rust-rusqlite0.31+vtab-devel \
 rust-rusqlite0.31+window-devel \
 rust-rusqlite0.31-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rusqlite0.31-0.31.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3af778249cda6af66db606d4ac8495e5692bbcd59cd77ff9590dc4dd4c725927"

URI_x86_64_v2_rust-rusqlite0.31+array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+array-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+array-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+array-devel.sha256sum] = "656a6873e1a17274bd8f879c86f09b2d20bd606353457b97a6c28e7aaa9cc86a"

URI_x86_64_v2_rust-rusqlite0.31+backup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+backup-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+backup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+backup-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+backup-devel.sha256sum] = "d1b7ad0099c5fc81815b077beae0985f965c5e3e5e799417279d6ff0df2db0f8"

URI_x86_64_v2_rust-rusqlite0.31+blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+blob-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+blob-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+blob-devel.sha256sum] = "7700d1a45a56fd84efb22523eb41d50995603fe35297f98850b65ef2949908d8"
RPROVIDES:rust-rusqlite0.31+blob-devel:x86_64_v2 = "virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.40.0~"

URI_x86_64_v2_rust-rusqlite0.31+buildtime_bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+buildtime_bindgen-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+buildtime_bindgen-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+buildtime_bindgen-devel.sha256sum] = "2ce53535d3c5c321b3d901c5f5879641a8ae27c2b697d419d2fc547dbb7079c2"

URI_x86_64_v2_rust-rusqlite0.31+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+chrono-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+chrono-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+chrono-devel.sha256sum] = "dd71a8b053a7d2522dd73adff6da93cc2f30bb09afbe6ae2dce72f4f70f637ca"

URI_x86_64_v2_rust-rusqlite0.31+collation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+collation-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+collation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+collation-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+collation-devel.sha256sum] = "184b776a45c58f3e3e0200204969284e46148b1e92b673f2fc0c43ad0470c81e"
RPROVIDES:rust-rusqlite0.31+collation-devel:x86_64_v2 = "virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.40.0~"

URI_x86_64_v2_rust-rusqlite0.31+column_decltype-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+column_decltype-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+column_decltype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+column_decltype-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+column_decltype-devel.sha256sum] = "fc71ae86e92b25d56810359e13c540bcf719a036e3956e10b432c85aede436a4"

URI_x86_64_v2_rust-rusqlite0.31+csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+csv-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+csv-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+csv-devel.sha256sum] = "8fb730f46fd7e2368687c5c531c0f3dc809c800e93f0158dfecb44ec14ec6a85"

URI_x86_64_v2_rust-rusqlite0.31+csvtab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+csvtab-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+csvtab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+csvtab-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+csvtab-devel.sha256sum] = "b595e22deada02add721de4f5658ae72919fa3a1222d4b745fecb4257b1258b0"

URI_x86_64_v2_rust-rusqlite0.31+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+default-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+default-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+default-devel.sha256sum] = "6aa4a127c5bc0bc8b8f19ca50ad02ebf044b56caca42964eb70e2fe39e2724c4"
RPROVIDES:rust-rusqlite0.31+default-devel:x86_64_v2 = "virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.40.0~"

URI_x86_64_v2_rust-rusqlite0.31+extra_check-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+extra_check-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+extra_check-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+extra_check-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+extra_check-devel.sha256sum] = "387ceb38351b400430be40dc2da2deb07460a7984c9268d9cd0cb86191e0f607"

URI_x86_64_v2_rust-rusqlite0.31+functions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+functions-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+functions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+functions-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+functions-devel.sha256sum] = "f65b085ea1ccda9a957af6aa7917544783a02a7969f32365d9c0e5c4b9e915c1"

URI_x86_64_v2_rust-rusqlite0.31+hooks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+hooks-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+hooks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+hooks-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+hooks-devel.sha256sum] = "cb15de35fa80048a077d4c6e5eef6c4ebb3f94240d6f4f8779991d9bca721a7d"

URI_x86_64_v2_rust-rusqlite0.31+i128_blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+i128_blob-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+i128_blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+i128_blob-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+i128_blob-devel.sha256sum] = "7cae421fd4b9a5992e92438f406b8e6c7ef12c6cc33fefac424001fba7d88f09"

URI_x86_64_v2_rust-rusqlite0.31+limits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+limits-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+limits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+limits-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+limits-devel.sha256sum] = "9a0ce53299a23dccbe84ac9843f888e698e5896624e3618b4d77ee9dfd255b5d"

URI_x86_64_v2_rust-rusqlite0.31+load_extension-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+load_extension-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+load_extension-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+load_extension-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+load_extension-devel.sha256sum] = "db215e19471e9fa4692fc420f820c7367fe2bce07bca7f4c8fa8fd6e8d0f7de0"

URI_x86_64_v2_rust-rusqlite0.31+modern-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+modern-full-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+modern-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+modern-full-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+modern-full-devel.sha256sum] = "d411b793ff8fe4f2a0531108807be8875d7b96af3841b7223811342575809a5b"

URI_x86_64_v2_rust-rusqlite0.31+modern_sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+modern_sqlite-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+modern_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+modern_sqlite-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+modern_sqlite-devel.sha256sum] = "d060f3f6a821d01cb2f2d62b002c50c6d400b5dc5228fa7531c10f6d8051e7e2"

URI_x86_64_v2_rust-rusqlite0.31+release_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+release_memory-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+release_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+release_memory-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+release_memory-devel.sha256sum] = "3e930873682dd6d1f7721ab685069f9652e4e256951984728712ae77a13e2566"

URI_x86_64_v2_rust-rusqlite0.31+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+serde_json-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+serde_json-devel.sha256sum] = "afbdde0a715f57a0d3f94aba120d93f7efbf06b719f02c0413d58a94feb6fe5f"

URI_x86_64_v2_rust-rusqlite0.31+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+serialize-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+serialize-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+serialize-devel.sha256sum] = "34818c4f6927002a5970eb35fd89844e3722a04f9928e10e21d00c24a89d56af"

URI_x86_64_v2_rust-rusqlite0.31+series-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+series-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+series-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+series-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+series-devel.sha256sum] = "e8097059ad12a569fa68b3fc6460c1935d4fc9b86f302319ff66ce1e14074490"

URI_x86_64_v2_rust-rusqlite0.31+session-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+session-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+session-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+session-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+session-devel.sha256sum] = "c17cf2835b8734dffb916389b764484bd5c08a08dea7fccd55f678653ce92041"

URI_x86_64_v2_rust-rusqlite0.31+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+time-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+time-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+time-devel.sha256sum] = "762d7d12a9812c0c192146d51da89053e2834e7e28f2f74e521d31c029d01c8a"

URI_x86_64_v2_rust-rusqlite0.31+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+trace-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+trace-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+trace-devel.sha256sum] = "267931261573e92043031c5c815a331c06b38d15e5f192c1215a340263a7f213"
RPROVIDES:rust-rusqlite0.31+trace-devel:x86_64_v2 = "virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.40.0~"

URI_x86_64_v2_rust-rusqlite0.31+unlock_notify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+unlock_notify-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+unlock_notify-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+unlock_notify-devel.sha256sum] = "a99d6108bd94bc1827dbfd02e9b332ca89a1a00482a76afda2e11881307fefba"

URI_x86_64_v2_rust-rusqlite0.31+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+url-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+url-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+url-devel.sha256sum] = "299e415648efb65031901437e1683d7ef173736728230478681a6dbff01d0e5d"

URI_x86_64_v2_rust-rusqlite0.31+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+uuid-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+uuid-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+uuid-devel.sha256sum] = "6a91550d1ad0ebd58864be7656dd5c9eaa6341225eddab22df1a30e6aa2451d6"

URI_x86_64_v2_rust-rusqlite0.31+vtab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+vtab-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+vtab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+vtab-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+vtab-devel.sha256sum] = "bb866ab897dcfe1d402620d3df34c6f54007954784e2d4f4017667211ce13145"

URI_x86_64_v2_rust-rusqlite0.31+window-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31+window-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31+window-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31+window-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31+window-devel.sha256sum] = "e74b0fdc87dc05b472d2946fd4ff5bbd415ecf332512b6ab1d6b89d1067e8e5d"

URI_x86_64_v2_rust-rusqlite0.31-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite0.31-devel-0.31.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite0.31-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite0.31-devel}"
SRC_URI[x86_64_v2_rust-rusqlite0.31-devel.sha256sum] = "2a8cda78826f5610f1748db0faefb198983bb8834f17ca88c379154c5ca34bc8"

URI_aarch64_rust-rusqlite0.31+array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+array-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+array-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+array-devel.sha256sum] = "95fde22db636b5e4fc7172197f4143c71475b21a76602eb29a2b00f203ee8266"

URI_aarch64_rust-rusqlite0.31+backup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+backup-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+backup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+backup-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+backup-devel.sha256sum] = "dc6fe656df6231360f42c028a769c5bd458b619c8b1778b3cd3167e21a88a53b"

URI_aarch64_rust-rusqlite0.31+blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+blob-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+blob-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+blob-devel.sha256sum] = "fd59e27d94d3a0a444f8f2373cff8b5776769f1a32a6632194062b0309ac3091"
RPROVIDES:rust-rusqlite0.31+blob-devel:aarch64 = "virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.40.0~"

URI_aarch64_rust-rusqlite0.31+buildtime_bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+buildtime_bindgen-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+buildtime_bindgen-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+buildtime_bindgen-devel.sha256sum] = "1fa6712c4e97d9e0e8bfba11257641b41f32d8790f38fcee9ac513d1ab81f2c6"

URI_aarch64_rust-rusqlite0.31+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+chrono-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+chrono-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+chrono-devel.sha256sum] = "a0667f1ca24f5d08452a6b4e38681502276e88d40bc4ccae6382769ec28f5edd"

URI_aarch64_rust-rusqlite0.31+collation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+collation-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+collation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+collation-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+collation-devel.sha256sum] = "dcd95789e902d4a16fc6ee7bc235934a4cdbd119a951602599c455863b93e7ed"
RPROVIDES:rust-rusqlite0.31+collation-devel:aarch64 = "virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.40.0~"

URI_aarch64_rust-rusqlite0.31+column_decltype-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+column_decltype-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+column_decltype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+column_decltype-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+column_decltype-devel.sha256sum] = "9350344c7763c69da10f8f4ec159cbc88ca5c5e7b5a09c673fffe6be00e9468e"

URI_aarch64_rust-rusqlite0.31+csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+csv-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+csv-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+csv-devel.sha256sum] = "2da36a7a8fc0e85a76dc3a8563e7b7fe4969ff26178860a0131000fc14bfbbad"

URI_aarch64_rust-rusqlite0.31+csvtab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+csvtab-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+csvtab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+csvtab-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+csvtab-devel.sha256sum] = "5b64b30d91ab162876035e87d1ca3b52ad98decff5d511a0495cd0becd5ea46a"

URI_aarch64_rust-rusqlite0.31+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+default-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+default-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+default-devel.sha256sum] = "ae01d0373f608d9b4d4242db6cfab0a15521b5f67addea275cde67755c87e470"
RPROVIDES:rust-rusqlite0.31+default-devel:aarch64 = "virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.40.0~"

URI_aarch64_rust-rusqlite0.31+extra_check-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+extra_check-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+extra_check-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+extra_check-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+extra_check-devel.sha256sum] = "119bc91508b7a0f3a7967fb73e8358891ef766d17b6437922212018a7ade2dc8"

URI_aarch64_rust-rusqlite0.31+functions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+functions-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+functions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+functions-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+functions-devel.sha256sum] = "11e5b01eb9c3076522a058b5ed965ae126dbf986921686524f1f9a6d595dde1d"

URI_aarch64_rust-rusqlite0.31+hooks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+hooks-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+hooks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+hooks-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+hooks-devel.sha256sum] = "af559127179df48a77245c7836f36e146af972a03795dc47e9bd0caa9c244799"

URI_aarch64_rust-rusqlite0.31+i128_blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+i128_blob-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+i128_blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+i128_blob-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+i128_blob-devel.sha256sum] = "42d3f6663cc8fae1b4efeaed773ec0be5e576647351f46f9b87533fea0f02850"

URI_aarch64_rust-rusqlite0.31+limits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+limits-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+limits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+limits-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+limits-devel.sha256sum] = "abe3d607940cb30d7e324c9053aeb42090e7156dd452f44fe1511a5ae4c1bc28"

URI_aarch64_rust-rusqlite0.31+load_extension-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+load_extension-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+load_extension-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+load_extension-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+load_extension-devel.sha256sum] = "950b674c96ee8985f31d26c6874cd6e8ad8032e2cfa475675663fd429849c669"

URI_aarch64_rust-rusqlite0.31+modern-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+modern-full-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+modern-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+modern-full-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+modern-full-devel.sha256sum] = "02b41cae539b789192ca0a3f3abc537267c2cbca1ee6f6be979902e2e6fda4c4"

URI_aarch64_rust-rusqlite0.31+modern_sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+modern_sqlite-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+modern_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+modern_sqlite-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+modern_sqlite-devel.sha256sum] = "f96b44f1fcd65fdb8658d36b27923a039540735d5b723a7f451594bc2d1eaab2"

URI_aarch64_rust-rusqlite0.31+release_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+release_memory-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+release_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+release_memory-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+release_memory-devel.sha256sum] = "5d941136de4948348a807edf4b19fb7a5ca339bb31d15012a5a4c16dba355628"

URI_aarch64_rust-rusqlite0.31+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+serde_json-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+serde_json-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+serde_json-devel.sha256sum] = "44f542f320188cc7a3490aaa1f166f9302c1c534f8521e5f1eb65132f2d1855a"

URI_aarch64_rust-rusqlite0.31+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+serialize-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+serialize-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+serialize-devel.sha256sum] = "ed2adec335056f35a0c0870157545c34198a39347274d3cdbe7e081712d2373b"

URI_aarch64_rust-rusqlite0.31+series-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+series-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+series-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+series-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+series-devel.sha256sum] = "529685c3dce0f4c0e2bcae791e460b5f313b6f4da84c9b798e0af11b5b2762a9"

URI_aarch64_rust-rusqlite0.31+session-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+session-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+session-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+session-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+session-devel.sha256sum] = "7b08666b1e8861f9b52ef00245cf5f3267ab61f81b8d1bf5b5fdb108d2d53100"

URI_aarch64_rust-rusqlite0.31+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+time-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+time-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+time-devel.sha256sum] = "cdc84655fb2900c91b668d2ec2522a451dc6e051b783c64739cc880fa8702373"

URI_aarch64_rust-rusqlite0.31+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+trace-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+trace-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+trace-devel.sha256sum] = "6df91576ba572c746a42958138a730577fe14050d4f7d7ab20072b1cc15ccd39"
RPROVIDES:rust-rusqlite0.31+trace-devel:aarch64 = "virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.40.0~"

URI_aarch64_rust-rusqlite0.31+unlock_notify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+unlock_notify-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+unlock_notify-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+unlock_notify-devel.sha256sum] = "e593365cad0d5f341ee71f5f01a780cb251ab4d84337aacbcfe55a87173bbaf3"

URI_aarch64_rust-rusqlite0.31+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+url-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+url-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+url-devel.sha256sum] = "fbcac6598399ab1b72d622657f8fccb41a89b610fdfa6adee9bf500f80691b95"

URI_aarch64_rust-rusqlite0.31+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+uuid-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+uuid-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+uuid-devel.sha256sum] = "d230bf54dbbda0698d29077cc6320fbb7654c6f8bd9fa8097fbe080a70e6b1fb"

URI_aarch64_rust-rusqlite0.31+vtab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+vtab-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+vtab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+vtab-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+vtab-devel.sha256sum] = "918c05a24bbd54c465d19ee1ccd62f2fbc8e2bd74bf24353fe27533ca6a73fd2"

URI_aarch64_rust-rusqlite0.31+window-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31+window-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31+window-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31+window-devel}"
SRC_URI[aarch64_rust-rusqlite0.31+window-devel.sha256sum] = "551622bdfff048cf450a815ddfc58ac64dabf2d2686f49dfede6ef00d09ba151"

URI_aarch64_rust-rusqlite0.31-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite0.31-devel-0.31.0-1.el10_2.noarch.rpm;name=aarch64_rust-rusqlite0.31-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite0.31-devel}"
SRC_URI[aarch64_rust-rusqlite0.31-devel.sha256sum] = "ea5abe967406f17025a54f66d01c03053b11c6c7206f22cd09004f3fb45fa399"

RDEPENDS:rust-rusqlite0.31+array-devel = " \
 cargo \
 rust-rusqlite0.31+vtab-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+backup-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+blob-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+buildtime_bindgen-devel = " \
 cargo \
 rust-libsqlite3-sys0.28+buildtime_bindgen-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+collation-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+column_decltype-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+csv-devel = " \
 cargo \
 rust-csv+default-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+csvtab-devel = " \
 cargo \
 rust-rusqlite0.31+csv-devel \
 rust-rusqlite0.31+vtab-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+default-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+extra_check-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+functions-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+hooks-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+i128_blob-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+limits-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+load_extension-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+modern-full-devel = " \
 cargo \
 rust-rusqlite0.31+array-devel \
 rust-rusqlite0.31+backup-devel \
 rust-rusqlite0.31+blob-devel \
 rust-rusqlite0.31+chrono-devel \
 rust-rusqlite0.31+collation-devel \
 rust-rusqlite0.31+column_decltype-devel \
 rust-rusqlite0.31+csvtab-devel \
 rust-rusqlite0.31+extra_check-devel \
 rust-rusqlite0.31+functions-devel \
 rust-rusqlite0.31+hooks-devel \
 rust-rusqlite0.31+i128_blob-devel \
 rust-rusqlite0.31+limits-devel \
 rust-rusqlite0.31+load_extension-devel \
 rust-rusqlite0.31+modern_sqlite-devel \
 rust-rusqlite0.31+serde_json-devel \
 rust-rusqlite0.31+series-devel \
 rust-rusqlite0.31+time-devel \
 rust-rusqlite0.31+trace-devel \
 rust-rusqlite0.31+unlock_notify-devel \
 rust-rusqlite0.31+url-devel \
 rust-rusqlite0.31+uuid-devel \
 rust-rusqlite0.31+vtab-devel \
 rust-rusqlite0.31+window-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+modern_sqlite-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+release_memory-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+serde_json-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rusqlite0.31+serialize-devel = " \
 cargo \
 rust-rusqlite0.31+modern_sqlite-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+series-devel = " \
 cargo \
 rust-rusqlite0.31+vtab-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+session-devel = " \
 cargo \
 rust-libsqlite3-sys0.28+session-devel \
 rust-rusqlite0.31+hooks-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+time-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-rusqlite0.31+trace-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+unlock_notify-devel = " \
 cargo \
 rust-libsqlite3-sys0.28+unlock_notify-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+url-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-rusqlite0.31+uuid-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-rusqlite0.31+vtab-devel = " \
 cargo \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31+window-devel = " \
 cargo \
 rust-rusqlite0.31+functions-devel \
 rust-rusqlite0.31-devel \
 "
RDEPENDS:rust-rusqlite0.31-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-fallible-iterator+default-devel \
 rust-fallible-streaming-iterator+default-devel \
 rust-hashlink0.10+default-devel \
 rust-libsqlite3-sys0.28+default-devel \
 rust-smallvec+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.40.0~ rpm/virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.40.0~ rpm/virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.40.0~ rpm/virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.40.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_rusqlite/blob__ge_0.29.0_with_crate_rusqlite/blob__lt_0.40.0~ rpm/virtual/crate_rusqlite/collation__ge_0.29.0_with_crate_rusqlite/collation__lt_0.40.0~ rpm/virtual/crate_rusqlite/default__ge_0.29.0_with_crate_rusqlite/default__lt_0.40.0~ rpm/virtual/crate_rusqlite/trace__ge_0.29.0_with_crate_rusqlite/trace__lt_0.40.0~"
