# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgxps"
PV = "0.3.2"
PR = "10.el10"
PACKAGES = " \
 libgxps \
 libgxps-devel \
 libgxps-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libgxps-0.3.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1190889190f707d986e90ab81c38460379125a5814eec0441661f660c2394a86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgxps-0.3.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libgxps;unpack=0"
SRC_URI[x86_64_v2_libgxps.sha256sum] = "d8a3d9ea4cf6cd761aeaae5445763d83bfec18875c838848cf908b2029cca8f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgxps-devel-0.3.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libgxps-devel;unpack=0"
SRC_URI[x86_64_v2_libgxps-devel.sha256sum] = "aa64e01277c45774704eea7b63a99b75570a7308a9059e763eda3d12db656305"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgxps-tools-0.3.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libgxps-tools;unpack=0"
SRC_URI[x86_64_v2_libgxps-tools.sha256sum] = "01f875f2fb3c627387e94ebf0a906bfb5ca85296b03f02edd7b1f4f0b2f6ca8b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgxps-0.3.2-10.el10.aarch64.rpm;name=aarch64_libgxps;unpack=0"
SRC_URI[aarch64_libgxps.sha256sum] = "390a1a2af1a2ab5bb88e269daa17e24aff2feb146776e859e00e8c1e5a455744"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgxps-devel-0.3.2-10.el10.aarch64.rpm;name=aarch64_libgxps-devel;unpack=0"
SRC_URI[aarch64_libgxps-devel.sha256sum] = "0354d1ec82146635e25c61b580a695014b3ebdb6b346da493fed5216edb5515c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgxps-tools-0.3.2-10.el10.aarch64.rpm;name=aarch64_libgxps-tools;unpack=0"
SRC_URI[aarch64_libgxps-tools.sha256sum] = "10fca4c5fd63d54576e494ff8129fa46fa672942de39dea68489c7b9c1d07f33"

RDEPENDS:libgxps = " \
 cairo \
 freetype \
 glib2 \
 glibc \
 lcms2 \
 libarchive \
 libjpeg-turbo \
 libpng \
 libtiff \
 "
RDEPENDS:libgxps-devel = " \
 cairo-devel \
 glib2-devel \
 libarchive-devel \
 libgxps \
 pkgconf-pkg-config \
 "
RDEPENDS:libgxps-tools = " \
 cairo \
 glib2 \
 glibc \
 libgxps \
 libjpeg-turbo \
 libpng \
 "
