# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-webpki"
PV = "0.103.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki+default-devel \
 rust-rustls-webpki+ring-devel \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-webpki-0.103.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe1eb10c5b1dbfba999d77d0dfdc808c101e67e191c27ea973e5536f4185b5a7"

URI_x86_64_v2_rust-rustls-webpki+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+alloc-devel-0.103.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+alloc-devel.sha256sum] = "7e2e1d50c79730f01c1c92477f9f32c571913fea28e0e6bedc1ef5a113916dd2"

URI_x86_64_v2_rust-rustls-webpki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+default-devel-0.103.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+default-devel.sha256sum] = "ba9f47ebb4e7d0d10c5cc3b5a596426f03a1cd1e43a91c2cf742bdda6028b5d7"

URI_x86_64_v2_rust-rustls-webpki+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+ring-devel-0.103.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+ring-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+ring-devel.sha256sum] = "00b546be073b9efcefdc92273d33b3886228be8e69a01069d8e30f6c6f2d8d63"

URI_x86_64_v2_rust-rustls-webpki+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+std-devel-0.103.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+std-devel.sha256sum] = "6fc5905b3a9bdda8be29c8aa69bd48a66c15304759f648b35ccbee68a2f82468"

URI_x86_64_v2_rust-rustls-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki-devel-0.103.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki-devel.sha256sum] = "49911e3552210412d5e147bb278e6436cdecf8632b8a2af8f25a67fa57135ea0"

URI_aarch64_rust-rustls-webpki+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+alloc-devel-0.103.13-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+alloc-devel}"
SRC_URI[aarch64_rust-rustls-webpki+alloc-devel.sha256sum] = "d9804b881ebd2884e1c6f8c2c158ee59343b1f8eede18c786099c14f795c5166"

URI_aarch64_rust-rustls-webpki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+default-devel-0.103.13-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+default-devel}"
SRC_URI[aarch64_rust-rustls-webpki+default-devel.sha256sum] = "474adc8521c1b14c2659c76681214c2bf42b175104f488bfdbe32b93a05cc6ae"

URI_aarch64_rust-rustls-webpki+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+ring-devel-0.103.13-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+ring-devel}"
SRC_URI[aarch64_rust-rustls-webpki+ring-devel.sha256sum] = "c3a1f7aaa82a7be1931c24467b107b9475241842dc400920e26b17c898552267"

URI_aarch64_rust-rustls-webpki+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+std-devel-0.103.13-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+std-devel}"
SRC_URI[aarch64_rust-rustls-webpki+std-devel.sha256sum] = "803e7aaec6ba4420437e3a2614de86f70e01ff88a9e3658b25ac7e0ab38c8506"

URI_aarch64_rust-rustls-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki-devel-0.103.13-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki-devel}"
SRC_URI[aarch64_rust-rustls-webpki-devel.sha256sum] = "649b3df5688d8907a0f3236a40133e49ab459a44d9823f944d529ce4da668ee4"

RDEPENDS:rust-rustls-webpki+alloc-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+default-devel = " \
 cargo \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+ring-devel = " \
 cargo \
 rust-ring-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+std-devel = " \
 cargo \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 rust-untrusted+default-devel \
 "
