# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-link-cplusplus"
PV = "1.0.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-link-cplusplus+default-devel \
 rust-link-cplusplus+libc++-devel \
 rust-link-cplusplus+libcxx-devel \
 rust-link-cplusplus+libstdc++-devel \
 rust-link-cplusplus+libstdcxx-devel \
 rust-link-cplusplus+nothing-devel \
 rust-link-cplusplus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-link-cplusplus-1.0.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df607ca7b456ec8a547f6ef9ae93dd9b33d07a51f5ae2115543755e6efe4bcb8"

URI_x86_64_v2_rust-link-cplusplus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+default-devel-1.0.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+default-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+default-devel.sha256sum] = "55082ab11531ffff5caa7c24ef0e774594f2e5b448f2a722115bb7f6f03badb8"

URI_x86_64_v2_rust-link-cplusplus+libc++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libc++-devel-1.0.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libc++-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libc++-devel.sha256sum] = "9f34c933fcac37ea71a06662deb7afc8325282f674264d784d88a381289ff7d3"

URI_x86_64_v2_rust-link-cplusplus+libcxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libcxx-devel-1.0.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libcxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libcxx-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libcxx-devel.sha256sum] = "f59520a4a6ed6ac7672e2ca0a950a8719d6832ad19b37fae7afa945ba03e62b6"

URI_x86_64_v2_rust-link-cplusplus+libstdc++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libstdc++-devel-1.0.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libstdc++-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libstdc++-devel.sha256sum] = "cf4cffecfe763ab0dc741cc4252084e58c5e37af774a6fc855878f3bce50d7e3"

URI_x86_64_v2_rust-link-cplusplus+libstdcxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libstdcxx-devel-1.0.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libstdcxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libstdcxx-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libstdcxx-devel.sha256sum] = "f6b92c4dd49bfac19cca5c55966bb0f40286fefbe5d6538517654c6cc34630a8"

URI_x86_64_v2_rust-link-cplusplus+nothing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+nothing-devel-1.0.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+nothing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+nothing-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+nothing-devel.sha256sum] = "f2cca1d7b3937d3cef019716cc2b354153499470c171bf742bc93ece45cee667"

URI_x86_64_v2_rust-link-cplusplus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus-devel-1.0.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus-devel.sha256sum] = "57cc58878eeb59b0b8cd50059a2922ab23113b50fe4809248f9efd24cdd79b48"

URI_aarch64_rust-link-cplusplus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+default-devel-1.0.12-1.el10_2.noarch.rpm;name=aarch64_rust-link-cplusplus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+default-devel}"
SRC_URI[aarch64_rust-link-cplusplus+default-devel.sha256sum] = "9dd533caea257dc3553c8d7f34a5d6cabeda01b132c95632f413f18fdd4fee13"

URI_aarch64_rust-link-cplusplus+libc++-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libc++-devel-1.0.12-1.el10_2.noarch.rpm;name=aarch64_rust-link-cplusplus+libc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libc++-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libc++-devel.sha256sum] = "b8c1acb3b5b16a4bc67e57ecfb5292324b14a0d646602b5ce1cd9ccdfa1fff80"

URI_aarch64_rust-link-cplusplus+libcxx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libcxx-devel-1.0.12-1.el10_2.noarch.rpm;name=aarch64_rust-link-cplusplus+libcxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libcxx-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libcxx-devel.sha256sum] = "98bb15f001f26d689203e8cf7c3b05b8f11818932cc449bf9c7f0333bda4b6e8"

URI_aarch64_rust-link-cplusplus+libstdc++-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libstdc++-devel-1.0.12-1.el10_2.noarch.rpm;name=aarch64_rust-link-cplusplus+libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libstdc++-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libstdc++-devel.sha256sum] = "c54843a785cafbf5ac4e3c0172fc7bee9902c700f93f95d5c54a3dc8fa98eb3e"

URI_aarch64_rust-link-cplusplus+libstdcxx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libstdcxx-devel-1.0.12-1.el10_2.noarch.rpm;name=aarch64_rust-link-cplusplus+libstdcxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libstdcxx-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libstdcxx-devel.sha256sum] = "a6e1dd1d27e5d00196fd3ba7dcaa77b4d59eec763ea4aca7f45f5f188b24946c"

URI_aarch64_rust-link-cplusplus+nothing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+nothing-devel-1.0.12-1.el10_2.noarch.rpm;name=aarch64_rust-link-cplusplus+nothing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+nothing-devel}"
SRC_URI[aarch64_rust-link-cplusplus+nothing-devel.sha256sum] = "25b9a15e4cc5475de1f584a53435b5365c7275642839683cddc3cd6416bf97c4"

URI_aarch64_rust-link-cplusplus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus-devel-1.0.12-1.el10_2.noarch.rpm;name=aarch64_rust-link-cplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus-devel}"
SRC_URI[aarch64_rust-link-cplusplus-devel.sha256sum] = "430e6937feba180461057a3e1ffa3bf5a62aad2c0a95d38f4c72f7f56b54c563"

RDEPENDS:rust-link-cplusplus+default-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libc++-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libcxx-devel = " \
 cargo \
 rust-link-cplusplus+libc++-devel \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libstdc++-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libstdcxx-devel = " \
 cargo \
 rust-link-cplusplus+libstdc++-devel \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+nothing-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 "
