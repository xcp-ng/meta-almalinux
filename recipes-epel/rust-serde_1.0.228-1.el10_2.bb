# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde"
PV = "1.0.228"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde+alloc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde+serde_derive-devel \
 rust-serde+std-devel \
 rust-serde+unstable-devel \
 rust-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde-1.0.228-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d29c9a36bd75d98fbc3f85d5d39b4117064c699ceffbfac3b94cf6c2a52697ed"

URI_x86_64_v2_rust-serde+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+alloc-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde+alloc-devel.sha256sum] = "dd0836f8edda5e93e050108ff70931a65b676ed01c5bfbd1a7cade95a4092526"

URI_x86_64_v2_rust-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+default-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+default-devel}"
SRC_URI[x86_64_v2_rust-serde+default-devel.sha256sum] = "677b23be43e65ffbe9431f78b78273f097798d8579aceac34db7db159faa9ffc"

URI_x86_64_v2_rust-serde+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+derive-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+derive-devel}"
SRC_URI[x86_64_v2_rust-serde+derive-devel.sha256sum] = "f62e1d6b8a0b90cb950f27fe2a9653f5c31044819389636bbb8af409647c9b6e"

URI_x86_64_v2_rust-serde+rc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+rc-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+rc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+rc-devel}"
SRC_URI[x86_64_v2_rust-serde+rc-devel.sha256sum] = "3d3113148754d81ea47e661b7048f85f643ab0b23403e17becf5f1d9825ea465"

URI_x86_64_v2_rust-serde+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+serde_derive-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-serde+serde_derive-devel.sha256sum] = "97f9ca10c7029736a235aa8d0d8709d4a25868726c33627fa88687d8c2cd38d9"

URI_x86_64_v2_rust-serde+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+std-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+std-devel}"
SRC_URI[x86_64_v2_rust-serde+std-devel.sha256sum] = "466c017c5f157847e086cbc30f6a8927cf719a21f7c81185bbb072cddb91dc1c"

URI_x86_64_v2_rust-serde+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde+unstable-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde+unstable-devel}"
SRC_URI[x86_64_v2_rust-serde+unstable-devel.sha256sum] = "bce2839c52a66528594393361949d693bfed008192ec24d42eff7cb0a1a0a003"

URI_x86_64_v2_rust-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-devel-1.0.228-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-devel}"
SRC_URI[x86_64_v2_rust-serde-devel.sha256sum] = "fbd32f5705ef08eb968a79ac55c7e2538c3af4f05528062924a038ceee531518"

URI_aarch64_rust-serde+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+alloc-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+alloc-devel}"
SRC_URI[aarch64_rust-serde+alloc-devel.sha256sum] = "35b033d2ee42e3cabfca205aa2834b17755a99fa4f1572ba2356e93b760e64f4"

URI_aarch64_rust-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+default-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+default-devel}"
SRC_URI[aarch64_rust-serde+default-devel.sha256sum] = "fef7add9805ad479b1807c0d8b61b3b2ea4e24da825b79178001645c3a615c62"

URI_aarch64_rust-serde+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+derive-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+derive-devel}"
SRC_URI[aarch64_rust-serde+derive-devel.sha256sum] = "ec6c8dd740d54257f9a381cc35fbbf94147772928f412486aa04b55ddc97316c"

URI_aarch64_rust-serde+rc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+rc-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde+rc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+rc-devel}"
SRC_URI[aarch64_rust-serde+rc-devel.sha256sum] = "8bbe85fd71c956f0fb54405453cca3a32240bf44676d200e8face54a4304eef4"

URI_aarch64_rust-serde+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+serde_derive-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+serde_derive-devel}"
SRC_URI[aarch64_rust-serde+serde_derive-devel.sha256sum] = "84598599d6c16d9365fb5c515dc15ed78d85f942f3b319b719eaec1ab0e44331"

URI_aarch64_rust-serde+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+std-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+std-devel}"
SRC_URI[aarch64_rust-serde+std-devel.sha256sum] = "1e87b3606aac1fa3eafdfecc9c9dafb802efaea1150d7e4fdf0107cb261d329f"

URI_aarch64_rust-serde+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde+unstable-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde+unstable-devel}"
SRC_URI[aarch64_rust-serde+unstable-devel.sha256sum] = "9f10965ce65183bfa9cfea2e9cff2d2391b5c4a677dc39e414d4ebbe0c808f10"

URI_aarch64_rust-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-devel-1.0.228-1.el10_2.noarch.rpm;name=aarch64_rust-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-devel}"
SRC_URI[aarch64_rust-serde-devel.sha256sum] = "f21d2234f1ad18f58a3ebc9bda4a63a826e4b94113ff460a4eab7cc306253dfd"

RDEPENDS:rust-serde+alloc-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 "
RDEPENDS:rust-serde+default-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-serde+derive-devel = " \
 cargo \
 rust-serde+serde_derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-serde+rc-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+rc-devel \
 "
RDEPENDS:rust-serde+serde_derive-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-serde+std-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+std-devel \
 "
RDEPENDS:rust-serde+unstable-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_core+unstable-devel \
 "
RDEPENDS:rust-serde-devel = " \
 cargo \
 rust \
 rust-serde_core+result-devel \
 rust-serde_core-devel \
 "
