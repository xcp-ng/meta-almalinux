# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-git2"
PV = "0.19.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-git2+default-devel \
 rust-git2+https-devel \
 rust-git2+openssl-probe-devel \
 rust-git2+openssl-sys-devel \
 rust-git2+ssh-devel \
 rust-git2+ssh_key_from_memory-devel \
 rust-git2+unstable-devel \
 rust-git2+vendored-libgit2-devel \
 rust-git2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-git2-0.19.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f011530ce9911d5a39732a0c471f0da9295b2e5aed0d1390e72f297c0ae52b4"

URI_x86_64_v2_rust-git2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+default-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+default-devel}"
SRC_URI[x86_64_v2_rust-git2+default-devel.sha256sum] = "480b9008c6c423447dec7b0c9cdef4f772dfd49216a0224285608b4b0d3234db"

URI_x86_64_v2_rust-git2+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+https-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+https-devel}"
SRC_URI[x86_64_v2_rust-git2+https-devel.sha256sum] = "30a99cc283e221ddb4cd363d1cdbbb0ccc4f56ba8d2bb453281ec431784dc78f"

URI_x86_64_v2_rust-git2+openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+openssl-probe-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-git2+openssl-probe-devel.sha256sum] = "5ebb433edb11cd6196b60875ee99e4a79d43ff0c85e4ae73ab687c1f6c9d215e"

URI_x86_64_v2_rust-git2+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+openssl-sys-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-git2+openssl-sys-devel.sha256sum] = "9ddd3616b4eb026128786a3083b94a7461671d2bfbb483af4fc6f4b88c4659c3"

URI_x86_64_v2_rust-git2+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+ssh-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+ssh-devel}"
SRC_URI[x86_64_v2_rust-git2+ssh-devel.sha256sum] = "f2ea909683d136542531f39f8b76e711b919b2bb4ad5eabcc5fba0db8fcb0bb9"

URI_x86_64_v2_rust-git2+ssh_key_from_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+ssh_key_from_memory-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+ssh_key_from_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+ssh_key_from_memory-devel}"
SRC_URI[x86_64_v2_rust-git2+ssh_key_from_memory-devel.sha256sum] = "3aa1326c24787f77a2930cd3b6d7387ca8f01927083b86e698ae45a5c6b2edac"

URI_x86_64_v2_rust-git2+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+unstable-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+unstable-devel}"
SRC_URI[x86_64_v2_rust-git2+unstable-devel.sha256sum] = "593d888d0d479d2c42c0cad2b7a8128631582f9837e642a77bb726b49e86ae5c"

URI_x86_64_v2_rust-git2+vendored-libgit2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2+vendored-libgit2-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2+vendored-libgit2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2+vendored-libgit2-devel}"
SRC_URI[x86_64_v2_rust-git2+vendored-libgit2-devel.sha256sum] = "6769dd4d13d220936478cf637aec6d2eebbde83793b0f8c6b2e0b499484eab54"

URI_x86_64_v2_rust-git2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2-devel-0.19.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2-devel}"
SRC_URI[x86_64_v2_rust-git2-devel.sha256sum] = "2588413895b40d94d39a477ad3b42a6a2f741074ac4e2c647318544606ef0ba7"

URI_aarch64_rust-git2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+default-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+default-devel}"
SRC_URI[aarch64_rust-git2+default-devel.sha256sum] = "240fed4d6f044df2f9f420a6f336477313ae156b0d8ede4fc2d43fd0657f3cb6"

URI_aarch64_rust-git2+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+https-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+https-devel}"
SRC_URI[aarch64_rust-git2+https-devel.sha256sum] = "11e7abcd79a882b1d20d76a94bc0ee6a5fe1500b879c1ab2cbf19d710dd7348a"

URI_aarch64_rust-git2+openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+openssl-probe-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+openssl-probe-devel}"
SRC_URI[aarch64_rust-git2+openssl-probe-devel.sha256sum] = "ad48ba446077fe067fa2fbb77feddd22af2c61faf4d4ed16385bf2debde60f4f"

URI_aarch64_rust-git2+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+openssl-sys-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+openssl-sys-devel}"
SRC_URI[aarch64_rust-git2+openssl-sys-devel.sha256sum] = "c6fe5f60f84de072ad368305f310e112ccef470c2e1c9c35d8941f4ea83a8df2"

URI_aarch64_rust-git2+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+ssh-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+ssh-devel}"
SRC_URI[aarch64_rust-git2+ssh-devel.sha256sum] = "398f33962d1174374a537b82716837a519aff3d52702f9e51e66713e14834816"

URI_aarch64_rust-git2+ssh_key_from_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+ssh_key_from_memory-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2+ssh_key_from_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+ssh_key_from_memory-devel}"
SRC_URI[aarch64_rust-git2+ssh_key_from_memory-devel.sha256sum] = "a95c8bbca67e1e8452bb67e3647dbf50234cd44e6a1ec686fa98126a7cd13d06"

URI_aarch64_rust-git2+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+unstable-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+unstable-devel}"
SRC_URI[aarch64_rust-git2+unstable-devel.sha256sum] = "9c2ad838a11b6dd942ef755bdaf9d659f3eec77522d62fed5897be90c3366844"

URI_aarch64_rust-git2+vendored-libgit2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2+vendored-libgit2-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2+vendored-libgit2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2+vendored-libgit2-devel}"
SRC_URI[aarch64_rust-git2+vendored-libgit2-devel.sha256sum] = "e158e7f5e87d3e73984567f8413e65001095c53772a395b7e21e33e8efbbca73"

URI_aarch64_rust-git2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2-devel-0.19.0-1.el10_0.noarch.rpm;name=aarch64_rust-git2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2-devel}"
SRC_URI[aarch64_rust-git2-devel.sha256sum] = "a444bed26860265f9f2ba3218989b4401ad11f8e8d89bc51983964daf05d0f93"

RDEPENDS:rust-git2+default-devel = " \
 cargo \
 rust-git2+https-devel \
 rust-git2+ssh-devel \
 rust-git2+ssh_key_from_memory-devel \
 rust-git2-devel \
 "
RDEPENDS:rust-git2+https-devel = " \
 cargo \
 rust-git2+openssl-probe-devel \
 rust-git2+openssl-sys-devel \
 rust-git2-devel \
 rust-libgit2-sys+https-devel \
 "
RDEPENDS:rust-git2+openssl-probe-devel = " \
 cargo \
 rust-git2-devel \
 rust-openssl-probe+default-devel \
 "
RDEPENDS:rust-git2+openssl-sys-devel = " \
 cargo \
 rust-git2-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-git2+ssh-devel = " \
 cargo \
 rust-git2-devel \
 rust-libgit2-sys+ssh-devel \
 "
RDEPENDS:rust-git2+ssh_key_from_memory-devel = " \
 cargo \
 rust-git2-devel \
 rust-libgit2-sys+ssh_key_from_memory-devel \
 "
RDEPENDS:rust-git2+unstable-devel = " \
 cargo \
 rust-git2-devel \
 "
RDEPENDS:rust-git2+vendored-libgit2-devel = " \
 cargo \
 rust-git2-devel \
 rust-libgit2-sys+vendored-devel \
 "
RDEPENDS:rust-git2-devel = " \
 bash \
 cargo \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys+default-devel \
 rust-log+default-devel \
 rust-url+default-devel \
 "
