# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "orca"
PV = "48.9"
PR = "3.el10"
PACKAGES = " \
 orca \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/orca-48.9-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e035ba3d06c1b80b0b1a5a5112400d3000de3dc7b82413f41b5d2d3119c95be"

URI_x86_64_v2_orca = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/orca-48.9-3.el10.noarch.rpm;name=x86_64_v2_orca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_orca}"
SRC_URI[x86_64_v2_orca.sha256sum] = "e2e029be8ddf7eb696d27305092d90a243db7a545b5d135d56cb295b3aa87314"

URI_aarch64_orca = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/orca-48.9-3.el10.noarch.rpm;name=aarch64_orca;unpack=0"
SRC_URI:append = " ${URI_aarch64_orca}"
SRC_URI[aarch64_orca.sha256sum] = "e2e029be8ddf7eb696d27305092d90a243db7a545b5d135d56cb295b3aa87314"

RDEPENDS:orca = " \
 libwnck3 \
 python3 \
 python3-brlapi \
 python3-louis \
 python3-pyatspi \
 python3-speechd \
 speech-dispatcher \
 "
