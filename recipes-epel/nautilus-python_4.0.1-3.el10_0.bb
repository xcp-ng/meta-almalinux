# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nautilus-python"
PV = "4.0.1"
PR = "3.el10_0"
PACKAGES = " \
 nautilus-python \
 nautilus-python-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nautilus-python-4.0.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3998e8082dc0ec32ba9ab999a76dbabc3e3ad05aea86c19d8b449651b03f34f8"

URI_x86_64_v2_nautilus-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nautilus-python-4.0.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nautilus-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nautilus-python}"
SRC_URI[x86_64_v2_nautilus-python.sha256sum] = "57e48751db5e4474baf5681a28f96189a3fb2a1e25d459ec5c24f91c3df4f2b9"

URI_x86_64_v2_nautilus-python-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nautilus-python-devel-4.0.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nautilus-python-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nautilus-python-devel}"
SRC_URI[x86_64_v2_nautilus-python-devel.sha256sum] = "9df3d4a2d7587bac50909b71e157ade94fd27dcc47d0284f4466c81c9e4e7a85"

URI_aarch64_nautilus-python = "${EPEL_MIRROR}/aarch64/Packages/n/nautilus-python-4.0.1-3.el10_0.aarch64.rpm;name=aarch64_nautilus-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_nautilus-python}"
SRC_URI[aarch64_nautilus-python.sha256sum] = "c24155680cd14288851e08d21e5466301a0038137beda8462af5a0d0be341a2b"

URI_aarch64_nautilus-python-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nautilus-python-devel-4.0.1-3.el10_0.aarch64.rpm;name=aarch64_nautilus-python-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nautilus-python-devel}"
SRC_URI[aarch64_nautilus-python-devel.sha256sum] = "6e652893798ba170f2551fe5c9f73bda8bd30ff827eedf4fde869b0f2c44e2f2"

RDEPENDS:nautilus-python = " \
 glib2 \
 glibc \
 libgcc \
 nautilus-extensions \
 python3-gobject-base \
 python3-libs \
 "
RDEPENDS:nautilus-python-devel = " \
 nautilus-python \
 pkgconf-pkg-config \
 "
