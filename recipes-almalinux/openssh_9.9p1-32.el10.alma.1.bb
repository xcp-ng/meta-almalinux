# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssh"
PV = "9.9p1"
PR = "32.el10.alma.1"
PACKAGES = " \
 openssh \
 openssh-askpass \
 openssh-clients \
 openssh-keycat \
 openssh-keysign \
 openssh-server \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssh-9.9p1-32.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa784cb8d001a8bfd62ec6466327007f0547fbb0cb2dadb53804b9ba160c2f45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-9.9p1-32.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh;unpack=0"
SRC_URI[x86_64_v2_openssh.sha256sum] = "74551377e904d3df5974dcf41d7c4dbb8c4daf514bda1807afa816d0ef70d69c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-askpass-9.9p1-32.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-askpass;unpack=0"
SRC_URI[x86_64_v2_openssh-askpass.sha256sum] = "4e9859b50130383e5b28b6b44431e19178bacc9077dd0575c3275a987330e99b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-clients-9.9p1-32.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-clients;unpack=0"
SRC_URI[x86_64_v2_openssh-clients.sha256sum] = "a8f3b794291f56e2058685e7d7ca0e6897e818793522db1594adc26f63e6ae7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-keycat-9.9p1-32.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-keycat;unpack=0"
SRC_URI[x86_64_v2_openssh-keycat.sha256sum] = "7a168c4c22b460a6f3b402e17e476d3bbe2c439cae082a5823e4ed1a912bc745"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-keysign-9.9p1-32.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-keysign;unpack=0"
SRC_URI[x86_64_v2_openssh-keysign.sha256sum] = "5f9327cec218ba221619829d3cbe5d7e90c7091a3982dff48275903b9c9f8ae3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-server-9.9p1-32.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-server;unpack=0"
SRC_URI[x86_64_v2_openssh-server.sha256sum] = "7c060fc14d7714fe7f0bf1c9ed28687dcfed88ad32cc47f0ce3ff8c02a66da9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-9.9p1-32.el10.alma.1.aarch64.rpm;name=aarch64_openssh;unpack=0"
SRC_URI[aarch64_openssh.sha256sum] = "ce7bfcdf9a5b1d8bc237ad3a41313de04b5be83aca78de3847fccb76e0875a42"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-askpass-9.9p1-32.el10.alma.1.aarch64.rpm;name=aarch64_openssh-askpass;unpack=0"
SRC_URI[aarch64_openssh-askpass.sha256sum] = "7e15f4cf6105a630119892d463d269a54b7cb0cb66974e5be820e6275f5ee6d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-clients-9.9p1-32.el10.alma.1.aarch64.rpm;name=aarch64_openssh-clients;unpack=0"
SRC_URI[aarch64_openssh-clients.sha256sum] = "f394ef579aee04f279514d2bbb0fc6b53a1cf8e316c1f74d64886a7e6e267002"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-keycat-9.9p1-32.el10.alma.1.aarch64.rpm;name=aarch64_openssh-keycat;unpack=0"
SRC_URI[aarch64_openssh-keycat.sha256sum] = "689146606302a1be8efcb58518822bab2a3426ca908eb474a0d3ba8ba7452636"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-keysign-9.9p1-32.el10.alma.1.aarch64.rpm;name=aarch64_openssh-keysign;unpack=0"
SRC_URI[aarch64_openssh-keysign.sha256sum] = "6d2842f4b33dff9006fa172d41504cd6095eee0a60b822d47f515e4a54156acd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-server-9.9p1-32.el10.alma.1.aarch64.rpm;name=aarch64_openssh-server;unpack=0"
SRC_URI[aarch64_openssh-server.sha256sum] = "5c17f7887aa8911b1ee9a2455a69930611125ebc161de7c9450653cc46039003"

RDEPENDS:openssh = " \
 audit-libs \
 glibc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:openssh-askpass = " \
 glib2 \
 glibc \
 gtk3 \
 openssh \
 "
RDEPENDS:openssh-clients = " \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libedit \
 libfido2 \
 libselinux \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-keycat = " \
 glibc \
 openssh \
 pam-libs \
 "
RDEPENDS:openssh-keysign = " \
 glibc \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libcom_err \
 libselinux \
 libxcrypt \
 openssh \
 openssl-libs \
 pam \
 pam-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
