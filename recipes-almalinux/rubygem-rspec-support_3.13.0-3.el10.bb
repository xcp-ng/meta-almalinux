# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rspec-support"
PV = "3.13.0"
PR = "3.el10"
PACKAGES = " \
 rubygem-rspec-support \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/rubygem-rspec-support-3.13.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4594fbc5f87c179341b9c4bcf2886cf2e06b388bcea33fedf14aa5c5f7899e73"

URI_x86_64_v2_rubygem-rspec-support = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rubygem-rspec-support-3.13.0-3.el10.noarch.rpm;name=x86_64_v2_rubygem-rspec-support;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rspec-support}"
SRC_URI[x86_64_v2_rubygem-rspec-support.sha256sum] = "57b9591484d04aaf37d52e2c4ef4d9f42ca20db7aa68c4b60244702b3263ae2b"

URI_aarch64_rubygem-rspec-support = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rubygem-rspec-support-3.13.0-3.el10.noarch.rpm;name=aarch64_rubygem-rspec-support;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rspec-support}"
SRC_URI[aarch64_rubygem-rspec-support.sha256sum] = "57b9591484d04aaf37d52e2c4ef4d9f42ca20db7aa68c4b60244702b3263ae2b"

RDEPENDS:rubygem-rspec-support = " \
 rubygems \
 "
