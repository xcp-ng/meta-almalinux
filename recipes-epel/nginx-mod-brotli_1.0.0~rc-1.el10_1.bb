# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-brotli"
PV = "1.0.0~rc"
PR = "1.el10_1"
PACKAGES = " \
 nginx-mod-brotli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-brotli-1.0.0~rc-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "677ef6f3dd96f2e9e2419188d9fd04354803db6a12b30b48a2257898ca35ef1c"

URI_x86_64_v2_nginx-mod-brotli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-brotli-1.0.0~rc-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-brotli}"
SRC_URI[x86_64_v2_nginx-mod-brotli.sha256sum] = "14bb699743087213bb8540f5fedf80d90089ad2834ae7ae78bd1f308afe4e02c"

URI_aarch64_nginx-mod-brotli = "${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-brotli-1.0.0~rc-1.el10_1.aarch64.rpm;name=aarch64_nginx-mod-brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-brotli}"
SRC_URI[aarch64_nginx-mod-brotli.sha256sum] = "aa188b6f7e30b9db0acc529c6fadac719379e1425bfb5e2a91ce21b914cb8e4a"

RDEPENDS:nginx-mod-brotli = " \
 glibc \
 libbrotli \
 nginx \
 "
