# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcompletion"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kcompletion \
 kf6-kcompletion-devel \
 kf6-kcompletion-doc \
 kf6-kcompletion-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcompletion-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "921c2024b394728052cf56ca0b5391cbda625120088a66bb3519a521ec3b06eb"

URI_x86_64_v2_kf6-kcompletion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcompletion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion}"
SRC_URI[x86_64_v2_kf6-kcompletion.sha256sum] = "ac3d6959ce95727861e9ca1bc18fae2b2d1134abff4853d4c5244e4b577a82f9"

URI_x86_64_v2_kf6-kcompletion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcompletion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-devel}"
SRC_URI[x86_64_v2_kf6-kcompletion-devel.sha256sum] = "1662df9ec82faaf17e5636103eca33ca842a088021071709aa67e7c1a81212e2"

URI_x86_64_v2_kf6-kcompletion-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcompletion-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-doc}"
SRC_URI[x86_64_v2_kf6-kcompletion-doc.sha256sum] = "e3b7b9fd6691a831857f1aa48f26008be775b56d6861584e1c8a6ab7d85bb160"

URI_x86_64_v2_kf6-kcompletion-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcompletion-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-html}"
SRC_URI[x86_64_v2_kf6-kcompletion-html.sha256sum] = "3fc31a4fc4c9fdc7bdf96fc2069d882d46f8db9542e5035913734b176ed4cb8b"

URI_aarch64_kf6-kcompletion = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcompletion;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion}"
SRC_URI[aarch64_kf6-kcompletion.sha256sum] = "aebbc1f96106752f75fc5a6b48a2face3fc3a42a7983dd0807e3b8ddd908f053"

URI_aarch64_kf6-kcompletion-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcompletion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-devel}"
SRC_URI[aarch64_kf6-kcompletion-devel.sha256sum] = "92d2f5ff225419857d4dbd93b1a4502389a148a20dfb675f1fd4e11e8016e595"

URI_aarch64_kf6-kcompletion-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcompletion-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-doc}"
SRC_URI[aarch64_kf6-kcompletion-doc.sha256sum] = "76c2bf7e4982479d176fb20b2245e448461b2df2a32fc879015d2e1a776a64fc"

URI_aarch64_kf6-kcompletion-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcompletion-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-html}"
SRC_URI[aarch64_kf6-kcompletion-html.sha256sum] = "6c038bb9e51016ab178746f3cce8c3d57438e5591795f6b7dfc2d89e755c88d3"

RDEPENDS:kf6-kcompletion = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcompletion-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcompletion \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcompletion-doc = " \
 "
RDEPENDS:kf6-kcompletion-html = " \
 "
