# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbpf-cargo"
PV = "0.24.4"
PR = "3.el10_0"
PACKAGES = " \
 libbpf-cargo \
 rust-libbpf-cargo+default-devel \
 rust-libbpf-cargo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbpf-cargo-0.24.4-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ffa2992743fc93c6045e00ae5c43e112a8e96c1fa5cb28e501fa702a810d15c"

URI_x86_64_v2_libbpf-cargo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbpf-cargo-0.24.4-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbpf-cargo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbpf-cargo}"
SRC_URI[x86_64_v2_libbpf-cargo.sha256sum] = "f2946f3382c2ad0d3a6f3c163461845029312296b6e24925e5eed21c8ea7aaa4"

URI_x86_64_v2_rust-libbpf-cargo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-cargo+default-devel-0.24.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-cargo+default-devel}"
SRC_URI[x86_64_v2_rust-libbpf-cargo+default-devel.sha256sum] = "3c153eb48d8882e7d28abee52b4fbce54f88035f0e5d791c2ba38549034f52cb"

URI_x86_64_v2_rust-libbpf-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-cargo-devel-0.24.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-cargo-devel}"
SRC_URI[x86_64_v2_rust-libbpf-cargo-devel.sha256sum] = "71079d601c2a663a1bbc464fce0e9c265495109b7d4d2917314ceea051c75601"

URI_aarch64_libbpf-cargo = "${EPEL_MIRROR}/aarch64/Packages/l/libbpf-cargo-0.24.4-3.el10_0.aarch64.rpm;name=aarch64_libbpf-cargo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbpf-cargo}"
SRC_URI[aarch64_libbpf-cargo.sha256sum] = "0313982083cc30411719722b8cb66a53067fd5592553dcc8818541b95fffacd6"

URI_aarch64_rust-libbpf-cargo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-cargo+default-devel-0.24.4-3.el10_0.noarch.rpm;name=aarch64_rust-libbpf-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-cargo+default-devel}"
SRC_URI[aarch64_rust-libbpf-cargo+default-devel.sha256sum] = "d954511e200e91d22d704553de3098cbfc90af24503c5106b1a88ffa6516fcae"

URI_aarch64_rust-libbpf-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-cargo-devel-0.24.4-3.el10_0.noarch.rpm;name=aarch64_rust-libbpf-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-cargo-devel}"
SRC_URI[aarch64_rust-libbpf-cargo-devel.sha256sum] = "f436b268017297e286c57f25a94d5ad9c08f1c80850604e1bd9fc9350e9f4fb0"

RDEPENDS:libbpf-cargo = " \
 elfutils-libelf \
 glibc \
 libgcc \
 zlib-ng-compat \
 "
RDEPENDS:rust-libbpf-cargo+default-devel = " \
 cargo \
 rust-libbpf-cargo-devel \
 rust-libbpf-rs+default-devel \
 "
RDEPENDS:rust-libbpf-cargo-devel = " \
 cargo \
 clang \
 rust \
 rust-anyhow+default-devel \
 rust-cargo_metadata0.15+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-libbpf-rs-devel \
 rust-memmap2_0.5+default-devel \
 rust-regex+std-devel \
 rust-regex+unicode-perl-devel \
 rust-regex-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-tempfile+default-devel \
 rustfmt \
 "
