# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdump-utils"
PV = "1.0.58"
PR = "15.el10"
PACKAGES = " \
 kdump-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kdump-utils-1.0.58-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad4c95944a31edd25de346b480029c412e4d7a8301aa08508035ff9b115aecf4"

URI_x86_64_v2_kdump-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kdump-utils-1.0.58-15.el10.x86_64_v2.rpm;name=x86_64_v2_kdump-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdump-utils}"
SRC_URI[x86_64_v2_kdump-utils.sha256sum] = "9df2df2aa78045244482083d4e81471636e010d7fd0260b9ac95f55a245d37e9"

URI_aarch64_kdump-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kdump-utils-1.0.58-15.el10.aarch64.rpm;name=aarch64_kdump-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdump-utils}"
SRC_URI[aarch64_kdump-utils.sha256sum] = "1e7e2ce2d60808b15b16bcc11ecf74740a8a1c6948919ea6b33ef66811b5019f"

RDEPENDS:kdump-utils = " \
 bash \
 dracut \
 dracut-network \
 dracut-squash \
 ethtool \
 kexec-tools \
 makedumpfile \
 sed \
 systemd-udev \
 util-linux \
 virtual/coreutils \
 "
