# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smartmontools"
PE = "1"
PV = "7.4"
PR = "7.el10"
PACKAGES = " \
 smartmontools \
 smartmontools-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/smartmontools-7.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2cb483b4557c36a40ca25491479d882ef71d6e2469193c39858100cc6852ab69"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/smartmontools-7.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_smartmontools;unpack=0"
SRC_URI[x86_64_v2_smartmontools.sha256sum] = "14c44bfca8c0b07cd008929a025215ca337def997eeea26f604e3f106a8686fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/smartmontools-selinux-7.4-7.el10.noarch.rpm;name=x86_64_v2_smartmontools-selinux;unpack=0"
SRC_URI[x86_64_v2_smartmontools-selinux.sha256sum] = "9c945242f455b8bf79d75ee4e761aa7f53cf780b4e366a66c05a92dfec797844"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/smartmontools-7.4-7.el10.aarch64.rpm;name=aarch64_smartmontools;unpack=0"
SRC_URI[aarch64_smartmontools.sha256sum] = "7a1ebed89df45268b7402e284f89b17a0ae90ad798664a3073f18f5e4e3bdeca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/smartmontools-selinux-7.4-7.el10.noarch.rpm;name=aarch64_smartmontools-selinux;unpack=0"
SRC_URI[aarch64_smartmontools-selinux.sha256sum] = "9c945242f455b8bf79d75ee4e761aa7f53cf780b4e366a66c05a92dfec797844"

RDEPENDS:smartmontools = " \
 bash \
 glibc \
 libcap-ng \
 libgcc \
 libselinux \
 libstdc++ \
 smartmontools-selinux \
 systemd-libs \
 "
RDEPENDS:smartmontools-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 selinux-policy \
 selinux-policy-targeted \
 "
