# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-commitgraph"
PV = "0.37.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-commitgraph+default-devel \
 rust-gix-commitgraph+document-features-devel \
 rust-gix-commitgraph+serde-devel \
 rust-gix-commitgraph+sha1-devel \
 rust-gix-commitgraph+sha256-devel \
 rust-gix-commitgraph-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-commitgraph-0.37.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "857011699cab53c86fe24e6654d1d56c0c0cfcc144c95116f4ca60944f049ef3"

URI_x86_64_v2_rust-gix-commitgraph+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+default-devel-0.37.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+default-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+default-devel.sha256sum] = "7597a2d6a8f7eb1348825519a207f134d8d69b2227d27a4520ce4dbee29badbb"

URI_x86_64_v2_rust-gix-commitgraph+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+document-features-devel-0.37.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+document-features-devel.sha256sum] = "687197ae7d04e1cf34946ee2da96cf9bf28113ecfbfaf2e33aae2f66b496017b"

URI_x86_64_v2_rust-gix-commitgraph+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+serde-devel-0.37.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+serde-devel.sha256sum] = "98750298ab4e2910785aa3107c0f583bc8164cc72aa5a2112a1e32f80979dac2"

URI_x86_64_v2_rust-gix-commitgraph+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+sha1-devel-0.37.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+sha1-devel.sha256sum] = "34c39a69a14b0731584c893d306ad3210ea186e9987c837a295aed87e7017d7c"

URI_x86_64_v2_rust-gix-commitgraph+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+sha256-devel-0.37.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+sha256-devel.sha256sum] = "b0eceaa0022be38e59d3729ce25a842713a396cab4d31aa0181ada9060cc0942"

URI_x86_64_v2_rust-gix-commitgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph-devel-0.37.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph-devel.sha256sum] = "9c91a7667cd8be375719313fa2ad40516f18ffb508845666596e654eb2633d74"

URI_aarch64_rust-gix-commitgraph+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+default-devel-0.37.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-commitgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+default-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+default-devel.sha256sum] = "6a366b3953f7d2cd8314475f1e9d19f6988782466fdd58ccc226e899477c9b31"

URI_aarch64_rust-gix-commitgraph+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+document-features-devel-0.37.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-commitgraph+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+document-features-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+document-features-devel.sha256sum] = "8144e3e952a6a601d62df1e325f191b2d5f9190646261e9a2ee6ca945baacda1"

URI_aarch64_rust-gix-commitgraph+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+serde-devel-0.37.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-commitgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+serde-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+serde-devel.sha256sum] = "0b18e0308cc808e974f4352a5715128f1dfca88d3bd5abedd9a2c19c266bfc9a"

URI_aarch64_rust-gix-commitgraph+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+sha1-devel-0.37.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-commitgraph+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+sha1-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+sha1-devel.sha256sum] = "4acf05f127307d43b513f90ef5da0cf8b79e94e05b01912767bd20df98d163df"

URI_aarch64_rust-gix-commitgraph+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+sha256-devel-0.37.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-commitgraph+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+sha256-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+sha256-devel.sha256sum] = "305b9702c88b1490af81a7c11c6dcd6063e9d463714f36fd9a5a10ab6780e7a6"

URI_aarch64_rust-gix-commitgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph-devel-0.37.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-commitgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph-devel}"
SRC_URI[aarch64_rust-gix-commitgraph-devel.sha256sum] = "8879678714c1b45831652b0f4ba43ccec5f07e9dcfdf7048855fec2b86b47124"

RDEPENDS:rust-gix-commitgraph+default-devel = " \
 cargo \
 rust-gix-commitgraph-devel \
 "
RDEPENDS:rust-gix-commitgraph+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-commitgraph-devel \
 "
RDEPENDS:rust-gix-commitgraph+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-commitgraph-devel \
 rust-gix-hash+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-commitgraph+sha1-devel = " \
 cargo \
 rust-gix-commitgraph-devel \
 rust-gix-hash+sha1-devel \
 "
RDEPENDS:rust-gix-commitgraph+sha256-devel = " \
 cargo \
 rust-gix-commitgraph-devel \
 rust-gix-hash+sha256-devel \
 "
RDEPENDS:rust-gix-commitgraph-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-chunk+default-devel \
 rust-gix-error+default-devel \
 rust-gix-hash+default-devel \
 rust-memmap2+default-devel \
 rust-nonempty+default-devel \
 "
