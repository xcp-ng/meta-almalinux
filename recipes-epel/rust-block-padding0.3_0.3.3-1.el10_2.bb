# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-block-padding0.3"
PV = "0.3.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-block-padding0.3+default-devel \
 rust-block-padding0.3+std-devel \
 rust-block-padding0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-block-padding0.3-0.3.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34b9d7916fd4f9cfcdb7817c321d5286789ff4b85dadb5314bf1eedc1da9d952"

URI_x86_64_v2_rust-block-padding0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-padding0.3+default-devel-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-padding0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-padding0.3+default-devel}"
SRC_URI[x86_64_v2_rust-block-padding0.3+default-devel.sha256sum] = "ff4c910d97de604082f8d0774d71ade059def1013244d087a847c360debb2535"

URI_x86_64_v2_rust-block-padding0.3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-padding0.3+std-devel-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-padding0.3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-padding0.3+std-devel}"
SRC_URI[x86_64_v2_rust-block-padding0.3+std-devel.sha256sum] = "823aed84a6f60a695050aabd14e95c582bc3bbe8222501d719585a71aed27bb3"

URI_x86_64_v2_rust-block-padding0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-padding0.3-devel-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-padding0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-padding0.3-devel}"
SRC_URI[x86_64_v2_rust-block-padding0.3-devel.sha256sum] = "03eee32f42b44a2c74c4fda75feacc1350191aebcd4cb7ffd1842b4be734d9bf"

URI_aarch64_rust-block-padding0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-padding0.3+default-devel-0.3.3-1.el10_2.noarch.rpm;name=aarch64_rust-block-padding0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-padding0.3+default-devel}"
SRC_URI[aarch64_rust-block-padding0.3+default-devel.sha256sum] = "8fbedbc1a5a711e3f4265383e9725a9755da2e73772b7389aa9c7bb1120cbe9a"

URI_aarch64_rust-block-padding0.3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-padding0.3+std-devel-0.3.3-1.el10_2.noarch.rpm;name=aarch64_rust-block-padding0.3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-padding0.3+std-devel}"
SRC_URI[aarch64_rust-block-padding0.3+std-devel.sha256sum] = "17d7feedc6666be5a48c8afe1e2740db537a7f9b3a481b712bc632bb390dbd8b"

URI_aarch64_rust-block-padding0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-padding0.3-devel-0.3.3-1.el10_2.noarch.rpm;name=aarch64_rust-block-padding0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-padding0.3-devel}"
SRC_URI[aarch64_rust-block-padding0.3-devel.sha256sum] = "3e6b2a904176459e79551a397172e0988b8fc1581ae68505bd29fac55648f465"

RDEPENDS:rust-block-padding0.3+default-devel = " \
 cargo \
 rust-block-padding0.3-devel \
 "
RDEPENDS:rust-block-padding0.3+std-devel = " \
 cargo \
 rust-block-padding0.3-devel \
 "
RDEPENDS:rust-block-padding0.3-devel = " \
 cargo \
 rust \
 rust-generic-array+default-devel \
 "
