# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Runtime"
PV = "0.016"
PR = "24.el10"
PACKAGES = " \
 perl-Module-Runtime \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Module-Runtime-0.016-24.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bb4e4a0e7583e30fbc8aca9b44ab0df08f7f46ca2d51f74aa1752935153b480d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Module-Runtime-0.016-24.el10.noarch.rpm;name=x86_64_v2_perl-Module-Runtime;unpack=0"
SRC_URI[x86_64_v2_perl-Module-Runtime.sha256sum] = "12207527d7822fa2bf80666543990efe8ff1773a0f5e77517287a120704c873b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Module-Runtime-0.016-24.el10.noarch.rpm;name=aarch64_perl-Module-Runtime;unpack=0"
SRC_URI[aarch64_perl-Module-Runtime.sha256sum] = "12207527d7822fa2bf80666543990efe8ff1773a0f5e77517287a120704c873b"

RDEPENDS:perl-Module-Runtime = " \
 perl-libs \
 "
