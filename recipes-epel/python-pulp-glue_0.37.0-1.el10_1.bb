# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pulp-glue"
PV = "0.37.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-pulp-glue \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pulp-glue-0.37.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de984ccb0f9eb1e8bb0ad2cbb7e9f0c435d6faece71864f36c7e3fbf6af997dd"

URI_x86_64_v2_python3-pulp-glue = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pulp-glue-0.37.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pulp-glue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pulp-glue}"
SRC_URI[x86_64_v2_python3-pulp-glue.sha256sum] = "65c325afd39a71fcbae9a65eeb6e4f5b8e1c7e4d568813a2648bdc5968cd72c7"

URI_aarch64_python3-pulp-glue = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pulp-glue-0.37.0-1.el10_1.noarch.rpm;name=aarch64_python3-pulp-glue;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pulp-glue}"
SRC_URI[aarch64_python3-pulp-glue.sha256sum] = "3f6d7ab5841fda2688f5eb81f5e05d0ca677675a3ee0489f28ea79f7b7252cf7"

RDEPENDS:python3-pulp-glue = " \
 python3 \
 python3-multidict \
 python3-packaging \
 python3-requests \
 "
