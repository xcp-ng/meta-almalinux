# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cdi-api"
PV = "2.0.2"
PR = "15.el10"
PACKAGES = " \
 cdi-api \
 cdi-api-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cdi-api-2.0.2-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e98f1b327ffb35d79d6943e868748aaeb81789ba3a6263fe39dc1c6b1b2e85a3"

URI_x86_64_v2_cdi-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cdi-api-2.0.2-15.el10.noarch.rpm;name=x86_64_v2_cdi-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cdi-api}"
SRC_URI[x86_64_v2_cdi-api.sha256sum] = "56a3e83e1eb9243fa41c4b3e3d17575268da673a6d744c67db12ae59147d61f3"

URI_x86_64_v2_cdi-api-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cdi-api-javadoc-2.0.2-15.el10.noarch.rpm;name=x86_64_v2_cdi-api-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cdi-api-javadoc}"
SRC_URI[x86_64_v2_cdi-api-javadoc.sha256sum] = "9d021e0d8288181ece2055ad035da1fe09809b92323ea1d2156d5f6b0fd434f4"

URI_aarch64_cdi-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cdi-api-2.0.2-15.el10.noarch.rpm;name=aarch64_cdi-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_cdi-api}"
SRC_URI[aarch64_cdi-api.sha256sum] = "56a3e83e1eb9243fa41c4b3e3d17575268da673a6d744c67db12ae59147d61f3"

URI_aarch64_cdi-api-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cdi-api-javadoc-2.0.2-15.el10.noarch.rpm;name=aarch64_cdi-api-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cdi-api-javadoc}"
SRC_URI[aarch64_cdi-api-javadoc.sha256sum] = "9d021e0d8288181ece2055ad035da1fe09809b92323ea1d2156d5f6b0fd434f4"

RDEPENDS:cdi-api = " \
 atinject \
 javapackages-filesystem \
 "
RDEPENDS:cdi-api-javadoc = " \
 javapackages-filesystem \
 "
