# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "helm"
PV = "4.1.1"
PR = "1.el10_2"
PACKAGES = " \
 helm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/helm-4.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37138cbf4135d4b9a065d62f22b9a41fb5fcf996cc814244c1f1a6363cce2f54"

URI_x86_64_v2_helm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/helm-4.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_helm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_helm}"
SRC_URI[x86_64_v2_helm.sha256sum] = "56c30da8b67a0f98570ea75cd0b710a9c1425b6d8f1b95f0c29e72b2f4f04d95"

URI_aarch64_helm = "${EPEL_MIRROR}/aarch64/Packages/h/helm-4.1.1-1.el10_2.aarch64.rpm;name=aarch64_helm;unpack=0"
SRC_URI:append = " ${URI_aarch64_helm}"
SRC_URI[aarch64_helm.sha256sum] = "22491e150c236a1d700ae1d79196742695e73a6ffc198fdafc83a304182c26fc"

RDEPENDS:helm = " \
 glibc \
 "
