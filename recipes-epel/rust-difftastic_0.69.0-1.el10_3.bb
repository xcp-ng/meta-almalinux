# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-difftastic"
PV = "0.69.0"
PR = "1.el10_3"
PACKAGES = " \
 difftastic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-difftastic-0.69.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efadbaa0cb0047ee676bf38af0b19c8dd08284331065fbd17e836287720af44c"

URI_x86_64_v2_difftastic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/difftastic-0.69.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_difftastic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_difftastic}"
SRC_URI[x86_64_v2_difftastic.sha256sum] = "f51e26765da49c9348703937232b05b58eb740f39e5146e63f86c2730be68ebd"

URI_aarch64_difftastic = "${EPEL_MIRROR}/aarch64/Packages/d/difftastic-0.69.0-1.el10_3.aarch64.rpm;name=aarch64_difftastic;unpack=0"
SRC_URI:append = " ${URI_aarch64_difftastic}"
SRC_URI[aarch64_difftastic.sha256sum] = "9cf21d16422fe7a3d38bfaa118822eab441f32b43f8ed34d34c6731fbb58ec5c"

RDEPENDS:difftastic = " \
 glibc \
 jemalloc \
 libgcc \
 "
