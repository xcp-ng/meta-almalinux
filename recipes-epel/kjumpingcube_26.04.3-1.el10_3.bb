# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kjumpingcube"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kjumpingcube \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kjumpingcube-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aa61a8c0e451aaf0233b0da427e36abbf37da7010afda82f799d2aa1641d123"

URI_x86_64_v2_kjumpingcube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjumpingcube-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjumpingcube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjumpingcube}"
SRC_URI[x86_64_v2_kjumpingcube.sha256sum] = "e7c8ca000ec678fcc787fb1515c24baeb394b467d42710e22332389b77518df9"

URI_aarch64_kjumpingcube = "${EPEL_MIRROR}/aarch64/Packages/k/kjumpingcube-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kjumpingcube;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjumpingcube}"
SRC_URI[aarch64_kjumpingcube.sha256sum] = "3c9d5fdf3203885568aa6afbcbdbc4474f6870e3b447e999a3dfecc473f7acc0"

RDEPENDS:kjumpingcube = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
