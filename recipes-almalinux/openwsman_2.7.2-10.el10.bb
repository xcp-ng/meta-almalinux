# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openwsman"
PV = "2.7.2"
PR = "10.el10"
PACKAGES = " \
 libwsman-devel \
 libwsman1 \
 openwsman-client \
 openwsman-python3 \
 openwsman-selinux \
 openwsman-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openwsman-2.7.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6056b99720c43b03c9f7b53ed5797916f6b215f784658396fe83aa8aec38822"

URI_x86_64_v2_libwsman-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwsman-devel-2.7.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libwsman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwsman-devel}"
SRC_URI[x86_64_v2_libwsman-devel.sha256sum] = "3a63ba7bd509087a1d63425961cbda147a4c416394f811ba720d35f1f1dde651"

URI_x86_64_v2_libwsman1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwsman1-2.7.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libwsman1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwsman1}"
SRC_URI[x86_64_v2_libwsman1.sha256sum] = "70349cbcf85e383d372380f1b1ca52e0662c03baeeb85094d7247e3f7a23abc3"

URI_x86_64_v2_openwsman-client = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openwsman-client-2.7.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_openwsman-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openwsman-client}"
SRC_URI[x86_64_v2_openwsman-client.sha256sum] = "75f2885801aeb25fec8af60e6f9971dd088a22abfebfc74e142fcdc976623c59"

URI_x86_64_v2_openwsman-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openwsman-python3-2.7.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_openwsman-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openwsman-python3}"
SRC_URI[x86_64_v2_openwsman-python3.sha256sum] = "ce30cfc73631186d711ba769527b388a517a336fc8f5212b44800892155bc6a8"

URI_x86_64_v2_openwsman-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openwsman-selinux-2.7.2-10.el10.noarch.rpm;name=x86_64_v2_openwsman-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openwsman-selinux}"
SRC_URI[x86_64_v2_openwsman-selinux.sha256sum] = "ead94acd6e5c746288fdccd8c8b1f3c3365f395e5ee69979692a46317cf35354"

URI_x86_64_v2_openwsman-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openwsman-server-2.7.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_openwsman-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openwsman-server}"
SRC_URI[x86_64_v2_openwsman-server.sha256sum] = "e2088f359c40c1e764d49f2239b9c68df8b01a88cfc6d34e20215f415ba5881b"

URI_aarch64_libwsman-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwsman-devel-2.7.2-10.el10.aarch64.rpm;name=aarch64_libwsman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwsman-devel}"
SRC_URI[aarch64_libwsman-devel.sha256sum] = "5f326d71a2ff319ae13f79921c0a1174174d283ef66762bf83d813a4647053ac"

URI_aarch64_libwsman1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwsman1-2.7.2-10.el10.aarch64.rpm;name=aarch64_libwsman1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwsman1}"
SRC_URI[aarch64_libwsman1.sha256sum] = "c753e8895f2c74b444106bc97cc4d87d00178500d9d17f7bd0138aa53a862e9f"

URI_aarch64_openwsman-client = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openwsman-client-2.7.2-10.el10.aarch64.rpm;name=aarch64_openwsman-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_openwsman-client}"
SRC_URI[aarch64_openwsman-client.sha256sum] = "517d5b9e9b7850aed2a3c8c798c2eb34e716edbeeb70afbc9d3c99da040cd649"

URI_aarch64_openwsman-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openwsman-python3-2.7.2-10.el10.aarch64.rpm;name=aarch64_openwsman-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_openwsman-python3}"
SRC_URI[aarch64_openwsman-python3.sha256sum] = "95e1bd71436e2f512d9a5f4e09946209180cfe7a24ddebe4db03135e37519387"

URI_aarch64_openwsman-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openwsman-selinux-2.7.2-10.el10.noarch.rpm;name=aarch64_openwsman-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_openwsman-selinux}"
SRC_URI[aarch64_openwsman-selinux.sha256sum] = "ead94acd6e5c746288fdccd8c8b1f3c3365f395e5ee69979692a46317cf35354"

URI_aarch64_openwsman-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openwsman-server-2.7.2-10.el10.aarch64.rpm;name=aarch64_openwsman-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_openwsman-server}"
SRC_URI[aarch64_openwsman-server.sha256sum] = "195c835059a4e423ba0b3b891f8b37d52b373d8ee92173fe9494bead2177eace"

RDEPENDS:libwsman-devel = " \
 libcurl-devel \
 libwsman1 \
 libxml2-devel \
 openwsman-client \
 openwsman-server \
 pam-devel \
 pkgconf-pkg-config \
 sblim-sfcc-devel \
 "
RDEPENDS:libwsman1 = " \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:openwsman-client = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:openwsman-python3 = " \
 glibc \
 libwsman1 \
 python3 \
 "
RDEPENDS:openwsman-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:openwsman-server = " \
 bash \
 glibc \
 libwsman1 \
 libxcrypt \
 openssl-libs \
 openwsman-selinux \
 pam-libs \
 ruby-libs \
 sblim-sfcc \
 "
