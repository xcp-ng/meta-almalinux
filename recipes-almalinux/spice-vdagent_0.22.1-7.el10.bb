# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spice-vdagent"
PV = "0.22.1"
PR = "7.el10"
PACKAGES = " \
 spice-vdagent \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/spice-vdagent-0.22.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42f99bda893e76483d74d4d3797d6f05ebc37bdf5c912ac778abd86f0d66393c"

URI_x86_64_v2_spice-vdagent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/spice-vdagent-0.22.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_spice-vdagent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spice-vdagent}"
SRC_URI[x86_64_v2_spice-vdagent.sha256sum] = "246c0b59af76d22b6aec0235204c9a2d2f436eb282de558222835aff5558f443"

URI_aarch64_spice-vdagent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/spice-vdagent-0.22.1-7.el10.aarch64.rpm;name=aarch64_spice-vdagent;unpack=0"
SRC_URI:append = " ${URI_aarch64_spice-vdagent}"
SRC_URI[aarch64_spice-vdagent.sha256sum] = "d8e35a4f679a169013f442f4e9de00964d3ebc3cd88d1a9562f7f7a293af378a"

RDEPENDS:spice-vdagent = " \
 alsa-lib \
 bash \
 dbus-libs \
 glib2 \
 glibc \
 libX11 \
 libXfixes \
 libXinerama \
 libXrandr \
 libdrm \
 libpciaccess \
 systemd \
 systemd-libs \
 "
