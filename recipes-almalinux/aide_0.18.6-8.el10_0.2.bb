# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aide"
PV = "0.18.6"
PR = "8.el10_0.2"
PACKAGES = " \
 aide \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/aide-0.18.6-8.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5f1ccfb4ec5564f2c48dc89e8cbf2cfc8b5e694d401c67888700e8a7658303e"

URI_x86_64_v2_aide = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aide-0.18.6-8.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_aide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aide}"
SRC_URI[x86_64_v2_aide.sha256sum] = "103b624f7a98ad193fc21dc82e6bab602844c5c198eb6f32f9d02ea5dc326471"

URI_aarch64_aide = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aide-0.18.6-8.el10_0.2.aarch64.rpm;name=aarch64_aide;unpack=0"
SRC_URI:append = " ${URI_aarch64_aide}"
SRC_URI[aarch64_aide.sha256sum] = "467a2c0e541cff6d8876c294cf26d72d0253aedf031f5f68fbc4d77126992dd2"

RDEPENDS:aide = " \
 audit-libs \
 e2fsprogs-libs \
 glibc \
 gnutls \
 libacl \
 libselinux \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
