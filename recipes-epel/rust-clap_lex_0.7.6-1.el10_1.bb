# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_lex"
PV = "0.7.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-clap_lex+default-devel \
 rust-clap_lex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_lex-0.7.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ba53a116506d7b1239e2adb743a06c8ce2211c857f3d361ae568facf06c765b"

URI_x86_64_v2_rust-clap_lex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex+default-devel-0.7.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_lex+default-devel}"
SRC_URI[x86_64_v2_rust-clap_lex+default-devel.sha256sum] = "4e46f0d7d83f0135026233854433e4c392667b042a5fd404107b5f0bb9bf5212"

URI_x86_64_v2_rust-clap_lex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex-devel-0.7.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_lex-devel}"
SRC_URI[x86_64_v2_rust-clap_lex-devel.sha256sum] = "ef147195afce49d37aab183fc357500c63cf73edb5371b43e9900906e3fb7004"

URI_aarch64_rust-clap_lex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex+default-devel-0.7.6-1.el10_1.noarch.rpm;name=aarch64_rust-clap_lex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_lex+default-devel}"
SRC_URI[aarch64_rust-clap_lex+default-devel.sha256sum] = "2bf64ba1ffcfc5c353481888c268707e630003f1c322d562dc39cc2ea0387ec2"

URI_aarch64_rust-clap_lex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex-devel-0.7.6-1.el10_1.noarch.rpm;name=aarch64_rust-clap_lex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_lex-devel}"
SRC_URI[aarch64_rust-clap_lex-devel.sha256sum] = "3f7eb3222dbf9c42b6628c8ee817009b43e78415f6d2cfe80988e6891eddb4b7"

RDEPENDS:rust-clap_lex+default-devel = " \
 cargo \
 rust-clap_lex-devel \
 "
RDEPENDS:rust-clap_lex-devel = " \
 cargo \
 rust \
 "
