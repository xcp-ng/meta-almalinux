# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_locid_transform"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-icu_locid_transform+compiled_data-devel \
 rust-icu_locid_transform+datagen-devel \
 rust-icu_locid_transform+default-devel \
 rust-icu_locid_transform+serde-devel \
 rust-icu_locid_transform+std-devel \
 rust-icu_locid_transform-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_locid_transform-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de3b346d4dec87d2044cb8cce6060dbc9a49f9f600d0be58658193ef12eabec4"

URI_x86_64_v2_rust-icu_locid_transform+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid_transform+compiled_data-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid_transform+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid_transform+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_locid_transform+compiled_data-devel.sha256sum] = "c3db6dce7f0039c459c50886ccb96342158b8c5174dc8ef626a5149d8fd2ca75"

URI_x86_64_v2_rust-icu_locid_transform+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid_transform+datagen-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid_transform+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid_transform+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_locid_transform+datagen-devel.sha256sum] = "af46586bcee8f94800389bc9f153feb1174c0b63bff5c76e8985fb353b221f4c"

URI_x86_64_v2_rust-icu_locid_transform+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid_transform+default-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid_transform+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid_transform+default-devel}"
SRC_URI[x86_64_v2_rust-icu_locid_transform+default-devel.sha256sum] = "a6ea8eb013a047cc3edca6ea0207c3089e4cfa9d3275f8957df9ee2130b01311"

URI_x86_64_v2_rust-icu_locid_transform+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid_transform+serde-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid_transform+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid_transform+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_locid_transform+serde-devel.sha256sum] = "b8ae32921a58ba82086959e096dcb0ca85b7f3337fb27ba0aeaf72ede11715c5"

URI_x86_64_v2_rust-icu_locid_transform+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid_transform+std-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid_transform+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid_transform+std-devel}"
SRC_URI[x86_64_v2_rust-icu_locid_transform+std-devel.sha256sum] = "8a98b26e92225ff33217240cf486bf98f7cdb44303b683d3eac7ed2ef63f1d1c"

URI_x86_64_v2_rust-icu_locid_transform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid_transform-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid_transform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid_transform-devel}"
SRC_URI[x86_64_v2_rust-icu_locid_transform-devel.sha256sum] = "9838cc277cf8a37140506a554a3d6dca7ac7cf36a0215f801dc44a68d485a727"

URI_aarch64_rust-icu_locid_transform+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid_transform+compiled_data-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_locid_transform+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid_transform+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_locid_transform+compiled_data-devel.sha256sum] = "1b6dff5f57c2688c2688ce5baafe323460cf4472b56bfbde013317cbe0931878"

URI_aarch64_rust-icu_locid_transform+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid_transform+datagen-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_locid_transform+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid_transform+datagen-devel}"
SRC_URI[aarch64_rust-icu_locid_transform+datagen-devel.sha256sum] = "f9cba6d05994fd0d97468bb9ee4075d6f02e89851cfe9a4b45171f360a04642d"

URI_aarch64_rust-icu_locid_transform+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid_transform+default-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_locid_transform+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid_transform+default-devel}"
SRC_URI[aarch64_rust-icu_locid_transform+default-devel.sha256sum] = "93893e7d61f1a25ec74bd7901d6237bf38b5bd6f423c4b22ae0cbda64b2e6bc3"

URI_aarch64_rust-icu_locid_transform+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid_transform+serde-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_locid_transform+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid_transform+serde-devel}"
SRC_URI[aarch64_rust-icu_locid_transform+serde-devel.sha256sum] = "75dda92785afd224cbd271f9d6f221df698751e178dd04a169127b42f117f9ad"

URI_aarch64_rust-icu_locid_transform+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid_transform+std-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_locid_transform+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid_transform+std-devel}"
SRC_URI[aarch64_rust-icu_locid_transform+std-devel.sha256sum] = "c64c9733d4d1a931f7fc741447e3930815d4c013220749503992698d635306ce"

URI_aarch64_rust-icu_locid_transform-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid_transform-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-icu_locid_transform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid_transform-devel}"
SRC_URI[aarch64_rust-icu_locid_transform-devel.sha256sum] = "6e289183ced8f553cf6b39f432f4f2f6fd89d6787b22cfaed766211eeb865a83"

RDEPENDS:rust-icu_locid_transform+compiled_data-devel = " \
 cargo \
 rust-icu_locid_transform-devel \
 rust-icu_locid_transform_data-devel \
 "
RDEPENDS:rust-icu_locid_transform+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_locid+databake-devel \
 rust-icu_locid_transform+serde-devel \
 rust-icu_locid_transform-devel \
 rust-tinystr+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_locid_transform+default-devel = " \
 cargo \
 rust-icu_locid_transform+compiled_data-devel \
 rust-icu_locid_transform-devel \
 "
RDEPENDS:rust-icu_locid_transform+serde-devel = " \
 cargo \
 rust-icu_locid+serde-devel \
 rust-icu_locid_transform-devel \
 rust-icu_provider+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-tinystr+serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_locid_transform+std-devel = " \
 cargo \
 rust-icu_locid_transform-devel \
 "
RDEPENDS:rust-icu_locid_transform-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-icu_locid+zerovec-devel \
 rust-icu_locid-devel \
 rust-icu_provider+macros-devel \
 rust-icu_provider-devel \
 rust-tinystr+alloc-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
