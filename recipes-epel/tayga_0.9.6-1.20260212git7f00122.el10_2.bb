# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tayga"
PV = "0.9.6"
PR = "1.20260212git7f00122.el10_2"
PACKAGES = " \
 tayga \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tayga-0.9.6-1.20260212git7f00122.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf8887940ec7bd5af2bfa16193f88fc371e49bd5efa1b5c83d8b9c8968838b96"

URI_aarch64_tayga = "${EPEL_MIRROR}/aarch64/Packages/t/tayga-0.9.6-1.20260212git7f00122.el10_2.aarch64.rpm;name=aarch64_tayga;unpack=0"
SRC_URI:append = " ${URI_aarch64_tayga}"
SRC_URI[aarch64_tayga.sha256sum] = "a6fb75086e2c293da4f577688edd4adbadff18cf92d79f751331111b8c3e5904"

RDEPENDS:tayga = " \
 bash \
 glibc \
 iproute \
 "
