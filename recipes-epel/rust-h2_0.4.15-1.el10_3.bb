# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-h2"
PV = "0.4.15"
PR = "1.el10_3"
PACKAGES = " \
 rust-h2+default-devel \
 rust-h2+stream-devel \
 rust-h2+unstable-devel \
 rust-h2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-h2-0.4.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cb3407debc9db622b36c1d7fd3560c9c8da2c6018f7cebef45a95e6fd5b2de3"

URI_x86_64_v2_rust-h2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+default-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+default-devel}"
SRC_URI[x86_64_v2_rust-h2+default-devel.sha256sum] = "e07428a6bfa424966df82ba3bcb1e0dc82c24c2356c64f049a6f0a303e24622f"

URI_x86_64_v2_rust-h2+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+stream-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+stream-devel}"
SRC_URI[x86_64_v2_rust-h2+stream-devel.sha256sum] = "b8ddc32e46ecc05c28d60630c641b11b3f648a4c566a2c4bee824fa114f3d303"

URI_x86_64_v2_rust-h2+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+unstable-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2+unstable-devel}"
SRC_URI[x86_64_v2_rust-h2+unstable-devel.sha256sum] = "b1375742a71a6c7da3baa7af62de8c26d082b31958114e80da274bd310754ef8"

URI_x86_64_v2_rust-h2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2-devel-0.4.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-h2-devel}"
SRC_URI[x86_64_v2_rust-h2-devel.sha256sum] = "85a5d1de93bfe0db8d5c87aea42db639434bd8f50f2af1c5187697a9953e3395"

URI_aarch64_rust-h2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+default-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-h2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+default-devel}"
SRC_URI[aarch64_rust-h2+default-devel.sha256sum] = "b32fcba00f2d87252fd1db7cd5e4f080ce977c063593ae7b9e134091a1885213"

URI_aarch64_rust-h2+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+stream-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-h2+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+stream-devel}"
SRC_URI[aarch64_rust-h2+stream-devel.sha256sum] = "5294d38e437ee5371ee50f934a8c7934fdb892383b385f566403153ad1955c85"

URI_aarch64_rust-h2+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+unstable-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-h2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2+unstable-devel}"
SRC_URI[aarch64_rust-h2+unstable-devel.sha256sum] = "0802612c9290c30831c9d918e6d3939016784d3fab0d237da410d838cce57d6d"

URI_aarch64_rust-h2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-h2-devel-0.4.15-1.el10_3.noarch.rpm;name=aarch64_rust-h2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-h2-devel}"
SRC_URI[aarch64_rust-h2-devel.sha256sum] = "ec17bf55dea055cfd0fe24d49e9e8c2b5ae99f333e480f2f22a71332a91dfbd1"

RDEPENDS:rust-h2+default-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+stream-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+unstable-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2-devel = " \
 cargo \
 rust \
 rust-atomic-waker+default-devel \
 rust-bytes+default-devel \
 rust-fnv+default-devel \
 rust-futures-core-devel \
 rust-futures-sink-devel \
 rust-http+default-devel \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-slab+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
