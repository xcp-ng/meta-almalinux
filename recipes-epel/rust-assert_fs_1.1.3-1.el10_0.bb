# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert_fs"
PV = "1.1.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-assert_fs+color-auto-devel \
 rust-assert_fs+color-devel \
 rust-assert_fs+default-devel \
 rust-assert_fs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert_fs-1.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f775d36fa42b17178db225f4e89f4cf47d5af4d387e21a60cf0d35843fdf9134"

URI_x86_64_v2_rust-assert_fs+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+color-auto-devel-1.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+color-auto-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+color-auto-devel.sha256sum] = "2a0e42f0ce1af55d38e3fb385e48861728bb07c7696a0aad9aed042925463624"

URI_x86_64_v2_rust-assert_fs+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+color-devel-1.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+color-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+color-devel.sha256sum] = "f4a079a46611574712a6f7e90d7b14f4bd5af26edca40bde40dcade93303fede"

URI_x86_64_v2_rust-assert_fs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+default-devel-1.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+default-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+default-devel.sha256sum] = "43d9f43f2349d70a208813638836fad7e0a767643bdedca585165ffee8ebc010"

URI_x86_64_v2_rust-assert_fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs-devel-1.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs-devel}"
SRC_URI[x86_64_v2_rust-assert_fs-devel.sha256sum] = "3dcc514549a82de4966215974981f1cbe754a0c50610b5cd6a0844bcee001605"

URI_aarch64_rust-assert_fs+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+color-auto-devel-1.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-assert_fs+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+color-auto-devel}"
SRC_URI[aarch64_rust-assert_fs+color-auto-devel.sha256sum] = "c571d0f0237a4b9aa0b37fc7b0fdeb69484dd87c8f966c8085a2cecd91af30e6"

URI_aarch64_rust-assert_fs+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+color-devel-1.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-assert_fs+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+color-devel}"
SRC_URI[aarch64_rust-assert_fs+color-devel.sha256sum] = "07b9c23dcf773eb43b3c22ef226dbf7d911b633e388813342a6ba91c3abf271b"

URI_aarch64_rust-assert_fs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+default-devel-1.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-assert_fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+default-devel}"
SRC_URI[aarch64_rust-assert_fs+default-devel.sha256sum] = "9ae7e3b126dbf0f907a686b125d9ebee9dbff04ca410dee86e85bdd332322a7f"

URI_aarch64_rust-assert_fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs-devel-1.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-assert_fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs-devel}"
SRC_URI[aarch64_rust-assert_fs-devel.sha256sum] = "0752a395245488c060c09e3b10cbf229539c8707e03a83322b456aaf92deda8b"

RDEPENDS:rust-assert_fs+color-auto-devel = " \
 cargo \
 rust-assert_fs+color-devel \
 rust-assert_fs-devel \
 "
RDEPENDS:rust-assert_fs+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-assert_fs-devel \
 rust-predicates+color-devel \
 "
RDEPENDS:rust-assert_fs+default-devel = " \
 cargo \
 rust-assert_fs-devel \
 "
RDEPENDS:rust-assert_fs-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-doc-comment+default-devel \
 rust-globwalk+default-devel \
 rust-predicates+diff-devel \
 rust-predicates-core+default-devel \
 rust-predicates-devel \
 rust-predicates-tree+default-devel \
 rust-tempfile+default-devel \
 "
