# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsfdo"
PV = "0.1.3"
PR = "1.el10_0"
PACKAGES = " \
 libsfdo \
 libsfdo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libsfdo-0.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3190a7ab09c830f99b5ad3fa45fe3cff6c71f3333fb9d5db66473fdc12adc3f3"

URI_x86_64_v2_libsfdo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsfdo-0.1.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsfdo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsfdo}"
SRC_URI[x86_64_v2_libsfdo.sha256sum] = "da4a3889cacde7924c766bdacb6287b18a5f1775264eafda51a78d05e38a6c83"

URI_x86_64_v2_libsfdo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsfdo-devel-0.1.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsfdo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsfdo-devel}"
SRC_URI[x86_64_v2_libsfdo-devel.sha256sum] = "5ec9807044ff7d419ab3ccacf86fe923dd7025774aee83b24111c184ea7660fa"

URI_aarch64_libsfdo = "${EPEL_MIRROR}/aarch64/Packages/l/libsfdo-0.1.3-1.el10_0.aarch64.rpm;name=aarch64_libsfdo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsfdo}"
SRC_URI[aarch64_libsfdo.sha256sum] = "2b8dfb227ecd9d0eede49d0080080acf4c1caedd928d5c9dbc0e837c5e3c75b6"

URI_aarch64_libsfdo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsfdo-devel-0.1.3-1.el10_0.aarch64.rpm;name=aarch64_libsfdo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsfdo-devel}"
SRC_URI[aarch64_libsfdo-devel.sha256sum] = "5f13000eca6f6b852fb96427d6f66f1c98ac6b084b973015696030afd3fdff94"

RDEPENDS:libsfdo = " \
 glibc \
 "
RDEPENDS:libsfdo-devel = " \
 libsfdo \
 libsfdo-devel \
 pkgconf-pkg-config \
 "
