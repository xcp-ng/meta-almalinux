# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "breeze-gtk"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 breeze-gtk \
 breeze-gtk-common \
 breeze-gtk-gtk2 \
 breeze-gtk-gtk3 \
 breeze-gtk-gtk4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/breeze-gtk-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01e306362c5e4c39c2c159c4e24b9db58bd5e4041e635bc9cf4f753c2a0687a6"

URI_x86_64_v2_breeze-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk}"
SRC_URI[x86_64_v2_breeze-gtk.sha256sum] = "cff199d5fbd986de95636f5625d95abfd801b5a92643ad9d4b599db18de6cc45"

URI_x86_64_v2_breeze-gtk-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-common-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-common}"
SRC_URI[x86_64_v2_breeze-gtk-common.sha256sum] = "deb8580466c36143b9226eaf08ba2ca954495a2f84bef6d819b3578184e6a951"

URI_x86_64_v2_breeze-gtk-gtk2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk2-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk2}"
SRC_URI[x86_64_v2_breeze-gtk-gtk2.sha256sum] = "6a2347c858146849308344d6a2352db7467eac7f5f7de1c83b9d5153113e2727"

URI_x86_64_v2_breeze-gtk-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk3-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk3}"
SRC_URI[x86_64_v2_breeze-gtk-gtk3.sha256sum] = "b01b8000211247fa85e49f6c57130da621ab9e4c69269348fb98566cef03bb85"

URI_x86_64_v2_breeze-gtk-gtk4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk4-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk4}"
SRC_URI[x86_64_v2_breeze-gtk-gtk4.sha256sum] = "db96bbff82a21d6d0c961f81dcfbfdec9f945185558b5869b71c4f20158c7052"

URI_aarch64_breeze-gtk = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-6.7.3-1.el10_3.noarch.rpm;name=aarch64_breeze-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk}"
SRC_URI[aarch64_breeze-gtk.sha256sum] = "bf0db360590eaa70a0690e1e645a2ee25ca9759aa934429bc77c9ddf038eb484"

URI_aarch64_breeze-gtk-common = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-common-6.7.3-1.el10_3.noarch.rpm;name=aarch64_breeze-gtk-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-common}"
SRC_URI[aarch64_breeze-gtk-common.sha256sum] = "45b44a8db17266488a9af40e1f5c7d73b6b3228dfe30600bdb6dff6ee3f88822"

URI_aarch64_breeze-gtk-gtk2 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk2-6.7.3-1.el10_3.noarch.rpm;name=aarch64_breeze-gtk-gtk2;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk2}"
SRC_URI[aarch64_breeze-gtk-gtk2.sha256sum] = "9e6a5cf0407b936326434595fe1ae2416b1172f00cd7bd36ae722f15ed5f1a40"

URI_aarch64_breeze-gtk-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk3-6.7.3-1.el10_3.noarch.rpm;name=aarch64_breeze-gtk-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk3}"
SRC_URI[aarch64_breeze-gtk-gtk3.sha256sum] = "cb0603043d1c2afdfd3a2b0948f8443bfe515faffc323fe0f526937cc6a725eb"

URI_aarch64_breeze-gtk-gtk4 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk4-6.7.3-1.el10_3.noarch.rpm;name=aarch64_breeze-gtk-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk4}"
SRC_URI[aarch64_breeze-gtk-gtk4.sha256sum] = "ee5ca98f31c61b341de5470dd0542a82646699bad7610d0beea2e0f9ddb9a5d5"

RDEPENDS:breeze-gtk = " \
 breeze-gtk-gtk2 \
 breeze-gtk-gtk3 \
 breeze-gtk-gtk4 \
 "
RDEPENDS:breeze-gtk-common = " \
 "
RDEPENDS:breeze-gtk-gtk2 = " \
 breeze-gtk-common \
 gtk2-engines \
 "
RDEPENDS:breeze-gtk-gtk3 = " \
 breeze-gtk-common \
 "
RDEPENDS:breeze-gtk-gtk4 = " \
 breeze-gtk-common \
 "
