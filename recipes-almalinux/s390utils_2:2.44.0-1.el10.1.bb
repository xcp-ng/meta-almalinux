# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s390utils"
PE = "2"
PV = "2.44.0"
PR = "1.el10.1"
PACKAGES = " \
 s390utils \
 s390utils-se-data \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/s390utils-2.44.0-1.el10.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b6e4c799ffccf8ac3ce2133c3f75901ba05b961f42e4df1e7e4ae0e00fe012ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/s390utils-2.44.0-1.el10.1.x86_64_v2.rpm;name=x86_64_v2_s390utils;unpack=0"
SRC_URI[x86_64_v2_s390utils.sha256sum] = "20788ed4649693e8a350f201f0d8c8c2f251b136819d641fb48f96f080ece7e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/s390utils-se-data-2.44.0-1.el10.1.noarch.rpm;name=x86_64_v2_s390utils-se-data;unpack=0"
SRC_URI[x86_64_v2_s390utils-se-data.sha256sum] = "9429aee44583316d6740678c91f4f070589e0f49301aabc6c2e8f37fda3269be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/s390utils-2.44.0-1.el10.1.aarch64.rpm;name=aarch64_s390utils;unpack=0"
SRC_URI[aarch64_s390utils.sha256sum] = "6a483eba03b18f374474b7909a07151178c7b0d9ee8ed34df85812f7de36d7b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/s390utils-se-data-2.44.0-1.el10.1.noarch.rpm;name=aarch64_s390utils-se-data;unpack=0"
SRC_URI[aarch64_s390utils-se-data.sha256sum] = "9429aee44583316d6740678c91f4f070589e0f49301aabc6c2e8f37fda3269be"

RDEPENDS:s390utils = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 s390utils-se-data \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:s390utils-se-data = " \
 "
