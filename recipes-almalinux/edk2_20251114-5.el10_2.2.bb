# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "edk2"
PV = "20251114"
PR = "5.el10_2.2"
PACKAGES = " \
 edk2-aarch64 \
 edk2-ovmf \
 edk2-tools \
 edk2-tools-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/edk2-20251114-5.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "012d404eb9b03a3b364987506a003be7b9722c332c64be645792757381f7db13"

URI_x86_64_v2_edk2-aarch64 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-aarch64-20251114-5.el10_2.2.noarch.rpm;name=x86_64_v2_edk2-aarch64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-aarch64}"
SRC_URI[x86_64_v2_edk2-aarch64.sha256sum] = "5ebf1586f73cdbb4f6af4b6fac8634e21e96c81337572dd52d11cb6022b477ab"

URI_x86_64_v2_edk2-ovmf = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-ovmf-20251114-5.el10_2.2.noarch.rpm;name=x86_64_v2_edk2-ovmf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-ovmf}"
SRC_URI[x86_64_v2_edk2-ovmf.sha256sum] = "15c2aa72562324380757fa4e4264b27e8d215a4ead60505448e6556096472823"

URI_x86_64_v2_edk2-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-tools-20251114-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_edk2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-tools}"
SRC_URI[x86_64_v2_edk2-tools.sha256sum] = "03e79475670413dd27672a9a86d9b4bcec767f441f9c90f45a1f0ee02ce89a7a"

URI_x86_64_v2_edk2-tools-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-tools-doc-20251114-5.el10_2.2.noarch.rpm;name=x86_64_v2_edk2-tools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-tools-doc}"
SRC_URI[x86_64_v2_edk2-tools-doc.sha256sum] = "479f6e316a2a3e78e325be7c98c7571b7ca84ed1f03ce57d9fcd46506cb67901"

URI_aarch64_edk2-aarch64 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-aarch64-20251114-5.el10_2.2.noarch.rpm;name=aarch64_edk2-aarch64;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-aarch64}"
SRC_URI[aarch64_edk2-aarch64.sha256sum] = "5ebf1586f73cdbb4f6af4b6fac8634e21e96c81337572dd52d11cb6022b477ab"

URI_aarch64_edk2-ovmf = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-ovmf-20251114-5.el10_2.2.noarch.rpm;name=aarch64_edk2-ovmf;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-ovmf}"
SRC_URI[aarch64_edk2-ovmf.sha256sum] = "15c2aa72562324380757fa4e4264b27e8d215a4ead60505448e6556096472823"

URI_aarch64_edk2-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-tools-20251114-5.el10_2.2.aarch64.rpm;name=aarch64_edk2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-tools}"
SRC_URI[aarch64_edk2-tools.sha256sum] = "af98aa34697709248c2ce41cc93dcec5f399d90fa4c290d848a224fc86423431"

URI_aarch64_edk2-tools-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-tools-doc-20251114-5.el10_2.2.noarch.rpm;name=aarch64_edk2-tools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-tools-doc}"
SRC_URI[aarch64_edk2-tools-doc.sha256sum] = "479f6e316a2a3e78e325be7c98c7571b7ca84ed1f03ce57d9fcd46506cb67901"

RDEPENDS:edk2-aarch64 = " \
 "
RDEPENDS:edk2-ovmf = " \
 "
RDEPENDS:edk2-tools = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:edk2-tools-doc = " \
 "
