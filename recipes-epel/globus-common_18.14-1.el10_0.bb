# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-common"
PV = "18.14"
PR = "1.el10_0"
PACKAGES = " \
 globus-common \
 globus-common-devel \
 globus-common-doc \
 globus-common-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-common-18.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50a478787721afb42cef2629bb9dfc7ab10ef06ea77449326e88ba3a727712e8"

URI_x86_64_v2_globus-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-18.14-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common}"
SRC_URI[x86_64_v2_globus-common.sha256sum] = "71e1f6aecdc8789b065a0eb5ce868f738991cf62bededb8b643b8063207059e2"

URI_x86_64_v2_globus-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-devel-18.14-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common-devel}"
SRC_URI[x86_64_v2_globus-common-devel.sha256sum] = "e9825cb9cb99fa027a7b34d5b301b10f756731d3960f04ae45ce0fdf2d89503a"

URI_x86_64_v2_globus-common-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-doc-18.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-common-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common-doc}"
SRC_URI[x86_64_v2_globus-common-doc.sha256sum] = "1f03b57de48547d91d71028227c9c3e695cc0c7f549372e947bd7b162db7ea6c"

URI_x86_64_v2_globus-common-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-progs-18.14-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-common-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common-progs}"
SRC_URI[x86_64_v2_globus-common-progs.sha256sum] = "458848937c9216f9ef7d850cdbb645966ab2d6ca90ef53b2977fa07deabaa6df"

URI_aarch64_globus-common = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-18.14-1.el10_0.aarch64.rpm;name=aarch64_globus-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common}"
SRC_URI[aarch64_globus-common.sha256sum] = "727edfb4929d5191f6ac23dac71f5102c583b264be4a08364ad879edb2df974c"

URI_aarch64_globus-common-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-devel-18.14-1.el10_0.aarch64.rpm;name=aarch64_globus-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common-devel}"
SRC_URI[aarch64_globus-common-devel.sha256sum] = "f4e6093e5a105e4c4622bfa667ad74981d209b390967b5535eebff75bc9c6336"

URI_aarch64_globus-common-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-doc-18.14-1.el10_0.noarch.rpm;name=aarch64_globus-common-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common-doc}"
SRC_URI[aarch64_globus-common-doc.sha256sum] = "57f9f5496b59d0ad3fea786ffdef6ad6679bdf67165243073cb7e4356831fdc2"

URI_aarch64_globus-common-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-progs-18.14-1.el10_0.aarch64.rpm;name=aarch64_globus-common-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common-progs}"
SRC_URI[aarch64_globus-common-progs.sha256sum] = "334727788a97aec8379f7dcd4217c29e34a50830989485e29458bd6e6a6c923d"

RDEPENDS:globus-common = " \
 glibc \
 libtool-ltdl \
 perl-Exporter \
 perl-File-Basename \
 perl-libs \
 "
RDEPENDS:globus-common-devel = " \
 globus-common \
 libtool-ltdl-devel \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Usage \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-common-doc = " \
 "
RDEPENDS:globus-common-progs = " \
 bash \
 glibc \
 globus-common \
 libtool-ltdl \
 "
