# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-distutils-extra"
PV = "2.39"
PR = "39.el10_2"
PACKAGES = " \
 python3-distutils-extra \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-distutils-extra-2.39-39.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab2974ce78625fdb8a78abe32b43c671c5edd8e406090ea54ee63e5f2db2336a"

URI_x86_64_v2_python3-distutils-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-distutils-extra-2.39-39.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-distutils-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-distutils-extra}"
SRC_URI[x86_64_v2_python3-distutils-extra.sha256sum] = "fdb8e0d5c75438f147a1b5ad337d8e84ef30e7882e2f1a0cf423673603fd2bc3"

URI_aarch64_python3-distutils-extra = "${EPEL_MIRROR}/aarch64/Packages/p/python3-distutils-extra-2.39-39.el10_2.noarch.rpm;name=aarch64_python3-distutils-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-distutils-extra}"
SRC_URI[aarch64_python3-distutils-extra.sha256sum] = "823de67968e987a54dfcff8f2648cf8c5f411276c61e807a2d148e6d51cfa899"

RDEPENDS:python3-distutils-extra = " \
 intltool \
 python3 \
 python3-setuptools \
 "
