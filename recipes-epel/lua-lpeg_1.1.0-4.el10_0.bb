# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-lpeg"
PV = "1.1.0"
PR = "4.el10_0"
PACKAGES = " \
 lua-lpeg \
 lua5.1-lpeg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-lpeg-1.1.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2174e444f74a5df1042b36a3e9329347421702cea8bcb3703535a23c0bfeb46"

URI_x86_64_v2_lua-lpeg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-lpeg-1.1.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-lpeg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-lpeg}"
SRC_URI[x86_64_v2_lua-lpeg.sha256sum] = "ae95878e11670afc9e6cde6e604d8ab356e21bec2735e658b80d6a3defdea0bb"

URI_x86_64_v2_lua5.1-lpeg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-lpeg-1.1.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua5.1-lpeg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-lpeg}"
SRC_URI[x86_64_v2_lua5.1-lpeg.sha256sum] = "f76e2941f008e456c3f02a35436e20a171b8a5f914e0c60e59bbc820f5c92d22"

URI_aarch64_lua-lpeg = "${EPEL_MIRROR}/aarch64/Packages/l/lua-lpeg-1.1.0-4.el10_0.aarch64.rpm;name=aarch64_lua-lpeg;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-lpeg}"
SRC_URI[aarch64_lua-lpeg.sha256sum] = "7587f40435eacce9b953b69012bf30b8211b27c36789c5cd1dac3e03166c3682"

URI_aarch64_lua5.1-lpeg = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-lpeg-1.1.0-4.el10_0.aarch64.rpm;name=aarch64_lua5.1-lpeg;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-lpeg}"
SRC_URI[aarch64_lua5.1-lpeg.sha256sum] = "15e00224fd95954c7a36788d95460044da8ca82889abe99dbcaf589ef33c0886"

RDEPENDS:lua-lpeg = " \
 glibc \
 lua-libs \
 "
RDEPENDS:lua5.1-lpeg = " \
 compat-lua-libs \
 glibc \
 "
