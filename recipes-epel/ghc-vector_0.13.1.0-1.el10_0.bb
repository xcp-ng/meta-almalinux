# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-vector"
PV = "0.13.1.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-vector \
 ghc-vector-devel \
 ghc-vector-doc \
 ghc-vector-prof \
 ghc-vector-stream \
 ghc-vector-stream-devel \
 ghc-vector-stream-doc \
 ghc-vector-stream-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-vector-0.13.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be9457781f1b73d5d9e946a2a169642caba6a9d9d53ae130d8797d08619d4469"

URI_x86_64_v2_ghc-vector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-0.13.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector}"
SRC_URI[x86_64_v2_ghc-vector.sha256sum] = "dd0949362d133b1a5fee417a88b69dff5fcb546598e0020cc2bd6918e35cd263"

URI_x86_64_v2_ghc-vector-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-devel-0.13.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-devel}"
SRC_URI[x86_64_v2_ghc-vector-devel.sha256sum] = "32bfd0700a481aacc881f9ed5070dce470768f37647b3e6fcf89ea4916c4ca87"

URI_x86_64_v2_ghc-vector-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-doc-0.13.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-vector-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-doc}"
SRC_URI[x86_64_v2_ghc-vector-doc.sha256sum] = "96c19258d67abeed616438d7d95a9914d34c9202438a3a317eb0c09a13d422c4"

URI_x86_64_v2_ghc-vector-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-prof-0.13.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-prof}"
SRC_URI[x86_64_v2_ghc-vector-prof.sha256sum] = "95d85e98a5bfd830ae9d78b8344122b467d0eece1db12d90af91755a55cb1d0f"

URI_x86_64_v2_ghc-vector-stream = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-stream-0.1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-stream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-stream}"
SRC_URI[x86_64_v2_ghc-vector-stream.sha256sum] = "6150266adcad2159f9f1531cac0c1c51bbd5033f3d505f7c3e2eb8296f26eaf7"

URI_x86_64_v2_ghc-vector-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-stream-devel-0.1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-stream-devel}"
SRC_URI[x86_64_v2_ghc-vector-stream-devel.sha256sum] = "195a8c4a29a3eca92d20b16e92de749b92887b91ba04df42e8527f2fcd01de93"

URI_x86_64_v2_ghc-vector-stream-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-stream-doc-0.1.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-vector-stream-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-stream-doc}"
SRC_URI[x86_64_v2_ghc-vector-stream-doc.sha256sum] = "cdace55d39a3ecbaf674911f6034d1cdc18e4136086c3e5b8fdbb6dc74a6583d"

URI_x86_64_v2_ghc-vector-stream-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-stream-prof-0.1.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-stream-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-stream-prof}"
SRC_URI[x86_64_v2_ghc-vector-stream-prof.sha256sum] = "c5ab12d7494996bd413bf49a876ed724431b7a177b76c271e824e7ad686a5f9b"

URI_aarch64_ghc-vector = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-0.13.1.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-vector;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector}"
SRC_URI[aarch64_ghc-vector.sha256sum] = "fabb47e4ddef9d961329448f6f717202cd82e2bd2820602937e862a23987602e"

URI_aarch64_ghc-vector-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-devel-0.13.1.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-vector-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-devel}"
SRC_URI[aarch64_ghc-vector-devel.sha256sum] = "aa4642709bd6a02cd7a1ddfda305aa41b046decc3c094759f2fce3c41b50f654"

URI_aarch64_ghc-vector-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-doc-0.13.1.0-1.el10_0.noarch.rpm;name=aarch64_ghc-vector-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-doc}"
SRC_URI[aarch64_ghc-vector-doc.sha256sum] = "258c407e2fc5ce811325b7e18e67ece6ae3f1171953d94b70cfcb3b3425bda07"

URI_aarch64_ghc-vector-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-prof-0.13.1.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-vector-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-prof}"
SRC_URI[aarch64_ghc-vector-prof.sha256sum] = "44bd492ed06606d513b0ad653865aa00d6d3e4af66d8797c46a6508f6f4c94ea"

URI_aarch64_ghc-vector-stream = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-stream-0.1.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-vector-stream;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-stream}"
SRC_URI[aarch64_ghc-vector-stream.sha256sum] = "e1ddcc94fca124d1cdff12f9ed82f614351319d95c93580a63486536f60f277b"

URI_aarch64_ghc-vector-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-stream-devel-0.1.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-vector-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-stream-devel}"
SRC_URI[aarch64_ghc-vector-stream-devel.sha256sum] = "a53cd6e62df9367ea610accccc63bc70f8738159993bde9610e836f38b374876"

URI_aarch64_ghc-vector-stream-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-stream-doc-0.1.0.1-1.el10_0.noarch.rpm;name=aarch64_ghc-vector-stream-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-stream-doc}"
SRC_URI[aarch64_ghc-vector-stream-doc.sha256sum] = "1dc433229fdb50f2bd50f630b34acd20f80aab64e996a8e5200625b732ee8890"

URI_aarch64_ghc-vector-stream-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-stream-prof-0.1.0.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-vector-stream-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-stream-prof}"
SRC_URI[aarch64_ghc-vector-stream-prof.sha256sum] = "2de38a12b0acb8afbf41b0eca26ce85b597ee8dc59725de2972e5c7ee0212c05"

RDEPENDS:ghc-vector = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-transformers \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-vector-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-primitive-devel \
 ghc-vector \
 ghc-vector-stream-devel \
 "
RDEPENDS:ghc-vector-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-vector-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-primitive-prof \
 ghc-vector-devel \
 ghc-vector-stream-prof \
 "
RDEPENDS:ghc-vector-stream = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-vector-stream-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-vector-stream \
 "
RDEPENDS:ghc-vector-stream-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-vector-stream-prof = " \
 ghc-base-prof \
 ghc-vector-stream-devel \
 "
