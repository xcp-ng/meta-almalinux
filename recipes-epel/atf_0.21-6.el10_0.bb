# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "atf"
PV = "0.21"
PR = "6.el10_0"
PACKAGES = " \
 atf-tests \
 libatf-c \
 libatf-c++ \
 libatf-c++-devel \
 libatf-c-devel \
 libatf-sh \
 libatf-sh-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/atf-0.21-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20e25b1df0531bbedcc1c332e4cb644ea19f72630154095427e42a3ce8cd8881"

URI_x86_64_v2_atf-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atf-tests-0.21-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atf-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atf-tests}"
SRC_URI[x86_64_v2_atf-tests.sha256sum] = "16c8952cee63fa098352097623f7140d8f40431d908532195fed313ac71e053e"

URI_x86_64_v2_libatf-c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libatf-c-0.21-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libatf-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatf-c}"
SRC_URI[x86_64_v2_libatf-c.sha256sum] = "7c0098c2facb321f7aeae4bbe719232967088e655696be175b8a8ee9da6f88d8"

URI_x86_64_v2_libatf-c++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libatf-c++-0.21-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libatf-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatf-c++}"
SRC_URI[x86_64_v2_libatf-c++.sha256sum] = "892101f92277cbb79291eef057365a457453dc273c991a3123b26d94a7c0e831"

URI_x86_64_v2_libatf-c++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libatf-c++-devel-0.21-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libatf-c++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatf-c++-devel}"
SRC_URI[x86_64_v2_libatf-c++-devel.sha256sum] = "17501bda594acea6d795ae0105d98c61706ff8cf1ebfb2aaa5e5a5702d2e61be"

URI_x86_64_v2_libatf-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libatf-c-devel-0.21-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libatf-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatf-c-devel}"
SRC_URI[x86_64_v2_libatf-c-devel.sha256sum] = "ff8f5bdd661486d6eb8d247a676180d9177050118057b2e1b4ebccf9334e4231"

URI_x86_64_v2_libatf-sh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libatf-sh-0.21-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libatf-sh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatf-sh}"
SRC_URI[x86_64_v2_libatf-sh.sha256sum] = "cfee49e979c7bc6f0fb63889b01f193236950c83796c4d182b95f689aacb3a39"

URI_x86_64_v2_libatf-sh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libatf-sh-devel-0.21-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libatf-sh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libatf-sh-devel}"
SRC_URI[x86_64_v2_libatf-sh-devel.sha256sum] = "fab9a5ba627fca2ebf02e9056722f5f19c5042f55921630e98650c966b80eb27"

URI_aarch64_atf-tests = "${EPEL_MIRROR}/aarch64/Packages/a/atf-tests-0.21-6.el10_0.aarch64.rpm;name=aarch64_atf-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_atf-tests}"
SRC_URI[aarch64_atf-tests.sha256sum] = "992f75cbe86e635571d41c1207b862ccf2f54a919f3f83e97520146608f8b9b3"

URI_aarch64_libatf-c = "${EPEL_MIRROR}/aarch64/Packages/l/libatf-c-0.21-6.el10_0.aarch64.rpm;name=aarch64_libatf-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatf-c}"
SRC_URI[aarch64_libatf-c.sha256sum] = "936edb792d8b31bc16ad5fbb2981fb024529bcf73ab50f02feeb1ed5dce0024d"

URI_aarch64_libatf-c++ = "${EPEL_MIRROR}/aarch64/Packages/l/libatf-c++-0.21-6.el10_0.aarch64.rpm;name=aarch64_libatf-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatf-c++}"
SRC_URI[aarch64_libatf-c++.sha256sum] = "1f98512a5da7939ba266e57d00c21f2baeec0e478efa29988566af164b39607d"

URI_aarch64_libatf-c++-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libatf-c++-devel-0.21-6.el10_0.aarch64.rpm;name=aarch64_libatf-c++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatf-c++-devel}"
SRC_URI[aarch64_libatf-c++-devel.sha256sum] = "3b6a7261851856db4fcfcc7c0e85f8ad820ad279822fd296c3e0040ace0587d6"

URI_aarch64_libatf-c-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libatf-c-devel-0.21-6.el10_0.aarch64.rpm;name=aarch64_libatf-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatf-c-devel}"
SRC_URI[aarch64_libatf-c-devel.sha256sum] = "727ed2d0dd10281617cf19b32334a21141bbab7c240d001564fb403a10348e48"

URI_aarch64_libatf-sh = "${EPEL_MIRROR}/aarch64/Packages/l/libatf-sh-0.21-6.el10_0.aarch64.rpm;name=aarch64_libatf-sh;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatf-sh}"
SRC_URI[aarch64_libatf-sh.sha256sum] = "bf10148eff54005608aa23fe7e8b8b3a9b9f71f4850809f3d44929f7ca29f9d2"

URI_aarch64_libatf-sh-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libatf-sh-devel-0.21-6.el10_0.aarch64.rpm;name=aarch64_libatf-sh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libatf-sh-devel}"
SRC_URI[aarch64_libatf-sh-devel.sha256sum] = "c00583d1a1a7224d96a69cabca9fdd1abca93b4d1fc78a161d3a96b80a1bcbc5"

RDEPENDS:atf-tests = " \
 glibc \
 libatf-c \
 libatf-c++ \
 libatf-c++-devel \
 libatf-c-devel \
 libatf-sh \
 libatf-sh-devel \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libatf-c = " \
 glibc \
 "
RDEPENDS:libatf-c++ = " \
 glibc \
 libatf-c \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libatf-c++-devel = " \
 libatf-c \
 libatf-c++ \
 libatf-c-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libatf-c-devel = " \
 libatf-c \
 pkgconf-pkg-config \
 "
RDEPENDS:libatf-sh = " \
 glibc \
 libatf-c \
 libatf-c++ \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libatf-sh-devel = " \
 libatf-sh \
 pkgconf-pkg-config \
 "
