# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-altree-bigfloat"
PV = "0.2.0"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-altree-bigfloat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-altree-bigfloat-0.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "686fa4b3341d98d3df9bea8c0d8f4985407fb8c25b19f91489c0a4fa5c28e635"

URI_x86_64_v2_golang-github-altree-bigfloat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-altree-bigfloat-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-altree-bigfloat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-altree-bigfloat-devel}"
SRC_URI[x86_64_v2_golang-github-altree-bigfloat-devel.sha256sum] = "829983f56b38a8f23854586148747ad25604fb88185e9a9b11d1ce2d228b2179"

URI_aarch64_golang-github-altree-bigfloat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-altree-bigfloat-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_golang-github-altree-bigfloat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-altree-bigfloat-devel}"
SRC_URI[aarch64_golang-github-altree-bigfloat-devel.sha256sum] = "3aeed60fd9b2d7b10009e996a9aaca0618de733e41e2b6cb0ac1a7eab11ea511"

RDEPENDS:golang-github-altree-bigfloat-devel = " \
 go-filesystem \
 "
