# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpmcore"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kpmcore \
 kpmcore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpmcore-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20bdcb4fc90a105e45183f766d4afe5736f89fd3959af7aa7fb524a1e58a7ea8"

URI_x86_64_v2_kpmcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpmcore-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpmcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpmcore}"
SRC_URI[x86_64_v2_kpmcore.sha256sum] = "4779f89936673b18b1cab14d6184ffbafdd4757bea9da8bf757bd5a08db95a39"

URI_x86_64_v2_kpmcore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpmcore-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpmcore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpmcore-devel}"
SRC_URI[x86_64_v2_kpmcore-devel.sha256sum] = "feb61005749f440417f7c1b6e5a54d789c995abea78df83add51167949f97416"

URI_aarch64_kpmcore = "${EPEL_MIRROR}/aarch64/Packages/k/kpmcore-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kpmcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpmcore}"
SRC_URI[aarch64_kpmcore.sha256sum] = "c53defeee1f730875f2758490c6cece310051c43605955079838496233fe2854"

URI_aarch64_kpmcore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpmcore-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kpmcore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpmcore-devel}"
SRC_URI[aarch64_kpmcore-devel.sha256sum] = "43093dfb71107072546070db82f6ab72855f6c196c8f7894cfbe694831b6c959"

RDEPENDS:kpmcore = " \
 e2fsprogs \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libblkid \
 libgcc \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpmcore-devel = " \
 cmake-filesystem \
 kpmcore \
 qt6-qtbase-devel \
 "
