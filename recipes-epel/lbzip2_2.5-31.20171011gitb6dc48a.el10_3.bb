# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lbzip2"
PV = "2.5"
PR = "31.20171011gitb6dc48a.el10_3"
PACKAGES = " \
 lbzip2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lbzip2-2.5-31.20171011gitb6dc48a.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b39badcbc800396fa170b9fde47124e9b5f24a7ddb404cb1f615e17f9e1d86d"

URI_x86_64_v2_lbzip2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lbzip2-2.5-31.20171011gitb6dc48a.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lbzip2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lbzip2}"
SRC_URI[x86_64_v2_lbzip2.sha256sum] = "dc82b18e1da754b30835b42fa6072fe52df93ceea03ed5806ad40ccd37635191"

URI_aarch64_lbzip2 = "${EPEL_MIRROR}/aarch64/Packages/l/lbzip2-2.5-31.20171011gitb6dc48a.el10_3.aarch64.rpm;name=aarch64_lbzip2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lbzip2}"
SRC_URI[aarch64_lbzip2.sha256sum] = "03da75d344a36569b2ef3de92be9038c141eb534d8f9634037456c4ccd08c231"

RDEPENDS:lbzip2 = " \
 glibc \
 "
