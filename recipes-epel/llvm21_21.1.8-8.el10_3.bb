# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm21"
PV = "21.1.8"
PR = "8.el10_3"
PACKAGES = " \
 clang21 \
 clang21-analyzer \
 clang21-devel \
 clang21-libs \
 clang21-resource-filesystem \
 clang21-tools-extra \
 clang21-tools-extra-devel \
 compiler-rt21 \
 git-clang-format21 \
 libomp21 \
 libomp21-devel \
 lld21 \
 lld21-devel \
 lld21-libs \
 lldb21 \
 lldb21-devel \
 llvm21 \
 llvm21-cmake-utils \
 llvm21-devel \
 llvm21-doc \
 llvm21-filesystem \
 llvm21-googletest \
 llvm21-libs \
 llvm21-static \
 llvm21-test \
 llvm21-toolset \
 python3-clang21 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/llvm21-21.1.8-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d322461599f6f491f37db51053d3134964c1d3ee8d63b04b33583f433fc81d0"

URI_aarch64_clang21 = "${EPEL_MIRROR}/aarch64/Packages/c/clang21-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_clang21;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang21}"
SRC_URI[aarch64_clang21.sha256sum] = "0c3446d17bdfbbe662db4f4462a018e63b674c5beaf4b6f90d536f924966e818"

URI_aarch64_clang21-analyzer = "${EPEL_MIRROR}/aarch64/Packages/c/clang21-analyzer-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_clang21-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang21-analyzer}"
SRC_URI[aarch64_clang21-analyzer.sha256sum] = "a13338dd56726b3c32d6170f49c47c7a7ff0036bee238bfd9729ee5dd87c8da8"

URI_aarch64_clang21-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang21-devel-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_clang21-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang21-devel}"
SRC_URI[aarch64_clang21-devel.sha256sum] = "ad657feffaf3d0c9128dec1f027be7524bacc26b40188b37c77d59bc36418272"

URI_aarch64_clang21-libs = "${EPEL_MIRROR}/aarch64/Packages/c/clang21-libs-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_clang21-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang21-libs}"
SRC_URI[aarch64_clang21-libs.sha256sum] = "9366611d7fb752a9b9232e9e61b1666757b01029f81ad3e7ea91aa2a512843d7"
RPROVIDES:clang21-libs:aarch64 = "virtual/libclang-cpp.so.21.1_LLVM_21.1__64bit_ virtual/libclang-cpp.so.21.1___64bit_ virtual/libclang.so.21.1_LLVM_13__64bit_ virtual/libclang.so.21.1_LLVM_16__64bit_ virtual/libclang.so.21.1_LLVM_17__64bit_ virtual/libclang.so.21.1_LLVM_21__64bit_ virtual/libclang.so.21.1___64bit_"

URI_aarch64_clang21-resource-filesystem = "${EPEL_MIRROR}/aarch64/Packages/c/clang21-resource-filesystem-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_clang21-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang21-resource-filesystem}"
SRC_URI[aarch64_clang21-resource-filesystem.sha256sum] = "8ebe04a0861e452615898bbe90e9f58421f59471c3b893557c3d16125e160fad"

URI_aarch64_clang21-tools-extra = "${EPEL_MIRROR}/aarch64/Packages/c/clang21-tools-extra-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_clang21-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang21-tools-extra}"
SRC_URI[aarch64_clang21-tools-extra.sha256sum] = "7fe7b2e6905d6eab6d8a2c926046e783fdac3c016f1e1b20a1d311b9a31ce0d9"

URI_aarch64_clang21-tools-extra-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang21-tools-extra-devel-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_clang21-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang21-tools-extra-devel}"
SRC_URI[aarch64_clang21-tools-extra-devel.sha256sum] = "9469f781d03661aa4cead779a4ac7258d928a881b9335148bf45bc0c1af9b0ea"

URI_aarch64_compiler-rt21 = "${EPEL_MIRROR}/aarch64/Packages/c/compiler-rt21-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_compiler-rt21;unpack=0"
SRC_URI:append = " ${URI_aarch64_compiler-rt21}"
SRC_URI[aarch64_compiler-rt21.sha256sum] = "141067b1cf550614f6ab48cd48d321d29f4a3da76be8a1ab83ba6ad608d95811"

URI_aarch64_git-clang-format21 = "${EPEL_MIRROR}/aarch64/Packages/g/git-clang-format21-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_git-clang-format21;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-clang-format21}"
SRC_URI[aarch64_git-clang-format21.sha256sum] = "9c4b1918f98c5add1bef86be2d0691f17db1475c5f3b0dea91525a166c79ca33"

URI_aarch64_libomp21 = "${EPEL_MIRROR}/aarch64/Packages/l/libomp21-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_libomp21;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp21}"
SRC_URI[aarch64_libomp21.sha256sum] = "7dcb9d1c5468d8cf78e3db82833e40a956f13dee6f8b13adcffbc25c82991226"

URI_aarch64_libomp21-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libomp21-devel-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_libomp21-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp21-devel}"
SRC_URI[aarch64_libomp21-devel.sha256sum] = "8cb898ff45106f6127b536a3d31a38e6f79702eec180464ed435ea995ab57220"

URI_aarch64_lld21 = "${EPEL_MIRROR}/aarch64/Packages/l/lld21-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_lld21;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld21}"
SRC_URI[aarch64_lld21.sha256sum] = "0199700bac49ee104cfa903880115b2781f2633d42390bbee59a8f0302d017c1"

URI_aarch64_lld21-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lld21-devel-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_lld21-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld21-devel}"
SRC_URI[aarch64_lld21-devel.sha256sum] = "de9ff74759423e83ae4413f14e5559db4f83ea0de2f7952e4245e5fc4a47f483"

URI_aarch64_lld21-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lld21-libs-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_lld21-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld21-libs}"
SRC_URI[aarch64_lld21-libs.sha256sum] = "ba67247680306a6c753b91ef613550b27ed68c6d283c65bb7bab09aea4038906"

URI_aarch64_lldb21 = "${EPEL_MIRROR}/aarch64/Packages/l/lldb21-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_lldb21;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb21}"
SRC_URI[aarch64_lldb21.sha256sum] = "57901cec1a91a7b848cb18a2e473dde01e98ab03ba4684d10bc587d7c44dfbe7"

URI_aarch64_lldb21-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lldb21-devel-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_lldb21-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb21-devel}"
SRC_URI[aarch64_lldb21-devel.sha256sum] = "9ecae76d28dbcace543149225713bbbdd305a10e844b1f20fb63b3fabbf5f8e1"

URI_aarch64_llvm21 = "${EPEL_MIRROR}/aarch64/Packages/l/llvm21-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_llvm21;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm21}"
SRC_URI[aarch64_llvm21.sha256sum] = "65cdf1fbbf3e203b419c55664102a50163fee1b245b0d38889598b6f9cd274e1"

URI_aarch64_llvm21-cmake-utils = "${EPEL_MIRROR}/aarch64/Packages/l/llvm21-cmake-utils-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_llvm21-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm21-cmake-utils}"
SRC_URI[aarch64_llvm21-cmake-utils.sha256sum] = "b535c68646396f73f21e8c42ade2f68ae05503dc432cea54655c0ea39af4d96f"

URI_aarch64_llvm21-devel = "${EPEL_MIRROR}/aarch64/Packages/l/llvm21-devel-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_llvm21-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm21-devel}"
SRC_URI[aarch64_llvm21-devel.sha256sum] = "33411e632cfaa473f13e759e8fff3d99073a3fb4dcbde47f27e08c28a0073154"

URI_aarch64_llvm21-doc = "${EPEL_MIRROR}/aarch64/Packages/l/llvm21-doc-21.1.8-8.el10_3.noarch.rpm;name=aarch64_llvm21-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm21-doc}"
SRC_URI[aarch64_llvm21-doc.sha256sum] = "980c686797067035df0a284ab467b04a97f02075b1db9f093b8bce196eb004ec"

URI_aarch64_llvm21-filesystem = "${EPEL_MIRROR}/aarch64/Packages/l/llvm21-filesystem-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_llvm21-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm21-filesystem}"
SRC_URI[aarch64_llvm21-filesystem.sha256sum] = "0292bfe9bad34fdcf79fa020f8aebdaca35e66fa5d6333751e7bcd33e165d6f7"

URI_aarch64_llvm21-googletest = "${EPEL_MIRROR}/aarch64/Packages/l/llvm21-googletest-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_llvm21-googletest;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm21-googletest}"
SRC_URI[aarch64_llvm21-googletest.sha256sum] = "0998f0445b3521df11d9a1a9837457cf7d44f6fd6a66acdaac8fc26a6e55c0a5"

URI_aarch64_llvm21-libs = "${EPEL_MIRROR}/aarch64/Packages/l/llvm21-libs-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_llvm21-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm21-libs}"
SRC_URI[aarch64_llvm21-libs.sha256sum] = "e192970b73de22fe8a4ca0817e5b86b11fa9e7f8567ae63b452390f84eb14cf8"
RPROVIDES:llvm21-libs:aarch64 = "virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ virtual/libLLVM.so.21.1___64bit_"

URI_aarch64_llvm21-static = "${EPEL_MIRROR}/aarch64/Packages/l/llvm21-static-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_llvm21-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm21-static}"
SRC_URI[aarch64_llvm21-static.sha256sum] = "a51791389920f2a8ee9aae0361c331b14aaf05e15f5712e210f523cb350b6842"

URI_aarch64_llvm21-test = "${EPEL_MIRROR}/aarch64/Packages/l/llvm21-test-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_llvm21-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm21-test}"
SRC_URI[aarch64_llvm21-test.sha256sum] = "f68a0f9da8b75b2916bd6e6766b4906ea4165bb697bbaba2c551d82f339ed19b"

URI_aarch64_llvm21-toolset = "${EPEL_MIRROR}/aarch64/Packages/l/llvm21-toolset-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_llvm21-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm21-toolset}"
SRC_URI[aarch64_llvm21-toolset.sha256sum] = "cb1880f599d7f00a9916552576c7b913e15d37a989817193be8630206b6812f0"

URI_aarch64_python3-clang21 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-clang21-21.1.8-8.el10_3.aarch64.rpm;name=aarch64_python3-clang21;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-clang21}"
SRC_URI[aarch64_python3-clang21.sha256sum] = "7897a39f1edbceb3054fc97a250beac15594fc9f4554e10b2ae5ceba6eb724e4"

RDEPENDS:clang21 = " \
 clang21-libs \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libstdc++-devel \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
 virtual/libclang-cpp.so.21.1_LLVM_21.1__64bit_ \
 virtual/libclang-cpp.so.21.1___64bit_ \
 "
RDEPENDS:clang21-analyzer = " \
 clang21 \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Hash-Util \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3 \
 "
RDEPENDS:clang21-devel = " \
 clang21 \
 clang21-libs \
 clang21-tools-extra \
 glibc \
 libgcc \
 libstdc++ \
 llvm21-devel \
 virtual/libclang-cpp.so.21.1___64bit_ \
 virtual/libclang.so.21.1___64bit_ \
 "
RDEPENDS:clang21-libs = " \
 clang21-resource-filesystem \
 gcc-toolset-15-gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 llvm21-libs \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
 "
RDEPENDS:clang21-resource-filesystem = " \
 "
RDEPENDS:clang21-tools-extra = " \
 clang21-libs \
 emacs-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 python3 \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
 virtual/libclang-cpp.so.21.1_LLVM_21.1__64bit_ \
 virtual/libclang-cpp.so.21.1___64bit_ \
 virtual/libclang.so.21.1_LLVM_13__64bit_ \
 virtual/libclang.so.21.1_LLVM_16__64bit_ \
 virtual/libclang.so.21.1_LLVM_17__64bit_ \
 virtual/libclang.so.21.1_LLVM_21__64bit_ \
 virtual/libclang.so.21.1___64bit_ \
 "
RDEPENDS:clang21-tools-extra-devel = " \
 clang21-tools-extra \
 "
RDEPENDS:compiler-rt21 = " \
 clang21-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:git-clang-format21 = " \
 clang21-tools-extra \
 git \
 python3 \
 "
RDEPENDS:libomp21 = " \
 elfutils-libelf \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 llvm21-libs \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
 "
RDEPENDS:libomp21-devel = " \
 clang21-resource-filesystem \
 libomp21 \
 "
RDEPENDS:lld21 = " \
 alternatives \
 glibc \
 libgcc \
 libstdc++ \
 lld21-libs \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
 "
RDEPENDS:lld21-devel = " \
 lld21-libs \
 "
RDEPENDS:lld21-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm21-libs \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:lldb21 = " \
 clang21-libs \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 libxml2 \
 ncurses-libs \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
 virtual/libclang-cpp.so.21.1_LLVM_21.1__64bit_ \
 virtual/libclang-cpp.so.21.1___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb21-devel = " \
 lldb21 \
 "
RDEPENDS:llvm21 = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm21-libs \
 python3 \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:llvm21-cmake-utils = " \
 llvm21-filesystem \
 "
RDEPENDS:llvm21-devel = " \
 alternatives \
 bash \
 glibc \
 libedit-devel \
 libgcc \
 libstdc++ \
 libzstd-devel \
 llvm21 \
 llvm21-googletest \
 llvm21-libs \
 llvm21-static \
 llvm21-test \
 virtual/libLLVM.so.21.1___64bit_ \
 "
RDEPENDS:llvm21-doc = " \
 llvm21 \
 "
RDEPENDS:llvm21-filesystem = " \
 "
RDEPENDS:llvm21-googletest = " \
 llvm21-filesystem \
 "
RDEPENDS:llvm21-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 libxml2 \
 libzstd \
 llvm21-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:llvm21-static = " \
 llvm21-filesystem \
 "
RDEPENDS:llvm21-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm21 \
 llvm21-libs \
 virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ \
 virtual/libLLVM.so.21.1___64bit_ \
 "
RDEPENDS:llvm21-toolset = " \
 clang21 \
 lld21 \
 llvm21 \
 "
RDEPENDS:python3-clang21 = " \
 clang21-devel \
 python3 \
 "

PROVIDES:append:aarch64 = " rpm/virtual/libLLVM.so.21.1_LLVM_21.1__64bit_ rpm/virtual/libLLVM.so.21.1___64bit_ rpm/virtual/libclang-cpp.so.21.1_LLVM_21.1__64bit_ rpm/virtual/libclang-cpp.so.21.1___64bit_ rpm/virtual/libclang.so.21.1_LLVM_13__64bit_ rpm/virtual/libclang.so.21.1_LLVM_16__64bit_ rpm/virtual/libclang.so.21.1_LLVM_17__64bit_ rpm/virtual/libclang.so.21.1_LLVM_21__64bit_ rpm/virtual/libclang.so.21.1___64bit_"
