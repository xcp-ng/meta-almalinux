# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-lazy-fixture"
PV = "0.6.3"
PR = "27.el10_1"
PACKAGES = " \
 python3-pytest-lazy-fixture \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-lazy-fixture-0.6.3-27.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0af760630e4ffa445d5a61c3be5a38dd12c73ee695e3ef0ea0c2dac3068e2489"

URI_x86_64_v2_python3-pytest-lazy-fixture = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-lazy-fixture-0.6.3-27.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-lazy-fixture;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-lazy-fixture}"
SRC_URI[x86_64_v2_python3-pytest-lazy-fixture.sha256sum] = "6495c7a20f43b8b2ba4ecdeb36df0d7b3828636c5fe645fb1e723049b30e2d52"

URI_aarch64_python3-pytest-lazy-fixture = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-lazy-fixture-0.6.3-27.el10_1.noarch.rpm;name=aarch64_python3-pytest-lazy-fixture;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-lazy-fixture}"
SRC_URI[aarch64_python3-pytest-lazy-fixture.sha256sum] = "5d0a7497b521e78d1eaa9903fd54ebb69a88392a53de53f6425ac4835a42919e"

RDEPENDS:python3-pytest-lazy-fixture = " \
 python3 \
 python3-pytest \
 "
