# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "slirp4netns"
PV = "1.3.4"
PR = "1.el10"
PACKAGES = " \
 slirp4netns \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/slirp4netns-1.3.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a5a49c28dbe7d1640a1f84b511d6f70e2fdd54a916b89e8e67e42a0141d8432"

URI_x86_64_v2_slirp4netns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/slirp4netns-1.3.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_slirp4netns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slirp4netns}"
SRC_URI[x86_64_v2_slirp4netns.sha256sum] = "58e99bdf3398362013e4c330d174882cdc83d651a97a292acef9bbb9c38928f2"

URI_aarch64_slirp4netns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/slirp4netns-1.3.4-1.el10.aarch64.rpm;name=aarch64_slirp4netns;unpack=0"
SRC_URI:append = " ${URI_aarch64_slirp4netns}"
SRC_URI[aarch64_slirp4netns.sha256sum] = "28178a33ba3494cd9f7b39536be2c815a3d0ad40450632683e1cb65241f914ef"

RDEPENDS:slirp4netns = " \
 glib2 \
 glibc \
 libseccomp \
 libslirp \
 "
