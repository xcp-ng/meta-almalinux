# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-vendor-filterer"
PV = "0.5.18"
PR = "5.el10_2"
PACKAGES = " \
 cargo-vendor-filterer \
 rust-cargo-vendor-filterer+default-devel \
 rust-cargo-vendor-filterer+openssl-devel \
 rust-cargo-vendor-filterer+sha-rs-devel \
 rust-cargo-vendor-filterer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-vendor-filterer-0.5.18-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38012f957b51cd388a59c48abba705e850cae80b595852bfc7a8ffd94a82a0c7"

URI_x86_64_v2_cargo-vendor-filterer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-vendor-filterer-0.5.18-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cargo-vendor-filterer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo-vendor-filterer}"
SRC_URI[x86_64_v2_cargo-vendor-filterer.sha256sum] = "c99e69e7076f253c21e1de6b63d9302902d72df442f7845507714d1e541b9c5b"

URI_x86_64_v2_rust-cargo-vendor-filterer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer+default-devel-0.5.18-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer+default-devel.sha256sum] = "74b03362e83fc004fb18cb583fd0309edaf88eab7d0292376ebeeb06425ddf38"

URI_x86_64_v2_rust-cargo-vendor-filterer+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer+openssl-devel-0.5.18-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer+openssl-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer+openssl-devel.sha256sum] = "c948a9fb12ba1e977a65ed24da722c0c2cbafeaa2a80b0d876c65eb85cf22e64"

URI_x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer+sha-rs-devel-0.5.18-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer+sha-rs-devel.sha256sum] = "76d10e9a1d1acd812958eddfec926dbc473e75623c1efa6d826ad25f9bafea95"

URI_x86_64_v2_rust-cargo-vendor-filterer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer-devel-0.5.18-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer-devel.sha256sum] = "2914ace27416067c0199e58be54afc7ac5f0354d77dc5699dbd1d84d62e0a03e"

URI_aarch64_cargo-vendor-filterer = "${EPEL_MIRROR}/aarch64/Packages/c/cargo-vendor-filterer-0.5.18-5.el10_2.aarch64.rpm;name=aarch64_cargo-vendor-filterer;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo-vendor-filterer}"
SRC_URI[aarch64_cargo-vendor-filterer.sha256sum] = "60b35767b0f4774594b6ecaec69f50d0e8d9da828c29dcfe8b29425007d469de"

URI_aarch64_rust-cargo-vendor-filterer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer+default-devel-0.5.18-5.el10_2.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer+default-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer+default-devel.sha256sum] = "0332581d023f14d1a0f05d0d5ea99b85cb9195bb2b00862202f7313eb80e1497"

URI_aarch64_rust-cargo-vendor-filterer+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer+openssl-devel-0.5.18-5.el10_2.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer+openssl-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer+openssl-devel.sha256sum] = "1d2692a1856cbef962de872a0526c79fea7bee429f66a55b55e575b6b35adb85"

URI_aarch64_rust-cargo-vendor-filterer+sha-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer+sha-rs-devel-0.5.18-5.el10_2.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer+sha-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer+sha-rs-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer+sha-rs-devel.sha256sum] = "a32f9b2b380a54c11fe72790d787c8ca9e660879b34fc81f91dfe48ef4e91f6a"

URI_aarch64_rust-cargo-vendor-filterer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer-devel-0.5.18-5.el10_2.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer-devel.sha256sum] = "6e5e0ba67d9b0cd03020079a43b4f04739699fc80aff1ca930f32b93c14f3974"

RDEPENDS:cargo-vendor-filterer = " \
 glibc \
 libgcc \
 openssl-libs \
 "
RDEPENDS:rust-cargo-vendor-filterer+default-devel = " \
 cargo \
 rust-cargo-vendor-filterer+sha-rs-devel \
 rust-cargo-vendor-filterer-devel \
 "
RDEPENDS:rust-cargo-vendor-filterer+openssl-devel = " \
 cargo \
 rust-cargo-vendor-filterer-devel \
 rust-openssl+default-devel \
 "
RDEPENDS:rust-cargo-vendor-filterer+sha-rs-devel = " \
 cargo \
 rust-cargo-vendor-filterer-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-cargo-vendor-filterer-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-camino+default-devel \
 rust-cargo-lock+default-devel \
 rust-cargo_metadata0.18+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+wrap_help-devel \
 rust-either+default-devel \
 rust-flate2+default-devel \
 rust-glob+default-devel \
 rust-hex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_ignored+default-devel \
 rust-serde_json+default-devel \
 rust-smallvec+default-devel \
 rust-tar-devel \
 rust-tempfile+default-devel \
 rust-toml0.8+default-devel \
 rust-walkdir+default-devel \
 "
