# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opkssh"
PV = "0.16.0"
PR = "1.el10_3"
PACKAGES = " \
 opkssh \
 opkssh-doc \
 opkssh-server \
 opkssh-server-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opkssh-0.16.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45f50c1cd5e652d9eeaa35ec0407ef69eff4ed6f40c5adcbe08eaa835557ef5b"

URI_x86_64_v2_opkssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-0.16.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opkssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh}"
SRC_URI[x86_64_v2_opkssh.sha256sum] = "fb9cf5c475d51cd5bed0c8a62851f2ab3e342c175a418225e9e37e99d84d479a"

URI_x86_64_v2_opkssh-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-doc-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh-doc}"
SRC_URI[x86_64_v2_opkssh-doc.sha256sum] = "2bfa821964b3c0f8273cff17c1cbb28474decd56c359634903e3e80993a2537f"

URI_x86_64_v2_opkssh-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-server-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh-server}"
SRC_URI[x86_64_v2_opkssh-server.sha256sum] = "b8f3d06505b448245e5a92474110a743e54bf1a62a2f3e6139f4818df381b929"

URI_x86_64_v2_opkssh-server-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-server-selinux-0.16.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-server-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh-server-selinux}"
SRC_URI[x86_64_v2_opkssh-server-selinux.sha256sum] = "bf1aad2638ee06cecc6970e81551cfe789b5c9a14e3b5109144b8ece5383b866"

URI_aarch64_opkssh = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-0.16.0-1.el10_3.aarch64.rpm;name=aarch64_opkssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh}"
SRC_URI[aarch64_opkssh.sha256sum] = "2b4a929d50ccf3d82dce47d801b6d21c2cc84106dccc7aa953b6dbe72af7b681"

URI_aarch64_opkssh-doc = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-doc-0.16.0-1.el10_3.noarch.rpm;name=aarch64_opkssh-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh-doc}"
SRC_URI[aarch64_opkssh-doc.sha256sum] = "29ed23cdff6afef027b2cf3c2546da006c2337bbb2d0e4476ff0b1ca60b11d1a"

URI_aarch64_opkssh-server = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-server-0.16.0-1.el10_3.noarch.rpm;name=aarch64_opkssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh-server}"
SRC_URI[aarch64_opkssh-server.sha256sum] = "695018134d621862701f40e385f9775624df196082d74e33de7528259ef7cd60"

URI_aarch64_opkssh-server-selinux = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-server-selinux-0.16.0-1.el10_3.noarch.rpm;name=aarch64_opkssh-server-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh-server-selinux}"
SRC_URI[aarch64_opkssh-server-selinux.sha256sum] = "f436fa68ad8889670895375fb60d1ea4ab941b51b13d2aed4406d8ba4a644af6"

RDEPENDS:opkssh = " \
 glibc \
 shadow-utils \
 "
RDEPENDS:opkssh-doc = " \
 "
RDEPENDS:opkssh-server = " \
 bash \
 opkssh \
 opkssh-server-selinux \
 "
RDEPENDS:opkssh-server-selinux = " \
 bash \
 selinux-policy-targeted \
 "
