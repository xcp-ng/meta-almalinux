# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rfc3986-validator"
PV = "0.1.1"
PR = "17.el10_0"
PACKAGES = " \
 python3-rfc3986-validator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rfc3986-validator-0.1.1-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e7c13e404c20d6dc3b65aeee1fdfa5a466fd0a56b07783a5a57079c017a9dad"

URI_x86_64_v2_python3-rfc3986-validator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rfc3986-validator-0.1.1-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rfc3986-validator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rfc3986-validator}"
SRC_URI[x86_64_v2_python3-rfc3986-validator.sha256sum] = "3f7fd6027ad5f47cb036bc3c026afbf8f224a0226833e67763bdf041316617f3"

URI_aarch64_python3-rfc3986-validator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rfc3986-validator-0.1.1-17.el10_0.noarch.rpm;name=aarch64_python3-rfc3986-validator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rfc3986-validator}"
SRC_URI[aarch64_python3-rfc3986-validator.sha256sum] = "4bf7453af1b853d5c2ffcbe8e2be923376193cbd3f3d66bd9083cb6f12812f45"

RDEPENDS:python3-rfc3986-validator = " \
 python3 \
 "
