# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-compact_str0.9"
PV = "0.9.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-compact_str0.9+arbitrary-devel \
 rust-compact_str0.9+bytes-devel \
 rust-compact_str0.9+default-devel \
 rust-compact_str0.9+proptest-devel \
 rust-compact_str0.9+quickcheck-devel \
 rust-compact_str0.9+rkyv-devel \
 rust-compact_str0.9+serde-devel \
 rust-compact_str0.9+smallvec-devel \
 rust-compact_str0.9+std-devel \
 rust-compact_str0.9+zeroize-devel \
 rust-compact_str0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-compact_str0.9-0.9.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a16426067d5a48919fe3f359b6f7527ee3c81fe61442e7d8a2a8eb12274c804c"

URI_x86_64_v2_rust-compact_str0.9+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9+arbitrary-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9+arbitrary-devel.sha256sum] = "ced8a1f539f4b25fa36c90c9393e2f032c6e0461cb1d341f4a743f3990623d7b"

URI_x86_64_v2_rust-compact_str0.9+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9+bytes-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9+bytes-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9+bytes-devel.sha256sum] = "8909c106ae73eed589ff2a75665ad5ce34e84211dcea618518550a7feadafa45"

URI_x86_64_v2_rust-compact_str0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9+default-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9+default-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9+default-devel.sha256sum] = "7f245536b62b412ce4c428bdbc3037a30ca898714a5fca31762b43c79ed01711"

URI_x86_64_v2_rust-compact_str0.9+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9+proptest-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9+proptest-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9+proptest-devel.sha256sum] = "d551f4215c2f5703e8eaff094b77ae4e1c2f9e615a6e2a2cc0a36ee2e688112a"

URI_x86_64_v2_rust-compact_str0.9+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9+quickcheck-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9+quickcheck-devel.sha256sum] = "4852356201699d162d9b03e81baff1142e69c005c0503969a9145fe2c0554991"

URI_x86_64_v2_rust-compact_str0.9+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9+rkyv-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9+rkyv-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9+rkyv-devel.sha256sum] = "63c5a5ed4f391509af9c786c8230d630ee849fb1654e7df5ca30d775d5328753"

URI_x86_64_v2_rust-compact_str0.9+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9+serde-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9+serde-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9+serde-devel.sha256sum] = "19694c87e87f0e5d54b777da89717ea67f234f4249a57bf7d70184febaed8530"

URI_x86_64_v2_rust-compact_str0.9+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9+smallvec-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9+smallvec-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9+smallvec-devel.sha256sum] = "bca45e627f0f5eab04b4c678082beafbdd1865b878f7c7ff91a557e9c401e721"

URI_x86_64_v2_rust-compact_str0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9+std-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9+std-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9+std-devel.sha256sum] = "86273d31ea3c50f4fa577c7afa00c9651af75d82e00f817c3b61cb35c3bb1c97"

URI_x86_64_v2_rust-compact_str0.9+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9+zeroize-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9+zeroize-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9+zeroize-devel.sha256sum] = "903d406a10c83bf4b67a216f00f95f3075d6fe5894206a6ff7825c7ac2fd9213"

URI_x86_64_v2_rust-compact_str0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str0.9-devel-0.9.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str0.9-devel}"
SRC_URI[x86_64_v2_rust-compact_str0.9-devel.sha256sum] = "24d968566b39b8a21387da3c7d34d8aad7b037dce31975ee01cbd52c073d1c49"

URI_aarch64_rust-compact_str0.9+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9+arbitrary-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9+arbitrary-devel}"
SRC_URI[aarch64_rust-compact_str0.9+arbitrary-devel.sha256sum] = "038868fead6d55c0f7da22f8287d2ae1735ac3fc2592c795ef3c226d734790e5"

URI_aarch64_rust-compact_str0.9+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9+bytes-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9+bytes-devel}"
SRC_URI[aarch64_rust-compact_str0.9+bytes-devel.sha256sum] = "bab0fe21f9cc9d8a7fd2147270635cce81288a911c884cf751371fe4f014b5c9"

URI_aarch64_rust-compact_str0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9+default-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9+default-devel}"
SRC_URI[aarch64_rust-compact_str0.9+default-devel.sha256sum] = "d47e03bc4902f3ab489ad7e76edbd52258aa2cf8c5b4e80db01afa230fb81278"

URI_aarch64_rust-compact_str0.9+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9+proptest-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9+proptest-devel}"
SRC_URI[aarch64_rust-compact_str0.9+proptest-devel.sha256sum] = "c63849944331530ead543bc9aa2f1dba7ba2c01268f033691d9d887d78199d00"

URI_aarch64_rust-compact_str0.9+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9+quickcheck-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9+quickcheck-devel}"
SRC_URI[aarch64_rust-compact_str0.9+quickcheck-devel.sha256sum] = "740c0983aa3f97a3032b580b0b09d7770e41e5cdd9d274771ea5149db8ca2782"

URI_aarch64_rust-compact_str0.9+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9+rkyv-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9+rkyv-devel}"
SRC_URI[aarch64_rust-compact_str0.9+rkyv-devel.sha256sum] = "49c4c118cbca7a0a253312f911458189b6956fd4de7107de2bb9977f3d3a89a2"

URI_aarch64_rust-compact_str0.9+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9+serde-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9+serde-devel}"
SRC_URI[aarch64_rust-compact_str0.9+serde-devel.sha256sum] = "95c3dc731513404664c190b6db57c1b37cc10deacd5dd217531b78f552127731"

URI_aarch64_rust-compact_str0.9+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9+smallvec-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9+smallvec-devel}"
SRC_URI[aarch64_rust-compact_str0.9+smallvec-devel.sha256sum] = "dc91efbe1a50833af1704a80fb028562d152109058fe059f8a6e0bed5865f589"

URI_aarch64_rust-compact_str0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9+std-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9+std-devel}"
SRC_URI[aarch64_rust-compact_str0.9+std-devel.sha256sum] = "b97dc9cddc80948fe7093a5291ea02e970755aeda3920b9f35b29ca1184ae332"

URI_aarch64_rust-compact_str0.9+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9+zeroize-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9+zeroize-devel}"
SRC_URI[aarch64_rust-compact_str0.9+zeroize-devel.sha256sum] = "e10f1fc670c24de1354bec6c403c0ce7a7eb87f92c8477039696d4e7f25ce75c"

URI_aarch64_rust-compact_str0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str0.9-devel-0.9.1-1.el10_3.noarch.rpm;name=aarch64_rust-compact_str0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str0.9-devel}"
SRC_URI[aarch64_rust-compact_str0.9-devel.sha256sum] = "5616f0f4a4a4d161b37220df5a7b3a237fcdfd0671d4325f7c1755c302b2e4d8"

RDEPENDS:rust-compact_str0.9+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-compact_str0.9-devel \
 "
RDEPENDS:rust-compact_str0.9+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-compact_str0.9-devel \
 "
RDEPENDS:rust-compact_str0.9+default-devel = " \
 cargo \
 rust-compact_str0.9+std-devel \
 rust-compact_str0.9-devel \
 "
RDEPENDS:rust-compact_str0.9+proptest-devel = " \
 cargo \
 rust-compact_str0.9-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-compact_str0.9+quickcheck-devel = " \
 cargo \
 rust-compact_str0.9-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-compact_str0.9+rkyv-devel = " \
 cargo \
 rust-compact_str0.9-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-compact_str0.9+serde-devel = " \
 cargo \
 rust-compact_str0.9-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-compact_str0.9+smallvec-devel = " \
 cargo \
 rust-compact_str0.9-devel \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
RDEPENDS:rust-compact_str0.9+std-devel = " \
 cargo \
 rust-compact_str0.9-devel \
 "
RDEPENDS:rust-compact_str0.9+zeroize-devel = " \
 cargo \
 rust-compact_str0.9-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-compact_str0.9-devel = " \
 cargo \
 rust-castaway+alloc-devel \
 rust-castaway-devel \
 rust-cfg-if+default-devel \
 rust-itoa+default-devel \
 rust-rustversion+default-devel \
 rust-ryu+default-devel \
 rust-static_assertions+default-devel \
 "
