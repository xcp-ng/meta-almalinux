# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fqdn"
PV = "1.5.1"
PR = "15.el10_1"
PACKAGES = " \
 python3-fqdn \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fqdn-1.5.1-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ef4c9f87c1f2006c11d661a19eb05a768eff5006e3ffb32899069a77544f884"

URI_x86_64_v2_python3-fqdn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fqdn-1.5.1-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fqdn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fqdn}"
SRC_URI[x86_64_v2_python3-fqdn.sha256sum] = "3c8ade4d3b4da46e17e254dbef9dcf904703a9999769fba2d6b6c23c8b6ef863"

URI_aarch64_python3-fqdn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fqdn-1.5.1-15.el10_1.noarch.rpm;name=aarch64_python3-fqdn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fqdn}"
SRC_URI[aarch64_python3-fqdn.sha256sum] = "60a835147f5e12bdcdfa09bb648d6e4d264a09ed688e1f18a200123b0b2b685c"

RDEPENDS:python3-fqdn = " \
 python3 \
 "
