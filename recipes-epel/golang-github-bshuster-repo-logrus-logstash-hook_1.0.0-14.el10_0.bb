# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-bshuster-repo-logrus-logstash-hook"
PV = "1.0.0"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-bshuster-repo-logrus-logstash-hook-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-bshuster-repo-logrus-logstash-hook-1.0.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "816c9c55ebb84ae5e3194c94c770630401bf693fc8b675232ad88c5d7b5b48f5"

URI_x86_64_v2_golang-github-bshuster-repo-logrus-logstash-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-bshuster-repo-logrus-logstash-hook-devel-1.0.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-bshuster-repo-logrus-logstash-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-bshuster-repo-logrus-logstash-hook-devel}"
SRC_URI[x86_64_v2_golang-github-bshuster-repo-logrus-logstash-hook-devel.sha256sum] = "11bcb289275883136f92488ff88fdb0f5b34db8e99dc0b160cf8ad94fb535d15"

URI_aarch64_golang-github-bshuster-repo-logrus-logstash-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-bshuster-repo-logrus-logstash-hook-devel-1.0.0-14.el10_0.noarch.rpm;name=aarch64_golang-github-bshuster-repo-logrus-logstash-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-bshuster-repo-logrus-logstash-hook-devel}"
SRC_URI[aarch64_golang-github-bshuster-repo-logrus-logstash-hook-devel.sha256sum] = "e459f329a14977033d56e8f8114b55e2c4d1490d75ab9b0381b750d890715c14"

RDEPENDS:golang-github-bshuster-repo-logrus-logstash-hook-devel = " \
 go-filesystem \
 golang-github-sirupsen-logrus-devel \
 "
