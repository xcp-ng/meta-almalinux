# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fflas-ffpack"
PV = "2.5.0"
PR = "15.el10_1"
PACKAGES = " \
 fflas-ffpack-devel \
 fflas-ffpack-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fflas-ffpack-2.5.0-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "710a7879685c77a287008017b8ae78adf5b31af88aefe651281de07b925c8059"

URI_x86_64_v2_fflas-ffpack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fflas-ffpack-devel-2.5.0-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fflas-ffpack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fflas-ffpack-devel}"
SRC_URI[x86_64_v2_fflas-ffpack-devel.sha256sum] = "1f8a8acfd3478e09ca404e6d41b66e9ca944a96ccfcf79cdea4c41fd29746ea2"

URI_x86_64_v2_fflas-ffpack-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fflas-ffpack-doc-2.5.0-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fflas-ffpack-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fflas-ffpack-doc}"
SRC_URI[x86_64_v2_fflas-ffpack-doc.sha256sum] = "d8b2bb96da0d42ce9e890b4da7e95a13066906c478c6a8c288437d0803af069d"

URI_aarch64_fflas-ffpack-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fflas-ffpack-devel-2.5.0-15.el10_1.aarch64.rpm;name=aarch64_fflas-ffpack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fflas-ffpack-devel}"
SRC_URI[aarch64_fflas-ffpack-devel.sha256sum] = "ca9bc832ec232020007057afbdf6220f53ad91c40ad3584c6bed06147f107e8a"

URI_aarch64_fflas-ffpack-doc = "${EPEL_MIRROR}/aarch64/Packages/f/fflas-ffpack-doc-2.5.0-15.el10_1.noarch.rpm;name=aarch64_fflas-ffpack-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fflas-ffpack-doc}"
SRC_URI[aarch64_fflas-ffpack-doc.sha256sum] = "3fb1dbf47cf46bd22d64bfaa17c86553eab8df6862e9e5156afa8e7d35e0e956"

RDEPENDS:fflas-ffpack-devel = " \
 bash \
 flexiblas-devel \
 givaro-devel \
 gmp-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:fflas-ffpack-doc = " \
 "
