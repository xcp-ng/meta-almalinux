# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ipykernel"
PV = "6.29.3"
PR = "11.el10_1"
PACKAGES = " \
 python3-ipykernel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ipykernel-6.29.3-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5789d77072f234bc5fb6c2316af4f7f6a9fd68b4baeab59e7fc92f27941577f1"

URI_x86_64_v2_python3-ipykernel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipykernel-6.29.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipykernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipykernel}"
SRC_URI[x86_64_v2_python3-ipykernel.sha256sum] = "1cac1278aef7c359b984e9a8a7139c394450b03cfd55460f1cb97d31b614d899"

URI_aarch64_python3-ipykernel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipykernel-6.29.3-11.el10_1.noarch.rpm;name=aarch64_python3-ipykernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipykernel}"
SRC_URI[aarch64_python3-ipykernel.sha256sum] = "d735f5799db8f67ec08902a4a8980e7fce0041571775d7e1d5304ee46ba1aafd"

RDEPENDS:python3-ipykernel = " \
 python-jupyter-filesystem \
 python3 \
 python3-comm \
 python3-ipython \
 python3-jupyter-client \
 python3-jupyter-core \
 python3-matplotlib-inline \
 python3-nest-asyncio \
 python3-packaging \
 python3-psutil \
 python3-pyzmq \
 python3-tornado \
 python3-traitlets \
 "
