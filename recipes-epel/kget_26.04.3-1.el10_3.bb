# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kget"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kget \
 kget-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kget-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b0650ba7ff5fe45c4d46a5af23ac779dd9e15506eafa021f16f266739168f23"

URI_x86_64_v2_kget = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kget-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kget;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kget}"
SRC_URI[x86_64_v2_kget.sha256sum] = "2a24bb66c2eb5efdf4f13508783e74f3270bda96925c607fbb1700687e144a2b"

URI_x86_64_v2_kget-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kget-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kget-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kget-libs}"
SRC_URI[x86_64_v2_kget-libs.sha256sum] = "f924173cfb50c4444849b239dd6cf94ae5cb5ea2e144be6c10c0e65a90676802"

URI_aarch64_kget = "${EPEL_MIRROR}/aarch64/Packages/k/kget-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kget;unpack=0"
SRC_URI:append = " ${URI_aarch64_kget}"
SRC_URI[aarch64_kget.sha256sum] = "4a2aec3ac6dd255769aa721e9a63f5a463dc59081b60a979548105ff62eefe58"

URI_aarch64_kget-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kget-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kget-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kget-libs}"
SRC_URI[aarch64_kget-libs.sha256sum] = "73dd40150952dcad58c516ae814edf44616acd87cfefe09f1c13a117ece72cf4"

RDEPENDS:kget = " \
 glibc \
 gpgme2pp \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kget-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kget-libs = " \
 glibc \
 gpgme2pp \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kget \
 libgcc \
 libktorrent \
 libmms \
 libstdc++ \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
