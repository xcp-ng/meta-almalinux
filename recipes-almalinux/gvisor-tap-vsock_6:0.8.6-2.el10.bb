# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gvisor-tap-vsock"
PE = "6"
PV = "0.8.6"
PR = "2.el10"
PACKAGES = " \
 gvisor-tap-vsock \
 gvisor-tap-vsock-gvforwarder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gvisor-tap-vsock-0.8.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3744a1deebde45ec61e9f4c5457b2faa9cf454e6cac73badd498e1d819cda383"

URI_x86_64_v2_gvisor-tap-vsock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvisor-tap-vsock-0.8.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_gvisor-tap-vsock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvisor-tap-vsock}"
SRC_URI[x86_64_v2_gvisor-tap-vsock.sha256sum] = "a03d51603089374fe97af91ef31d71e5a70ac0270028e9a42c61d6d8bb0e2a7d"

URI_x86_64_v2_gvisor-tap-vsock-gvforwarder = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gvisor-tap-vsock-gvforwarder-0.8.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_gvisor-tap-vsock-gvforwarder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gvisor-tap-vsock-gvforwarder}"
SRC_URI[x86_64_v2_gvisor-tap-vsock-gvforwarder.sha256sum] = "c2b4edd2990699c3a93fa80a43ae45787da48a668ab3ea13c5e2533a789d4517"

URI_aarch64_gvisor-tap-vsock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvisor-tap-vsock-0.8.6-2.el10.aarch64.rpm;name=aarch64_gvisor-tap-vsock;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvisor-tap-vsock}"
SRC_URI[aarch64_gvisor-tap-vsock.sha256sum] = "04687811e08c49e84d969d29c29eb42a08715405408311828658f8c3d6bd3d9c"

URI_aarch64_gvisor-tap-vsock-gvforwarder = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gvisor-tap-vsock-gvforwarder-0.8.6-2.el10.aarch64.rpm;name=aarch64_gvisor-tap-vsock-gvforwarder;unpack=0"
SRC_URI:append = " ${URI_aarch64_gvisor-tap-vsock-gvforwarder}"
SRC_URI[aarch64_gvisor-tap-vsock-gvforwarder.sha256sum] = "3fc96bbda43d598b6d5e675da03035e42d585c627d2ce9adbb4b5669832c0463"

RDEPENDS:gvisor-tap-vsock = " \
 glibc \
 gvisor-tap-vsock-gvforwarder \
 "
RDEPENDS:gvisor-tap-vsock-gvforwarder = " \
 glibc \
 "
