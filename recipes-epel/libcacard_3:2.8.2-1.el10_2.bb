# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcacard"
PE = "3"
PV = "2.8.2"
PR = "1.el10_2"
PACKAGES = " \
 libcacard \
 libcacard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcacard-2.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4730aa6b2d4d74862dbaa4a30f19861d7881726b53909e8dfb443b7b8a58e5b"

URI_x86_64_v2_libcacard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcacard-2.8.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcacard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcacard}"
SRC_URI[x86_64_v2_libcacard.sha256sum] = "7de34c7dc74f3036a6156af43cf58a6f1895cf7d509af46681d28d6bcd304fb5"

URI_x86_64_v2_libcacard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcacard-devel-2.8.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcacard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcacard-devel}"
SRC_URI[x86_64_v2_libcacard-devel.sha256sum] = "4f93eeb7e93103abe26d0a540673ef60678cca26556c1c0ae07dcaefcbec56c7"

URI_aarch64_libcacard = "${EPEL_MIRROR}/aarch64/Packages/l/libcacard-2.8.2-1.el10_2.aarch64.rpm;name=aarch64_libcacard;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcacard}"
SRC_URI[aarch64_libcacard.sha256sum] = "ebca9d07c3f9a2ff5909bd63f1ca3fd9e8cb33bc09d2891782b29b7ce2c38ff5"

URI_aarch64_libcacard-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcacard-devel-2.8.2-1.el10_2.aarch64.rpm;name=aarch64_libcacard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcacard-devel}"
SRC_URI[aarch64_libcacard-devel.sha256sum] = "246082b3a7365ac9d2adfcf3d54837abe3f97ca7be89dc19900585d579afa7db"

RDEPENDS:libcacard = " \
 glib2 \
 glibc \
 nspr \
 nss \
 pcsc-lite-libs \
 "
RDEPENDS:libcacard-devel = " \
 glib2-devel \
 libcacard \
 nss-devel \
 pcsc-lite-devel \
 pkgconf-pkg-config \
 "
