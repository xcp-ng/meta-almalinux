# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Path"
PV = "2.18"
PR = "512.el10"
PACKAGES = " \
 perl-File-Path \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-File-Path-2.18-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42aeb1e05a205981a04b03d7937ae7faf20c3970bd0b9de0de0ed0fb7e7d14b4"

URI_x86_64_v2_perl-File-Path = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-Path-2.18-512.el10.noarch.rpm;name=x86_64_v2_perl-File-Path;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Path}"
SRC_URI[x86_64_v2_perl-File-Path.sha256sum] = "28f643273a72c297e9f68c3f8cb8018852c7bcd97ac7cd974198a673e7fbdc14"

URI_aarch64_perl-File-Path = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-Path-2.18-512.el10.noarch.rpm;name=aarch64_perl-File-Path;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Path}"
SRC_URI[aarch64_perl-File-Path.sha256sum] = "28f643273a72c297e9f68c3f8cb8018852c7bcd97ac7cd974198a673e7fbdc14"

RDEPENDS:perl-File-Path = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 perl-vars \
 "
