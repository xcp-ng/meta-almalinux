# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-authlib"
PV = "1.3.2"
PR = "5.el10_0"
PACKAGES = " \
 python3-authlib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-authlib-1.3.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bf8cb27ed57af99dde67a77d9f35c7689441e714688ca9e01bcf2f366d2761b"

URI_x86_64_v2_python3-authlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-authlib-1.3.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-authlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-authlib}"
SRC_URI[x86_64_v2_python3-authlib.sha256sum] = "959c442ba47127d82c9fd5a120e4dcbf8667a17f8ff215e0e7d5f482bc4da5d3"

URI_aarch64_python3-authlib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-authlib-1.3.2-5.el10_0.noarch.rpm;name=aarch64_python3-authlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-authlib}"
SRC_URI[aarch64_python3-authlib.sha256sum] = "1f289e62885260253f5af89058376e6e1a93668651dccdb6dd0257436d500401"

RDEPENDS:python3-authlib = " \
 python3 \
 python3-cryptography \
 "
