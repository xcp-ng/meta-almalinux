# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libloader"
PV = "1.1.3"
PR = "45.el10_2"
PACKAGES = " \
 libloader \
 libloader-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libloader-1.1.3-45.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fafdbcf05522cf60a300834f60a43c350af91599b6fce46f2704bd2797c2284"

URI_x86_64_v2_libloader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libloader-1.1.3-45.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libloader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libloader}"
SRC_URI[x86_64_v2_libloader.sha256sum] = "7e6efd5384766b3bd9e30a3cd0024a97aed16c96f264f6b43d5ddc5b7cc52ee8"

URI_x86_64_v2_libloader-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libloader-javadoc-1.1.3-45.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libloader-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libloader-javadoc}"
SRC_URI[x86_64_v2_libloader-javadoc.sha256sum] = "f954b4cf9e43efb2889591f7ac4a2a1fc233de517c2e74c2420d54b33c188c16"

URI_aarch64_libloader = "${EPEL_MIRROR}/aarch64/Packages/l/libloader-1.1.3-45.el10_2.noarch.rpm;name=aarch64_libloader;unpack=0"
SRC_URI:append = " ${URI_aarch64_libloader}"
SRC_URI[aarch64_libloader.sha256sum] = "ea6c7629aa481fba1c9eb6695728509d59608b73de5e3b1d95a8ecc49be48441"

URI_aarch64_libloader-javadoc = "${EPEL_MIRROR}/aarch64/Packages/l/libloader-javadoc-1.1.3-45.el10_2.noarch.rpm;name=aarch64_libloader-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libloader-javadoc}"
SRC_URI[aarch64_libloader-javadoc.sha256sum] = "b5c34d7de4b7bcefc87c28ee0bd8eaff13d5f3d1337aa8cc28865fc69e6900ea"

RDEPENDS:libloader = " \
 java-21-openjdk-headless \
 javapackages-tools \
 libbase \
 "
RDEPENDS:libloader-javadoc = " \
 javapackages-tools \
 libloader \
 "
