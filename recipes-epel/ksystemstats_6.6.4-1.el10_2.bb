# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksystemstats"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 ksystemstats \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksystemstats-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85dcced6be29aa952d526602cfd62ff327bcfa8dc8d0b3a092cd2e8200b31b86"

URI_x86_64_v2_ksystemstats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksystemstats-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksystemstats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksystemstats}"
SRC_URI[x86_64_v2_ksystemstats.sha256sum] = "22129f570da9fa01f44f4b62830004900f65516a24aa7aefc03d3c6932858665"

URI_aarch64_ksystemstats = "${EPEL_MIRROR}/aarch64/Packages/k/ksystemstats-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_ksystemstats;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksystemstats}"
SRC_URI[aarch64_ksystemstats.sha256sum] = "9daa5c6e53811767eb34f3c85c47e7959619896fad8315796137be8b78cd6c5f"

RDEPENDS:ksystemstats = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-networkmanager-qt \
 kf6-solid \
 libksysguard \
 libnl3 \
 libstdc++ \
 lm_sensors-libs \
 qt6-qtbase \
 systemd-libs \
 "
