# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glib2"
PV = "2.80.4"
PR = "12.el10_2.22"
PACKAGES = " \
 glib2 \
 glib2-devel \
 glib2-doc \
 glib2-static \
 glib2-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glib2-2.80.4-12.el10_2.22.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "12d570015f2a040149e7600ab484d6b239e540c6bdcf9bfccc5f3383b1330bab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glib2-2.80.4-12.el10_2.22.x86_64_v2.rpm;name=x86_64_v2_glib2;unpack=0"
SRC_URI[x86_64_v2_glib2.sha256sum] = "007e9c00087981454f1478beb3ed7757da7d69287b4e0456398c200ec25e7224"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-devel-2.80.4-12.el10_2.22.x86_64_v2.rpm;name=x86_64_v2_glib2-devel;unpack=0"
SRC_URI[x86_64_v2_glib2-devel.sha256sum] = "af37bff0c8110486e38069c1320714f0e985c4ea89c57d35a25d2bbb8b738d55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-doc-2.80.4-12.el10_2.22.x86_64_v2.rpm;name=x86_64_v2_glib2-doc;unpack=0"
SRC_URI[x86_64_v2_glib2-doc.sha256sum] = "dee638d0247d21e3595d0c28cdc9142994a184a156f50fd6109708373771f5ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-static-2.80.4-12.el10_2.22.x86_64_v2.rpm;name=x86_64_v2_glib2-static;unpack=0"
SRC_URI[x86_64_v2_glib2-static.sha256sum] = "27e157a68efda3aaa8c5069bdf21a4829fb4f5287a7e4a62215993e7c5d6502d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-tests-2.80.4-12.el10_2.22.x86_64_v2.rpm;name=x86_64_v2_glib2-tests;unpack=0"
SRC_URI[x86_64_v2_glib2-tests.sha256sum] = "6d61080a64fb755e303dcc622e093e0ef571a23f066f7952664d91271fb54275"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glib2-2.80.4-12.el10_2.22.aarch64.rpm;name=aarch64_glib2;unpack=0"
SRC_URI[aarch64_glib2.sha256sum] = "3f3049bede38292514364fe77a14c6bd883467b56869b232d8a24b8c7f150263"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-devel-2.80.4-12.el10_2.22.aarch64.rpm;name=aarch64_glib2-devel;unpack=0"
SRC_URI[aarch64_glib2-devel.sha256sum] = "3d5ff1cadad0a93c9047a2e93d832dd300e8a6a4f50ff9f9f00e43c3b1c7bc56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-doc-2.80.4-12.el10_2.22.aarch64.rpm;name=aarch64_glib2-doc;unpack=0"
SRC_URI[aarch64_glib2-doc.sha256sum] = "129eae69b2e188f9d75c1e3bd5cacd885918e549b6dc13e7f33c132974ff8ff8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-static-2.80.4-12.el10_2.22.aarch64.rpm;name=aarch64_glib2-static;unpack=0"
SRC_URI[aarch64_glib2-static.sha256sum] = "0da9ef8086e6e01e8cd8e7e685448d58eb72d59856b3c5d2b2507d8b855aae05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-tests-2.80.4-12.el10_2.22.aarch64.rpm;name=aarch64_glib2-tests;unpack=0"
SRC_URI[aarch64_glib2-tests.sha256sum] = "33cb47f71d26e46074007deceadc6da0f21b64ed9a3f3bb75dfb2b31ea4b6668"

RDEPENDS:glib2:x86_64_v2 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
"
RDEPENDS:glib2:aarch64 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libgcc \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
"
RDEPENDS:glib2-devel = " \
 bash \
 elfutils-libelf \
 glib2 \
 glib2-devel \
 glibc \
 libffi \
 libffi-devel \
 libmount-devel \
 libselinux-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 python3 \
 python3-packaging \
 sysprof-capture-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:glib2-doc = " \
 glib2 \
 "
RDEPENDS:glib2-static = " \
 glib2-devel \
 pcre2-static \
 sysprof-capture-devel \
 "
RDEPENDS:glib2-tests = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 pcre2 \
 python3 \
 "
