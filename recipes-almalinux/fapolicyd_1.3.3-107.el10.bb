# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fapolicyd"
PV = "1.3.3"
PR = "107.el10"
PACKAGES = " \
 fapolicyd \
 fapolicyd-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fapolicyd-1.3.3-107.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f1ce3392b233a37bf68e59c883ebd24a57e889fe20da508c236aed238d24ca2"

URI_x86_64_v2_fapolicyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fapolicyd-1.3.3-107.el10.x86_64_v2.rpm;name=x86_64_v2_fapolicyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicyd}"
SRC_URI[x86_64_v2_fapolicyd.sha256sum] = "e1de02d7e830a172dd22e4c0f7d67aedbb671708db387408b108db404f3d9333"

URI_x86_64_v2_fapolicyd-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fapolicyd-selinux-1.3.3-107.el10.noarch.rpm;name=x86_64_v2_fapolicyd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicyd-selinux}"
SRC_URI[x86_64_v2_fapolicyd-selinux.sha256sum] = "0946b4a69f9ff3a7cff97f1ae7783804cd974592aaa9d872dbaf5fefcfe4dd78"

URI_aarch64_fapolicyd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fapolicyd-1.3.3-107.el10.aarch64.rpm;name=aarch64_fapolicyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicyd}"
SRC_URI[aarch64_fapolicyd.sha256sum] = "4f4fa1e2b8f118403ec9ae289df369fa01cd43123e298fa3ce5944d72dfbe60e"

URI_aarch64_fapolicyd-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fapolicyd-selinux-1.3.3-107.el10.noarch.rpm;name=aarch64_fapolicyd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicyd-selinux}"
SRC_URI[aarch64_fapolicyd-selinux.sha256sum] = "0946b4a69f9ff3a7cff97f1ae7783804cd974592aaa9d872dbaf5fefcfe4dd78"

RDEPENDS:fapolicyd = " \
 bash \
 file-libs \
 glibc \
 libcap-ng \
 libseccomp \
 lmdb-libs \
 openssl-libs \
 rpm-libs \
 rpm-plugin-fapolicyd \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:fapolicyd-selinux = " \
 bash \
 fapolicyd \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
