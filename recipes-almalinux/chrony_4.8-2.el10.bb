# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chrony"
PV = "4.8"
PR = "2.el10"
PACKAGES = " \
 chrony \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/chrony-4.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9433890e4e00c70f8d597df9772b299cfe14f1dab2c688ad1b62373e7bde65e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/chrony-4.8-2.el10.x86_64_v2.rpm;name=x86_64_v2_chrony;unpack=0"
SRC_URI[x86_64_v2_chrony.sha256sum] = "cb1dcc8596440c214d8b1ed9040f212d09a681c3c9fe06304dfc81e3602cdae9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/chrony-4.8-2.el10.aarch64.rpm;name=aarch64_chrony;unpack=0"
SRC_URI[aarch64_chrony.sha256sum] = "4a07938e9497a2d032efe33b7bed2f8517addf1e530943f32d9d8b658e181bfe"

RDEPENDS:chrony = " \
 bash \
 glibc \
 gnutls \
 libcap \
 libedit \
 libseccomp \
 shadow-utils \
 systemd \
 tzdata \
 "
