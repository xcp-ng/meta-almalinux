# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-scaleway-sdk"
PV = "1.0.0~beta.20"
PR = "4.20230802git347472f.el10_0"
PACKAGES = " \
 golang-github-scaleway-sdk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-scaleway-sdk-1.0.0~beta.20-4.20230802git347472f.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21668a4708de871ae3588dc5a9596bb0498beb5989ef7fb7da270028cdb6665a"

URI_aarch64_golang-github-scaleway-sdk-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-scaleway-sdk-devel-1.0.0~beta.20-4.20230802git347472f.el10_0.noarch.rpm;name=aarch64_golang-github-scaleway-sdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-scaleway-sdk-devel}"
SRC_URI[aarch64_golang-github-scaleway-sdk-devel.sha256sum] = "46eae07dbd1e86d4eb59a8c9ddc5d4fdd7bc7d6cd9337eea62d169b40742d6ce"

RDEPENDS:golang-github-scaleway-sdk-devel = " \
 go-filesystem \
 golang-github-dnaeon-vcr-devel \
 golang-gopkg-yaml-2-devel \
 "
