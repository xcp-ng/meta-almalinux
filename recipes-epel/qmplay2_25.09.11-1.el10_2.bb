# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qmplay2"
PV = "25.09.11"
PR = "1.el10_2"
PACKAGES = " \
 qmplay2 \
 qmplay2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qmplay2-25.09.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef930573784d3ccddcb3d6392a95cd31a261d6a3d47d8e8818cdda2623b04294"

URI_x86_64_v2_qmplay2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmplay2-25.09.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmplay2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qmplay2}"
SRC_URI[x86_64_v2_qmplay2.sha256sum] = "1468bbc67116dc51c3053863774e598609808a79fc645b3cdc99f2bdbaac4fe5"

URI_x86_64_v2_qmplay2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmplay2-devel-25.09.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmplay2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qmplay2-devel}"
SRC_URI[x86_64_v2_qmplay2-devel.sha256sum] = "23a3a1a114a0c05e7ab72632530f549199545de12e8e9be3334baeb6151d727b"

URI_aarch64_qmplay2 = "${EPEL_MIRROR}/aarch64/Packages/q/qmplay2-25.09.11-1.el10_2.aarch64.rpm;name=aarch64_qmplay2;unpack=0"
SRC_URI:append = " ${URI_aarch64_qmplay2}"
SRC_URI[aarch64_qmplay2.sha256sum] = "91864e80e39332f2a7e247c0550588e7d05bd053be6d770b4f25369af865d2f4"

URI_aarch64_qmplay2-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qmplay2-devel-25.09.11-1.el10_2.aarch64.rpm;name=aarch64_qmplay2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qmplay2-devel}"
SRC_URI[aarch64_qmplay2-devel.sha256sum] = "bd9be3f98a823f418f00b7f1680f5555364ee6cd24203d987c2bae75786166ac"

RDEPENDS:qmplay2 = " \
 alsa-lib \
 game-music-emu \
 glibc \
 hicolor-icon-theme \
 kde-filesystem \
 libX11 \
 libXv \
 libass \
 libavcodec-free \
 libavdevice-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libcddb \
 libcdio \
 libgcc \
 libglvnd-egl \
 libglvnd-opengl \
 libsidplayfp \
 libstdc++ \
 libswresample-free \
 libswscale-free \
 libva \
 pipewire-libs \
 pulseaudio-libs \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 rubberband \
 shared-mime-info \
 taglib \
 "
RDEPENDS:qmplay2-devel = " \
 qmplay2 \
 "
