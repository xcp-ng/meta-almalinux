# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-io"
PV = "12.4"
PR = "4.el10_0"
PACKAGES = " \
 globus-io \
 globus-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-io-12.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "add640ba953631996829498c292f71fcf0cab5dcc8472d1869c40f88de439f11"

URI_x86_64_v2_globus-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-io-12.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-io}"
SRC_URI[x86_64_v2_globus-io.sha256sum] = "aca9f5badedc274f643011579c74bebb8c30fc8d57eb14798c6632d76a9bf720"

URI_x86_64_v2_globus-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-io-devel-12.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-io-devel}"
SRC_URI[x86_64_v2_globus-io-devel.sha256sum] = "2e5bd6cbb923ab387cadd55d47dd75db8327843f5f2a57d24a045972c10b059e"

URI_aarch64_globus-io = "${EPEL_MIRROR}/aarch64/Packages/g/globus-io-12.4-4.el10_0.aarch64.rpm;name=aarch64_globus-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-io}"
SRC_URI[aarch64_globus-io.sha256sum] = "c372195a12de3955c99c9088ca511dd829638146701230a86df829ea87fd3a6e"

URI_aarch64_globus-io-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-io-devel-12.4-4.el10_0.aarch64.rpm;name=aarch64_globus-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-io-devel}"
SRC_URI[aarch64_globus-io-devel.sha256sum] = "6848aae6fd1630f96e7731ab8b746739b409e9c0773c36bea9174e7e3feb47db"

RDEPENDS:globus-io = " \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-error \
 globus-gssapi-gsi \
 globus-xio \
 globus-xio-gsi-driver \
 "
RDEPENDS:globus-io-devel = " \
 globus-common-devel \
 globus-gss-assist-devel \
 globus-gssapi-error-devel \
 globus-gssapi-gsi-devel \
 globus-io \
 globus-xio-devel \
 globus-xio-gsi-driver-devel \
 pkgconf-pkg-config \
 "
