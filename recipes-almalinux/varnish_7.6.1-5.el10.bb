# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "varnish"
PV = "7.6.1"
PR = "5.el10"
PACKAGES = " \
 varnish \
 varnish-devel \
 varnish-docs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/varnish-7.6.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9397e1b1d878700a345020159298f7974878d3ec4c5e4ac88d7659c75bcb63d"

URI_x86_64_v2_varnish = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/varnish-7.6.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_varnish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_varnish}"
SRC_URI[x86_64_v2_varnish.sha256sum] = "54f9ad9bcfa8c6df27761d79598cb7d13c56867f071cf02b2ec83a0f7401e5e6"

URI_x86_64_v2_varnish-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/varnish-devel-7.6.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_varnish-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_varnish-devel}"
SRC_URI[x86_64_v2_varnish-devel.sha256sum] = "d5b86559f92d2a38982e74397d4630bb56e8c2591f8f54c3cdc5890dad6527f8"

URI_x86_64_v2_varnish-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/varnish-docs-7.6.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_varnish-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_varnish-docs}"
SRC_URI[x86_64_v2_varnish-docs.sha256sum] = "21988a4a016509cbafd2ab57b0fa0aebe4f6916336d7ef199ad514776349f869"

URI_aarch64_varnish = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/varnish-7.6.1-5.el10.aarch64.rpm;name=aarch64_varnish;unpack=0"
SRC_URI:append = " ${URI_aarch64_varnish}"
SRC_URI[aarch64_varnish.sha256sum] = "250d560f3a35daf6d05b19494235ce24c350a9e77c215faa70615f0bc36d1d53"

URI_aarch64_varnish-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/varnish-devel-7.6.1-5.el10.aarch64.rpm;name=aarch64_varnish-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_varnish-devel}"
SRC_URI[aarch64_varnish-devel.sha256sum] = "950d2c44a3c630456a718f11f854cfd462208ef165af5ce69246f992f2b951fb"

URI_aarch64_varnish-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/varnish-docs-7.6.1-5.el10.aarch64.rpm;name=aarch64_varnish-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_varnish-docs}"
SRC_URI[aarch64_varnish-docs.sha256sum] = "ed90f74da0d38a35b379712145c935ecbd1fece97cac033caf6240a580137f8f"

RDEPENDS:varnish = " \
 bash \
 gcc \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 logrotate \
 ncurses \
 ncurses-libs \
 pcre2 \
 redhat-rpm-config \
 shadow-utils \
 systemd \
 util-linux \
 "
RDEPENDS:varnish-devel = " \
 pkgconf-pkg-config \
 python3 \
 varnish \
 "
RDEPENDS:varnish-docs = " \
 "
