# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mp4parse"
PV = "0.17.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-mp4parse+3gpp-devel \
 rust-mp4parse+default-devel \
 rust-mp4parse+meta-xml-devel \
 rust-mp4parse+missing-pixi-permitted-devel \
 rust-mp4parse+mp4v-devel \
 rust-mp4parse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mp4parse-0.17.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e2c5e6dcf771c5c96834db3ded9ba9f69591fca08785d5cf39cc2dddcbb8c67"

URI_x86_64_v2_rust-mp4parse+3gpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse+3gpp-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse+3gpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse+3gpp-devel}"
SRC_URI[x86_64_v2_rust-mp4parse+3gpp-devel.sha256sum] = "2eb916e3bac81d2a9ab2d72d60075022042e70ea7457323e161d7608c3509f44"

URI_x86_64_v2_rust-mp4parse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse+default-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse+default-devel}"
SRC_URI[x86_64_v2_rust-mp4parse+default-devel.sha256sum] = "59971ea32f334ce7f90613d3a941741a372ddc2beaf52a71870befe3bb209a5b"

URI_x86_64_v2_rust-mp4parse+meta-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse+meta-xml-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse+meta-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse+meta-xml-devel}"
SRC_URI[x86_64_v2_rust-mp4parse+meta-xml-devel.sha256sum] = "49682f10d0d040e82532265b3559f46cd4e0c3a94c63ed271868e89e98fd2005"

URI_x86_64_v2_rust-mp4parse+missing-pixi-permitted-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse+missing-pixi-permitted-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse+missing-pixi-permitted-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse+missing-pixi-permitted-devel}"
SRC_URI[x86_64_v2_rust-mp4parse+missing-pixi-permitted-devel.sha256sum] = "39c1cea5992770f21c33e13cb481a10366c574d2d0f46e7343c123ac5593f3f1"

URI_x86_64_v2_rust-mp4parse+mp4v-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse+mp4v-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse+mp4v-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse+mp4v-devel}"
SRC_URI[x86_64_v2_rust-mp4parse+mp4v-devel.sha256sum] = "21667cd8532bc18ee06e3c239a288cf2cfe1f05b3474379ddf0d47520202191d"

URI_x86_64_v2_rust-mp4parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mp4parse-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mp4parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mp4parse-devel}"
SRC_URI[x86_64_v2_rust-mp4parse-devel.sha256sum] = "cb8eab70e85dc41bb6ab45fbcde1ee089169d47dcc46a2b13ff9dbf78763a542"

URI_aarch64_rust-mp4parse+3gpp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse+3gpp-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-mp4parse+3gpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse+3gpp-devel}"
SRC_URI[aarch64_rust-mp4parse+3gpp-devel.sha256sum] = "0af0912881bc1b06c9901e9fea1729c9a8779a36a1b92aa352933fa94e16e2c2"

URI_aarch64_rust-mp4parse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse+default-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-mp4parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse+default-devel}"
SRC_URI[aarch64_rust-mp4parse+default-devel.sha256sum] = "26ebe05e93fe691a1308e48e4e4d0bf01029bf8f7cf830433845e4dbf9d206e6"

URI_aarch64_rust-mp4parse+meta-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse+meta-xml-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-mp4parse+meta-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse+meta-xml-devel}"
SRC_URI[aarch64_rust-mp4parse+meta-xml-devel.sha256sum] = "106486a5c6dedde595a727b655584356a845ef68fe8cda1377853ae975880f46"

URI_aarch64_rust-mp4parse+missing-pixi-permitted-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse+missing-pixi-permitted-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-mp4parse+missing-pixi-permitted-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse+missing-pixi-permitted-devel}"
SRC_URI[aarch64_rust-mp4parse+missing-pixi-permitted-devel.sha256sum] = "e787c10c40ade7482ac8bdb6dbaaedcdf22182b4e9bac99450f85b5f8e483da9"

URI_aarch64_rust-mp4parse+mp4v-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse+mp4v-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-mp4parse+mp4v-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse+mp4v-devel}"
SRC_URI[aarch64_rust-mp4parse+mp4v-devel.sha256sum] = "3cb681bb160e8866ff81ac04050416f2beb0d99d0158707190586d23f63b0809"

URI_aarch64_rust-mp4parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mp4parse-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-mp4parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mp4parse-devel}"
SRC_URI[aarch64_rust-mp4parse-devel.sha256sum] = "d5751191133716dc360329a319f4d228aafc638431489fdb98533ce8ad924f15"

RDEPENDS:rust-mp4parse+3gpp-devel = " \
 cargo \
 rust-mp4parse-devel \
 "
RDEPENDS:rust-mp4parse+default-devel = " \
 cargo \
 rust-mp4parse-devel \
 "
RDEPENDS:rust-mp4parse+meta-xml-devel = " \
 cargo \
 rust-mp4parse-devel \
 "
RDEPENDS:rust-mp4parse+missing-pixi-permitted-devel = " \
 cargo \
 rust-mp4parse-devel \
 "
RDEPENDS:rust-mp4parse+mp4v-devel = " \
 cargo \
 rust-mp4parse-devel \
 "
RDEPENDS:rust-mp4parse-devel = " \
 cargo \
 rust-bitreader+default-devel \
 rust-byteorder+default-devel \
 rust-fallible_collections+default-devel \
 rust-fallible_collections+std_io-devel \
 rust-log+default-devel \
 rust-num-traits+default-devel \
 rust-static_assertions+default-devel \
 "
