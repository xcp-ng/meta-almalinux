# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tlfloat"
PV = "1.15.0"
PR = "1.el10_1"
PACKAGES = " \
 tlfloat \
 tlfloat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tlfloat-1.15.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c752822a77daa5829940cbce13f1aa0ea74db24cda12f4c45f8ed85b07fc450f"

URI_x86_64_v2_tlfloat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tlfloat-1.15.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tlfloat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tlfloat}"
SRC_URI[x86_64_v2_tlfloat.sha256sum] = "f1919f45bd9698704de0aaaf1c610e8b4f23ae660a57bd183c4dd76b6ab8fe3b"

URI_x86_64_v2_tlfloat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tlfloat-devel-1.15.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tlfloat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tlfloat-devel}"
SRC_URI[x86_64_v2_tlfloat-devel.sha256sum] = "15666a743599232d506066eee67d5ae716198ae35488b49ee5f7d8d16f183130"

URI_aarch64_tlfloat = "${EPEL_MIRROR}/aarch64/Packages/t/tlfloat-1.15.0-1.el10_1.aarch64.rpm;name=aarch64_tlfloat;unpack=0"
SRC_URI:append = " ${URI_aarch64_tlfloat}"
SRC_URI[aarch64_tlfloat.sha256sum] = "b33c1fef7ea8210f9e11ce1c25713bce673b3f8cedd3a32004ae5a1d1a0069d4"

URI_aarch64_tlfloat-devel = "${EPEL_MIRROR}/aarch64/Packages/t/tlfloat-devel-1.15.0-1.el10_1.aarch64.rpm;name=aarch64_tlfloat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tlfloat-devel}"
SRC_URI[aarch64_tlfloat-devel.sha256sum] = "0c8259824a240647cc492c15e50323ec1a02fbb02f3df88165b6e95c35e3ebe7"

RDEPENDS:tlfloat:x86_64_v2 = " \
 glibc \
"
RDEPENDS:tlfloat:aarch64 = " \
 glibc \
 libgcc \
"
RDEPENDS:tlfloat-devel = " \
 pkgconf-pkg-config \
 tlfloat \
 "
