# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-boltons"
PV = "25.0.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-boltons \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-boltons-25.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "78cd606e1a18c218ebca494111f7e4f81370df34c825b995283b89039f07e93a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-boltons-25.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-boltons;unpack=0"
SRC_URI[x86_64_v2_python3-boltons.sha256sum] = "d9695c94c742ca190f149a77fc6a9f00207acc4b742bb2c499eb49fb1c2ef8cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-boltons-25.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-boltons;unpack=0"
SRC_URI[aarch64_python3-boltons.sha256sum] = "1e2e73921dba8e21c732a00f0ef3fb896257c712bcc7a240c8a380f0d878b238"

RDEPENDS:python3-boltons = " \
 python3 \
 "
