# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapd"
PV = "2.70"
PR = "1.el10_1"
PACKAGES = " \
 snap-confine \
 snapd \
 snapd-devel \
 snapd-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapd-2.70-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "388cd0811fe4065a19b5b7d4cd84f80a8b507d7a84ebf9c1187c1b864ae7b496"

URI_x86_64_v2_snap-confine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snap-confine-2.70-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snap-confine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snap-confine}"
SRC_URI[x86_64_v2_snap-confine.sha256sum] = "d22c0ac328bdc83bfeb9f5cd1138d55ed4a07abbdef45fe1890fb1d105c28146"

URI_x86_64_v2_snapd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-2.70-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd}"
SRC_URI[x86_64_v2_snapd.sha256sum] = "961b5881c1933bdb4d7b187d2bc6b13bc3ae60b14bb5465ab02d19470667c6fa"

URI_x86_64_v2_snapd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-devel-2.70-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_snapd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-devel}"
SRC_URI[x86_64_v2_snapd-devel.sha256sum] = "3394c0ec68ff4d59ec1198450e7fb7de42277a9c07b87944f483dbd8a85c0a66"

URI_x86_64_v2_snapd-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-selinux-2.70-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_snapd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-selinux}"
SRC_URI[x86_64_v2_snapd-selinux.sha256sum] = "eef7eb94919fb443aaee0b627993ad64c23a63c254e1126f6e5abc5fbde919d6"

URI_aarch64_snap-confine = "${EPEL_MIRROR}/aarch64/Packages/s/snap-confine-2.70-1.el10_1.aarch64.rpm;name=aarch64_snap-confine;unpack=0"
SRC_URI:append = " ${URI_aarch64_snap-confine}"
SRC_URI[aarch64_snap-confine.sha256sum] = "d81f793b28539746ee4da0548e6f58ec641efff2141488718ad24f64e16a5c17"

URI_aarch64_snapd = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-2.70-1.el10_1.aarch64.rpm;name=aarch64_snapd;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd}"
SRC_URI[aarch64_snapd.sha256sum] = "370a4f94ac57a1e0d42b4e90e540d4b9ab0cd16805a0a0f31ea0aa0079f6b914"

URI_aarch64_snapd-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-devel-2.70-1.el10_1.noarch.rpm;name=aarch64_snapd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-devel}"
SRC_URI[aarch64_snapd-devel.sha256sum] = "d02a10ce69796741fd6f2f9f0e8e7295b889f1114ebd57eb5dadeda6e3ee7a6d"

URI_aarch64_snapd-selinux = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-selinux-2.70-1.el10_1.noarch.rpm;name=aarch64_snapd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-selinux}"
SRC_URI[aarch64_snapd-selinux.sha256sum] = "257cbaa2e24bff31fe4a6c191f2c9073d8a1f5d172be91a113ac63c27d9dad92"

RDEPENDS:snap-confine = " \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 systemd-libs \
 "
RDEPENDS:snapd = " \
 bash \
 bash-completion \
 glibc \
 snap-confine \
 snapd-selinux \
 squashfs-tools \
 systemd \
 virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_ \
 xdelta \
 "
RDEPENDS:snapd-devel = " \
 "
RDEPENDS:snapd-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
