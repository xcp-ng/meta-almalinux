# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_meta"
PV = "2.8.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-pest_meta+default-devel \
 rust-pest_meta+grammar-extras-devel \
 rust-pest_meta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_meta-2.8.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb1ec16a1758de1cdb080a78af17ca37cbed830d3664bf87498d9a610db93585"

URI_x86_64_v2_rust-pest_meta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta+default-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta+default-devel}"
SRC_URI[x86_64_v2_rust-pest_meta+default-devel.sha256sum] = "2d7f924dd34147be8f93d33d67897e9f54a71acca0b50bf615eef7cca5cd3521"

URI_x86_64_v2_rust-pest_meta+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta+grammar-extras-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_meta+grammar-extras-devel.sha256sum] = "b05e90336b7c187bb9c99fd891d57baa1eb97ec9d97eae1b8954bf04b71ab367"

URI_x86_64_v2_rust-pest_meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta-devel-2.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta-devel}"
SRC_URI[x86_64_v2_rust-pest_meta-devel.sha256sum] = "e397d5b21d824bb4da7c4e51b5bf139f4221373f04194dc713899c2c029de3bc"

URI_aarch64_rust-pest_meta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta+default-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta+default-devel}"
SRC_URI[aarch64_rust-pest_meta+default-devel.sha256sum] = "c152f848e5969fd95df77e038d914c69e363fe2776dd79e0ff3103a828aa635f"

URI_aarch64_rust-pest_meta+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta+grammar-extras-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_meta+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_meta+grammar-extras-devel.sha256sum] = "2ba85793d747498de5c5ae4eb43b6e56e0d4ef04cfebea1e9d58d29aecb0c9ed"

URI_aarch64_rust-pest_meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta-devel-2.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-pest_meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta-devel}"
SRC_URI[aarch64_rust-pest_meta-devel.sha256sum] = "c1c945d6b1d711e538b6e6cab55f76df5f9217f795e02a947324f2a6fd5b9d47"

RDEPENDS:rust-pest_meta+default-devel = " \
 cargo \
 rust-pest_meta-devel \
 "
RDEPENDS:rust-pest_meta+grammar-extras-devel = " \
 cargo \
 rust-pest_meta-devel \
 "
RDEPENDS:rust-pest_meta-devel = " \
 cargo \
 rust \
 rust-pest+default-devel \
 rust-sha2-devel \
 "
