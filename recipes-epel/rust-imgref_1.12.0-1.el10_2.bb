# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imgref"
PV = "1.12.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-imgref+default-devel \
 rust-imgref+deprecated-devel \
 rust-imgref-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-imgref-1.12.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "904b5f14645c8c10a8780bcbd8d84c8d03988b9cf736d1cf3d95a856e13842e9"

URI_x86_64_v2_rust-imgref+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref+default-devel-1.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imgref+default-devel}"
SRC_URI[x86_64_v2_rust-imgref+default-devel.sha256sum] = "3ea9a0bc5aa821b86d4bbf122cddc94b55e762cdd6c59d9112ae790d4ba9e81f"

URI_x86_64_v2_rust-imgref+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref+deprecated-devel-1.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imgref+deprecated-devel}"
SRC_URI[x86_64_v2_rust-imgref+deprecated-devel.sha256sum] = "41d48d51071ac97a468f3e10853c473979bc34353c74d8c2867e0087c38f6121"

URI_x86_64_v2_rust-imgref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref-devel-1.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imgref-devel}"
SRC_URI[x86_64_v2_rust-imgref-devel.sha256sum] = "78b002a19f0939d13f8c58a482b20f68fa3a5e63c28e6bc17ba516efd546add4"

URI_aarch64_rust-imgref+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref+default-devel-1.12.0-1.el10_2.noarch.rpm;name=aarch64_rust-imgref+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imgref+default-devel}"
SRC_URI[aarch64_rust-imgref+default-devel.sha256sum] = "9d2a68790fbd612268540c369ea9445995bb57034cd09d5a672ed7e8c7e2537e"

URI_aarch64_rust-imgref+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref+deprecated-devel-1.12.0-1.el10_2.noarch.rpm;name=aarch64_rust-imgref+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imgref+deprecated-devel}"
SRC_URI[aarch64_rust-imgref+deprecated-devel.sha256sum] = "218522a456235a52456840cf5664b53940c83960ba17181019d0b3aeff5fafd7"

URI_aarch64_rust-imgref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref-devel-1.12.0-1.el10_2.noarch.rpm;name=aarch64_rust-imgref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imgref-devel}"
SRC_URI[aarch64_rust-imgref-devel.sha256sum] = "2e041609a28960cd56bfb2e6851f73e2fb05cf2785362cb56c8497f6491181ec"

RDEPENDS:rust-imgref+default-devel = " \
 cargo \
 rust-imgref+deprecated-devel \
 rust-imgref-devel \
 "
RDEPENDS:rust-imgref+deprecated-devel = " \
 cargo \
 rust-imgref-devel \
 "
RDEPENDS:rust-imgref-devel = " \
 cargo \
 rust \
 "
