# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serial_test_derive"
PV = "3.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-serial_test_derive+async-devel \
 rust-serial_test_derive+default-devel \
 rust-serial_test_derive+file_locks-devel \
 rust-serial_test_derive+test_logging-devel \
 rust-serial_test_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serial_test_derive-3.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fcd0032bbd8ec5ab3532fbda5c92d9f4d34e9fda594452821659539cab0966e"

URI_x86_64_v2_rust-serial_test_derive+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+async-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+async-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+async-devel.sha256sum] = "c08a807c3c47175cb792041940cdded7c3e25b601bbd7db013d2e786a4daca98"

URI_x86_64_v2_rust-serial_test_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+default-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+default-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+default-devel.sha256sum] = "0b857608379aa1b57f1bc282beeb63d811926a4ebc168f8b1642de7c8ce02587"

URI_x86_64_v2_rust-serial_test_derive+file_locks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+file_locks-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+file_locks-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+file_locks-devel.sha256sum] = "7ddc116574ae0a5ecce6413502be8402454ae9ae1886655f8e1cf34990e0bc0d"

URI_x86_64_v2_rust-serial_test_derive+test_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+test_logging-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+test_logging-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+test_logging-devel.sha256sum] = "1b096eb7de5c877705e66063a9277fa11e37691ce0b362a2f29bbc0c894cbe5e"

URI_x86_64_v2_rust-serial_test_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive-devel-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive-devel.sha256sum] = "eca0d022741595832b935a4614d2e15c7362c3208053e74f66dee49a7a9e8700"

URI_aarch64_rust-serial_test_derive+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+async-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test_derive+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+async-devel}"
SRC_URI[aarch64_rust-serial_test_derive+async-devel.sha256sum] = "2686a2b0ae98aeedfd8e48019120b8cae11c7e0830a61fe48832370325cb3d98"

URI_aarch64_rust-serial_test_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+default-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+default-devel}"
SRC_URI[aarch64_rust-serial_test_derive+default-devel.sha256sum] = "69d9374e35f5ccf4cba2072c8741ce8746fa5035bd1eaef77e30bcb9e79875e8"

URI_aarch64_rust-serial_test_derive+file_locks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+file_locks-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test_derive+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+file_locks-devel}"
SRC_URI[aarch64_rust-serial_test_derive+file_locks-devel.sha256sum] = "6450fcef2cc7acabcb59136ea6cdd3059ecdd290d06e15cafcb0b8a6b7ad49a0"

URI_aarch64_rust-serial_test_derive+test_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+test_logging-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test_derive+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+test_logging-devel}"
SRC_URI[aarch64_rust-serial_test_derive+test_logging-devel.sha256sum] = "12d616a3ab60ac2f39b8ce75b2aa6223f65b61e96757ed311bc9146d41462798"

URI_aarch64_rust-serial_test_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive-devel-3.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-serial_test_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive-devel}"
SRC_URI[aarch64_rust-serial_test_derive-devel.sha256sum] = "a1442b2307e566c3c1465446dc5fc5b191532619bb5e19e4f1c1c17c51f222f6"

RDEPENDS:rust-serial_test_derive+async-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive+default-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive+file_locks-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive+test_logging-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
