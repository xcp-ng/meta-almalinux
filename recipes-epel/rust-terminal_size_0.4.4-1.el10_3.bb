# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-terminal_size"
PV = "0.4.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-terminal_size+default-devel \
 rust-terminal_size-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-terminal_size-0.4.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e892201af221d566d771ed47c572bca35667f912a963c4b18f4c8a7dd9b9f6ac"

URI_x86_64_v2_rust-terminal_size+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size+default-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal_size+default-devel}"
SRC_URI[x86_64_v2_rust-terminal_size+default-devel.sha256sum] = "8db7a0106c08fe701deba1d2d13daa208c5fb843e6b700d5f7c4b5a1fabebab5"

URI_x86_64_v2_rust-terminal_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size-devel-0.4.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal_size-devel}"
SRC_URI[x86_64_v2_rust-terminal_size-devel.sha256sum] = "7e83ab48c23e99955363e362efce30391b76a9464dc5165d38739a0b0002441a"

URI_aarch64_rust-terminal_size+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size+default-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-terminal_size+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal_size+default-devel}"
SRC_URI[aarch64_rust-terminal_size+default-devel.sha256sum] = "0167afa896f26919abfa56e7ebc8389218e60cc9c0b2b1fe4832775b1c93485a"

URI_aarch64_rust-terminal_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size-devel-0.4.4-1.el10_3.noarch.rpm;name=aarch64_rust-terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal_size-devel}"
SRC_URI[aarch64_rust-terminal_size-devel.sha256sum] = "8fdc7882157f6beec7cb72e1d7aeeaf50a2d3d74ea53737c0db6c23f05255d80"

RDEPENDS:rust-terminal_size+default-devel = " \
 cargo \
 rust-terminal_size-devel \
 "
RDEPENDS:rust-terminal_size-devel = " \
 cargo \
 rust \
 rust-rustix+default-devel \
 rust-rustix+termios-devel \
 "
