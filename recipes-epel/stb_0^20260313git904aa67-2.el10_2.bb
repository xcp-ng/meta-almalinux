# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stb"
PV = "0^20260313git904aa67"
PR = "2.el10_2"
PACKAGES = " \
 stb-devel \
 stb-doc \
 stb_c_lexer-devel \
 stb_connected_components-devel \
 stb_divide-devel \
 stb_ds-devel \
 stb_dxt-devel \
 stb_easy_font-devel \
 stb_herringbone_wang_tile-devel \
 stb_hexwave-devel \
 stb_image-devel \
 stb_image_resize-devel \
 stb_image_resize2-devel \
 stb_image_write-devel \
 stb_leakcheck-devel \
 stb_perlin-devel \
 stb_rect_pack-devel \
 stb_sprintf-devel \
 stb_textedit-devel \
 stb_tilemap_editor-devel \
 stb_truetype-devel \
 stb_vorbis-devel \
 stb_voxel_render-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stb-0^20260313git904aa67-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55ec19c918cc26fa60b1ab0ab3990da03de729b440a4fc55f9a7efdf9c2fcb21"

URI_x86_64_v2_stb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb-devel-0^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb-devel}"
SRC_URI[x86_64_v2_stb-devel.sha256sum] = "e7b032e4c37510bb38b47da50eb59978770970ab6a34ed47b6e746aa04aee8e7"

URI_x86_64_v2_stb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb-doc-0^20260313git904aa67-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_stb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb-doc}"
SRC_URI[x86_64_v2_stb-doc.sha256sum] = "8e4facffe5c95779fc345578741c380d8d0ae6ba96e0121fd233b471cbf24a13"

URI_x86_64_v2_stb_c_lexer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_c_lexer-devel-0.12^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_c_lexer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_c_lexer-devel}"
SRC_URI[x86_64_v2_stb_c_lexer-devel.sha256sum] = "533ed16e82eebd420799d9cf58cd1bca269504e9c6197fd94fd585d833041f4e"

URI_x86_64_v2_stb_connected_components-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_connected_components-devel-0.96^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_connected_components-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_connected_components-devel}"
SRC_URI[x86_64_v2_stb_connected_components-devel.sha256sum] = "95cb57a42d24486cb26196d6b29918aea05f3265674639a1b056f9a62bdf1758"

URI_x86_64_v2_stb_divide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_divide-devel-0.94^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_divide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_divide-devel}"
SRC_URI[x86_64_v2_stb_divide-devel.sha256sum] = "4121689093c03ee7b09dda41b8efe87093badd355850788c30f6a17b94f9a5a6"

URI_x86_64_v2_stb_ds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_ds-devel-0.67^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_ds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_ds-devel}"
SRC_URI[x86_64_v2_stb_ds-devel.sha256sum] = "d73f9a24a738377138d30fe229ca52f08ef0eab25c8f44847e27dfcd8e9ebe45"

URI_x86_64_v2_stb_dxt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_dxt-devel-1.12^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_dxt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_dxt-devel}"
SRC_URI[x86_64_v2_stb_dxt-devel.sha256sum] = "d04b6ea96166ae62b67c89db6c43af011bd320c631d2326c0fe10b9fe8ad4034"

URI_x86_64_v2_stb_easy_font-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_easy_font-devel-1.1^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_easy_font-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_easy_font-devel}"
SRC_URI[x86_64_v2_stb_easy_font-devel.sha256sum] = "045ba1f8e8f9dc0814720ad0eac5e6cc4985a3bc42458b0675ce55f8f87ea8f8"

URI_x86_64_v2_stb_herringbone_wang_tile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_herringbone_wang_tile-devel-0.7^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_herringbone_wang_tile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_herringbone_wang_tile-devel}"
SRC_URI[x86_64_v2_stb_herringbone_wang_tile-devel.sha256sum] = "a0177e0e5b5bd554f9cab8a2b3e9bdc4e0cebb8d3aaa8702faa69986fcb7670e"

URI_x86_64_v2_stb_hexwave-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_hexwave-devel-0.5^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_hexwave-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_hexwave-devel}"
SRC_URI[x86_64_v2_stb_hexwave-devel.sha256sum] = "c59119ddcff9d351e0a453b10be8bcd63acc2784b928b0152bd3318fa5839f0a"

URI_x86_64_v2_stb_image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image-devel-2.30^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image-devel}"
SRC_URI[x86_64_v2_stb_image-devel.sha256sum] = "0ca0214fd41ca5dd705418f5007faa0f11c21d3cec054017362c8df55959b5f5"

URI_x86_64_v2_stb_image_resize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_resize-devel-0.97^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_resize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_resize-devel}"
SRC_URI[x86_64_v2_stb_image_resize-devel.sha256sum] = "1cc113532234ee4362e6069e06085c1376371065aae5d115a013ed6ec8326789"

URI_x86_64_v2_stb_image_resize2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_resize2-devel-2.18^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_resize2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_resize2-devel}"
SRC_URI[x86_64_v2_stb_image_resize2-devel.sha256sum] = "c85067b909adefd66a74c47ccbce7c3128b0d5b1c48eae36f9607fdbd21f48fa"

URI_x86_64_v2_stb_image_write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_write-devel-1.16^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_write-devel}"
SRC_URI[x86_64_v2_stb_image_write-devel.sha256sum] = "a08c50580e97a404b39a8dbdbe6bbe7047e30581065117bca84f6031641e6d2e"

URI_x86_64_v2_stb_leakcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_leakcheck-devel-0.6^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_leakcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_leakcheck-devel}"
SRC_URI[x86_64_v2_stb_leakcheck-devel.sha256sum] = "df12f631a11ef4c4c401874c6a4da85e28baaef800e7529c26d30de31ed07f2c"

URI_x86_64_v2_stb_perlin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_perlin-devel-0.5^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_perlin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_perlin-devel}"
SRC_URI[x86_64_v2_stb_perlin-devel.sha256sum] = "20411b7ffc38427202da25cf47a32db6141cf4e27697d81f3f2826cb055b18ec"

URI_x86_64_v2_stb_rect_pack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_rect_pack-devel-1.1^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_rect_pack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_rect_pack-devel}"
SRC_URI[x86_64_v2_stb_rect_pack-devel.sha256sum] = "6aa67deb9fd5d04a7b3e698e1c22cbc0b572d43925e8d390fc6ad0fd83c06885"

URI_x86_64_v2_stb_sprintf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_sprintf-devel-1.10^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_sprintf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_sprintf-devel}"
SRC_URI[x86_64_v2_stb_sprintf-devel.sha256sum] = "08ac2b9027bfa308ea3423301fc6e1f7be3a80f4096263ed4a9dd58d30747551"

URI_x86_64_v2_stb_textedit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_textedit-devel-1.14^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_textedit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_textedit-devel}"
SRC_URI[x86_64_v2_stb_textedit-devel.sha256sum] = "4cfe0a76cd90f8ba5b0596929e59024ada2cbfeeaf88b6f24c4e347ad6079a55"

URI_x86_64_v2_stb_tilemap_editor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_tilemap_editor-devel-0.42^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_tilemap_editor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_tilemap_editor-devel}"
SRC_URI[x86_64_v2_stb_tilemap_editor-devel.sha256sum] = "a5fe91e72a96d650d8c64a845b7bfa496165d3268fca4bf48a881cbaf081bc2e"

URI_x86_64_v2_stb_truetype-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_truetype-devel-1.26^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_truetype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_truetype-devel}"
SRC_URI[x86_64_v2_stb_truetype-devel.sha256sum] = "673e1861343891f5e38044d687e765f234d44f3782bb60079bdfe34819f74059"

URI_x86_64_v2_stb_vorbis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_vorbis-devel-1.22^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_vorbis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_vorbis-devel}"
SRC_URI[x86_64_v2_stb_vorbis-devel.sha256sum] = "103bee29a80f8af76924afd93ebcabb3a9f8fd04607978caa7c5379829d47db8"

URI_x86_64_v2_stb_voxel_render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_voxel_render-devel-0.89^20260313git904aa67-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_voxel_render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_voxel_render-devel}"
SRC_URI[x86_64_v2_stb_voxel_render-devel.sha256sum] = "47e7409d766986911207f0f96bf409841be8d1994f415859946af03cb9131524"

URI_aarch64_stb-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb-devel-0^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb-devel}"
SRC_URI[aarch64_stb-devel.sha256sum] = "3cc0c0c5da7622fec37d3c208d468a90671d68f060a522674d40ae48c5a280ba"

URI_aarch64_stb-doc = "${EPEL_MIRROR}/aarch64/Packages/s/stb-doc-0^20260313git904aa67-2.el10_2.noarch.rpm;name=aarch64_stb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb-doc}"
SRC_URI[aarch64_stb-doc.sha256sum] = "362ef41b5ef4bd9c4133a2f5d591e63adf91980c49de2308bd2404d1df4c728e"

URI_aarch64_stb_c_lexer-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_c_lexer-devel-0.12^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_c_lexer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_c_lexer-devel}"
SRC_URI[aarch64_stb_c_lexer-devel.sha256sum] = "310ec74c5bd6c056ee0eb76164f4e5c0ee8d18f398be38673b4236586e0ca8e3"

URI_aarch64_stb_connected_components-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_connected_components-devel-0.96^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_connected_components-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_connected_components-devel}"
SRC_URI[aarch64_stb_connected_components-devel.sha256sum] = "7786e9406d7e0c388b568bd611aca8001a7aee2f053a213f151b62fefbc6331b"

URI_aarch64_stb_divide-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_divide-devel-0.94^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_divide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_divide-devel}"
SRC_URI[aarch64_stb_divide-devel.sha256sum] = "5b0dd56e8d10bb62db81857f3671d39556f4ee452dbc611f96578a28b45d360c"

URI_aarch64_stb_ds-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_ds-devel-0.67^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_ds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_ds-devel}"
SRC_URI[aarch64_stb_ds-devel.sha256sum] = "91b9c05a3848e79a80a572aa8042fbb206cb6c6317eb44912f4f3fadded5dfbc"

URI_aarch64_stb_dxt-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_dxt-devel-1.12^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_dxt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_dxt-devel}"
SRC_URI[aarch64_stb_dxt-devel.sha256sum] = "9b1232fba80de0665344f296ec698ebf6945dbe91a8f43ea2d386724930f06a5"

URI_aarch64_stb_easy_font-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_easy_font-devel-1.1^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_easy_font-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_easy_font-devel}"
SRC_URI[aarch64_stb_easy_font-devel.sha256sum] = "4d63a322c9bcaa989de7bae4934e6cdd14061481fcdb3d0cb27a88227d80e3ef"

URI_aarch64_stb_herringbone_wang_tile-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_herringbone_wang_tile-devel-0.7^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_herringbone_wang_tile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_herringbone_wang_tile-devel}"
SRC_URI[aarch64_stb_herringbone_wang_tile-devel.sha256sum] = "0405aa1b5b38a16d3b7639ec03a03a767fb403e0f1fd7f725180c4017313e1b9"

URI_aarch64_stb_hexwave-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_hexwave-devel-0.5^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_hexwave-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_hexwave-devel}"
SRC_URI[aarch64_stb_hexwave-devel.sha256sum] = "8510120de3d7962c8b6cb34cf3a6b04e85ec8bfa5dcd9c0bbdff7ccaaf0f4bf7"

URI_aarch64_stb_image-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image-devel-2.30^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image-devel}"
SRC_URI[aarch64_stb_image-devel.sha256sum] = "943cc6acc7d450c97758ef9b638069ae2ba984df64dbcb0b0c1fbaecc6b3d6d3"

URI_aarch64_stb_image_resize-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_resize-devel-0.97^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_image_resize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_resize-devel}"
SRC_URI[aarch64_stb_image_resize-devel.sha256sum] = "99b88929fde2f576e85cd1200fbf58e3fb4a81009763afb7a039c36d9f89215d"

URI_aarch64_stb_image_resize2-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_resize2-devel-2.18^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_image_resize2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_resize2-devel}"
SRC_URI[aarch64_stb_image_resize2-devel.sha256sum] = "3c38394c0f540a75949bf83fbda13205fa69a7b6636d842778aadd1c3cd8105e"

URI_aarch64_stb_image_write-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_write-devel-1.16^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_image_write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_write-devel}"
SRC_URI[aarch64_stb_image_write-devel.sha256sum] = "4dd4e55e1397b3d3dbda8fc4cb0b02130f7dd34cfe5fa6bb45411bcae26273d3"

URI_aarch64_stb_leakcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_leakcheck-devel-0.6^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_leakcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_leakcheck-devel}"
SRC_URI[aarch64_stb_leakcheck-devel.sha256sum] = "291e57fd1a8cf45546c5808ae50bc2125a4f3e08a52d4f6e91f17ef241358a43"

URI_aarch64_stb_perlin-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_perlin-devel-0.5^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_perlin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_perlin-devel}"
SRC_URI[aarch64_stb_perlin-devel.sha256sum] = "6a9eeba1337ad36d159b699fbb6aad1969c354bf88a11f60dcc278e79b8fc42b"

URI_aarch64_stb_rect_pack-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_rect_pack-devel-1.1^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_rect_pack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_rect_pack-devel}"
SRC_URI[aarch64_stb_rect_pack-devel.sha256sum] = "dc674c7f2ec47fa1234d0f6d22bdea820283fbf00646c913a9874860f61caa3e"

URI_aarch64_stb_sprintf-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_sprintf-devel-1.10^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_sprintf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_sprintf-devel}"
SRC_URI[aarch64_stb_sprintf-devel.sha256sum] = "1bb02b095a5790ebf65770f936f829a197e6a8c6c91a2f40698c6c7210a6d49b"

URI_aarch64_stb_textedit-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_textedit-devel-1.14^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_textedit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_textedit-devel}"
SRC_URI[aarch64_stb_textedit-devel.sha256sum] = "5469dc9eadeb2c7a4fe9a8a96dc32ea618a30e0c27ed077483fa8277ec9adb5f"

URI_aarch64_stb_tilemap_editor-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_tilemap_editor-devel-0.42^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_tilemap_editor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_tilemap_editor-devel}"
SRC_URI[aarch64_stb_tilemap_editor-devel.sha256sum] = "f4bd2b8cc35d3cf9e485b8603c3a4db383caa9999d04434cca4912b47b0e1968"

URI_aarch64_stb_truetype-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_truetype-devel-1.26^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_truetype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_truetype-devel}"
SRC_URI[aarch64_stb_truetype-devel.sha256sum] = "ac5eb96940b93d8d8f6f7226e9f2139bf40135a9a121b32c4200a130d46614ba"

URI_aarch64_stb_vorbis-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_vorbis-devel-1.22^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_vorbis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_vorbis-devel}"
SRC_URI[aarch64_stb_vorbis-devel.sha256sum] = "5a0f8f62e0b627e6d5cd5e4cfa8ede3740ade27d79e8caaa17345b7ce15ecfe5"

URI_aarch64_stb_voxel_render-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_voxel_render-devel-0.89^20260313git904aa67-2.el10_2.aarch64.rpm;name=aarch64_stb_voxel_render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_voxel_render-devel}"
SRC_URI[aarch64_stb_voxel_render-devel.sha256sum] = "93bcb99ae5b1d5e5fa22ed1a89a99b8016103ed959b013a47d43d527ab036832"

RDEPENDS:stb-devel = " \
 stb_c_lexer-devel \
 stb_connected_components-devel \
 stb_divide-devel \
 stb_ds-devel \
 stb_dxt-devel \
 stb_easy_font-devel \
 stb_herringbone_wang_tile-devel \
 stb_hexwave-devel \
 stb_image-devel \
 stb_image_resize2-devel \
 stb_image_write-devel \
 stb_leakcheck-devel \
 stb_perlin-devel \
 stb_rect_pack-devel \
 stb_sprintf-devel \
 stb_textedit-devel \
 stb_tilemap_editor-devel \
 stb_truetype-devel \
 stb_vorbis-devel \
 stb_voxel_render-devel \
 "
RDEPENDS:stb-doc = " \
 "
RDEPENDS:stb_c_lexer-devel = " \
 "
RDEPENDS:stb_connected_components-devel = " \
 "
RDEPENDS:stb_divide-devel = " \
 "
RDEPENDS:stb_ds-devel = " \
 "
RDEPENDS:stb_dxt-devel = " \
 "
RDEPENDS:stb_easy_font-devel = " \
 "
RDEPENDS:stb_herringbone_wang_tile-devel = " \
 "
RDEPENDS:stb_hexwave-devel = " \
 "
RDEPENDS:stb_image-devel = " \
 "
RDEPENDS:stb_image_resize-devel = " \
 "
RDEPENDS:stb_image_resize2-devel = " \
 "
RDEPENDS:stb_image_write-devel = " \
 "
RDEPENDS:stb_leakcheck-devel = " \
 "
RDEPENDS:stb_perlin-devel = " \
 "
RDEPENDS:stb_rect_pack-devel = " \
 "
RDEPENDS:stb_sprintf-devel = " \
 "
RDEPENDS:stb_textedit-devel = " \
 "
RDEPENDS:stb_tilemap_editor-devel = " \
 "
RDEPENDS:stb_truetype-devel = " \
 "
RDEPENDS:stb_vorbis-devel = " \
 "
RDEPENDS:stb_voxel_render-devel = " \
 "
