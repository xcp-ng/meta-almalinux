# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-ds"
PV = "1.8.0"
PR = "2.el10_2"
PACKAGES = " \
 php-pecl-ds \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-ds-1.8.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05b4b0031fbf9ad3fa167add4ecf6c02506b3d4eabcebb735720edabef4c56bd"

URI_x86_64_v2_php-pecl-ds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-ds-1.8.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-ds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-ds}"
SRC_URI[x86_64_v2_php-pecl-ds.sha256sum] = "758698e2022cecea0d8b9437793df6b271a945a9cd94865943f919abcd1043f4"

URI_aarch64_php-pecl-ds = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-ds-1.8.0-2.el10_2.aarch64.rpm;name=aarch64_php-pecl-ds;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-ds}"
SRC_URI[aarch64_php-pecl-ds.sha256sum] = "c3d98611aca45f5b4ae1c7bdfc53c0b00a363279fe8fb0106c6fc63982b72b91"

RDEPENDS:php-pecl-ds:x86_64_v2 = " \
 glibc \
 php-common \
 virtual/php-json_x86-64_ \
"
RDEPENDS:php-pecl-ds:aarch64 = " \
 glibc \
 php-common \
 virtual/php-json_aarch-64_ \
"
