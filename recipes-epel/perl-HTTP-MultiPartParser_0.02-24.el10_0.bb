# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-MultiPartParser"
PV = "0.02"
PR = "24.el10_0"
PACKAGES = " \
 perl-HTTP-MultiPartParser \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTTP-MultiPartParser-0.02-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ccb139b8fe76360f6c1ec036fa3d2d700c67de92cc19397706bf5ecee2f999b"

URI_x86_64_v2_perl-HTTP-MultiPartParser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-MultiPartParser-0.02-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-MultiPartParser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-MultiPartParser}"
SRC_URI[x86_64_v2_perl-HTTP-MultiPartParser.sha256sum] = "5648f1847b0df258aac2bcdf588f9dbed5fd570d378c1e797eb112a6fd695406"

URI_aarch64_perl-HTTP-MultiPartParser = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-MultiPartParser-0.02-24.el10_0.noarch.rpm;name=aarch64_perl-HTTP-MultiPartParser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-MultiPartParser}"
SRC_URI[aarch64_perl-HTTP-MultiPartParser.sha256sum] = "9380fe67a6bec70344f445a79b32753b1b189487069411615898596fc5cef423"

RDEPENDS:perl-HTTP-MultiPartParser = " \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 "
