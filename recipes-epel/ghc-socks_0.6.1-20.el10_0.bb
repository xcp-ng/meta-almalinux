# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-socks"
PV = "0.6.1"
PR = "20.el10_0"
PACKAGES = " \
 ghc-socks \
 ghc-socks-devel \
 ghc-socks-doc \
 ghc-socks-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-socks-0.6.1-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "44b0f6ac71d183a2a3a427e69f41f866d599404e5f903cce4e65393cecd72cc3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-socks-0.6.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-socks;unpack=0"
SRC_URI[x86_64_v2_ghc-socks.sha256sum] = "5526aa962d0c769bbcb859d0ef324cc3238013cf0d16fa5a334f5d089e89df49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-socks-devel-0.6.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-socks-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-socks-devel.sha256sum] = "623692960bfb57e2ec601ac3a0d437d5096a885ad771290c9c45ed9094b97288"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-socks-doc-0.6.1-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-socks-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-socks-doc.sha256sum] = "8e2142e71d6bfd4f1c2196d343643d0634199c4d91278eda4b2faf1c28cc79a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-socks-prof-0.6.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-socks-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-socks-prof.sha256sum] = "40715aea04c32f70dc30dabd4bae252ff9327ce12dd33c7353051d4eff499b25"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-socks-0.6.1-20.el10_0.aarch64.rpm;name=aarch64_ghc-socks;unpack=0"
SRC_URI[aarch64_ghc-socks.sha256sum] = "9680f3556171e2fcde1ccb47d45a7fc06dd3d2b9950d21c2f3c453069b355d3f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-socks-devel-0.6.1-20.el10_0.aarch64.rpm;name=aarch64_ghc-socks-devel;unpack=0"
SRC_URI[aarch64_ghc-socks-devel.sha256sum] = "76823bcbf66490a561edcdff35cb0475bf3a030a87a45f4d7bdab41c5570f997"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-socks-doc-0.6.1-20.el10_0.noarch.rpm;name=aarch64_ghc-socks-doc;unpack=0"
SRC_URI[aarch64_ghc-socks-doc.sha256sum] = "4bac301949b48e351a5714cf90c4fa727a23bbc95bef7e26920c2257163b3a0b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-socks-prof-0.6.1-20.el10_0.aarch64.rpm;name=aarch64_ghc-socks-prof;unpack=0"
SRC_URI[aarch64_ghc-socks-prof.sha256sum] = "787f4a16d62c5ff761c011802e081b4002cc46b3263bdf7f1693f9fd8a523634"

RDEPENDS:ghc-socks = " \
 ghc-array \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-cereal \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-network \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-socks-devel = " \
 ghc-base-devel \
 ghc-basement-devel \
 ghc-bytestring-devel \
 ghc-cereal-devel \
 ghc-compiler \
 ghc-network-devel \
 ghc-socks \
 "
RDEPENDS:ghc-socks-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-socks-prof = " \
 ghc-base-prof \
 ghc-basement-prof \
 ghc-bytestring-prof \
 ghc-cereal-prof \
 ghc-network-prof \
 ghc-socks-devel \
 "
