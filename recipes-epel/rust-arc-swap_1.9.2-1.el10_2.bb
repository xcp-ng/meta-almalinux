# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arc-swap"
PV = "1.9.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-arc-swap+default-devel \
 rust-arc-swap+experimental-strategies-devel \
 rust-arc-swap+experimental-thread-local-devel \
 rust-arc-swap+internal-test-strategies-devel \
 rust-arc-swap+serde-devel \
 rust-arc-swap+weak-devel \
 rust-arc-swap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arc-swap-1.9.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73d2e82c7c721500c5916712f7c93d36715dc6b3a2e5b98b8590edce53a65f21"

URI_x86_64_v2_rust-arc-swap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+default-devel-1.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+default-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+default-devel.sha256sum] = "6ceb0bdc2551269934a175ad0e7b6b65bfbd03a4f26eca0b9aca594e63983048"

URI_x86_64_v2_rust-arc-swap+experimental-strategies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+experimental-strategies-devel-1.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+experimental-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+experimental-strategies-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+experimental-strategies-devel.sha256sum] = "59ab833f0e66e5b9f0a61b82b28e0182b759601f46266b48bb34b64155d5b1d0"

URI_x86_64_v2_rust-arc-swap+experimental-thread-local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+experimental-thread-local-devel-1.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+experimental-thread-local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+experimental-thread-local-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+experimental-thread-local-devel.sha256sum] = "b34eb6e66c7b0f66488e6a95c3b248a99df2fe8404c725dd181b3f9680575e38"

URI_x86_64_v2_rust-arc-swap+internal-test-strategies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+internal-test-strategies-devel-1.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+internal-test-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+internal-test-strategies-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+internal-test-strategies-devel.sha256sum] = "8abd3c9166e4e304170e380ad965ac14135545ce70cdf8a9957abe4e20379439"

URI_x86_64_v2_rust-arc-swap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+serde-devel-1.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+serde-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+serde-devel.sha256sum] = "654391049a7dd64f08c6681e8a54f1809d3c34f6d74e42735eb6aa4a6a868a27"

URI_x86_64_v2_rust-arc-swap+weak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+weak-devel-1.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+weak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+weak-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+weak-devel.sha256sum] = "6825835ec84123ce8ad768d70e96dde7c90f08b3b21a1f13cedefeaaeee250b2"

URI_x86_64_v2_rust-arc-swap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap-devel-1.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap-devel}"
SRC_URI[x86_64_v2_rust-arc-swap-devel.sha256sum] = "eb1a6bf9320e37010f972d945e932f6f47c90e54bd0b44bf9cb1136ce503d259"

URI_aarch64_rust-arc-swap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+default-devel-1.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-arc-swap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+default-devel}"
SRC_URI[aarch64_rust-arc-swap+default-devel.sha256sum] = "42aee9cfd526a74b997385de94ad11661d6a9593ca31533828c3d4a8ca3ebeb8"

URI_aarch64_rust-arc-swap+experimental-strategies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+experimental-strategies-devel-1.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-arc-swap+experimental-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+experimental-strategies-devel}"
SRC_URI[aarch64_rust-arc-swap+experimental-strategies-devel.sha256sum] = "40df1a5ef9da4c5192b364b1c2da556241c36aead5459ff4016bdb5445233bb0"

URI_aarch64_rust-arc-swap+experimental-thread-local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+experimental-thread-local-devel-1.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-arc-swap+experimental-thread-local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+experimental-thread-local-devel}"
SRC_URI[aarch64_rust-arc-swap+experimental-thread-local-devel.sha256sum] = "b1d5a96e9dd852165d304142cf4fd4b11a44e704bc9adac5632ceb9b42a286b0"

URI_aarch64_rust-arc-swap+internal-test-strategies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+internal-test-strategies-devel-1.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-arc-swap+internal-test-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+internal-test-strategies-devel}"
SRC_URI[aarch64_rust-arc-swap+internal-test-strategies-devel.sha256sum] = "a15b7c88f47c50923a674b17f6f08a14b24107a47596be6a7ae50f764364cd91"

URI_aarch64_rust-arc-swap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+serde-devel-1.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-arc-swap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+serde-devel}"
SRC_URI[aarch64_rust-arc-swap+serde-devel.sha256sum] = "09925f94172503b87087dd220b7a14e4d0ca71b9473e98c1fda5ffe8a88e5bfe"

URI_aarch64_rust-arc-swap+weak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+weak-devel-1.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-arc-swap+weak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+weak-devel}"
SRC_URI[aarch64_rust-arc-swap+weak-devel.sha256sum] = "ddcf6e6ca05e67f206f4d305a60b8e5ab54021be629c67f51f67502a8d30abe0"

URI_aarch64_rust-arc-swap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap-devel-1.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-arc-swap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap-devel}"
SRC_URI[aarch64_rust-arc-swap-devel.sha256sum] = "069e3b08b2571853146cfd4287458d5295001f06735c71d809d71a1b182a736e"

RDEPENDS:rust-arc-swap+default-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+experimental-strategies-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+experimental-thread-local-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+internal-test-strategies-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+serde-devel = " \
 cargo \
 rust-arc-swap-devel \
 rust-serde+default-devel \
 rust-serde+rc-devel \
 "
RDEPENDS:rust-arc-swap+weak-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap-devel = " \
 bash \
 cargo \
 rust-rustversion+default-devel \
 "
