# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-autoar"
PV = "0.4.5"
PR = "2.el10"
PACKAGES = " \
 gnome-autoar \
 gnome-autoar-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-autoar-0.4.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8ece7f3b2f3c7365e29b0841c168ed4d9eb4460e4b14372e3b1d6c87e5c73b6"

URI_x86_64_v2_gnome-autoar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-autoar-0.4.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-autoar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-autoar}"
SRC_URI[x86_64_v2_gnome-autoar.sha256sum] = "e36d8c0eeba5a840f51401e75d9de7571544887029fc440d3279166e5a9dbea7"

URI_x86_64_v2_gnome-autoar-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-autoar-devel-0.4.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-autoar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-autoar-devel}"
SRC_URI[x86_64_v2_gnome-autoar-devel.sha256sum] = "121c145fb5a0f51efc138fd26656115211066e80f4882c9cc711d02635c8b1f7"

URI_aarch64_gnome-autoar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-autoar-0.4.5-2.el10.aarch64.rpm;name=aarch64_gnome-autoar;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-autoar}"
SRC_URI[aarch64_gnome-autoar.sha256sum] = "fdb29c71b2957e9a469cf566a05b6ccaf5ba38c24f04a524ec56f5161ebd1448"

URI_aarch64_gnome-autoar-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-autoar-devel-0.4.5-2.el10.aarch64.rpm;name=aarch64_gnome-autoar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-autoar-devel}"
SRC_URI[aarch64_gnome-autoar-devel.sha256sum] = "9d958179750e40ecb32f191fac03ff97a17a86f80ab83d7e5b060ef732e61a95"

RDEPENDS:gnome-autoar = " \
 glib2 \
 glibc \
 gtk3 \
 libarchive \
 libgcc \
 "
RDEPENDS:gnome-autoar-devel = " \
 glib2-devel \
 gnome-autoar \
 gtk3-devel \
 libarchive-devel \
 pkgconf-pkg-config \
 "
