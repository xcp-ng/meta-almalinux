# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rtl-433"
PV = "23.11"
PR = "1.20240826gitf0ba153.el10_0"
PACKAGES = " \
 rtl-433 \
 rtl-433-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rtl-433-23.11-1.20240826gitf0ba153.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f93a08b8b7d37e47ab6944480a19f54f52513fbf27d62547162fae1123218ca8"

URI_x86_64_v2_rtl-433 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rtl-433-23.11-1.20240826gitf0ba153.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rtl-433;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rtl-433}"
SRC_URI[x86_64_v2_rtl-433.sha256sum] = "e4d8b5546aa7acb1f811df7cc859016f51f51f73c593098a07a5bbddff88b869"

URI_x86_64_v2_rtl-433-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rtl-433-devel-23.11-1.20240826gitf0ba153.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rtl-433-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rtl-433-devel}"
SRC_URI[x86_64_v2_rtl-433-devel.sha256sum] = "286ef9c898908338c079969b30475898d0e9b36962416a6ddf5e3694e11f4a88"

URI_aarch64_rtl-433 = "${EPEL_MIRROR}/aarch64/Packages/r/rtl-433-23.11-1.20240826gitf0ba153.el10_0.aarch64.rpm;name=aarch64_rtl-433;unpack=0"
SRC_URI:append = " ${URI_aarch64_rtl-433}"
SRC_URI[aarch64_rtl-433.sha256sum] = "470b6c4439068f53ae22a076964a05b3f71db499ebab9f2b223de24de39b6ae8"

URI_aarch64_rtl-433-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rtl-433-devel-23.11-1.20240826gitf0ba153.el10_0.aarch64.rpm;name=aarch64_rtl-433-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rtl-433-devel}"
SRC_URI[aarch64_rtl-433-devel.sha256sum] = "9ec7c44a9d8ef3883c98ba045bbf006ca25ee21418ef497ab61d134585093866"

RDEPENDS:rtl-433 = " \
 SoapySDR \
 glibc \
 libusb1 \
 rtl-sdr \
 "
RDEPENDS:rtl-433-devel = " \
 rtl-433 \
 "
