# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-yubico"
PV = "1.3.3"
PR = "17.el10"
PACKAGES = " \
 python3-yubico \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-yubico-1.3.3-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ab530511192b4096e953115b71b3908f6550100b2004442c3dda1d955148eb2"

URI_x86_64_v2_python3-yubico = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-yubico-1.3.3-17.el10.noarch.rpm;name=x86_64_v2_python3-yubico;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-yubico}"
SRC_URI[x86_64_v2_python3-yubico.sha256sum] = "f7a3f14abf65bac39d53531b674865ebf89f53eca5a6f7536402529e702e0734"

URI_aarch64_python3-yubico = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-yubico-1.3.3-17.el10.noarch.rpm;name=aarch64_python3-yubico;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-yubico}"
SRC_URI[aarch64_python3-yubico.sha256sum] = "f7a3f14abf65bac39d53531b674865ebf89f53eca5a6f7536402529e702e0734"

RDEPENDS:python3-yubico = " \
 python3 \
 python3-pyusb \
 "
