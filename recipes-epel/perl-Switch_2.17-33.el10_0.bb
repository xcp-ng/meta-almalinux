# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Switch"
PV = "2.17"
PR = "33.el10_0"
PACKAGES = " \
 perl-Switch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Switch-2.17-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19e3999887ba3a560febbab5dacf4555c3b582b64affd6def0892d1fe383b732"

URI_x86_64_v2_perl-Switch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Switch-2.17-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Switch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Switch}"
SRC_URI[x86_64_v2_perl-Switch.sha256sum] = "8ccc0d8fe79eebf021c8a57eebfbb3ecae3b12adc8ed3f301e44724a690ece98"

URI_aarch64_perl-Switch = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Switch-2.17-33.el10_0.noarch.rpm;name=aarch64_perl-Switch;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Switch}"
SRC_URI[aarch64_perl-Switch.sha256sum] = "23f936706ed9198cdfa0287752b812b078fd6852e9cf2aa0a5d9c7afcab1d65e"

RDEPENDS:perl-Switch = " \
 perl-Carp \
 perl-Filter \
 perl-Text-Balanced \
 perl-deprecate \
 perl-if \
 perl-libs \
 perl-overload \
 perl-vars \
 "
