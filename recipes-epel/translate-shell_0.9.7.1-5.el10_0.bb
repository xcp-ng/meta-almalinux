# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "translate-shell"
PV = "0.9.7.1"
PR = "5.el10_0"
PACKAGES = " \
 translate-shell \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/translate-shell-0.9.7.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c85296c7f1984484b7781ca3dd4ae70baa96d11749025beadd78535c1ac5aadf"

URI_x86_64_v2_translate-shell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/translate-shell-0.9.7.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_translate-shell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_translate-shell}"
SRC_URI[x86_64_v2_translate-shell.sha256sum] = "b4dee53c71f0cfd28dab9ebd125fd8f083861235ec58b9811dda1745b2362d3b"

URI_aarch64_translate-shell = "${EPEL_MIRROR}/aarch64/Packages/t/translate-shell-0.9.7.1-5.el10_0.noarch.rpm;name=aarch64_translate-shell;unpack=0"
SRC_URI:append = " ${URI_aarch64_translate-shell}"
SRC_URI[aarch64_translate-shell.sha256sum] = "d6fcd91eda7e9f884791b119427c4a8091412651134576afda4329ce7173206d"

RDEPENDS:translate-shell = " \
 bash \
 curl \
 fribidi \
 gawk \
 rlwrap \
 "
