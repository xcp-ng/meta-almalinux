# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-confluent-kafka"
PV = "1.6.1"
PR = "9.el10_0"
PACKAGES = " \
 python3-confluent-kafka \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-confluent-kafka-1.6.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dca48c55ee69e366deda8f04fc4edf59208e0266071c51cdcd5e82418b6c44f1"

URI_x86_64_v2_python3-confluent-kafka = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-confluent-kafka-1.6.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-confluent-kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-confluent-kafka}"
SRC_URI[x86_64_v2_python3-confluent-kafka.sha256sum] = "6c3cd96778d04f8d9ff25bff4d7602a3abe14c6cb0abec48927980adb7f1fb88"

URI_aarch64_python3-confluent-kafka = "${EPEL_MIRROR}/aarch64/Packages/p/python3-confluent-kafka-1.6.1-9.el10_0.aarch64.rpm;name=aarch64_python3-confluent-kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-confluent-kafka}"
SRC_URI[aarch64_python3-confluent-kafka.sha256sum] = "32b25a7881a43c3b3fc944dcbe6ee1425d619e38b000b89447c73005e79c90d3"

RDEPENDS:python3-confluent-kafka = " \
 glibc \
 librdkafka \
 python3 \
 python3-fastavro \
 python3-requests \
 "
