# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "py-radix"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-py-radix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/py-radix-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6470d25371b4df8c3028e1be145941961c59f14dc00b4a220459492c356b6e5c"

URI_x86_64_v2_python3-py-radix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-py-radix-1.1.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-py-radix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-py-radix}"
SRC_URI[x86_64_v2_python3-py-radix.sha256sum] = "8b2b45b9761d88d5474cb0b9004486840c7d7ae984e85d17d981e2f1b173d88b"

URI_aarch64_python3-py-radix = "${EPEL_MIRROR}/aarch64/Packages/p/python3-py-radix-1.1.0-1.el10_2.aarch64.rpm;name=aarch64_python3-py-radix;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-py-radix}"
SRC_URI[aarch64_python3-py-radix.sha256sum] = "7cc9b35acd7c9f958e4362eec4594e98042accdf30a447c0974d41168af7c764"

RDEPENDS:python3-py-radix = " \
 glibc \
 python3 \
 "
