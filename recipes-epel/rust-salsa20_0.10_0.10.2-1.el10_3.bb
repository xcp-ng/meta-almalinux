# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-salsa20_0.10"
PV = "0.10.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-salsa20_0.10+default-devel \
 rust-salsa20_0.10+std-devel \
 rust-salsa20_0.10+zeroize-devel \
 rust-salsa20_0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-salsa20_0.10-0.10.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78998cdcaef44baa1f9809c02f196b6e05209d77156b402a54d706f1b8d51c24"

URI_x86_64_v2_rust-salsa20_0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20_0.10+default-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20_0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20_0.10+default-devel}"
SRC_URI[x86_64_v2_rust-salsa20_0.10+default-devel.sha256sum] = "54f143bc041fe1c2335f093235953db3941404655f538a20b9af3a4bd502383a"

URI_x86_64_v2_rust-salsa20_0.10+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20_0.10+std-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20_0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20_0.10+std-devel}"
SRC_URI[x86_64_v2_rust-salsa20_0.10+std-devel.sha256sum] = "ccc02727ec5af70ca2ff0b2e1504ae47b864055afe88776ee89deff7a546b2dd"

URI_x86_64_v2_rust-salsa20_0.10+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20_0.10+zeroize-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20_0.10+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20_0.10+zeroize-devel}"
SRC_URI[x86_64_v2_rust-salsa20_0.10+zeroize-devel.sha256sum] = "29d795f5e31c6ec9b4a1393202ebadaddcc2fc6a84413b46bf67629059453f30"

URI_x86_64_v2_rust-salsa20_0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20_0.10-devel-0.10.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20_0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20_0.10-devel}"
SRC_URI[x86_64_v2_rust-salsa20_0.10-devel.sha256sum] = "5f7ee4a9f9517a3c51ac6a3b111a7698c4fcab4ab27991c32db29e749aea84d4"

URI_aarch64_rust-salsa20_0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20_0.10+default-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-salsa20_0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20_0.10+default-devel}"
SRC_URI[aarch64_rust-salsa20_0.10+default-devel.sha256sum] = "116078e1581e8be0dbfac50177ebac2b0750154ac9a362436a1cc673a2e547db"

URI_aarch64_rust-salsa20_0.10+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20_0.10+std-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-salsa20_0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20_0.10+std-devel}"
SRC_URI[aarch64_rust-salsa20_0.10+std-devel.sha256sum] = "9828ac3f5440339f39975a0c8a36aa246def6001461f8776a35f44486e3ad5e3"

URI_aarch64_rust-salsa20_0.10+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20_0.10+zeroize-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-salsa20_0.10+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20_0.10+zeroize-devel}"
SRC_URI[aarch64_rust-salsa20_0.10+zeroize-devel.sha256sum] = "3b11ac03f00e6252b15535197b6785b45e2a0cc68cd0461f61e6b8e39d9ac35f"

URI_aarch64_rust-salsa20_0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20_0.10-devel-0.10.2-1.el10_3.noarch.rpm;name=aarch64_rust-salsa20_0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20_0.10-devel}"
SRC_URI[aarch64_rust-salsa20_0.10-devel.sha256sum] = "97de19e20cc9f8c7db312451790e6e5706b4062678c10ba09f18b54156f679f1"

RDEPENDS:rust-salsa20_0.10+default-devel = " \
 cargo \
 rust-salsa20_0.10-devel \
 "
RDEPENDS:rust-salsa20_0.10+std-devel = " \
 cargo \
 rust-cipher0.4+std-devel \
 rust-salsa20_0.10-devel \
 "
RDEPENDS:rust-salsa20_0.10+zeroize-devel = " \
 cargo \
 rust-cipher0.4+zeroize-devel \
 rust-salsa20_0.10-devel \
 "
RDEPENDS:rust-salsa20_0.10-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
