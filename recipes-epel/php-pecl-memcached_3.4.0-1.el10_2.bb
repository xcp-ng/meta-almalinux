# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-memcached"
PV = "3.4.0"
PR = "1.el10_2"
PACKAGES = " \
 php-pecl-memcached \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-memcached-3.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8232ee7c415f160de44588fea10d63b43b629ba7a3e83e9e5dffcbcc965a6ff3"

URI_x86_64_v2_php-pecl-memcached = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-memcached-3.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-memcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-memcached}"
SRC_URI[x86_64_v2_php-pecl-memcached.sha256sum] = "932e8be180a21ada07f9773de5f313691529c2a76b9a4a588603dd5747f01148"

URI_aarch64_php-pecl-memcached = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-memcached-3.4.0-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-memcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-memcached}"
SRC_URI[aarch64_php-pecl-memcached.sha256sum] = "b543087256738ccca1c89f9bd0f9acde2d30e149837dfadcd98bbc10cf229d6f"

RDEPENDS:php-pecl-memcached:x86_64_v2 = " \
 cyrus-sasl-lib \
 fastlz \
 glibc \
 libevent \
 libmemcached-awesome \
 libzstd \
 php-common \
 php-pecl-igbinary \
 php-pecl-msgpack \
 virtual/php-json_x86-64_ \
 zlib-ng-compat \
"
RDEPENDS:php-pecl-memcached:aarch64 = " \
 cyrus-sasl-lib \
 fastlz \
 glibc \
 libevent \
 libmemcached-awesome \
 libzstd \
 php-common \
 php-pecl-igbinary \
 php-pecl-msgpack \
 virtual/php-json_aarch-64_ \
 zlib-ng-compat \
"
