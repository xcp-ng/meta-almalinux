# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yansi"
PV = "1.0.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-yansi+alloc-devel \
 rust-yansi+default-devel \
 rust-yansi+detect-env-devel \
 rust-yansi+detect-tty-devel \
 rust-yansi+hyperlink-devel \
 rust-yansi+is-terminal-devel \
 rust-yansi+std-devel \
 rust-yansi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yansi-1.0.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58b94fffc61df14f3c0d57859dcf4f3c8423a85095f5bea72322803a804e3ab1"

URI_x86_64_v2_rust-yansi+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi+alloc-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi+alloc-devel}"
SRC_URI[x86_64_v2_rust-yansi+alloc-devel.sha256sum] = "a5bce9e473b8273a0c10d9272081b5cb14af3deb23f344bf2fe22e002d50a5dd"

URI_x86_64_v2_rust-yansi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi+default-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi+default-devel}"
SRC_URI[x86_64_v2_rust-yansi+default-devel.sha256sum] = "f46d32034a6da0c662413869f5bf99961e699350f05f60605157dc55ddb46c9a"

URI_x86_64_v2_rust-yansi+detect-env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi+detect-env-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi+detect-env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi+detect-env-devel}"
SRC_URI[x86_64_v2_rust-yansi+detect-env-devel.sha256sum] = "23e52db3adc2ddce2f61322c84069fe92cc2f3c61fb1f3b199da1c324369fdc8"

URI_x86_64_v2_rust-yansi+detect-tty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi+detect-tty-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi+detect-tty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi+detect-tty-devel}"
SRC_URI[x86_64_v2_rust-yansi+detect-tty-devel.sha256sum] = "1703566d4adc0b0fe66f00f955b2cd576990c9b72e5f4715ecaf99dc09f4eb21"

URI_x86_64_v2_rust-yansi+hyperlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi+hyperlink-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi+hyperlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi+hyperlink-devel}"
SRC_URI[x86_64_v2_rust-yansi+hyperlink-devel.sha256sum] = "1a9e4b3d67e2713c17e1ad23cd3267b023c514b6e6ff49dee86425bc81067f71"

URI_x86_64_v2_rust-yansi+is-terminal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi+is-terminal-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi+is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi+is-terminal-devel}"
SRC_URI[x86_64_v2_rust-yansi+is-terminal-devel.sha256sum] = "677dba2ba104626e8c89420a1e354ee24b31de94d7347be9f00bc1b0facdb44a"

URI_x86_64_v2_rust-yansi+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi+std-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi+std-devel}"
SRC_URI[x86_64_v2_rust-yansi+std-devel.sha256sum] = "2ee6d5c4e61724efa78022af35ed4682e43e291509cebbfbaf1e38a72ef5b988"

URI_x86_64_v2_rust-yansi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yansi-devel-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yansi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yansi-devel}"
SRC_URI[x86_64_v2_rust-yansi-devel.sha256sum] = "19ba9f8f06631e5f06318168118f54389586318f6c966fbf751ae4fefd2aba7c"

URI_aarch64_rust-yansi+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi+alloc-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-yansi+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi+alloc-devel}"
SRC_URI[aarch64_rust-yansi+alloc-devel.sha256sum] = "61c83f78a57645f25e72a2133dc766a7101000a24f9cd2b71f500dba348681cf"

URI_aarch64_rust-yansi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi+default-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-yansi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi+default-devel}"
SRC_URI[aarch64_rust-yansi+default-devel.sha256sum] = "e275d611190e5d41c4fa715e71a91f8e55a6adb79c516770dbe6ad5ffdf3a218"

URI_aarch64_rust-yansi+detect-env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi+detect-env-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-yansi+detect-env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi+detect-env-devel}"
SRC_URI[aarch64_rust-yansi+detect-env-devel.sha256sum] = "752cb3a423a980b586b6604b9bbc0efe21d1cc66e2bfb9ed24ff78db286900d4"

URI_aarch64_rust-yansi+detect-tty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi+detect-tty-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-yansi+detect-tty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi+detect-tty-devel}"
SRC_URI[aarch64_rust-yansi+detect-tty-devel.sha256sum] = "25572bdf26fdbe1d3a524558567532dd12a06121ca0a9f812d390ceac6176ea2"

URI_aarch64_rust-yansi+hyperlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi+hyperlink-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-yansi+hyperlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi+hyperlink-devel}"
SRC_URI[aarch64_rust-yansi+hyperlink-devel.sha256sum] = "8219f332760b133c007496dbf522d241bea0ab202695d25ef266839d2a25d4be"

URI_aarch64_rust-yansi+is-terminal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi+is-terminal-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-yansi+is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi+is-terminal-devel}"
SRC_URI[aarch64_rust-yansi+is-terminal-devel.sha256sum] = "a9a2fad58765dcbbfa3fde245ceb00a06db9381b8edd5620cc2964199d17a2d3"

URI_aarch64_rust-yansi+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi+std-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-yansi+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi+std-devel}"
SRC_URI[aarch64_rust-yansi+std-devel.sha256sum] = "c1fff2004b7fae5714c0a000baea308e5d216a77da82f21d0858538929f148b4"

URI_aarch64_rust-yansi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yansi-devel-1.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-yansi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yansi-devel}"
SRC_URI[aarch64_rust-yansi-devel.sha256sum] = "06d1b9882d2a2ebb47119cae0464a19880a6ca4c950a0cf397bf9bffd26cdd93"

RDEPENDS:rust-yansi+alloc-devel = " \
 cargo \
 rust-yansi-devel \
 "
RDEPENDS:rust-yansi+default-devel = " \
 cargo \
 rust-yansi+std-devel \
 rust-yansi-devel \
 "
RDEPENDS:rust-yansi+detect-env-devel = " \
 cargo \
 rust-yansi+std-devel \
 rust-yansi-devel \
 "
RDEPENDS:rust-yansi+detect-tty-devel = " \
 cargo \
 rust-yansi+is-terminal-devel \
 rust-yansi+std-devel \
 rust-yansi-devel \
 "
RDEPENDS:rust-yansi+hyperlink-devel = " \
 cargo \
 rust-yansi+std-devel \
 rust-yansi-devel \
 "
RDEPENDS:rust-yansi+is-terminal-devel = " \
 cargo \
 rust-is-terminal+default-devel \
 rust-yansi-devel \
 "
RDEPENDS:rust-yansi+std-devel = " \
 cargo \
 rust-yansi+alloc-devel \
 rust-yansi-devel \
 "
RDEPENDS:rust-yansi-devel = " \
 cargo \
 rust \
 "
