# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-exhaustigen"
PV = "0.1.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-exhaustigen+default-devel \
 rust-exhaustigen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-exhaustigen-0.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff671f0939234d662a540bd4aa680d9669f337d1fb4e053fd3fa8811322f9362"

URI_x86_64_v2_rust-exhaustigen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exhaustigen+default-devel-0.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exhaustigen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exhaustigen+default-devel}"
SRC_URI[x86_64_v2_rust-exhaustigen+default-devel.sha256sum] = "f85b69ecc79c5b236d10c6313a2d2e56f13ae1fce477aef811f0c3a327b47d4f"

URI_x86_64_v2_rust-exhaustigen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exhaustigen-devel-0.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exhaustigen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exhaustigen-devel}"
SRC_URI[x86_64_v2_rust-exhaustigen-devel.sha256sum] = "e8ce47e4e34ede755191604a7ba00998809249416da9e8ee3a5f78b3c7f1fe62"

URI_aarch64_rust-exhaustigen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exhaustigen+default-devel-0.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-exhaustigen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exhaustigen+default-devel}"
SRC_URI[aarch64_rust-exhaustigen+default-devel.sha256sum] = "9985ac514bfabde423ced062801a050a9745ef1d578945f2f46c9354960037cb"

URI_aarch64_rust-exhaustigen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exhaustigen-devel-0.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-exhaustigen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exhaustigen-devel}"
SRC_URI[aarch64_rust-exhaustigen-devel.sha256sum] = "fc1ff02a355a6cd751f5f478f5cede0400facd9734e654dd545aee674d1998ad"

RDEPENDS:rust-exhaustigen+default-devel = " \
 cargo \
 rust-exhaustigen-devel \
 "
RDEPENDS:rust-exhaustigen-devel = " \
 cargo \
 "
