# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parsertl17"
PE = "1"
PV = "1.2.1"
PR = "1.el10_1"
PACKAGES = " \
 parsertl17-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/parsertl17-1.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b27e5f4dce55413ba03337813520f3ea54daeb7a4e4a2b6b9150926783a0bdb"

URI_x86_64_v2_parsertl17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parsertl17-devel-1.2.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parsertl17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parsertl17-devel}"
SRC_URI[x86_64_v2_parsertl17-devel.sha256sum] = "705b63584e64f3ec7048cf127d241b3f7e0c2335ab3793b8e066310ba877b7d6"

URI_aarch64_parsertl17-devel = "${EPEL_MIRROR}/aarch64/Packages/p/parsertl17-devel-1.2.1-1.el10_1.aarch64.rpm;name=aarch64_parsertl17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parsertl17-devel}"
SRC_URI[aarch64_parsertl17-devel.sha256sum] = "fab7689fd3ad8517ad5bcb681610b388a4abad36c141b75563a1146a8154cec8"

RDEPENDS:parsertl17-devel = " \
 cmake-filesystem \
 lexertl17-devel \
 "
