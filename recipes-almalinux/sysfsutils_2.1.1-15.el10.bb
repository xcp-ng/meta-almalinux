# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sysfsutils"
PV = "2.1.1"
PR = "15.el10"
PACKAGES = " \
 libsysfs \
 libsysfs-devel \
 sysfsutils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sysfsutils-2.1.1-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "796e9bbca882e9c359d18f4120bfd672f82bbd179865cff176235472f0357655"

URI_x86_64_v2_libsysfs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsysfs-2.1.1-15.el10.x86_64_v2.rpm;name=x86_64_v2_libsysfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsysfs}"
SRC_URI[x86_64_v2_libsysfs.sha256sum] = "67377459f9ecbf19342bb10667af7d24a013afc5e2596cee72fed10971665ef4"

URI_x86_64_v2_libsysfs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsysfs-devel-2.1.1-15.el10.x86_64_v2.rpm;name=x86_64_v2_libsysfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsysfs-devel}"
SRC_URI[x86_64_v2_libsysfs-devel.sha256sum] = "3ab652fe1c8f2d8f36f610701575a1bf53d1c8f65d66b3217f7760c085c71632"

URI_x86_64_v2_sysfsutils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sysfsutils-2.1.1-15.el10.x86_64_v2.rpm;name=x86_64_v2_sysfsutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sysfsutils}"
SRC_URI[x86_64_v2_sysfsutils.sha256sum] = "10d2e2c06552880be58a19e90cfdf1f16839e575bd3c5a47ff1b337c7ea1b535"

URI_aarch64_libsysfs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsysfs-2.1.1-15.el10.aarch64.rpm;name=aarch64_libsysfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsysfs}"
SRC_URI[aarch64_libsysfs.sha256sum] = "2d3476ee20b80df399a68f6a26143709fa31569b714be79a647265684c94b684"

URI_aarch64_libsysfs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsysfs-devel-2.1.1-15.el10.aarch64.rpm;name=aarch64_libsysfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsysfs-devel}"
SRC_URI[aarch64_libsysfs-devel.sha256sum] = "7df9fc5ee8c58b961c12617229bdb533ec41370b5cdc6585e12e73fbb7d636bc"

URI_aarch64_sysfsutils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sysfsutils-2.1.1-15.el10.aarch64.rpm;name=aarch64_sysfsutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_sysfsutils}"
SRC_URI[aarch64_sysfsutils.sha256sum] = "860c3556f925017a0ed93757b1b1697112eb5d529200a04b8d97087aa40e8661"

RDEPENDS:libsysfs = " \
 glibc \
 "
RDEPENDS:libsysfs-devel = " \
 libsysfs \
 pkgconf-pkg-config \
 "
RDEPENDS:sysfsutils = " \
 glibc \
 libsysfs \
 "
