# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gif"
PV = "0.14.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-gif+color_quant-devel \
 rust-gif+default-devel \
 rust-gif+raii_no_panic-devel \
 rust-gif+std-devel \
 rust-gif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gif-0.14.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cd1a968150b7f4960d911d0204841a67563343cdd42813bf342cb71c9c57f02"

URI_x86_64_v2_rust-gif+color_quant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+color_quant-devel-0.14.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+color_quant-devel}"
SRC_URI[x86_64_v2_rust-gif+color_quant-devel.sha256sum] = "664b5cb224c8fa0cc4ef59335aacc8e5f93c77f8829aee79c60c000069425db8"

URI_x86_64_v2_rust-gif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+default-devel-0.14.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+default-devel}"
SRC_URI[x86_64_v2_rust-gif+default-devel.sha256sum] = "de10ee4c56257d1e22977c3f020510442dbca02a2792909d0e2270f675bb5f6d"

URI_x86_64_v2_rust-gif+raii_no_panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+raii_no_panic-devel-0.14.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+raii_no_panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+raii_no_panic-devel}"
SRC_URI[x86_64_v2_rust-gif+raii_no_panic-devel.sha256sum] = "db895c3bd794267c7255f9517f75e0d9bf8919c0e0fe27ad026ab4edba19efb8"

URI_x86_64_v2_rust-gif+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif+std-devel-0.14.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif+std-devel}"
SRC_URI[x86_64_v2_rust-gif+std-devel.sha256sum] = "8ff7d6f3e54fa02e997b4943322643b4935cc20e08fae959874a7cde8ad113f5"

URI_x86_64_v2_rust-gif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gif-devel-0.14.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gif-devel}"
SRC_URI[x86_64_v2_rust-gif-devel.sha256sum] = "2c9dbf5811573df2463da409eb06e5cf82a80e8ca34a5c86565c1858766e9f90"

URI_aarch64_rust-gif+color_quant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+color_quant-devel-0.14.2-1.el10_2.noarch.rpm;name=aarch64_rust-gif+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+color_quant-devel}"
SRC_URI[aarch64_rust-gif+color_quant-devel.sha256sum] = "e05947d1ef32ba14b4b3850b5d29e8efea79dff2b0d4ab65529fabe229318e28"

URI_aarch64_rust-gif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+default-devel-0.14.2-1.el10_2.noarch.rpm;name=aarch64_rust-gif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+default-devel}"
SRC_URI[aarch64_rust-gif+default-devel.sha256sum] = "4638c10a0176787d13d509213c5452b66009c2e4711168b59b0f8ef0f3b63d23"

URI_aarch64_rust-gif+raii_no_panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+raii_no_panic-devel-0.14.2-1.el10_2.noarch.rpm;name=aarch64_rust-gif+raii_no_panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+raii_no_panic-devel}"
SRC_URI[aarch64_rust-gif+raii_no_panic-devel.sha256sum] = "9430095b83218ac55f82fd64f54977e0afd9bca40cdba3f7ea94e1d4d00adde5"

URI_aarch64_rust-gif+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif+std-devel-0.14.2-1.el10_2.noarch.rpm;name=aarch64_rust-gif+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif+std-devel}"
SRC_URI[aarch64_rust-gif+std-devel.sha256sum] = "cc5306545c72f413ac252a5e5cac0d42e128592bfdfd843c0c5840ebcab5a9c3"

URI_aarch64_rust-gif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gif-devel-0.14.2-1.el10_2.noarch.rpm;name=aarch64_rust-gif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gif-devel}"
SRC_URI[aarch64_rust-gif-devel.sha256sum] = "7ad6366b2b3c9893faeeeb4eaaebbf207f482dd3ee92d71fc6eca1f1cff7f096"

RDEPENDS:rust-gif+color_quant-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+default-devel = " \
 cargo \
 rust-gif+color_quant-devel \
 rust-gif+raii_no_panic-devel \
 rust-gif+std-devel \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+raii_no_panic-devel = " \
 cargo \
 rust-gif-devel \
 "
RDEPENDS:rust-gif+std-devel = " \
 cargo \
 rust-gif-devel \
 "
RDEPENDS:rust-gif-devel = " \
 cargo \
 rust \
 rust-weezl+default-devel \
 "
