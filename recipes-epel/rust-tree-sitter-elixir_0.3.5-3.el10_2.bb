# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-elixir"
PV = "0.3.5"
PR = "3.el10_2"
PACKAGES = " \
 rust-tree-sitter-elixir+default-devel \
 rust-tree-sitter-elixir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-elixir-0.3.5-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ea1c8fae6c22bca6804884454755ca2691718bc46b3a0cdc8ce7086c22353f8"

URI_x86_64_v2_rust-tree-sitter-elixir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elixir+default-devel-0.3.5-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elixir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elixir+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elixir+default-devel.sha256sum] = "656d3ce806af99a31fb3a71550ae24deaa299319fb72684b987fc75154aa48e0"

URI_x86_64_v2_rust-tree-sitter-elixir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elixir-devel-0.3.5-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elixir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elixir-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elixir-devel.sha256sum] = "c75f1eb3586d9aa0376e8d4832c63b5b1044056fbeeeb1a75964e00fb860f8cf"

URI_aarch64_rust-tree-sitter-elixir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elixir+default-devel-0.3.5-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-elixir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elixir+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-elixir+default-devel.sha256sum] = "c39ea16cd88eae7f94054ad0c3233f24ba92e8be747143032f00a4d457954365"

URI_aarch64_rust-tree-sitter-elixir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elixir-devel-0.3.5-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-elixir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elixir-devel}"
SRC_URI[aarch64_rust-tree-sitter-elixir-devel.sha256sum] = "3f55a875a6b54a01cc6fbfbd278bb3b7e45b2756ade8349e3fb2bf579f4586a3"

RDEPENDS:rust-tree-sitter-elixir+default-devel = " \
 cargo \
 rust-tree-sitter-elixir-devel \
 "
RDEPENDS:rust-tree-sitter-elixir-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
