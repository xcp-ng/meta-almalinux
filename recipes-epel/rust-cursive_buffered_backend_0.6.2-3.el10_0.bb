# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive_buffered_backend"
PV = "0.6.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-cursive_buffered_backend+default-devel \
 rust-cursive_buffered_backend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive_buffered_backend-0.6.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab4c42685997877391d8833a8f4484e5aabf558ecaa1a8e3b10ab01450d7da11"

URI_x86_64_v2_rust-cursive_buffered_backend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_buffered_backend+default-devel-0.6.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_buffered_backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_buffered_backend+default-devel}"
SRC_URI[x86_64_v2_rust-cursive_buffered_backend+default-devel.sha256sum] = "522d0b85bbda74565dd9cf17385472c22be3ec8c37347d31e2d042e5e1e2b3ee"

URI_x86_64_v2_rust-cursive_buffered_backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_buffered_backend-devel-0.6.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_buffered_backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_buffered_backend-devel}"
SRC_URI[x86_64_v2_rust-cursive_buffered_backend-devel.sha256sum] = "6ca58b608b793fb97460c9c97171fa54a5bdc13751ffc3efb226254044b392bc"

URI_aarch64_rust-cursive_buffered_backend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_buffered_backend+default-devel-0.6.2-3.el10_0.noarch.rpm;name=aarch64_rust-cursive_buffered_backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_buffered_backend+default-devel}"
SRC_URI[aarch64_rust-cursive_buffered_backend+default-devel.sha256sum] = "924c8b36ba6d150827cae243ecb044cbcd42aefe285291e91bd4e7bcc4f502a3"

URI_aarch64_rust-cursive_buffered_backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_buffered_backend-devel-0.6.2-3.el10_0.noarch.rpm;name=aarch64_rust-cursive_buffered_backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_buffered_backend-devel}"
SRC_URI[aarch64_rust-cursive_buffered_backend-devel.sha256sum] = "4a574802c18279531f621552e4a00b0e0fc54d3ae5ed814e68ad032f6696fe61"

RDEPENDS:rust-cursive_buffered_backend+default-devel = " \
 cargo \
 rust-cursive_buffered_backend-devel \
 "
RDEPENDS:rust-cursive_buffered_backend-devel = " \
 cargo \
 rust-cursive_core0.3+default-devel \
 rust-enumset+default-devel \
 rust-log+default-devel \
 rust-smallvec+default-devel \
 rust-unicode-segmentation+default-devel \
 virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~ \
 "
