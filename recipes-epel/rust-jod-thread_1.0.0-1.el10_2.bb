# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jod-thread"
PV = "1.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-jod-thread+default-devel \
 rust-jod-thread-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jod-thread-1.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6055477eaf9eb920572c82d4fe4f9d0ba8d1872927b7aa8e9092dc8302487870"

URI_x86_64_v2_rust-jod-thread+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jod-thread+default-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jod-thread+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jod-thread+default-devel}"
SRC_URI[x86_64_v2_rust-jod-thread+default-devel.sha256sum] = "2f0c792b058651eb4485b867a0c9fd991dc3988fab8a888274ea0399eb639721"

URI_x86_64_v2_rust-jod-thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jod-thread-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jod-thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jod-thread-devel}"
SRC_URI[x86_64_v2_rust-jod-thread-devel.sha256sum] = "c3cd613ec163ad034b66ceeae851dc5f61f7f81867d4a2edf3f681eb02423c59"

URI_aarch64_rust-jod-thread+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jod-thread+default-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-jod-thread+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jod-thread+default-devel}"
SRC_URI[aarch64_rust-jod-thread+default-devel.sha256sum] = "162715cbe4aa8066f155a2157ce2f75ac7e562484a5ec005304085b917ee9784"

URI_aarch64_rust-jod-thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jod-thread-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-jod-thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jod-thread-devel}"
SRC_URI[aarch64_rust-jod-thread-devel.sha256sum] = "7702230106f500d4e35b6bd72bb981cdf6b70e7046eebab2d450cb7d2b1b0cd1"

RDEPENDS:rust-jod-thread+default-devel = " \
 cargo \
 rust-jod-thread-devel \
 "
RDEPENDS:rust-jod-thread-devel = " \
 cargo \
 "
