# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyxdameraulevenshtein"
PV = "1.10.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-pyxdameraulevenshtein \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyxdameraulevenshtein-1.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3269c64f2826dcf676cd5e7d63b5de292887dbb9084062e13b29818f5acf0e43"

URI_x86_64_v2_python3-pyxdameraulevenshtein = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyxdameraulevenshtein-1.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyxdameraulevenshtein;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyxdameraulevenshtein}"
SRC_URI[x86_64_v2_python3-pyxdameraulevenshtein.sha256sum] = "dc992d95f3782210de2a2527b8b8cc3f23bc615b68e8f5040c6ecec95047e7ef"

URI_aarch64_python3-pyxdameraulevenshtein = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyxdameraulevenshtein-1.10.0-1.el10_3.aarch64.rpm;name=aarch64_python3-pyxdameraulevenshtein;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyxdameraulevenshtein}"
SRC_URI[aarch64_python3-pyxdameraulevenshtein.sha256sum] = "5155d38f26792a3902c85622bc6ebfb76f95a56fbd9dd714ea48ab90968517b7"

RDEPENDS:python3-pyxdameraulevenshtein = " \
 glibc \
 python3 \
 "
