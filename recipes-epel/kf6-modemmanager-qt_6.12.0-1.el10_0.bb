# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-modemmanager-qt"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-modemmanager-qt \
 kf6-modemmanager-qt-devel \
 kf6-modemmanager-qt-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-modemmanager-qt-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "048816f624d4522f9b1bbf77157c92d0ad206e09642f9e98815e794941dfee93"

URI_x86_64_v2_kf6-modemmanager-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-modemmanager-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt.sha256sum] = "b490ef7addfc8207ac0c2cadc39a7c7c78705c1006462bcc896acc0129d77bb1"

URI_x86_64_v2_kf6-modemmanager-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-modemmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-devel}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-devel.sha256sum] = "6a81add02c958d0e35ad678d1db57843ff28f8177b61907513d82f0a00d7f4ad"

URI_x86_64_v2_kf6-modemmanager-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-modemmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-doc}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-doc.sha256sum] = "8189248ef918e657a64efeb679c1fd1b09fe8cc3551e9369d29dbfc5d68bbf0e"

URI_aarch64_kf6-modemmanager-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-modemmanager-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt}"
SRC_URI[aarch64_kf6-modemmanager-qt.sha256sum] = "f7ffde0203aa266c8283bd8b169b1f9b832f608690a22d50d54616f4040dcaeb"

URI_aarch64_kf6-modemmanager-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-modemmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-devel}"
SRC_URI[aarch64_kf6-modemmanager-qt-devel.sha256sum] = "91572569a294c030463e169d0fec7bb8ae728dba11ff119d544d897ef939ac89"

URI_aarch64_kf6-modemmanager-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-modemmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-doc}"
SRC_URI[aarch64_kf6-modemmanager-qt-doc.sha256sum] = "abaa3623915e5cdf10d21832230baaf6dde30cbf8a54d477316909525d4b9b65"

RDEPENDS:kf6-modemmanager-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-modemmanager-qt-devel = " \
 ModemManager-devel \
 cmake-filesystem \
 kf6-modemmanager-qt \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-modemmanager-qt-doc = " \
 "
