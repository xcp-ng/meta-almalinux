# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Strict"
PV = "0.54"
PR = "2.el10_0"
PACKAGES = " \
 perl-Test-Strict \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Strict-0.54-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8aa8c04008703dbea95425b72cda9b8a0dd61e3b2b82f3ad6866b140fc08afb"

URI_x86_64_v2_perl-Test-Strict = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Strict-0.54-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Strict;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Strict}"
SRC_URI[x86_64_v2_perl-Test-Strict.sha256sum] = "18b090df574f520361f20ecd580634bd13527b86f5eacb56ce4cc70707940f86"

URI_aarch64_perl-Test-Strict = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Strict-0.54-2.el10_0.noarch.rpm;name=aarch64_perl-Test-Strict;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Strict}"
SRC_URI[aarch64_perl-Test-Strict.sha256sum] = "06453a45dd6a1cd5a952f61a68ae320ae8c8c6893a2147471fc27b580982a03b"

RDEPENDS:perl-Test-Strict = " \
 perl-File-Find \
 perl-FindBin \
 perl-PathTools \
 perl-Test-Simple \
 perl-libs \
 "
