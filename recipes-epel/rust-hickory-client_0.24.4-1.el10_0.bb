# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-client"
PV = "0.24.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-hickory-client+backtrace-devel \
 rust-hickory-client+default-devel \
 rust-hickory-client+dns-over-native-tls-devel \
 rust-hickory-client+dns-over-openssl-devel \
 rust-hickory-client+dns-over-tls-devel \
 rust-hickory-client+dnssec-devel \
 rust-hickory-client+dnssec-openssl-devel \
 rust-hickory-client+mdns-devel \
 rust-hickory-client+serde-config-devel \
 rust-hickory-client+serde-devel \
 rust-hickory-client-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-client-0.24.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3d0104e025575d0f3272cca00c2a106cc2a3f7e350d360c23deeb261687b37b"

URI_x86_64_v2_rust-hickory-client+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+backtrace-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+backtrace-devel.sha256sum] = "6bb4cb993c67f5be2ee6a516d3c1d491c7a2308d568a62f0697d11e264b8ab35"

URI_x86_64_v2_rust-hickory-client+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+default-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+default-devel.sha256sum] = "541976216dc320bbedf4bcee98f17e6768ca696ebf2f070deb73461e813097ee"

URI_x86_64_v2_rust-hickory-client+dns-over-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+dns-over-native-tls-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+dns-over-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+dns-over-native-tls-devel.sha256sum] = "8b4671e2c13aea4a720ec699ed6f1bda43acfe42530737cb1eb4262b392b516c"

URI_x86_64_v2_rust-hickory-client+dns-over-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+dns-over-openssl-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+dns-over-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+dns-over-openssl-devel.sha256sum] = "3478d009a53ae56f311d1b439f749bb3b13da85f7b9611469c9555f57d74413c"

URI_x86_64_v2_rust-hickory-client+dns-over-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+dns-over-tls-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+dns-over-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+dns-over-tls-devel.sha256sum] = "0348ba335c00f639af3af95e543bc2fd656cb2868626ee781f58d43309f3e803"

URI_x86_64_v2_rust-hickory-client+dnssec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+dnssec-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+dnssec-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+dnssec-devel.sha256sum] = "994610427ed32d5747994f2f346ad6cf3eae9004fd80878358e02e76e935320b"

URI_x86_64_v2_rust-hickory-client+dnssec-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+dnssec-openssl-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+dnssec-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+dnssec-openssl-devel.sha256sum] = "ae99f74ef3e28e6cfabcd53f3cf77b1dcf4ebd97028f4c3848060019bfa5a72d"

URI_x86_64_v2_rust-hickory-client+mdns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+mdns-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+mdns-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+mdns-devel.sha256sum] = "d6036dd27e2f0db24c2acfe82b5b69b1898dd55cdcee5e878bb35e9776a55d62"

URI_x86_64_v2_rust-hickory-client+serde-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+serde-config-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+serde-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+serde-config-devel.sha256sum] = "39431d7d7de672ccda8cee612755b9386fb04c297e843d15d98ffe494c7e5197"

URI_x86_64_v2_rust-hickory-client+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client+serde-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-client+serde-devel.sha256sum] = "9b08cbf201ae2db1970e882e8a86fbe958c2842eb812a8aa28320f2c5adda2c6"

URI_x86_64_v2_rust-hickory-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-client-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-client-devel}"
SRC_URI[x86_64_v2_rust-hickory-client-devel.sha256sum] = "4d1a253b542795eee8f3105e1b752ae44e0a8bfbe7d193ed1aede726a3a92036"

URI_aarch64_rust-hickory-client+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+backtrace-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-client+backtrace-devel.sha256sum] = "5bafef1c29b715df5e5691cb435ee9140fd51fb11db2d36d6313f9d28c2ca42a"

URI_aarch64_rust-hickory-client+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+default-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+default-devel}"
SRC_URI[aarch64_rust-hickory-client+default-devel.sha256sum] = "e0ce9f8ddd3086e914a3fc77fe7fa3e82fe5f69e8af3f9a442c83e9c724fcabc"

URI_aarch64_rust-hickory-client+dns-over-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+dns-over-native-tls-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+dns-over-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-client+dns-over-native-tls-devel.sha256sum] = "d3bf21b35ef6da1e5dd52eb64383d51d2b16034a5df4bf74072474490d38ee25"

URI_aarch64_rust-hickory-client+dns-over-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+dns-over-openssl-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+dns-over-openssl-devel}"
SRC_URI[aarch64_rust-hickory-client+dns-over-openssl-devel.sha256sum] = "d22a289309247501ad812cdcf8c5d0ed55a9668fe8eb3e079162833165359b2f"

URI_aarch64_rust-hickory-client+dns-over-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+dns-over-tls-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+dns-over-tls-devel}"
SRC_URI[aarch64_rust-hickory-client+dns-over-tls-devel.sha256sum] = "95a3bdc38b0e79c0fee30ae2ed0dc3bf8daeb3df4219fb6b18ef65c92ee34a95"

URI_aarch64_rust-hickory-client+dnssec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+dnssec-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+dnssec-devel}"
SRC_URI[aarch64_rust-hickory-client+dnssec-devel.sha256sum] = "ceec311e07edd925647b3f1e93ffd632a60e7cb41dd6dd00f77efca9f011ef3f"

URI_aarch64_rust-hickory-client+dnssec-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+dnssec-openssl-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+dnssec-openssl-devel}"
SRC_URI[aarch64_rust-hickory-client+dnssec-openssl-devel.sha256sum] = "e478025f54f1de3506a1144e27bee808b23eb1e270cf78c40bc223adc07054dd"

URI_aarch64_rust-hickory-client+mdns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+mdns-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+mdns-devel}"
SRC_URI[aarch64_rust-hickory-client+mdns-devel.sha256sum] = "d7b7673d9425ee72761b8bc610b7bc22169bed0d1c6b740fdc64b00eee5cce7a"

URI_aarch64_rust-hickory-client+serde-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+serde-config-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+serde-config-devel}"
SRC_URI[aarch64_rust-hickory-client+serde-config-devel.sha256sum] = "5203690541e21d28a79009eaadd20aa4866cb3e6681036400ff7042a3b32c667"

URI_aarch64_rust-hickory-client+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client+serde-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client+serde-devel}"
SRC_URI[aarch64_rust-hickory-client+serde-devel.sha256sum] = "fab0614c2d24a45bc7ee9bd50258c5575c17ed85c7314941e56607ba6b0d96f5"

URI_aarch64_rust-hickory-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-client-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-client-devel}"
SRC_URI[aarch64_rust-hickory-client-devel.sha256sum] = "660480f7b1ae47fdbeddda96b0caefdb399ebd1773e19d6cf284c4668d5d5b78"

RDEPENDS:rust-hickory-client+backtrace-devel = " \
 cargo \
 rust-hickory-client-devel \
 rust-hickory-proto+backtrace-devel \
 "
RDEPENDS:rust-hickory-client+default-devel = " \
 cargo \
 rust-hickory-client-devel \
 "
RDEPENDS:rust-hickory-client+dns-over-native-tls-devel = " \
 cargo \
 rust-hickory-client+dns-over-tls-devel \
 rust-hickory-client-devel \
 rust-hickory-proto+dns-over-native-tls-devel \
 "
RDEPENDS:rust-hickory-client+dns-over-openssl-devel = " \
 cargo \
 rust-hickory-client+dns-over-tls-devel \
 rust-hickory-client+dnssec-openssl-devel \
 rust-hickory-client-devel \
 "
RDEPENDS:rust-hickory-client+dns-over-tls-devel = " \
 cargo \
 rust-hickory-client-devel \
 "
RDEPENDS:rust-hickory-client+dnssec-devel = " \
 cargo \
 rust-hickory-client-devel \
 rust-hickory-proto+dnssec-devel \
 "
RDEPENDS:rust-hickory-client+dnssec-openssl-devel = " \
 cargo \
 rust-hickory-client+dnssec-devel \
 rust-hickory-client-devel \
 rust-hickory-proto+dnssec-openssl-devel \
 "
RDEPENDS:rust-hickory-client+mdns-devel = " \
 cargo \
 rust-hickory-client-devel \
 rust-hickory-proto+mdns-devel \
 "
RDEPENDS:rust-hickory-client+serde-config-devel = " \
 cargo \
 rust-hickory-client+serde-devel \
 rust-hickory-client-devel \
 rust-hickory-proto+serde-config-devel \
 "
RDEPENDS:rust-hickory-client+serde-devel = " \
 cargo \
 rust-hickory-client-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-hickory-client-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-data-encoding+default-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-proto+text-parsing-devel \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-proto-devel \
 rust-once_cell+default-devel \
 rust-radix_trie+default-devel \
 rust-rand0.8+default-devel \
 rust-thiserror1+default-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tracing+default-devel \
 "
