# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nextcloud"
PV = "33.0.3"
PR = "1.el10_1"
PACKAGES = " \
 nextcloud \
 nextcloud-httpd \
 nextcloud-mysql \
 nextcloud-nginx \
 nextcloud-postgresql \
 nextcloud-sqlite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nextcloud-33.0.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58a45638a91ab8ccb35ae03eb6357ce5863645fbb93a2327cbf0e858cd0fe4ae"

URI_x86_64_v2_nextcloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-33.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud}"
SRC_URI[x86_64_v2_nextcloud.sha256sum] = "08bb4fe0fbe868440ac4f64223dc5cdff0ed1756b0ab1a28f74965268e9ff7cb"

URI_x86_64_v2_nextcloud-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-httpd-33.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-httpd}"
SRC_URI[x86_64_v2_nextcloud-httpd.sha256sum] = "e44d88fe824af04988effa04968b30776840e6d94b34a396979218b49d6e79e4"
RPROVIDES:nextcloud-httpd:append:x86_64_v2 = " virtual/nextcloud-webserver_eq_33.0.3-1.el10_1.alma_altarch"

URI_x86_64_v2_nextcloud-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-mysql-33.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-mysql}"
SRC_URI[x86_64_v2_nextcloud-mysql.sha256sum] = "65f8f41292f4fb3d4fb70bd00d81f0ea9583031ea1c584110498bd01782e4676"
RPROVIDES:nextcloud-mysql:append:x86_64_v2 = " virtual/nextcloud-database_eq_33.0.3-1.el10_1.alma_altarch"

URI_x86_64_v2_nextcloud-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-nginx-33.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-nginx}"
SRC_URI[x86_64_v2_nextcloud-nginx.sha256sum] = "8a83355fc25ad601544a5ba1991a7a960766aca079e6864b17295dddf94b357b"
RPROVIDES:nextcloud-nginx:append:x86_64_v2 = " virtual/nextcloud-webserver_eq_33.0.3-1.el10_1.alma_altarch"

URI_x86_64_v2_nextcloud-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-postgresql-33.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-postgresql}"
SRC_URI[x86_64_v2_nextcloud-postgresql.sha256sum] = "a0320abe3771b0cb70e0a171491f63b3d39a17fc29d5d2cac348a1db3923b219"
RPROVIDES:nextcloud-postgresql:append:x86_64_v2 = " virtual/nextcloud-database_eq_33.0.3-1.el10_1.alma_altarch"

URI_x86_64_v2_nextcloud-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-sqlite-33.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-sqlite}"
SRC_URI[x86_64_v2_nextcloud-sqlite.sha256sum] = "a5bf711a2a5af195ad3b4dd4df0b27d057279482ca6814a5c67619a2e9aaea77"
RPROVIDES:nextcloud-sqlite:append:x86_64_v2 = " virtual/nextcloud-database_eq_33.0.3-1.el10_1.alma_altarch"

URI_aarch64_nextcloud = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-33.0.3-1.el10_1.noarch.rpm;name=aarch64_nextcloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud}"
SRC_URI[aarch64_nextcloud.sha256sum] = "6a9ac44242f84da07ce1e92ab5c89f5ea16c78d3864c724922fab2a839874206"

URI_aarch64_nextcloud-httpd = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-httpd-33.0.3-1.el10_1.noarch.rpm;name=aarch64_nextcloud-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-httpd}"
SRC_URI[aarch64_nextcloud-httpd.sha256sum] = "a39d999e166e5b2d841c67e907b63dce24169d8cf5b1b041fb7368fce336719d"
RPROVIDES:nextcloud-httpd:append:aarch64 = " virtual/nextcloud-webserver_eq_33.0.3-1.el10_1"

URI_aarch64_nextcloud-mysql = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-mysql-33.0.3-1.el10_1.noarch.rpm;name=aarch64_nextcloud-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-mysql}"
SRC_URI[aarch64_nextcloud-mysql.sha256sum] = "76f21c85d2175afc5d200e357b4eb2f1353c521f6f638d8f53350657fe682536"
RPROVIDES:nextcloud-mysql:append:aarch64 = " virtual/nextcloud-database_eq_33.0.3-1.el10_1"

URI_aarch64_nextcloud-nginx = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-nginx-33.0.3-1.el10_1.noarch.rpm;name=aarch64_nextcloud-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-nginx}"
SRC_URI[aarch64_nextcloud-nginx.sha256sum] = "4bcebb055868fbebc923e304cd1cbb3eaff8da42bc7186c495c98d551b7e1fd8"
RPROVIDES:nextcloud-nginx:append:aarch64 = " virtual/nextcloud-webserver_eq_33.0.3-1.el10_1"

URI_aarch64_nextcloud-postgresql = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-postgresql-33.0.3-1.el10_1.noarch.rpm;name=aarch64_nextcloud-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-postgresql}"
SRC_URI[aarch64_nextcloud-postgresql.sha256sum] = "f4621814af7170f3ebe421957b3ae295cc8bd5ed0f29ea55df1ba91590280d28"
RPROVIDES:nextcloud-postgresql:append:aarch64 = " virtual/nextcloud-database_eq_33.0.3-1.el10_1"

URI_aarch64_nextcloud-sqlite = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-sqlite-33.0.3-1.el10_1.noarch.rpm;name=aarch64_nextcloud-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-sqlite}"
SRC_URI[aarch64_nextcloud-sqlite.sha256sum] = "3557ad985f6726b1ee4b1817bf55bd96c396fcdd2fe2f8cb9fa0c77cac2e0cc4"
RPROVIDES:nextcloud-sqlite:append:aarch64 = " virtual/nextcloud-database_eq_33.0.3-1.el10_1"

RDEPENDS:nextcloud:x86_64_v2 = " \
 bash \
 ca-certificates \
 php-bcmath \
 php-cli \
 php-common \
 php-gd \
 php-gmp \
 php-intl \
 php-ldap \
 php-mbstring \
 php-opcache \
 php-pdo \
 php-pecl-apcu \
 php-pecl-imagick \
 php-pecl-memcached \
 php-pecl-redis6 \
 php-pecl-zip \
 php-process \
 php-smbclient \
 php-xml \
 systemd \
 virtual/nextcloud-database_eq_33.0.3-1.el10_1.alma_altarch \
 virtual/nextcloud-webserver_eq_33.0.3-1.el10_1.alma_altarch \
"
RDEPENDS:nextcloud:aarch64 = " \
 bash \
 ca-certificates \
 php-bcmath \
 php-cli \
 php-common \
 php-gd \
 php-gmp \
 php-intl \
 php-ldap \
 php-mbstring \
 php-opcache \
 php-pdo \
 php-pecl-apcu \
 php-pecl-imagick \
 php-pecl-memcached \
 php-pecl-redis6 \
 php-pecl-zip \
 php-process \
 php-smbclient \
 php-xml \
 systemd \
 virtual/nextcloud-database_eq_33.0.3-1.el10_1 \
 virtual/nextcloud-webserver_eq_33.0.3-1.el10_1 \
"
RDEPENDS:nextcloud-httpd = " \
 bash \
 httpd \
 nextcloud \
 php-fpm \
 "
RDEPENDS:nextcloud-mysql = " \
 nextcloud \
 php-mysqlnd \
 "
RDEPENDS:nextcloud-nginx = " \
 bash \
 nextcloud \
 nginx \
 php-fpm \
 "
RDEPENDS:nextcloud-postgresql = " \
 nextcloud \
 php-pgsql \
 "
RDEPENDS:nextcloud-sqlite = " \
 nextcloud \
 "
