# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyudev"
PV = "0.24.1"
PR = "10.el10"
PACKAGES = " \
 python3-pyudev \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-pyudev-0.24.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4d93ca6d5aa2d749c30fc18fc41b672116eb2ef9fafdd4546132c042d6cf828"

URI_x86_64_v2_python3-pyudev = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-pyudev-0.24.1-10.el10.noarch.rpm;name=x86_64_v2_python3-pyudev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyudev}"
SRC_URI[x86_64_v2_python3-pyudev.sha256sum] = "8d90d8b87c4cbf1e45c7138e15167897ac0189610d1d8c32b08adcfb90d91301"

URI_aarch64_python3-pyudev = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-pyudev-0.24.1-10.el10.noarch.rpm;name=aarch64_python3-pyudev;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyudev}"
SRC_URI[aarch64_python3-pyudev.sha256sum] = "8d90d8b87c4cbf1e45c7138e15167897ac0189610d1d8c32b08adcfb90d91301"

RDEPENDS:python3-pyudev = " \
 python3 \
 systemd-libs \
 "
