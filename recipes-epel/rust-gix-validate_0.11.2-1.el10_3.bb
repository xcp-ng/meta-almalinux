# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-validate"
PV = "0.11.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-validate+default-devel \
 rust-gix-validate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-validate-0.11.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cebee1d9c7722285a2d56f2a353fcf7a0f03155990bbe6099e6d3f540fd1b067"

URI_x86_64_v2_rust-gix-validate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-validate+default-devel-0.11.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-validate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-validate+default-devel}"
SRC_URI[x86_64_v2_rust-gix-validate+default-devel.sha256sum] = "29100a0f043f2f198a28837c0926a1c5c3b55d8badcb6d84430bdd89d21d0bd0"

URI_x86_64_v2_rust-gix-validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-validate-devel-0.11.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-validate-devel}"
SRC_URI[x86_64_v2_rust-gix-validate-devel.sha256sum] = "9fa2e88da3fb377f4a9297c1032a671f9eafc2ff97c89090fd4f33717a11c158"

URI_aarch64_rust-gix-validate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-validate+default-devel-0.11.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-validate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-validate+default-devel}"
SRC_URI[aarch64_rust-gix-validate+default-devel.sha256sum] = "4aede55600d6ad148368abb78194502d233b8319c26ac5f5ad82c14b83cf6a3f"

URI_aarch64_rust-gix-validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-validate-devel-0.11.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-validate-devel}"
SRC_URI[aarch64_rust-gix-validate-devel.sha256sum] = "f9377a4ab9d7f8da94fdaabc2f8ea97afabd6476a20eed342609457664ceb32c"

RDEPENDS:rust-gix-validate+default-devel = " \
 cargo \
 rust-gix-validate-devel \
 "
RDEPENDS:rust-gix-validate-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 "
