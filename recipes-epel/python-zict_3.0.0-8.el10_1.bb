# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zict"
PV = "3.0.0"
PR = "8.el10_1"
PACKAGES = " \
 python3-zict \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-zict-3.0.0-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "801007b4fd7a70aee380acc46564f8d939a13616df354a7e5a56dea8d1aa3d73"

URI_x86_64_v2_python3-zict = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zict-3.0.0-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zict;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zict}"
SRC_URI[x86_64_v2_python3-zict.sha256sum] = "316399145e23331eceaf9fa84ed50fa1d1d67a4ad8d8a7c90e4b86e86fc818a9"

URI_aarch64_python3-zict = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zict-3.0.0-8.el10_1.noarch.rpm;name=aarch64_python3-zict;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zict}"
SRC_URI[aarch64_python3-zict.sha256sum] = "9504c99f14506f9294824ba5badc3e0b7dda4ea09c3c8f93215119804857e53d"

RDEPENDS:python3-zict = " \
 python3 \
 "
