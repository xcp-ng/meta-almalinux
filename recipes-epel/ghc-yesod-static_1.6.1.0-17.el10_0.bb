# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-yesod-static"
PV = "1.6.1.0"
PR = "17.el10_0"
PACKAGES = " \
 ghc-yesod-static \
 ghc-yesod-static-devel \
 ghc-yesod-static-doc \
 ghc-yesod-static-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-yesod-static-1.6.1.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "804bf2d0a57d6be39bb4f2170d0c61a695192b2fbc7f1526a77437720e0f0d6d"

URI_x86_64_v2_ghc-yesod-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-static-1.6.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-static}"
SRC_URI[x86_64_v2_ghc-yesod-static.sha256sum] = "e1baa9a16c28ae3b9644c2bf2a2961bc2d5b1526641647a7a2e2abec70a2d683"

URI_x86_64_v2_ghc-yesod-static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-static-devel-1.6.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-static-devel}"
SRC_URI[x86_64_v2_ghc-yesod-static-devel.sha256sum] = "d78a407d94abed46bd72c6934809e56a9d114af5f6a02f8b5839808ed59f4fd2"

URI_x86_64_v2_ghc-yesod-static-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-static-doc-1.6.1.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-yesod-static-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-static-doc}"
SRC_URI[x86_64_v2_ghc-yesod-static-doc.sha256sum] = "d52eb75865380ac68740c68669210f527175147478c2de4041ad1052a4f88404"

URI_x86_64_v2_ghc-yesod-static-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-static-prof-1.6.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-static-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-static-prof}"
SRC_URI[x86_64_v2_ghc-yesod-static-prof.sha256sum] = "e9439b3317daf4fb30216662e5068e352d08d5f4c6afdf8480e16406547add26"

URI_aarch64_ghc-yesod-static = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-static-1.6.1.0-17.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-static}"
SRC_URI[aarch64_ghc-yesod-static.sha256sum] = "369b11d9b2d5903ae61d9cc99be78d2d72d1e9af27f106fd2363672b6163e808"

URI_aarch64_ghc-yesod-static-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-static-devel-1.6.1.0-17.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-static-devel}"
SRC_URI[aarch64_ghc-yesod-static-devel.sha256sum] = "effa3bba3ab13c60cd8cb7815f4b94497fa0e271fc55f292cfc9e218356d0173"

URI_aarch64_ghc-yesod-static-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-static-doc-1.6.1.0-17.el10_0.noarch.rpm;name=aarch64_ghc-yesod-static-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-static-doc}"
SRC_URI[aarch64_ghc-yesod-static-doc.sha256sum] = "80b36072490f9c81b26863a693cd9907da66189275ca9ba9dd1ed7cd13a31d2d"

URI_aarch64_ghc-yesod-static-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-static-prof-1.6.1.0-17.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-static-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-static-prof}"
SRC_URI[aarch64_ghc-yesod-static-prof.sha256sum] = "fcdaba2a532ce0b89d7623cf96fef44f417d8058f661d64dcba325f004548e2a"

RDEPENDS:ghc-yesod-static = " \
 ghc-HUnit \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-auto-update \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bsb-http-chunked \
 ghc-byteorder \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-clientsession \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypto-api \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-cryptonite \
 ghc-cryptonite-conduit \
 ghc-css-text \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-easy-file \
 ghc-entropy \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hjsmin \
 ghc-hourglass \
 ghc-http-date \
 ghc-http-types \
 ghc-http2 \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-language-javascript \
 ghc-lifted-base \
 ghc-memory \
 ghc-mime-types \
 ghc-monad-control \
 ghc-monad-logger \
 ghc-monad-loops \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-byte-order \
 ghc-network-control \
 ghc-old-locale \
 ghc-old-time \
 ghc-optparse-applicative \
 ghc-os-string \
 ghc-parsec \
 ghc-path-pieces \
 ghc-pem \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-primitive \
 ghc-process \
 ghc-psqueues \
 ghc-random \
 ghc-recv \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-setenv \
 ghc-shakespeare \
 ghc-simple-sendfile \
 ghc-skein \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-stm-chans \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-time-manager \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-wai \
 ghc-wai-app-static \
 ghc-wai-extra \
 ghc-wai-logger \
 ghc-warp \
 ghc-witherable \
 ghc-word8 \
 ghc-yesod-core \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-yesod-static-devel = " \
 ghc-async-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-blaze-builder-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-containers-devel \
 ghc-cryptonite-conduit-devel \
 ghc-cryptonite-devel \
 ghc-css-text-devel \
 ghc-data-default-devel \
 ghc-directory-devel \
 ghc-file-embed-devel \
 ghc-filepath-devel \
 ghc-hashable-devel \
 ghc-hjsmin-devel \
 ghc-http-types-devel \
 ghc-memory-devel \
 ghc-mime-types-devel \
 ghc-process-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-unix-compat-devel \
 ghc-unordered-containers-devel \
 ghc-wai-app-static-devel \
 ghc-wai-devel \
 ghc-yesod-core-devel \
 ghc-yesod-static \
 "
RDEPENDS:ghc-yesod-static-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-yesod-static-prof = " \
 ghc-async-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-blaze-builder-prof \
 ghc-bytestring-prof \
 ghc-conduit-prof \
 ghc-containers-prof \
 ghc-cryptonite-conduit-prof \
 ghc-cryptonite-prof \
 ghc-css-text-prof \
 ghc-data-default-prof \
 ghc-directory-prof \
 ghc-file-embed-prof \
 ghc-filepath-prof \
 ghc-hashable-prof \
 ghc-hjsmin-prof \
 ghc-http-types-prof \
 ghc-memory-prof \
 ghc-mime-types-prof \
 ghc-process-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-unix-compat-prof \
 ghc-unordered-containers-prof \
 ghc-wai-app-static-prof \
 ghc-wai-prof \
 ghc-yesod-core-prof \
 ghc-yesod-static-devel \
 "
