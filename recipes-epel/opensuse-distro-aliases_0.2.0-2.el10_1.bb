# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opensuse-distro-aliases"
PV = "0.2.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-opensuse-distro-aliases \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opensuse-distro-aliases-0.2.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf57d7160ade3a9e2713cda030f4d10632cf5b01472011b91aa783612a8e504e"

URI_x86_64_v2_python3-opensuse-distro-aliases = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensuse-distro-aliases-0.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensuse-distro-aliases;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensuse-distro-aliases}"
SRC_URI[x86_64_v2_python3-opensuse-distro-aliases.sha256sum] = "ee338a6fb5a1e06c678b19a2e1c29faf5fef274be6164594bab00829dc059454"

URI_aarch64_python3-opensuse-distro-aliases = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensuse-distro-aliases-0.2.0-2.el10_1.noarch.rpm;name=aarch64_python3-opensuse-distro-aliases;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensuse-distro-aliases}"
SRC_URI[aarch64_python3-opensuse-distro-aliases.sha256sum] = "b585d7f7597cfb7fceac47cd6b82d3f0482bc2a1cf10ff933d0b1544a3289e00"

RDEPENDS:python3-opensuse-distro-aliases = " \
 python3 \
 python3-requests \
 "
