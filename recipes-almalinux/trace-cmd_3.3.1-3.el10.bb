# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "trace-cmd"
PV = "3.3.1"
PR = "3.el10"
PACKAGES = " \
 trace-cmd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/trace-cmd-3.3.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccf913142d792a19708b489e30fe6f4b319a8ffab92b4badacfa1fe0721d33e2"

URI_x86_64_v2_trace-cmd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/trace-cmd-3.3.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_trace-cmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trace-cmd}"
SRC_URI[x86_64_v2_trace-cmd.sha256sum] = "9c41d613215c32204dc2240b6ea2755b79693f8c10afb285e85f830cfeba0bb1"

URI_aarch64_trace-cmd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/trace-cmd-3.3.1-3.el10.aarch64.rpm;name=aarch64_trace-cmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_trace-cmd}"
SRC_URI[aarch64_trace-cmd.sha256sum] = "34d128fb6fce435adb9876e7d5aaba8b845b0be9ecb91cbc2b7318e3c9d5e545"

RDEPENDS:trace-cmd = " \
 audit-libs \
 bash \
 glibc \
 libtraceevent \
 libtracefs \
 libzstd \
 "
