# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "recoll"
PV = "1.44.2"
PR = "1.el10_3"
PACKAGES = " \
 recoll \
 recoll-devel \
 recoll-gssp \
 recoll-helpers \
 recoll-kio \
 recoll-krunner \
 recoll-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/recoll-1.44.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d3669874d791b163eb7e3f99ce20e9f26f4635eee7fe941f6b041efe1b9eb0cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-1.44.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll;unpack=0"
SRC_URI[x86_64_v2_recoll.sha256sum] = "c3b532c6a0c7e18f23c96dd4d53bf616bc92c08010334dfa4808949ce5513096"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-devel-1.44.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-devel;unpack=0"
SRC_URI[x86_64_v2_recoll-devel.sha256sum] = "95637b6fd9262397ad2a896060e16f4e0d03019e6e586f8f3b71cc24ef4d7987"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-gssp-1.44.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-gssp;unpack=0"
SRC_URI[x86_64_v2_recoll-gssp.sha256sum] = "620691b99abb6a6584adbc957ef96b01578fb3b8320534a49a5e39333e70b63d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-helpers-1.44.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-helpers;unpack=0"
SRC_URI[x86_64_v2_recoll-helpers.sha256sum] = "252e9305b6f4f9d4d808010a478639e5e89e6878d233374db0589af394eb26ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-kio-1.44.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-kio;unpack=0"
SRC_URI[x86_64_v2_recoll-kio.sha256sum] = "2eb0fb598b450f1e0bec938a11187b98f1b77e3d460918e1eb6edcd0c9ed4db8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-krunner-1.44.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-krunner;unpack=0"
SRC_URI[x86_64_v2_recoll-krunner.sha256sum] = "c6755e85b9f30fbd3888b412a236b81a2fbc9389b4278a809b1b99455510b162"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-libs-1.44.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-libs;unpack=0"
SRC_URI[x86_64_v2_recoll-libs.sha256sum] = "29593eab5a28e09791c35ed2d494bced064c0e5217b0ecbaecd0e711ceebfa28"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-1.44.2-1.el10_3.aarch64.rpm;name=aarch64_recoll;unpack=0"
SRC_URI[aarch64_recoll.sha256sum] = "4fff5cfda2cb12a0f4cccdfad992f8926014fc2e9375602828f747a3d8846b7c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-devel-1.44.2-1.el10_3.aarch64.rpm;name=aarch64_recoll-devel;unpack=0"
SRC_URI[aarch64_recoll-devel.sha256sum] = "55b857d19e25df87ababcf49f6f3a29ec39386da223e82f6199d3fd24403a8ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-gssp-1.44.2-1.el10_3.aarch64.rpm;name=aarch64_recoll-gssp;unpack=0"
SRC_URI[aarch64_recoll-gssp.sha256sum] = "eaf9071311110a630eb75b0a63e46c32983afd90adfaac22ce285664ee494ce6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-helpers-1.44.2-1.el10_3.aarch64.rpm;name=aarch64_recoll-helpers;unpack=0"
SRC_URI[aarch64_recoll-helpers.sha256sum] = "24cf47bf85873e2827705027baa307eb9855d9ef8ef6325480021eb07d7022ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-kio-1.44.2-1.el10_3.aarch64.rpm;name=aarch64_recoll-kio;unpack=0"
SRC_URI[aarch64_recoll-kio.sha256sum] = "c527910eae1709e5ff0859d0e96cb7feacb7508a700172fe084b21e4700b0459"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-krunner-1.44.2-1.el10_3.aarch64.rpm;name=aarch64_recoll-krunner;unpack=0"
SRC_URI[aarch64_recoll-krunner.sha256sum] = "7121228345803ca2b9856208c6ffe80a5a54a0b6bdca9131389ae87fbd10e075"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-libs-1.44.2-1.el10_3.aarch64.rpm;name=aarch64_recoll-libs;unpack=0"
SRC_URI[aarch64_recoll-libs.sha256sum] = "1e9554756d126082b6aadbb85f11b06598e236f7e800c5865c10b69cdb5f9516"

RDEPENDS:recoll = " \
 aspell \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 recoll-libs \
 xdg-utils \
 "
RDEPENDS:recoll-devel = " \
 recoll-libs \
 "
RDEPENDS:recoll-gssp = " \
 gnome-shell \
 python3 \
 python3-gobject-base \
 recoll \
 "
RDEPENDS:recoll-helpers = " \
 recoll \
 "
RDEPENDS:recoll-kio = " \
 glibc \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 recoll \
 recoll-libs \
 "
RDEPENDS:recoll-krunner = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-krunner \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 recoll \
 recoll-libs \
 "
RDEPENDS:recoll-libs = " \
 file-libs \
 glibc \
 jsoncpp \
 libX11 \
 libgcc \
 libstdc++ \
 libxml2 \
 libxslt \
 xapian-core-libs \
 zlib-ng-compat \
 "
