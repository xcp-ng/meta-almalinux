# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kimageformats"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kimageformats \
 kf6-kimageformats-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kimageformats-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6738d13e271542d11a05167b6d57f9fcdebd5437d96985fa1b87e79613a04e58"

URI_x86_64_v2_kf6-kimageformats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kimageformats-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kimageformats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kimageformats}"
SRC_URI[x86_64_v2_kf6-kimageformats.sha256sum] = "4b3b0eb4d0342be2638c23886edc115a48ad381675705f8bd1f4c594ec1065f0"

URI_x86_64_v2_kf6-kimageformats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kimageformats-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kimageformats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kimageformats-devel}"
SRC_URI[x86_64_v2_kf6-kimageformats-devel.sha256sum] = "4b79f0620e0fff270068d99622fb689991c072d48ff875c2c60100440d146c67"

URI_aarch64_kf6-kimageformats = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kimageformats-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kimageformats;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kimageformats}"
SRC_URI[aarch64_kf6-kimageformats.sha256sum] = "4eb88f4146fc46c2d747536e00f9b725983d7dca598df806f708a5c7a7cc81f1"

URI_aarch64_kf6-kimageformats-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kimageformats-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kimageformats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kimageformats-devel}"
SRC_URI[aarch64_kf6-kimageformats-devel.sha256sum] = "8a89f619fa5396cb3533387363d054221a185406e963593ab47dd97c9106a2b7"

RDEPENDS:kf6-kimageformats = " \
 LibRaw \
 glibc \
 imath \
 jxrlib \
 kf6-filesystem \
 kf6-karchive \
 libavif \
 libgcc \
 libheif \
 libjxl \
 libstdc++ \
 openexr-libs \
 openjpeg2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kimageformats-devel = " \
 cmake-filesystem \
 kf6-kimageformats \
 "
