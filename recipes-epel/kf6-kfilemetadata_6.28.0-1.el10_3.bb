# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kfilemetadata"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kfilemetadata \
 kf6-kfilemetadata-devel \
 kf6-kfilemetadata-doc \
 kf6-kfilemetadata-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kfilemetadata-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e818c2388a0c8474e46349bfc95890e98315a0dd47cd6f5587e45d040e97e351"

URI_x86_64_v2_kf6-kfilemetadata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kfilemetadata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata}"
SRC_URI[x86_64_v2_kf6-kfilemetadata.sha256sum] = "27224ca39acd3a3874b94b6ce458f105907ec0ddbfa99f7c9b3daf7020761d93"

URI_x86_64_v2_kf6-kfilemetadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kfilemetadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-devel}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-devel.sha256sum] = "ef57c71451170f709ba9129d6d7f5e85d197d56b210531192692e2afc81e6efc"

URI_x86_64_v2_kf6-kfilemetadata-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kfilemetadata-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-doc}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-doc.sha256sum] = "2695fba52f380c9dc4abca93ae8b2e87f77f553560e27a408a271bd05f0b175b"

URI_x86_64_v2_kf6-kfilemetadata-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kfilemetadata-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-html}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-html.sha256sum] = "65c555109545ac758fec1b0955ba8389ac802315e28b985a1953ac32cfa842ca"

URI_aarch64_kf6-kfilemetadata = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kfilemetadata;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata}"
SRC_URI[aarch64_kf6-kfilemetadata.sha256sum] = "0366791553620d495fe53e13dcbc0e4c3c14e8569353bfa2c2ea053d56a2e43a"

URI_aarch64_kf6-kfilemetadata-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kfilemetadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-devel}"
SRC_URI[aarch64_kf6-kfilemetadata-devel.sha256sum] = "1597a92893dd36e47de610c71cf715fa92db61f498592952e48558b66d5d3107"

URI_aarch64_kf6-kfilemetadata-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kfilemetadata-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-doc}"
SRC_URI[aarch64_kf6-kfilemetadata-doc.sha256sum] = "0801c42574a8a90201fbd6f603bb773d25b9229f15683b38708e5151163ac53f"

URI_aarch64_kf6-kfilemetadata-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kfilemetadata-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-html}"
SRC_URI[aarch64_kf6-kfilemetadata-html.sha256sum] = "ea35cc8b75c0b2e0026c463d80b4f787848475288e3cea3a8f0c076119396392"

RDEPENDS:kf6-kfilemetadata = " \
 exiv2-libs \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libstdc++ \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 taglib \
 "
RDEPENDS:kf6-kfilemetadata-devel = " \
 cmake-filesystem \
 kf6-kfilemetadata \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kfilemetadata-doc = " \
 "
RDEPENDS:kf6-kfilemetadata-html = " \
 "
