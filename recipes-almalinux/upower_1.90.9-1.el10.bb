# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "upower"
PV = "1.90.9"
PR = "1.el10"
PACKAGES = " \
 upower \
 upower-devel \
 upower-devel-docs \
 upower-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/upower-1.90.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3e3903cc1d1583d0f3668346be68149e158df5e91415e133c27895d9620b2a38"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/upower-1.90.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_upower;unpack=0"
SRC_URI[x86_64_v2_upower.sha256sum] = "6640d2a9245d1f5f2b9a64990cf3ef22269e0b9a7c7eec57d8dd18929a57c1e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/upower-devel-1.90.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_upower-devel;unpack=0"
SRC_URI[x86_64_v2_upower-devel.sha256sum] = "52dfc550b33bd8937951eef4e064ed5f2ac7d577256cad9bc651d1e65a1169a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/upower-devel-docs-1.90.9-1.el10.noarch.rpm;name=x86_64_v2_upower-devel-docs;unpack=0"
SRC_URI[x86_64_v2_upower-devel-docs.sha256sum] = "6d830c1b5da4d49f87eba835da6ca87968bde40cac2ae7224dab115b67d06e68"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/upower-libs-1.90.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_upower-libs;unpack=0"
SRC_URI[x86_64_v2_upower-libs.sha256sum] = "9422cb774fa091cb8a1728a2b89ed931b7bdd7a32e8c2787b69f36737f883660"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/upower-1.90.9-1.el10.aarch64.rpm;name=aarch64_upower;unpack=0"
SRC_URI[aarch64_upower.sha256sum] = "dc40e170fdaf71c775490430bf53b2a276bee5ff4b497ffc9bff4dccba5cc32a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/upower-devel-1.90.9-1.el10.aarch64.rpm;name=aarch64_upower-devel;unpack=0"
SRC_URI[aarch64_upower-devel.sha256sum] = "f637a7397411cb7275c5a26973dbf8b5baf70791d25e21135b7215bf78f52860"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/upower-devel-docs-1.90.9-1.el10.noarch.rpm;name=aarch64_upower-devel-docs;unpack=0"
SRC_URI[aarch64_upower-devel-docs.sha256sum] = "6d830c1b5da4d49f87eba835da6ca87968bde40cac2ae7224dab115b67d06e68"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/upower-libs-1.90.9-1.el10.aarch64.rpm;name=aarch64_upower-libs;unpack=0"
SRC_URI[aarch64_upower-libs.sha256sum] = "2e7f6ada2e0ba0f3b36281b646085d4b2ace796f67222189810ac41cb170fd75"

RDEPENDS:upower = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libgudev \
 polkit-libs \
 python3 \
 systemd-udev \
 upower-libs \
 "
RDEPENDS:upower-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 polkit-devel \
 upower-libs \
 "
RDEPENDS:upower-devel-docs = " \
 upower-libs \
 "
RDEPENDS:upower-libs = " \
 glib2 \
 glibc \
 gobject-introspection \
 libgcc \
 "
