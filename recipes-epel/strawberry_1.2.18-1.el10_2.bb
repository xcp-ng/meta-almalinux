# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "strawberry"
PV = "1.2.18"
PR = "1.el10_2"
PACKAGES = " \
 strawberry \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/strawberry-1.2.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "727b343f656e0d3584421818c356a2e929dbb993fc54089fdd16c3899823478d"

URI_x86_64_v2_strawberry = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strawberry-1.2.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strawberry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strawberry}"
SRC_URI[x86_64_v2_strawberry.sha256sum] = "a8fe6dbdce24da839b07df0923565ffae616dfc4e0f5ee953730c6085ea327aa"

URI_aarch64_strawberry = "${EPEL_MIRROR}/aarch64/Packages/s/strawberry-1.2.18-1.el10_2.aarch64.rpm;name=aarch64_strawberry;unpack=0"
SRC_URI:append = " ${URI_aarch64_strawberry}"
SRC_URI[aarch64_strawberry.sha256sum] = "dac3db9542aeaa7489206d81d43f9f0e37511f35846b4b83f5fd59b91fc8553a"

RDEPENDS:strawberry = " \
 alsa-lib \
 fftw-libs-double \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 hicolor-icon-theme \
 kdsingleapplication-qt6 \
 libX11 \
 libcdio \
 libchromaprint \
 libebur128 \
 libgcc \
 libicu \
 libmtp \
 libstdc++ \
 pulseaudio-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 sqlite-libs \
 taglib \
 "
