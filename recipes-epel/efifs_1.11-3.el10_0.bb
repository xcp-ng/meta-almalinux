# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "efifs"
PV = "1.11"
PR = "3.el10_0"
PACKAGES = " \
 efifs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/efifs-1.11-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e241f3632180095d09feadb53c685c6ba4224b57f7f61882846fd0ceb77b81a3"

URI_x86_64_v2_efifs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/efifs-1.11-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_efifs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_efifs}"
SRC_URI[x86_64_v2_efifs.sha256sum] = "f3f30a29ed943d8c5335a7fabad7ad25e97ec5e0909bc12ef5537d32c42b5467"

URI_aarch64_efifs = "${EPEL_MIRROR}/aarch64/Packages/e/efifs-1.11-3.el10_0.aarch64.rpm;name=aarch64_efifs;unpack=0"
SRC_URI:append = " ${URI_aarch64_efifs}"
SRC_URI[aarch64_efifs.sha256sum] = "b63481977df18fafc47c2c0d564b120f29506d39ebf366f2bd3f7d2b904b2b4f"

RDEPENDS:efifs = " \
 efi-filesystem \
 "
