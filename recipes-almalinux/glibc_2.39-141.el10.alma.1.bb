# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glibc"
PV = "2.39"
PR = "141.el10.alma.1"
PACKAGES = " \
 glibc \
 glibc-all-langpacks \
 glibc-benchtests \
 glibc-common \
 glibc-devel \
 glibc-doc \
 glibc-gconv-extra \
 glibc-langpack-aa \
 glibc-langpack-af \
 glibc-langpack-agr \
 glibc-langpack-ak \
 glibc-langpack-am \
 glibc-langpack-an \
 glibc-langpack-anp \
 glibc-langpack-ar \
 glibc-langpack-as \
 glibc-langpack-ast \
 glibc-langpack-ayc \
 glibc-langpack-az \
 glibc-langpack-be \
 glibc-langpack-bem \
 glibc-langpack-ber \
 glibc-langpack-bg \
 glibc-langpack-bhb \
 glibc-langpack-bho \
 glibc-langpack-bi \
 glibc-langpack-bn \
 glibc-langpack-bo \
 glibc-langpack-br \
 glibc-langpack-brx \
 glibc-langpack-bs \
 glibc-langpack-byn \
 glibc-langpack-ca \
 glibc-langpack-ce \
 glibc-langpack-chr \
 glibc-langpack-ckb \
 glibc-langpack-cmn \
 glibc-langpack-crh \
 glibc-langpack-cs \
 glibc-langpack-csb \
 glibc-langpack-cv \
 glibc-langpack-cy \
 glibc-langpack-da \
 glibc-langpack-de \
 glibc-langpack-doi \
 glibc-langpack-dsb \
 glibc-langpack-dv \
 glibc-langpack-dz \
 glibc-langpack-el \
 glibc-langpack-en \
 glibc-langpack-eo \
 glibc-langpack-es \
 glibc-langpack-et \
 glibc-langpack-eu \
 glibc-langpack-fa \
 glibc-langpack-ff \
 glibc-langpack-fi \
 glibc-langpack-fil \
 glibc-langpack-fo \
 glibc-langpack-fr \
 glibc-langpack-fur \
 glibc-langpack-fy \
 glibc-langpack-ga \
 glibc-langpack-gbm \
 glibc-langpack-gd \
 glibc-langpack-gez \
 glibc-langpack-gl \
 glibc-langpack-gu \
 glibc-langpack-gv \
 glibc-langpack-ha \
 glibc-langpack-hak \
 glibc-langpack-he \
 glibc-langpack-hi \
 glibc-langpack-hif \
 glibc-langpack-hne \
 glibc-langpack-hr \
 glibc-langpack-hsb \
 glibc-langpack-ht \
 glibc-langpack-hu \
 glibc-langpack-hy \
 glibc-langpack-ia \
 glibc-langpack-id \
 glibc-langpack-ig \
 glibc-langpack-ik \
 glibc-langpack-is \
 glibc-langpack-it \
 glibc-langpack-iu \
 glibc-langpack-ja \
 glibc-langpack-ka \
 glibc-langpack-kab \
 glibc-langpack-kk \
 glibc-langpack-kl \
 glibc-langpack-km \
 glibc-langpack-kn \
 glibc-langpack-ko \
 glibc-langpack-kok \
 glibc-langpack-ks \
 glibc-langpack-ku \
 glibc-langpack-kv \
 glibc-langpack-kw \
 glibc-langpack-ky \
 glibc-langpack-lb \
 glibc-langpack-lg \
 glibc-langpack-li \
 glibc-langpack-lij \
 glibc-langpack-ln \
 glibc-langpack-lo \
 glibc-langpack-lt \
 glibc-langpack-lv \
 glibc-langpack-lzh \
 glibc-langpack-mag \
 glibc-langpack-mai \
 glibc-langpack-mfe \
 glibc-langpack-mg \
 glibc-langpack-mhr \
 glibc-langpack-mi \
 glibc-langpack-miq \
 glibc-langpack-mjw \
 glibc-langpack-mk \
 glibc-langpack-ml \
 glibc-langpack-mn \
 glibc-langpack-mni \
 glibc-langpack-mnw \
 glibc-langpack-mr \
 glibc-langpack-ms \
 glibc-langpack-mt \
 glibc-langpack-my \
 glibc-langpack-nan \
 glibc-langpack-nb \
 glibc-langpack-nds \
 glibc-langpack-ne \
 glibc-langpack-nhn \
 glibc-langpack-niu \
 glibc-langpack-nl \
 glibc-langpack-nn \
 glibc-langpack-nr \
 glibc-langpack-nso \
 glibc-langpack-oc \
 glibc-langpack-om \
 glibc-langpack-or \
 glibc-langpack-os \
 glibc-langpack-pa \
 glibc-langpack-pap \
 glibc-langpack-pl \
 glibc-langpack-ps \
 glibc-langpack-pt \
 glibc-langpack-quz \
 glibc-langpack-raj \
 glibc-langpack-rif \
 glibc-langpack-ro \
 glibc-langpack-ru \
 glibc-langpack-rw \
 glibc-langpack-sa \
 glibc-langpack-sah \
 glibc-langpack-sat \
 glibc-langpack-sc \
 glibc-langpack-sd \
 glibc-langpack-se \
 glibc-langpack-sgs \
 glibc-langpack-shn \
 glibc-langpack-shs \
 glibc-langpack-si \
 glibc-langpack-sid \
 glibc-langpack-sk \
 glibc-langpack-sl \
 glibc-langpack-sm \
 glibc-langpack-so \
 glibc-langpack-sq \
 glibc-langpack-sr \
 glibc-langpack-ss \
 glibc-langpack-ssy \
 glibc-langpack-st \
 glibc-langpack-su \
 glibc-langpack-sv \
 glibc-langpack-sw \
 glibc-langpack-syr \
 glibc-langpack-szl \
 glibc-langpack-ta \
 glibc-langpack-tcy \
 glibc-langpack-te \
 glibc-langpack-tg \
 glibc-langpack-th \
 glibc-langpack-the \
 glibc-langpack-ti \
 glibc-langpack-tig \
 glibc-langpack-tk \
 glibc-langpack-tl \
 glibc-langpack-tn \
 glibc-langpack-to \
 glibc-langpack-tok \
 glibc-langpack-tpi \
 glibc-langpack-tr \
 glibc-langpack-ts \
 glibc-langpack-tt \
 glibc-langpack-ug \
 glibc-langpack-uk \
 glibc-langpack-unm \
 glibc-langpack-ur \
 glibc-langpack-uz \
 glibc-langpack-ve \
 glibc-langpack-vi \
 glibc-langpack-wa \
 glibc-langpack-wae \
 glibc-langpack-wal \
 glibc-langpack-wo \
 glibc-langpack-xh \
 glibc-langpack-yi \
 glibc-langpack-yo \
 glibc-langpack-yue \
 glibc-langpack-yuw \
 glibc-langpack-zgh \
 glibc-langpack-zh \
 glibc-langpack-zu \
 glibc-locale-source \
 glibc-minimal-langpack \
 glibc-nss-devel \
 glibc-static \
 glibc-utils \
 libnsl \
 nss_db \
 nss_hesiod \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glibc-2.39-141.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d01b258750e7bf791abfd2e9d89f610016abe205f88a8f29ae66e8dfa7f7be07"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc;unpack=0"
SRC_URI[x86_64_v2_glibc.sha256sum] = "c8d7c94021b2812d6835ddbc3478e6b2f47527c46fa5f858ab46c33db2814d45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-all-langpacks-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-all-langpacks;unpack=0"
SRC_URI[x86_64_v2_glibc-all-langpacks.sha256sum] = "32ee3e9e9e350529a9f699a31a3f396664f01f09c846327339ab5200c4312b17"
RPROVIDES:glibc-all-langpacks:append:x86_64_v2 = " virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-benchtests-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-benchtests;unpack=0"
SRC_URI[x86_64_v2_glibc-benchtests.sha256sum] = "fd10199116b8278f8a36d8faa031e24ae183e50769a37487a488415975aa431b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-common-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-common;unpack=0"
SRC_URI[x86_64_v2_glibc-common.sha256sum] = "eb794c79b092abaa70a1e0a09aeaf931c3b926dd2e13c007b6da4817c75de832"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-devel-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-devel;unpack=0"
SRC_URI[x86_64_v2_glibc-devel.sha256sum] = "9b84d4867c430975a12a800d302f12b4f30bcda582106bf576870ddc65ee0cf8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-doc-2.39-141.el10.alma.1.noarch.rpm;name=x86_64_v2_glibc-doc;unpack=0"
SRC_URI[x86_64_v2_glibc-doc.sha256sum] = "98446240c120c326f1d81c0ad7f3c01ca0c2b28e09ac8b68708012536ef6f21a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-gconv-extra-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-gconv-extra;unpack=0"
SRC_URI[x86_64_v2_glibc-gconv-extra.sha256sum] = "28f9f18b407bfe561d595756d561690d2cd55e9360c084b6321c638f107257b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-aa-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-aa;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-aa.sha256sum] = "6598fe753d7b2c0e439ed848d4ffbf97a964e45fc550cb9f510b9191d6d75450"
RPROVIDES:glibc-langpack-aa:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-af-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-af;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-af.sha256sum] = "b7cef5949937572f97feb3c7f6f1ee554f1bff92bcca45537c0ff629e30ae364"
RPROVIDES:glibc-langpack-af:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-agr-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-agr;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-agr.sha256sum] = "a2513f26a4805afa9cdeefa7c66153fc12b2f7d3f60b97cf3f3c539ff4f128bf"
RPROVIDES:glibc-langpack-agr:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ak-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ak;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ak.sha256sum] = "c6179291023708fa0c8be96db0a8139fafe557002ee850de5858ad1a52c7335b"
RPROVIDES:glibc-langpack-ak:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-am-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-am;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-am.sha256sum] = "88ce8a71f15c745bbf7d0396d145b67eed4565d4a6bf4f53b817d5395d64697b"
RPROVIDES:glibc-langpack-am:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-an-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-an;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-an.sha256sum] = "4799d7f9f066ee406aa28cb140983807720c15e88667a8cf6c42143049786628"
RPROVIDES:glibc-langpack-an:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-anp-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-anp;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-anp.sha256sum] = "018ad7358b0d3c4c0fb16f3d5aa40913f82a62ee5f94d4c48caab96288519851"
RPROVIDES:glibc-langpack-anp:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ar-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ar;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ar.sha256sum] = "61f5e2ae001204aef8bdb94d7fb0fc97f1a370e49ad253cf11e107a682f9e530"
RPROVIDES:glibc-langpack-ar:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-as-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-as;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-as.sha256sum] = "81971f10bbdaa1b184914e9311168b4ccfd4b9616f75369934606f7770bf47c6"
RPROVIDES:glibc-langpack-as:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ast-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ast;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ast.sha256sum] = "d09120b878d8cd5d1d3d64de1599e68666f7d201fa52a88836463a4bd16caf53"
RPROVIDES:glibc-langpack-ast:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ayc-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ayc;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ayc.sha256sum] = "65b6639632804d9c86d4d9faf92fab5c259eeeec758bf00ffbf9368de15fee7a"
RPROVIDES:glibc-langpack-ayc:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-az-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-az;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-az.sha256sum] = "410c92014d32f1dcc60c8f9a3da0af383ac29630f86badaab0d2eb87f3cb8779"
RPROVIDES:glibc-langpack-az:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-be-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-be;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-be.sha256sum] = "846d439b67accf07f1761c62f65bcc5868a70262e46e2bf515694b2d919f119f"
RPROVIDES:glibc-langpack-be:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bem-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bem;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-bem.sha256sum] = "f79a3f07be1fb926024468dd0b94b6e93d791c95cf9c22f2120b643f192fcf22"
RPROVIDES:glibc-langpack-bem:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ber-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ber;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ber.sha256sum] = "af282d2bf388ca7869623d65cf0f0edcf39a8df1178e795364b76ed6d8344bc6"
RPROVIDES:glibc-langpack-ber:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bg-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bg;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-bg.sha256sum] = "81b0b47382332afdbc837fd521906e066a8d03723f3b6fab2595a3933bede97f"
RPROVIDES:glibc-langpack-bg:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bhb-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bhb;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-bhb.sha256sum] = "4d134aae614a5d0e75caa1a7bde842bce7f059ccf08a4d7f301a3c6ae2aa74c3"
RPROVIDES:glibc-langpack-bhb:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bho-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bho;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-bho.sha256sum] = "2e9652d87d33fa200b46af69623d8ede74bb6d8d84e6ceab290cf72581383a7c"
RPROVIDES:glibc-langpack-bho:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bi-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bi;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-bi.sha256sum] = "c436d59bf9d6d69d4ae7974becf5b769792ae1dd828cd2c06ea4d93c2b9b0e69"
RPROVIDES:glibc-langpack-bi:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bn-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bn;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-bn.sha256sum] = "fe453cc1ce2fe76e9b47ba505bd1b375f4d48c3319db7c9dc36c5d5ac0405001"
RPROVIDES:glibc-langpack-bn:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bo-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bo;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-bo.sha256sum] = "c23670fd335abe69629cb3a8516e73beda1db64fe92ab0604a446b02b8738a5c"
RPROVIDES:glibc-langpack-bo:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-br-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-br;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-br.sha256sum] = "aebf47bcf92041f8654a9dd1e5f57879c69d273531a985860cc624b2dfe9e2b8"
RPROVIDES:glibc-langpack-br:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-brx-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-brx;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-brx.sha256sum] = "088a498bc4904573731ff75bc86d95fd1ae0eee67f44c692ab5934bcacf642a1"
RPROVIDES:glibc-langpack-brx:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bs-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bs;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-bs.sha256sum] = "d55042496cd0bbb19a472756cbb2d6dd6e2e1b35f9a05889a88a986ccfb4d8cc"
RPROVIDES:glibc-langpack-bs:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-byn-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-byn;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-byn.sha256sum] = "b3c5b1078fc2901813031f71382b69279a30e715c5ee6d6dafaaf4b77acc7293"
RPROVIDES:glibc-langpack-byn:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ca-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ca;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ca.sha256sum] = "14f7dfdd74e9118d46d83bf60cf728ebdaf7bd2bec00c54f9725cda2f97be820"
RPROVIDES:glibc-langpack-ca:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ce-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ce;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ce.sha256sum] = "a962b1e1c5c7686bf1e71bb474b3e69982fa84236e820c003980dd640c0e714a"
RPROVIDES:glibc-langpack-ce:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-chr-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-chr;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-chr.sha256sum] = "fda63dab0e9108e226f32b22b566dca86bcbf361c66a74106c4a8fb1e06b1fb2"
RPROVIDES:glibc-langpack-chr:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ckb-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ckb;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ckb.sha256sum] = "d35e072247211d55c51adbabb47d0765405bda3469591ba7e4bcc8376d93c432"
RPROVIDES:glibc-langpack-ckb:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cmn-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cmn;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-cmn.sha256sum] = "e6d09edb421b7e7e938c0a123dbc74309d0330d5c97214aabe5993351d74e098"
RPROVIDES:glibc-langpack-cmn:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-crh-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-crh;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-crh.sha256sum] = "08637b3d4640ad5cbf4cdd5420b7880f272bb5b2b69dd358e10756d9350cfb4b"
RPROVIDES:glibc-langpack-crh:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cs-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cs;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-cs.sha256sum] = "992c52f9315cb24a03bca0b82d32276ee4ffae78617ab470eedacb07b43fcd66"
RPROVIDES:glibc-langpack-cs:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-csb-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-csb;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-csb.sha256sum] = "9ebb6ae32b601638cad2be3ac5b99ce95deb8e780803e8755335b8aa442034f7"
RPROVIDES:glibc-langpack-csb:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cv-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cv;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-cv.sha256sum] = "5d8840abd285e4a50c968c0f68fbdbc6a133adb429a864e2244e6d18663e0c6a"
RPROVIDES:glibc-langpack-cv:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cy-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cy;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-cy.sha256sum] = "4860dceba5c36e3ef65f2551c4d3703cbae97b2b7e86143baeaaee9a7a5e25fa"
RPROVIDES:glibc-langpack-cy:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-da-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-da;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-da.sha256sum] = "23a626af7778d57d630a0b8374e2e1c93502f76d2b01a3a70eb788dfc8633819"
RPROVIDES:glibc-langpack-da:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-de-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-de;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-de.sha256sum] = "8a23ba6cf493e941829575dda61d59d46436b127dbbd8c842c9806a527e1c53c"
RPROVIDES:glibc-langpack-de:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-doi-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-doi;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-doi.sha256sum] = "61d5e7308db3d65961eb723a170e04437a95e17756a98e97676c29c207c87e93"
RPROVIDES:glibc-langpack-doi:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dsb-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dsb;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-dsb.sha256sum] = "a1fb7d46042929af01ebfe9e886b5055425cea9b472418e8cf1c4756beeb4e66"
RPROVIDES:glibc-langpack-dsb:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dv-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dv;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-dv.sha256sum] = "c7b5f8c8d51ce958917c9902b70a70b2098ade2fc8ed2c921eb39a2dbe560436"
RPROVIDES:glibc-langpack-dv:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dz-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dz;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-dz.sha256sum] = "440e49daeff2343ff703e45e9fe7080e34981bc23486429d6a0eb3db9f38dfdd"
RPROVIDES:glibc-langpack-dz:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-el-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-el;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-el.sha256sum] = "9cdec9ce61733ce36dbd32840b266c4a489208bc1035d83de14b8d52943c72dc"
RPROVIDES:glibc-langpack-el:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-en-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-en;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-en.sha256sum] = "cf6838d4d273b1e3b79b01930b2c339dfaddd09073758593586d1cff3a51e361"
RPROVIDES:glibc-langpack-en:append:x86_64_v2 = " virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eo-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-eo;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-eo.sha256sum] = "9de7922176cf40c8f761b52ad8de3574fff98b3a06d1cbf0404b901cd699b8ac"
RPROVIDES:glibc-langpack-eo:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-es-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-es;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-es.sha256sum] = "b1115c18efa9780406593d0b8f417dc8c9452a8464421c17c80d6f55cf582467"
RPROVIDES:glibc-langpack-es:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-et-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-et;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-et.sha256sum] = "a1725b0841e42a1e23c84d275a9913f75e9d8db0a1d47079ffa533e6f2bb374b"
RPROVIDES:glibc-langpack-et:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eu-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-eu;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-eu.sha256sum] = "f89a3543c8cd5c4b80a554b029b01f8f70582e989fa80e22fe4a79a8abaeaab8"
RPROVIDES:glibc-langpack-eu:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fa-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fa;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-fa.sha256sum] = "322710aa4416f25ebb6014279ebbe318d908689525424768557ab0072cb6d926"
RPROVIDES:glibc-langpack-fa:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ff-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ff;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ff.sha256sum] = "3acea4f835ee6a6ce70dad7009a53e1f71fe978f077c25856fe956058ed94271"
RPROVIDES:glibc-langpack-ff:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fi-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fi;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-fi.sha256sum] = "981490a04d73a687a59f4b51d1ebd3c1036384132c90baa2d5ea83fce1fe32a8"
RPROVIDES:glibc-langpack-fi:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fil-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fil;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-fil.sha256sum] = "e93eb952af84c1120d0fbadbd54db942387f88835bc8bec4ff0caf5d0a7793a8"
RPROVIDES:glibc-langpack-fil:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fo-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fo;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-fo.sha256sum] = "2cf6be75a4e93301a156cd3283d39e01f274ce1f15f0a2b718b277a1c16867fc"
RPROVIDES:glibc-langpack-fo:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fr-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fr;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-fr.sha256sum] = "9e7d77b9fde5f9e236b599d84970df24961e20fa056ff4484cef1a9a55e7072f"
RPROVIDES:glibc-langpack-fr:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fur-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fur;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-fur.sha256sum] = "b27c2e83888382d267efd5ef7f6d6cce678752c3b3b4e536b44f211f93b484b6"
RPROVIDES:glibc-langpack-fur:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fy-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fy;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-fy.sha256sum] = "04ddc9048b2de9c87ee64c5b06a13b9d0e5323fcb6b047b4168bf9d94c73cd05"
RPROVIDES:glibc-langpack-fy:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ga-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ga;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ga.sha256sum] = "6d5d919f0f6f039273c706409062ed4d7fd47779066157c493316b8eb18ae68f"
RPROVIDES:glibc-langpack-ga:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gbm-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gbm;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-gbm.sha256sum] = "09db6cec405a49b45d58bb45b41a390318f1da695cb2c62e937b3a0dcb35a4dd"
RPROVIDES:glibc-langpack-gbm:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gd-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gd;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-gd.sha256sum] = "0df0f9a0dc39f53c6e6faa0d506c447232defecb95315e8713e004cee8364fe8"
RPROVIDES:glibc-langpack-gd:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gez-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gez;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-gez.sha256sum] = "4c2841530f3c607a9b9d951d431878ceea0e364b4e689dba34cf733008144ea9"
RPROVIDES:glibc-langpack-gez:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gl-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gl;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-gl.sha256sum] = "ea7417f5c389cb9bff10a3b8824f53b91ed4e13e9c07ba68510a9a54acf7185c"
RPROVIDES:glibc-langpack-gl:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gu-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gu;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-gu.sha256sum] = "fe9b99704dadf454a9af0e2d0464e846d4e742331462773bdfbef245b39e479b"
RPROVIDES:glibc-langpack-gu:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gv-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gv;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-gv.sha256sum] = "f1678596379f8dbd10b1174a20dcf322aa25bd401e30e4a8e2184277d67ac23e"
RPROVIDES:glibc-langpack-gv:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ha-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ha;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ha.sha256sum] = "ce2a0a182ee8cb2c60b52b00f440c88a01e4179572127c05e3df31776e7bc506"
RPROVIDES:glibc-langpack-ha:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hak-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hak;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-hak.sha256sum] = "3f33e26dadb2ce187f5bffd8be694798e3f94658417f15fdba183b85acd4829f"
RPROVIDES:glibc-langpack-hak:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-he-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-he;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-he.sha256sum] = "9d40b1daa6837f092579df8635ed8e8542f3fdefe79e8d457a6b82328dd73f6f"
RPROVIDES:glibc-langpack-he:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hi-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hi;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-hi.sha256sum] = "16b619ed86658638fdfe9047e38bfb098511518c1fbc629ef0c15b7269ff0225"
RPROVIDES:glibc-langpack-hi:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hif-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hif;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-hif.sha256sum] = "76e8a0a5f6772f3be41cb1033baff3f9ce6662c918a576fca4c9ba40954a76a3"
RPROVIDES:glibc-langpack-hif:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hne-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hne;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-hne.sha256sum] = "7eb6e8c910d13abf217554c84616f0cbf58400f6df5ac3351619cb0af3f00cc5"
RPROVIDES:glibc-langpack-hne:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hr-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hr;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-hr.sha256sum] = "8b50b12de1eb66d95a55fc2a82cf2a89f4ade5b94ca17467e015a127d0fb5843"
RPROVIDES:glibc-langpack-hr:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hsb-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hsb;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-hsb.sha256sum] = "77ed4f6809499023e95b49f92ccbefb6812fe0b5d7dba6e753e910e846ea4aaa"
RPROVIDES:glibc-langpack-hsb:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ht-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ht;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ht.sha256sum] = "4a28f25573fcd7e2e2fce2814184f1619ec6668fc5b8b3cb7f504463e6a3eae0"
RPROVIDES:glibc-langpack-ht:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hu-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hu;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-hu.sha256sum] = "18fb8c3b68bb1ad2f721cc202b70b9b575998d6fd309ec15d2cace76f3bea052"
RPROVIDES:glibc-langpack-hu:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hy-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hy;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-hy.sha256sum] = "504f1ae1f448b2e01621ab39f24f9d312748bf950e581ec34ff3e20162670a45"
RPROVIDES:glibc-langpack-hy:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ia-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ia;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ia.sha256sum] = "8e2186ff3783ef8e3c2400f0bceb918b531ba125e45d3278f18bd4729b22eed7"
RPROVIDES:glibc-langpack-ia:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-id-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-id;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-id.sha256sum] = "46d14454bab998a6a930d6d3d3b1bdbbc0f95feb26367a12a8f033a879dff881"
RPROVIDES:glibc-langpack-id:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ig-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ig;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ig.sha256sum] = "27631e86e9f50e35d047c49aa398abcd15c192d7ca2b0058e4a7d25580a63850"
RPROVIDES:glibc-langpack-ig:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ik-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ik;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ik.sha256sum] = "e51520a71702394c1e5a025fbaa279bbe73da6bd1cdef7da9e09dcf4ef2428f2"
RPROVIDES:glibc-langpack-ik:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-is-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-is;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-is.sha256sum] = "cb72b7feae202353c019eb042ebcd056356712e04316edca54137b32f408fa6d"
RPROVIDES:glibc-langpack-is:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-it-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-it;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-it.sha256sum] = "e04a05a465f2bbb0c6d59125da6f33a409e1c96d527ae6c8d2d6cfa656f63460"
RPROVIDES:glibc-langpack-it:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-iu-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-iu;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-iu.sha256sum] = "f120763b6443863e007c21b186c75240a8f759ea256caf8f8ca8fd69839ef7fa"
RPROVIDES:glibc-langpack-iu:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ja-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ja;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ja.sha256sum] = "be9bb540e70f832ce6c7e4f9b6565d59fe359b7cc93036180d13443757623a2f"
RPROVIDES:glibc-langpack-ja:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ka-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ka;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ka.sha256sum] = "e2f1157c4c315dd14675ea473e55ca9653312b8d6e2e8b8e9743776c8aef8a38"
RPROVIDES:glibc-langpack-ka:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kab-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kab;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-kab.sha256sum] = "6655dcf6573072c51fd5743a5f31da048f2219b89ec6e681e8d8354053d055ad"
RPROVIDES:glibc-langpack-kab:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kk-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kk;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-kk.sha256sum] = "e6faf79cb724670abbd20baca1150b5c8d08a31b49711bb8a19719e41ae76207"
RPROVIDES:glibc-langpack-kk:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kl-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kl;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-kl.sha256sum] = "ea521a97ad0c24b4b8d77af17409c2dfc6fd982fe125be6507e1652da74b3b9d"
RPROVIDES:glibc-langpack-kl:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-km-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-km;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-km.sha256sum] = "db175a408bdc50b6d59004bf87b0d286960875f94dee4420e838b6b3e6de8b27"
RPROVIDES:glibc-langpack-km:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kn-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kn;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-kn.sha256sum] = "bc6deed57fcb1e2136ee04b1f3aa5175a38488d35f15f4bd988f83714e6bbe0e"
RPROVIDES:glibc-langpack-kn:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ko-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ko;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ko.sha256sum] = "c26e87d8f04afd681859452639c6e6d52a175e7befb9ff1edf935a9a705b4ac3"
RPROVIDES:glibc-langpack-ko:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kok-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kok;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-kok.sha256sum] = "6b7e508dc2c91a40fb0c4a8eb9a9d5c72d4c83c4b8eb74ea3e39b4ae3263d34d"
RPROVIDES:glibc-langpack-kok:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ks-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ks;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ks.sha256sum] = "69a7044269042704f975d9e5535d62f9327aea3d6d43155d9997fb2735b2fe11"
RPROVIDES:glibc-langpack-ks:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ku-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ku;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ku.sha256sum] = "bfbf560100eade8139d392b40c955be8b7d218668964fc97a5f5be3ba4453c5b"
RPROVIDES:glibc-langpack-ku:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kv-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kv;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-kv.sha256sum] = "2d9a7807220c6b4d931c0a52ebd4d8da006a7143efbd533370887b8d79101c7c"
RPROVIDES:glibc-langpack-kv:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kw-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kw;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-kw.sha256sum] = "d2fbf089d3bdce9bf83363460773d1cd78921ad3f9c6fd2a76bd4a8ae9825339"
RPROVIDES:glibc-langpack-kw:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ky-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ky;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ky.sha256sum] = "57abf9ef685d99792ea688d5743f7b2ce05b18d8d663fcc81a1ffa2e0a2ad76c"
RPROVIDES:glibc-langpack-ky:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lb-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lb;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-lb.sha256sum] = "5ba5978004a59daab521e4497d2472753ab44a0d019805df1d6b3878a1eadb85"
RPROVIDES:glibc-langpack-lb:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lg-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lg;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-lg.sha256sum] = "99fa6fd9ae1ae45303082a59fc0c8505076a4419ab919a65a5cb9de8a9c0425e"
RPROVIDES:glibc-langpack-lg:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-li-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-li;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-li.sha256sum] = "fd5f7342fb51691a452f7d4c09177a61dd107cbce6a0c2cd553e2efb65e0567e"
RPROVIDES:glibc-langpack-li:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lij-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lij;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-lij.sha256sum] = "bce307de870bb53ccf5fc65a21647c53a77d0b889a1d307af705c4d7c869036a"
RPROVIDES:glibc-langpack-lij:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ln-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ln;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ln.sha256sum] = "46383e73e9b71af5b5595a27a25847c9473363b832516f2cc32a1d2052c8d794"
RPROVIDES:glibc-langpack-ln:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lo-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lo;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-lo.sha256sum] = "b132afb1f770e3b5ac5e83cc254b3ca009477e91a60ef208503d8f57174b8d95"
RPROVIDES:glibc-langpack-lo:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lt-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lt;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-lt.sha256sum] = "0c5df7e1bdaa6141406ff0ce5b49e9978dcda54086217a63f381ec79ee644591"
RPROVIDES:glibc-langpack-lt:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lv-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lv;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-lv.sha256sum] = "a41160ce1f45571a8229aa3c962088112ad513a2c6afb35cf3bca1ca4cb85cbd"
RPROVIDES:glibc-langpack-lv:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lzh-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lzh;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-lzh.sha256sum] = "131dcf9fd2e9587531f898a7e40c558cf7cb7e8acfac2b965ad0396d99253a62"
RPROVIDES:glibc-langpack-lzh:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mag-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mag;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mag.sha256sum] = "002fa2f2f74a641dc285ef36fe55a49f5f63ffe0e45af2650717d84310d2f57b"
RPROVIDES:glibc-langpack-mag:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mai-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mai;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mai.sha256sum] = "aacc7392c3a023aaaddeac08bbf6aa8c89c68b3cece611ed420830c46e4f1264"
RPROVIDES:glibc-langpack-mai:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mfe-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mfe;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mfe.sha256sum] = "60d13afe864a8d941c6effcf2b57ee82d6a1e6880750d3b1841ea66a16548e07"
RPROVIDES:glibc-langpack-mfe:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mg-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mg;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mg.sha256sum] = "7c1c648f82cc5471dd4f676f587cc05fc9186d37ee71314530de31474c6096fc"
RPROVIDES:glibc-langpack-mg:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mhr-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mhr;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mhr.sha256sum] = "081fad7ea8f85f1f0bb69c48eb65d726eed60b6b4f2a5b52e7371a21f2a8fd32"
RPROVIDES:glibc-langpack-mhr:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mi-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mi;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mi.sha256sum] = "38bd14d1229299fa09088ecb4f034b5645654d019eb0ddb0a8ba530e79e3aec6"
RPROVIDES:glibc-langpack-mi:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-miq-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-miq;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-miq.sha256sum] = "18d46f67450f4b1dde4ee8253d61a09451cfc5dca11250c83984ac91b17c6ae0"
RPROVIDES:glibc-langpack-miq:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mjw-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mjw;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mjw.sha256sum] = "45bd33c69e69290083f86117b673cae338adefe2a35eaf2cf155b82f8220bf1d"
RPROVIDES:glibc-langpack-mjw:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mk-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mk;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mk.sha256sum] = "ac0b8d50a047c1e54be7cb2112cadf0b27b969faa67be2157898916a410936d2"
RPROVIDES:glibc-langpack-mk:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ml-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ml;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ml.sha256sum] = "a2ba2c39026713220ec8170c063fba5c27212d42f258f0834cf770e1bf0ea8d5"
RPROVIDES:glibc-langpack-ml:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mn-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mn;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mn.sha256sum] = "f48b77e252d4174ca6a25a1f2a052c4c71fcd1df725c35b2d64cf3e67bff48cc"
RPROVIDES:glibc-langpack-mn:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mni-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mni;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mni.sha256sum] = "334aebce0417bbeecebbbbc22b2a4ddef7d7d36ec7c45cc7d15b98d7ca35a114"
RPROVIDES:glibc-langpack-mni:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mnw-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mnw;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mnw.sha256sum] = "53ae766721af1311b15976319af3983a6e8f3673f960ff6df62a79b7ba1e928a"
RPROVIDES:glibc-langpack-mnw:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mr-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mr;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mr.sha256sum] = "47a86e1ae0ff53d986b31df35f564cff3f713cee33b8be21ce38788d8dcfe223"
RPROVIDES:glibc-langpack-mr:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ms-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ms;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ms.sha256sum] = "6a632f701b2f0f60e49a66e3b166d61b72a4e93b54b4a1fa1abcee3e0d5caa37"
RPROVIDES:glibc-langpack-ms:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mt-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mt;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-mt.sha256sum] = "1c8f0642130ead88f8daa904b0f7e3cbbe4f6f7c8309d8c4734660af841f3ca4"
RPROVIDES:glibc-langpack-mt:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-my-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-my;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-my.sha256sum] = "7e2faf0d92cb41ca4389307886531865c143971f170f5b6b378ad700bc532812"
RPROVIDES:glibc-langpack-my:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nan-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nan;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-nan.sha256sum] = "5b4d3ebd93dab9600ac194e3c5e2d4cbbcca8bbce0cb92e576e13e314ac9c99a"
RPROVIDES:glibc-langpack-nan:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nb-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nb;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-nb.sha256sum] = "df78ad03425edc811c5f3ee25b8646ba7bfc20bc86668322dfccddb2d1c7707f"
RPROVIDES:glibc-langpack-nb:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nds-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nds;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-nds.sha256sum] = "d91e66df88a33695675a3481a613e41618c086a09bb5586f47409eb5026479eb"
RPROVIDES:glibc-langpack-nds:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ne-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ne;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ne.sha256sum] = "15f5dbc6b1e455ad487c0134b663252b053861722867be444c3882b0111b51b2"
RPROVIDES:glibc-langpack-ne:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nhn-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nhn;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-nhn.sha256sum] = "fef54421da64bac2b7d7fd6f47ba7874c776e5e8c3a9c3b4dfc1197eacb665b0"
RPROVIDES:glibc-langpack-nhn:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-niu-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-niu;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-niu.sha256sum] = "cefe3df616b9c51b9e0463799c533ba0b97b6408b492b00c8842facde14c1405"
RPROVIDES:glibc-langpack-niu:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nl-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nl;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-nl.sha256sum] = "c1cac5c946f6be3deea0a7c01f10ae311f588975f7e48b48d4b805a066a97fe3"
RPROVIDES:glibc-langpack-nl:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nn-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nn;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-nn.sha256sum] = "2082dfebfd578d144d9d146fc82594d9e1467c8527abb8967e2b1969ca648711"
RPROVIDES:glibc-langpack-nn:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nr-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nr;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-nr.sha256sum] = "c72bd0f642b87d003a825297e7c1d61d53c3c5503c2a9f88573b32ec4505d428"
RPROVIDES:glibc-langpack-nr:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nso-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nso;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-nso.sha256sum] = "da1f0d3205bd006cdd3d89309c96cd6a39220326982592755f4cebfaf6529e7a"
RPROVIDES:glibc-langpack-nso:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-oc-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-oc;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-oc.sha256sum] = "f7ee0e4fc0aadc2461f35f98864c1f916653f42c80b4d6a2dd4d12a5c5d24ea1"
RPROVIDES:glibc-langpack-oc:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-om-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-om;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-om.sha256sum] = "31c6d24e372be28a392edea4b84fe0459d9d2d1da9b02b73976a654692565188"
RPROVIDES:glibc-langpack-om:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-or-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-or;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-or.sha256sum] = "50e51f4a4fe4a0215cd3b32a54b72063d29a5fdbc415aa9f840548e77efab361"
RPROVIDES:glibc-langpack-or:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-os-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-os;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-os.sha256sum] = "2bfd55a88a7ceabbcb071fe440f7175f7d5f8aa120d84d25faeb91ce12a2a164"
RPROVIDES:glibc-langpack-os:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pa-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pa;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-pa.sha256sum] = "48a22215425877c986e1661034d14919881aac716f08de025beca28890e92ecd"
RPROVIDES:glibc-langpack-pa:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pap-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pap;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-pap.sha256sum] = "c0d102c9cb895110fc59ae753d7268b0f82bbf0e81dc6cd3b7bde0f5e9199a59"
RPROVIDES:glibc-langpack-pap:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pl-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pl;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-pl.sha256sum] = "bbc6ac5881034a284617f563979b0d5b13d5fdb5468605998d8009812232cf65"
RPROVIDES:glibc-langpack-pl:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ps-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ps;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ps.sha256sum] = "88cfe718d96453b00aadb99dac4ca529c2114abe6e4c095e65af7cd2b5179480"
RPROVIDES:glibc-langpack-ps:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pt-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pt;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-pt.sha256sum] = "1f7d8bf88b1d4429944adb9addfc4cfeec3a38c277ddb989ad71ac3a338ae686"
RPROVIDES:glibc-langpack-pt:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-quz-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-quz;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-quz.sha256sum] = "4b110332a838b65b554db1314a8aa358a476c9aa2e607e5aa34f03dcda4fdf40"
RPROVIDES:glibc-langpack-quz:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-raj-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-raj;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-raj.sha256sum] = "5f3301d8ffeed3b84fcdd4a8196d522445e543cfee41ea811586ff4afb3caf91"
RPROVIDES:glibc-langpack-raj:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rif-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-rif;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-rif.sha256sum] = "0d16d3960170cf4a3fe7ecd65ed37e4f01abc256f1f465c4544efeaaab1df1ad"
RPROVIDES:glibc-langpack-rif:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ro-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ro;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ro.sha256sum] = "fb11f90395c7d34ee51d2cc0ff70f3e12b5cba9ce9c32ec00577e6a3e0d882f1"
RPROVIDES:glibc-langpack-ro:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ru-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ru;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ru.sha256sum] = "e8f117b076980c31405678bf4f992bb1bced5ee666c47bd19d83a21f7775c2f7"
RPROVIDES:glibc-langpack-ru:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rw-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-rw;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-rw.sha256sum] = "2a3cec9f5c732fb34400aae9b53c62e49103e87f956917d3eaa0c3bc1b71908a"
RPROVIDES:glibc-langpack-rw:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sa-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sa;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sa.sha256sum] = "8da13a004ed212cbdb8d6d34c260e1df32b92fb35028e442448958f9cf3f5d06"
RPROVIDES:glibc-langpack-sa:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sah-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sah;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sah.sha256sum] = "4366af100e174ac2335c1b0a23c3cecb0688f7062eda1748c5a64d099ca2f208"
RPROVIDES:glibc-langpack-sah:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sat-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sat;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sat.sha256sum] = "81ec9d55c8d972159757fb4af12c0b6d903a4cd3b34a1aa619401dac56ab6fee"
RPROVIDES:glibc-langpack-sat:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sc-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sc;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sc.sha256sum] = "7028dd984e2ccab0250e75781cc5723b9c5f66eae81804568116db4f27ce990f"
RPROVIDES:glibc-langpack-sc:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sd-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sd;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sd.sha256sum] = "e4e5099f0e03f8e78598be70785b37c3a33678e321b6f050c7f828202e549030"
RPROVIDES:glibc-langpack-sd:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-se-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-se;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-se.sha256sum] = "0b261e8463160b1de413bd259a3fbeff3345775ea48681e331dc878f54fdb207"
RPROVIDES:glibc-langpack-se:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sgs-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sgs;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sgs.sha256sum] = "5020b9060f062d7b49fedbaaeae57cd77257a5e075e41696886ec6d973133176"
RPROVIDES:glibc-langpack-sgs:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shn-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-shn;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-shn.sha256sum] = "2647849572879f83fa0fe217d4a52bd638758f6868bd2c12250c7493af09ec6f"
RPROVIDES:glibc-langpack-shn:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shs-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-shs;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-shs.sha256sum] = "504fdc8bd82caaf666622b85ae6147fa11b7d509f54d7cd6eebf63fa6a23dcd5"
RPROVIDES:glibc-langpack-shs:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-si-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-si;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-si.sha256sum] = "e7112864b625c63cb1168afaffea90e0b8ab46e16ed2137dc1d153f9d25d8479"
RPROVIDES:glibc-langpack-si:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sid-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sid;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sid.sha256sum] = "9517553568a6446cbc2ea1014e3476c8f95a40517b0433c3ab88f4166e5f5471"
RPROVIDES:glibc-langpack-sid:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sk-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sk;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sk.sha256sum] = "d885b1908a781eaff7467a329e6fb83b7e5fa47e2a8a842b9aac6b1ad2e5dd4b"
RPROVIDES:glibc-langpack-sk:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sl-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sl;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sl.sha256sum] = "bd9e829a65649e99b8273d664ed7cbf29519b69ab26b1a4a1336d8f0ad81a1d2"
RPROVIDES:glibc-langpack-sl:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sm-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sm;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sm.sha256sum] = "01ef0427ae94c5c1c79c38702a22b4b6637c6cbbee0b299c02ac3376d8bf8c02"
RPROVIDES:glibc-langpack-sm:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-so-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-so;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-so.sha256sum] = "bb02961891b94e26e762f75cc4b311f4d3b64b1646ed6830156dfe2dd735948e"
RPROVIDES:glibc-langpack-so:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sq-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sq;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sq.sha256sum] = "55b8839a2e0700701245ace895192e9d8c2e24b3463009a4b6694a75953904f1"
RPROVIDES:glibc-langpack-sq:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sr-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sr;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sr.sha256sum] = "05eaeb2aadcec27997185eb50168a82bb1dbb111d1a0455c1a8e4bc730e8e3ca"
RPROVIDES:glibc-langpack-sr:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ss-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ss;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ss.sha256sum] = "bba07e6ebc692f9882511b7a8722ec6e8f9b0091a7d235ae0211f665b50eb76b"
RPROVIDES:glibc-langpack-ss:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ssy-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ssy;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ssy.sha256sum] = "1c794afd04f62fc7c8094f142704f7a1b5f4b03febd7065b0bb13fb97fc5f908"
RPROVIDES:glibc-langpack-ssy:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-st-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-st;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-st.sha256sum] = "d38784e4871168750e0aa90c3b44e13fa143a0d6a820c45a7558b5676a6cf728"
RPROVIDES:glibc-langpack-st:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-su-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-su;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-su.sha256sum] = "12f87365fd3c4eb75f9bff5a955d685802545d37ea5bf4592f092ba1eadf7760"
RPROVIDES:glibc-langpack-su:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sv-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sv;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sv.sha256sum] = "81973205476ba262a19784bacef0c88a71e76c18bbd8af794b55a8a36a55fc1f"
RPROVIDES:glibc-langpack-sv:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sw-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sw;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-sw.sha256sum] = "31a9f824a3545eadcff23384eec487dc44c3338c491127664f6b561db0de827d"
RPROVIDES:glibc-langpack-sw:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-syr-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-syr;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-syr.sha256sum] = "1ba72b1f83e2865204b282ced780a3ab2eba6547f8846bbceca7933574146f22"
RPROVIDES:glibc-langpack-syr:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-szl-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-szl;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-szl.sha256sum] = "b56c174d68a4724284c4a87288bcc022894badaafecd8885f58f3fcde182fd6d"
RPROVIDES:glibc-langpack-szl:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ta-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ta;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ta.sha256sum] = "76b73188275391aca9bd05ccd3befde578dccc3c92674fbb71e9df9f810f57c5"
RPROVIDES:glibc-langpack-ta:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tcy-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tcy;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-tcy.sha256sum] = "ff203ad1fcfd4aaf88a83319f3a97e14c0af9c19aab3f8ede8a59376905c5798"
RPROVIDES:glibc-langpack-tcy:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-te-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-te;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-te.sha256sum] = "79d0be88efec660f105107bdb508f0b614a5807668525f9ff37a60023556ea71"
RPROVIDES:glibc-langpack-te:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tg-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tg;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-tg.sha256sum] = "819bec0bd617dbdf82badec14764b599179f8db6d3d80f8d3b146fda93acef43"
RPROVIDES:glibc-langpack-tg:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-th-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-th;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-th.sha256sum] = "fa1a88e0f69ae17c3c2bbe7ca78dd3124cec87f61ac47f5f6921e379ee5ea9c3"
RPROVIDES:glibc-langpack-th:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-the-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-the;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-the.sha256sum] = "3dfb85897f17a9714814dccc8842d62b790f174725ecf053265ab06df1b6c6aa"
RPROVIDES:glibc-langpack-the:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ti-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ti;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ti.sha256sum] = "c77e5399213cd54a285203c18841ad29db261eed096bc60a33a91c495e67f710"
RPROVIDES:glibc-langpack-ti:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tig-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tig;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-tig.sha256sum] = "98db64bae8b4c4966b7a587bbb3c5c3aff86882f8b020abf61931ac6cb9d3012"
RPROVIDES:glibc-langpack-tig:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tk-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tk;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-tk.sha256sum] = "cb6d8b4fd471765ebe88a8e0e3bd33da8b85c87b52e533123a87752d78d3fbf2"
RPROVIDES:glibc-langpack-tk:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tl-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tl;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-tl.sha256sum] = "00a095dd39e62bc67ae727f26ec91b8889b061dfbbfef15cf8237c520d8da156"
RPROVIDES:glibc-langpack-tl:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tn-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tn;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-tn.sha256sum] = "b790cc6d9de48ffe9865a6f79591cdf1e1ecd9c811d9d0e1f666a9958c58886b"
RPROVIDES:glibc-langpack-tn:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-to-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-to;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-to.sha256sum] = "cfd53ce8ed087d4d4b450f8c09ce84fddf76c96b3e8613f8d6649f9503b3d94d"
RPROVIDES:glibc-langpack-to:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tok-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tok;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-tok.sha256sum] = "0e08b5d6fdf0fd41cc1f5f566120095e8188cc15a66f4dc48e0f7c0c5ad3458f"
RPROVIDES:glibc-langpack-tok:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tpi-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tpi;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-tpi.sha256sum] = "16798a38a4cccc34f6757883abc1374b0dab422ad8e1c5f95a8ef8a69cfbe2c9"
RPROVIDES:glibc-langpack-tpi:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tr-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tr;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-tr.sha256sum] = "a77ced185eae6e22142078a3a7d3c8afdd84d1f5b025d655e664b4f859a7018c"
RPROVIDES:glibc-langpack-tr:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ts-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ts;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ts.sha256sum] = "af5b121c028aba5e7f1879058c7f77b6713d08bacc4c2998e04ad85199e8f37f"
RPROVIDES:glibc-langpack-ts:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tt-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tt;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-tt.sha256sum] = "30d4d1f39ac23bda67d37894e4b45261cd14c408995b12c59718307b79d02f1f"
RPROVIDES:glibc-langpack-tt:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ug-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ug;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ug.sha256sum] = "6dcc6105ef0eef76b00fb3e234e1c968fa98a01330063679f0fa42e3e696f380"
RPROVIDES:glibc-langpack-ug:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uk-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-uk;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-uk.sha256sum] = "e9a2df1bbfd65f8c5a5892056d0cf300f14d6bd19b9c5939b501ee6ca0a0155d"
RPROVIDES:glibc-langpack-uk:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-unm-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-unm;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-unm.sha256sum] = "19970f76e5f0761185acc82c3d1c437047f33d25b276e6158152bbecdcca1a6f"
RPROVIDES:glibc-langpack-unm:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ur-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ur;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ur.sha256sum] = "63cedda11b22cf829f6315f43031530f9129085a925a29e200321e0fd9ad7075"
RPROVIDES:glibc-langpack-ur:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uz-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-uz;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-uz.sha256sum] = "472b1d647809077ee8d783e9ee6ef649bfcee8ea00acd3f3c2ebf4b9116d129a"
RPROVIDES:glibc-langpack-uz:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ve-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ve;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-ve.sha256sum] = "839a4afea45864e3b332af5fa8d012b2fa41c0b4599d59adc679a111a58443e2"
RPROVIDES:glibc-langpack-ve:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-vi-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-vi;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-vi.sha256sum] = "3364ad8fcadac83d932294f3fddc727389dac97b6bebd1e7ff6c2dce1ed4b434"
RPROVIDES:glibc-langpack-vi:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wa-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wa;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-wa.sha256sum] = "5a0bdf1df086f6a8a40200f01c22e9706eaa79e6626835290cc3dab1b5771678"
RPROVIDES:glibc-langpack-wa:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wae-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wae;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-wae.sha256sum] = "e33b7857541bd3c0bcaf7b040061b70c43cc802b55aec964f1dbd10623bcf286"
RPROVIDES:glibc-langpack-wae:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wal-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wal;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-wal.sha256sum] = "8f63e5ee3b12a6c2d174c5fbcbb615173b721b430339eb4048aa7209a6239187"
RPROVIDES:glibc-langpack-wal:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wo-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wo;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-wo.sha256sum] = "3569623bec329e5e2b17b07e43eefc84c7bc2e4f4fe7084c8a48af4850f834fe"
RPROVIDES:glibc-langpack-wo:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-xh-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-xh;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-xh.sha256sum] = "268696ef91c846d475c309e4a9d1b634808a1a5c77bdfddc05558b56911b3c23"
RPROVIDES:glibc-langpack-xh:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yi-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yi;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-yi.sha256sum] = "89915dda84eab24f56afeb4bb0abf8339319d29ee55cca2141841e1e9b73ea91"
RPROVIDES:glibc-langpack-yi:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yo-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yo;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-yo.sha256sum] = "19af6f7a46b4151bf7fc51558b61b11aaa3c525cb488aec4ffa619f7339a528e"
RPROVIDES:glibc-langpack-yo:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yue-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yue;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-yue.sha256sum] = "4772f7977f1569c070d71277b0a1599e8235f41b917922da7d2f3342b460c8ec"
RPROVIDES:glibc-langpack-yue:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yuw-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yuw;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-yuw.sha256sum] = "f450412349eec74350dddf21030a83740dcf641c06bdba9e3f5ecc0b0a5a16bc"
RPROVIDES:glibc-langpack-yuw:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zgh-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zgh;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-zgh.sha256sum] = "6ae47c3deeb7e0da3c0a6586e7d6edb003a4495a7b61ec4736aa302d223ba6ae"
RPROVIDES:glibc-langpack-zgh:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zh-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zh;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-zh.sha256sum] = "b37ccf1dcc26806cac4da13eea3b7e85032868555543f3963591a4415b96802c"
RPROVIDES:glibc-langpack-zh:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zu-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zu;unpack=0"
SRC_URI[x86_64_v2_glibc-langpack-zu.sha256sum] = "0605342d119cbfe0e383ccd36ae2c24cd2bda23e60e1957149a445bd2f6728c9"
RPROVIDES:glibc-langpack-zu:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-locale-source-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-locale-source;unpack=0"
SRC_URI[x86_64_v2_glibc-locale-source.sha256sum] = "21bb61eda26d9c9001bd61414734cbd9b21029f77900e3947acc0afe7a765a77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-minimal-langpack-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-minimal-langpack;unpack=0"
SRC_URI[x86_64_v2_glibc-minimal-langpack.sha256sum] = "bcca5faece6bbe54a04f6587da2e9c15cfe048a2251cf1a05df527629821eeb1"
RPROVIDES:glibc-minimal-langpack:append:x86_64_v2 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-nss-devel-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-nss-devel;unpack=0"
SRC_URI[x86_64_v2_glibc-nss-devel.sha256sum] = "7d4ac9c838712b3906884dd2e0f41c03bc00b3f622310f019ecc6fbdbb111d60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-static-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-static;unpack=0"
SRC_URI[x86_64_v2_glibc-static.sha256sum] = "b444525f5dba5323515d1c5c60ac4faa07c6bbcb224ddacbb9690f9fe8cee9d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-utils-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-utils;unpack=0"
SRC_URI[x86_64_v2_glibc-utils.sha256sum] = "b4d79d5802997b78379095c7309fa5b917624bc407634ca696fe9e8ce1274641"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnsl-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libnsl;unpack=0"
SRC_URI[x86_64_v2_libnsl.sha256sum] = "b878fbff9efc2f7cfc51db14f5d7ac4141794590930b2db651cab2e6e1e62aa7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nss_db-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_nss_db;unpack=0"
SRC_URI[x86_64_v2_nss_db.sha256sum] = "7d14f5f721aadbf6cb371eb438b86ac94bda48e77ebd6740426f203e1e046e9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nss_hesiod-2.39-141.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_nss_hesiod;unpack=0"
SRC_URI[x86_64_v2_nss_hesiod.sha256sum] = "d562c65c2258a1168419932d4346f65e47f78ada365f8aac038c55ebadaa8657"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc;unpack=0"
SRC_URI[aarch64_glibc.sha256sum] = "1a9adfc3b55078b6f75bf3e7b509c5ff82b8e19bb949c3b48195ec43ae701c1b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-all-langpacks-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-all-langpacks;unpack=0"
SRC_URI[aarch64_glibc-all-langpacks.sha256sum] = "31604afd7ab5bcd80a7f46827bdc2e31d76b083f87250185ce7d9c23963420b5"
RPROVIDES:glibc-all-langpacks:append:aarch64 = " virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-benchtests-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-benchtests;unpack=0"
SRC_URI[aarch64_glibc-benchtests.sha256sum] = "78e01ee667fb08d4659ce5c1c457f175053dedcb2b16a23ebe63b2fec30800d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-common-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-common;unpack=0"
SRC_URI[aarch64_glibc-common.sha256sum] = "367e46e42d1578f3801b41f6e29cb8988295d9bfcd2a05d4081f79a60503fe56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-devel-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-devel;unpack=0"
SRC_URI[aarch64_glibc-devel.sha256sum] = "42e21278bae61a363270448b9f98090157b715eadff1371de8043bba52ceeba6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-doc-2.39-141.el10.alma.1.noarch.rpm;name=aarch64_glibc-doc;unpack=0"
SRC_URI[aarch64_glibc-doc.sha256sum] = "98446240c120c326f1d81c0ad7f3c01ca0c2b28e09ac8b68708012536ef6f21a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-gconv-extra-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-gconv-extra;unpack=0"
SRC_URI[aarch64_glibc-gconv-extra.sha256sum] = "2c81cf379eff18906572d6dfec528409d9de21a61173ac33a94a617635d2e472"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-aa-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-aa;unpack=0"
SRC_URI[aarch64_glibc-langpack-aa.sha256sum] = "6bb98e963af0203ea3bb81b56bd4b0bd5841b17fc2b636359233b1e6407efbb2"
RPROVIDES:glibc-langpack-aa:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-af-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-af;unpack=0"
SRC_URI[aarch64_glibc-langpack-af.sha256sum] = "51d8c81c579132a127dfa7f68779b19842d6c3c86d96834ad24276b60931578c"
RPROVIDES:glibc-langpack-af:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-agr-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-agr;unpack=0"
SRC_URI[aarch64_glibc-langpack-agr.sha256sum] = "ece9e55baf28aa2b92640f7c7074fe62ea73f38fd10d6725affca1a0427bcbe1"
RPROVIDES:glibc-langpack-agr:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ak-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ak;unpack=0"
SRC_URI[aarch64_glibc-langpack-ak.sha256sum] = "1b7529b02dc52b17aa40a2f2a46c654597725d1aadd93de4fac647249b67d517"
RPROVIDES:glibc-langpack-ak:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-am-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-am;unpack=0"
SRC_URI[aarch64_glibc-langpack-am.sha256sum] = "dfc9fe68d90efc5edd2899f97fb456d3614055b158bcf1bccec443e47d44a753"
RPROVIDES:glibc-langpack-am:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-an-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-an;unpack=0"
SRC_URI[aarch64_glibc-langpack-an.sha256sum] = "945bf15f80c4a00716960633b8d83eaa1021968d4231b159447b00f33448405d"
RPROVIDES:glibc-langpack-an:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-anp-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-anp;unpack=0"
SRC_URI[aarch64_glibc-langpack-anp.sha256sum] = "3beddb711d29b1bc1423ebeb986c948c43df5958d401ec3adef94df1c3110794"
RPROVIDES:glibc-langpack-anp:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ar-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ar;unpack=0"
SRC_URI[aarch64_glibc-langpack-ar.sha256sum] = "d9fe1d2cf68c73a755b74b52da8de8f92d773b86e8cb51a8215a17d8469b2ba0"
RPROVIDES:glibc-langpack-ar:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-as-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-as;unpack=0"
SRC_URI[aarch64_glibc-langpack-as.sha256sum] = "8b6b62be85f63cb3c29f0c4c995f7546a2eca7690e4dbbaab7d320a989c93e9b"
RPROVIDES:glibc-langpack-as:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ast-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ast;unpack=0"
SRC_URI[aarch64_glibc-langpack-ast.sha256sum] = "51e6dc1ddb5092888f94c40b76edcbd8554389ec79ef942271f96002dfb4f7f1"
RPROVIDES:glibc-langpack-ast:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ayc-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ayc;unpack=0"
SRC_URI[aarch64_glibc-langpack-ayc.sha256sum] = "23b1d084483d381138e6d4f9d5aa839a2a45656bd1d4b2db0038b489e78d4ba1"
RPROVIDES:glibc-langpack-ayc:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-az-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-az;unpack=0"
SRC_URI[aarch64_glibc-langpack-az.sha256sum] = "3756e9749cf466c09c0c450db5773ea00d6e0e18d4fb3af7495b4b14716e42ef"
RPROVIDES:glibc-langpack-az:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-be-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-be;unpack=0"
SRC_URI[aarch64_glibc-langpack-be.sha256sum] = "b6ff1d62eb6dbcc972e295fcb48527a3030077a06ad03d0f5548f5cd8be5d162"
RPROVIDES:glibc-langpack-be:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bem-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bem;unpack=0"
SRC_URI[aarch64_glibc-langpack-bem.sha256sum] = "43400a4e8d888ad954eaa7a6b399b1222334c9e9b073102ae23edccee71515ca"
RPROVIDES:glibc-langpack-bem:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ber-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ber;unpack=0"
SRC_URI[aarch64_glibc-langpack-ber.sha256sum] = "5c20a8edbb09de642294f42254705cd14673471b6a4d38b15f0aef945d0bc803"
RPROVIDES:glibc-langpack-ber:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bg-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bg;unpack=0"
SRC_URI[aarch64_glibc-langpack-bg.sha256sum] = "1a8e5c5961511d08c289d98a3d4b1a6830c722b3265c4bcf3eceb8fb9a25c47c"
RPROVIDES:glibc-langpack-bg:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bhb-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bhb;unpack=0"
SRC_URI[aarch64_glibc-langpack-bhb.sha256sum] = "f7a40cdf62932431a7ace06ce1e72c7271fbd0d543eae0ea6fd7bd33ce430b90"
RPROVIDES:glibc-langpack-bhb:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bho-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bho;unpack=0"
SRC_URI[aarch64_glibc-langpack-bho.sha256sum] = "956efcbced9c1d8a64f1170677a45d8c290ca06430bfd207cc536028ff77527e"
RPROVIDES:glibc-langpack-bho:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bi-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bi;unpack=0"
SRC_URI[aarch64_glibc-langpack-bi.sha256sum] = "96e28de4174e092d681102e0934911eed686d2ddb5742e6e78a66519c1263d56"
RPROVIDES:glibc-langpack-bi:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bn-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bn;unpack=0"
SRC_URI[aarch64_glibc-langpack-bn.sha256sum] = "cbea1ca9c2f7f40a44aefd652695e8b768b7b6e6507bbc14462a745a530603cb"
RPROVIDES:glibc-langpack-bn:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bo-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bo;unpack=0"
SRC_URI[aarch64_glibc-langpack-bo.sha256sum] = "f89fcaa48983ec9a571801d1a0d87406477914bc3df9d96508b4a415419f5691"
RPROVIDES:glibc-langpack-bo:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-br-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-br;unpack=0"
SRC_URI[aarch64_glibc-langpack-br.sha256sum] = "dc8e535fe76d4208e693fa6a10bac698c25bf2b247620a16de491f302790e949"
RPROVIDES:glibc-langpack-br:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-brx-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-brx;unpack=0"
SRC_URI[aarch64_glibc-langpack-brx.sha256sum] = "8ef45e8daf786143931c05e08a65165f543489f187c212c023de8b9ad07d95ee"
RPROVIDES:glibc-langpack-brx:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bs-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bs;unpack=0"
SRC_URI[aarch64_glibc-langpack-bs.sha256sum] = "eec85539a87a0d1e2359c0de8f8ebc1d236acc596659d429c5bbaba4eba75211"
RPROVIDES:glibc-langpack-bs:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-byn-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-byn;unpack=0"
SRC_URI[aarch64_glibc-langpack-byn.sha256sum] = "260bf356e08ad1c4d83c8eebee6be01095aecae832441d46092b6529a3a062e8"
RPROVIDES:glibc-langpack-byn:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ca-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ca;unpack=0"
SRC_URI[aarch64_glibc-langpack-ca.sha256sum] = "0ebac0e8d8261ba8df58a1a1dfa2ce7ca1d0009b02ee8f19ed68e3379310d8f9"
RPROVIDES:glibc-langpack-ca:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ce-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ce;unpack=0"
SRC_URI[aarch64_glibc-langpack-ce.sha256sum] = "0be89629733dcbd4e885881bfbe5055543ae86e19d2db75cf8d122db0ac4591a"
RPROVIDES:glibc-langpack-ce:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-chr-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-chr;unpack=0"
SRC_URI[aarch64_glibc-langpack-chr.sha256sum] = "858990bc50f151a75c08c51dc5adef62fcf62ce6d1ccd155403d499c7c0b65d3"
RPROVIDES:glibc-langpack-chr:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ckb-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ckb;unpack=0"
SRC_URI[aarch64_glibc-langpack-ckb.sha256sum] = "d4a4942014b0b5ae712cfb6d193c30a4465b4c168937e073235cbfb048b7ac5a"
RPROVIDES:glibc-langpack-ckb:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cmn-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cmn;unpack=0"
SRC_URI[aarch64_glibc-langpack-cmn.sha256sum] = "440188ec25bcab28740921aa82f88f9c0c1153bc36f33dcc332c5fa9f41e25c7"
RPROVIDES:glibc-langpack-cmn:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-crh-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-crh;unpack=0"
SRC_URI[aarch64_glibc-langpack-crh.sha256sum] = "1eb64631b3c772f46568d1d26adea83e1830f985a25b570bfc210a3b3641cf2e"
RPROVIDES:glibc-langpack-crh:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cs-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cs;unpack=0"
SRC_URI[aarch64_glibc-langpack-cs.sha256sum] = "044e12662f473f7ab232474a53fb5995d1671e5b85cf57912c509aaf98d4c675"
RPROVIDES:glibc-langpack-cs:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-csb-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-csb;unpack=0"
SRC_URI[aarch64_glibc-langpack-csb.sha256sum] = "0a534f53977a88b782298430bac1672796f3e0b23ae1c4a57c1418e0000e9b22"
RPROVIDES:glibc-langpack-csb:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cv-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cv;unpack=0"
SRC_URI[aarch64_glibc-langpack-cv.sha256sum] = "3d6c80491a37bdfba31eca2e4b4aff6103148ef942d5c9cfc48b8effa1ea5abb"
RPROVIDES:glibc-langpack-cv:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cy-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cy;unpack=0"
SRC_URI[aarch64_glibc-langpack-cy.sha256sum] = "e5aa9d6719f40a2ee9c8f3601f477d2b9c744ef6810b28ecfe7daf3097009149"
RPROVIDES:glibc-langpack-cy:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-da-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-da;unpack=0"
SRC_URI[aarch64_glibc-langpack-da.sha256sum] = "ab02283c8a6ed5c0ff0376f7ea52fe91fd80f315578777a01378fa40e4765108"
RPROVIDES:glibc-langpack-da:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-de-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-de;unpack=0"
SRC_URI[aarch64_glibc-langpack-de.sha256sum] = "76aa27163411be15df7c727b1dfc7deee1c75f07f2de17b9e72a07171ab31184"
RPROVIDES:glibc-langpack-de:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-doi-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-doi;unpack=0"
SRC_URI[aarch64_glibc-langpack-doi.sha256sum] = "93a62533b20e404d664138eb0ec344420440d660909093eae9d47fb82a98f85e"
RPROVIDES:glibc-langpack-doi:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dsb-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dsb;unpack=0"
SRC_URI[aarch64_glibc-langpack-dsb.sha256sum] = "ce8266c3add7547cf5f96a45d15cab72a2f41dd9acec280071161f98ea1fb9c4"
RPROVIDES:glibc-langpack-dsb:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dv-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dv;unpack=0"
SRC_URI[aarch64_glibc-langpack-dv.sha256sum] = "d7c61d29f6fc325537946293031782fc2d8054474dd45b9f251052baeaf4c786"
RPROVIDES:glibc-langpack-dv:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dz-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dz;unpack=0"
SRC_URI[aarch64_glibc-langpack-dz.sha256sum] = "1180315169b21d0744d5c22d61c37da8a90545722625a3249e4fd3e180d1b76e"
RPROVIDES:glibc-langpack-dz:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-el-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-el;unpack=0"
SRC_URI[aarch64_glibc-langpack-el.sha256sum] = "e528db9aaa281cf08850be3377208f774b3110be1998c223c8d8ce309d16595d"
RPROVIDES:glibc-langpack-el:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-en-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-en;unpack=0"
SRC_URI[aarch64_glibc-langpack-en.sha256sum] = "7e2731521c38ebcd95f6f6d6e711942896f14a3ddb2a41a79986872882d21291"
RPROVIDES:glibc-langpack-en:append:aarch64 = " virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-eo-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-eo;unpack=0"
SRC_URI[aarch64_glibc-langpack-eo.sha256sum] = "6714d256dda6aa6bce58f0153a60c6c4a038335986305fa75c2e2c94cc2eb42a"
RPROVIDES:glibc-langpack-eo:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-es-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-es;unpack=0"
SRC_URI[aarch64_glibc-langpack-es.sha256sum] = "ee3784ab1dea18e84352c39fede9e6084ef80a9d91e85aeca578b19406ceb8c3"
RPROVIDES:glibc-langpack-es:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-et-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-et;unpack=0"
SRC_URI[aarch64_glibc-langpack-et.sha256sum] = "8f145b66aa8ec43032484176790aa80e5a5919c063bf384b426feebb2b191e2c"
RPROVIDES:glibc-langpack-et:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-eu-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-eu;unpack=0"
SRC_URI[aarch64_glibc-langpack-eu.sha256sum] = "486211b4b198bd7b45c4a033f52ffa4b2b1a97cc9174831cab24124113685c26"
RPROVIDES:glibc-langpack-eu:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fa-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fa;unpack=0"
SRC_URI[aarch64_glibc-langpack-fa.sha256sum] = "34b64e56db7af15ebc2df3bdbb3aa5f2995ab1a25b1ed17192f68ddda4a537d0"
RPROVIDES:glibc-langpack-fa:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ff-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ff;unpack=0"
SRC_URI[aarch64_glibc-langpack-ff.sha256sum] = "72fcf39cbb54efa0619916b1f1506f217752b897c99b2be80544feb74cc1e7e6"
RPROVIDES:glibc-langpack-ff:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fi-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fi;unpack=0"
SRC_URI[aarch64_glibc-langpack-fi.sha256sum] = "f1aa683aebe259411ffd8d189b7c9dd4eb0df8ae2ec57b399f43c3927c3a00aa"
RPROVIDES:glibc-langpack-fi:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fil-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fil;unpack=0"
SRC_URI[aarch64_glibc-langpack-fil.sha256sum] = "cd6d2404814082b489364c628a7089bdcf17cddf4fd23ce96333a720912a1f8c"
RPROVIDES:glibc-langpack-fil:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fo-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fo;unpack=0"
SRC_URI[aarch64_glibc-langpack-fo.sha256sum] = "33fd954a4dbc8b841ba1bf56540601e5d0a00003b977167769e53452abc8db66"
RPROVIDES:glibc-langpack-fo:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fr-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fr;unpack=0"
SRC_URI[aarch64_glibc-langpack-fr.sha256sum] = "66f10c3b49058075f4e6ba7fa34f0b986fd8f460a102280949e3cdea80163701"
RPROVIDES:glibc-langpack-fr:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fur-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fur;unpack=0"
SRC_URI[aarch64_glibc-langpack-fur.sha256sum] = "fc761fb439e35600dd0b400e74fbae8d25872dc8a2163b063fa81b07dcd9a57f"
RPROVIDES:glibc-langpack-fur:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fy-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fy;unpack=0"
SRC_URI[aarch64_glibc-langpack-fy.sha256sum] = "c34943f5b7d77bf9e5a32eb1597fb88596c5cc1d7a91c253ad9e7b3de9473497"
RPROVIDES:glibc-langpack-fy:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ga-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ga;unpack=0"
SRC_URI[aarch64_glibc-langpack-ga.sha256sum] = "ffe7424e148705def91fc370bd0d7738a41c753e278a80833d9f56b9022439f2"
RPROVIDES:glibc-langpack-ga:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gbm-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gbm;unpack=0"
SRC_URI[aarch64_glibc-langpack-gbm.sha256sum] = "654be3fed2bac5cb0f3d9f90eb9f34fa4604395f9baeaf743608393f2cde22ba"
RPROVIDES:glibc-langpack-gbm:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gd-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gd;unpack=0"
SRC_URI[aarch64_glibc-langpack-gd.sha256sum] = "7eecaf01947e99e37e08efd61fde7f3576a626dfce0467d3dafec24b195dd289"
RPROVIDES:glibc-langpack-gd:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gez-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gez;unpack=0"
SRC_URI[aarch64_glibc-langpack-gez.sha256sum] = "2a27b24775698c6e3890eece13123dee320931253133ad8103a5c9d0f0059c79"
RPROVIDES:glibc-langpack-gez:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gl-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gl;unpack=0"
SRC_URI[aarch64_glibc-langpack-gl.sha256sum] = "562147b5dd714e630f16f3ad1d60da97480deee1686ce9235cc4a24bee01875c"
RPROVIDES:glibc-langpack-gl:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gu-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gu;unpack=0"
SRC_URI[aarch64_glibc-langpack-gu.sha256sum] = "23270151b3a9172b06416c0cfb256c79364e98f9f8af4e64f18df24d4fcd97a0"
RPROVIDES:glibc-langpack-gu:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gv-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gv;unpack=0"
SRC_URI[aarch64_glibc-langpack-gv.sha256sum] = "b8b9b3e74d358ab3442ebba7d46393f6e7aff85da8ebdb5ecfb86fe0fd43914c"
RPROVIDES:glibc-langpack-gv:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ha-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ha;unpack=0"
SRC_URI[aarch64_glibc-langpack-ha.sha256sum] = "30925fb970215c53095ef9ea32587bdacd575943396ac85adfc6dcaea781ba89"
RPROVIDES:glibc-langpack-ha:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hak-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hak;unpack=0"
SRC_URI[aarch64_glibc-langpack-hak.sha256sum] = "8ed3553c58ae362b14c855d5e4bedf3d83f363439c028864d07493c2acfe563c"
RPROVIDES:glibc-langpack-hak:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-he-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-he;unpack=0"
SRC_URI[aarch64_glibc-langpack-he.sha256sum] = "eeb492bf39fe53656d5c40018a883d767129552e03a9c66c819add0da75c2004"
RPROVIDES:glibc-langpack-he:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hi-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hi;unpack=0"
SRC_URI[aarch64_glibc-langpack-hi.sha256sum] = "aa65eeb779cd032b4a6de4069909841266f630e519a698831c1bbe2caa401aa0"
RPROVIDES:glibc-langpack-hi:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hif-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hif;unpack=0"
SRC_URI[aarch64_glibc-langpack-hif.sha256sum] = "e76fe4974a9c2cbdc3035e2affe6cddfefaf20020412528c7feb235a6ec80041"
RPROVIDES:glibc-langpack-hif:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hne-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hne;unpack=0"
SRC_URI[aarch64_glibc-langpack-hne.sha256sum] = "baa3b5e1293101550a57b223278b5ad40c784471b91dbef2b76cd3c3e4e43394"
RPROVIDES:glibc-langpack-hne:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hr-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hr;unpack=0"
SRC_URI[aarch64_glibc-langpack-hr.sha256sum] = "5432d9a27a1075dbc2c829798caf4f002dfb4898d4e506f17ac38f2e499aef19"
RPROVIDES:glibc-langpack-hr:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hsb-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hsb;unpack=0"
SRC_URI[aarch64_glibc-langpack-hsb.sha256sum] = "99243aab357c8b078610480ec826782380fec7f1264d370c72bf91994892bb82"
RPROVIDES:glibc-langpack-hsb:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ht-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ht;unpack=0"
SRC_URI[aarch64_glibc-langpack-ht.sha256sum] = "a4e54ecab88ce7a3c7b396c167e9e9a4a8e021d93108806c17c89e4a85f8d144"
RPROVIDES:glibc-langpack-ht:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hu-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hu;unpack=0"
SRC_URI[aarch64_glibc-langpack-hu.sha256sum] = "93028e5eaee33b17cfb9fece691f64737ae0c747eed6a17b8761803de7aa2e98"
RPROVIDES:glibc-langpack-hu:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hy-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hy;unpack=0"
SRC_URI[aarch64_glibc-langpack-hy.sha256sum] = "7c01d0fb75644750f9ab7e1afb743bd38f64a6879e7724c9ef3178fddce9a9c9"
RPROVIDES:glibc-langpack-hy:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ia-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ia;unpack=0"
SRC_URI[aarch64_glibc-langpack-ia.sha256sum] = "92191f103b12a82e0241bf9745588f853ffe330953bdc9e3412d9d6f6da12b93"
RPROVIDES:glibc-langpack-ia:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-id-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-id;unpack=0"
SRC_URI[aarch64_glibc-langpack-id.sha256sum] = "0bac84abe79f845e772d2062fcf95b99109a55fb6a3c05df65f0e65e8647a5d6"
RPROVIDES:glibc-langpack-id:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ig-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ig;unpack=0"
SRC_URI[aarch64_glibc-langpack-ig.sha256sum] = "90fa93c6439f7f0701502ff34ed07548c26825a0049d9d201268f4dbba8c4aec"
RPROVIDES:glibc-langpack-ig:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ik-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ik;unpack=0"
SRC_URI[aarch64_glibc-langpack-ik.sha256sum] = "3d8a5290cd1770e5544e3633983a0ab5a8f7b18f5e01026dc57ec16ae20fa9ee"
RPROVIDES:glibc-langpack-ik:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-is-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-is;unpack=0"
SRC_URI[aarch64_glibc-langpack-is.sha256sum] = "bc45b48812f7c6d52ba9e2d7cc833a20d3e42ada4802cebd00e5a83fc26ded46"
RPROVIDES:glibc-langpack-is:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-it-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-it;unpack=0"
SRC_URI[aarch64_glibc-langpack-it.sha256sum] = "66bec0aadc5aabd13d45f904473380bb263fe9087c4812ffd9a8f8916a269368"
RPROVIDES:glibc-langpack-it:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-iu-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-iu;unpack=0"
SRC_URI[aarch64_glibc-langpack-iu.sha256sum] = "31d27737bed0ca6a4c72d3e1b6153dcf0e66ede8a23f698847a836ab895ecaa0"
RPROVIDES:glibc-langpack-iu:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ja-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ja;unpack=0"
SRC_URI[aarch64_glibc-langpack-ja.sha256sum] = "db65b36b621c45326e6f1512dc239887637fee5d1f349f8b97e830de741fd2be"
RPROVIDES:glibc-langpack-ja:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ka-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ka;unpack=0"
SRC_URI[aarch64_glibc-langpack-ka.sha256sum] = "17d1a0ee6640e42c6f6c62c67e32c4abe56619df6f69187e967d91704228d204"
RPROVIDES:glibc-langpack-ka:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kab-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kab;unpack=0"
SRC_URI[aarch64_glibc-langpack-kab.sha256sum] = "7cdcd1db8912d3ed278f5de59fbbbb064519d0ae28b8df0071a0124cb74a2e3e"
RPROVIDES:glibc-langpack-kab:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kk-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kk;unpack=0"
SRC_URI[aarch64_glibc-langpack-kk.sha256sum] = "f618e776be391fbc44bb6c714866dba935d7105f81fbb146988698a11cc63aa8"
RPROVIDES:glibc-langpack-kk:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kl-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kl;unpack=0"
SRC_URI[aarch64_glibc-langpack-kl.sha256sum] = "f391d7962679b0b64b03cdcb7fd1140e1113fda505b7d32cdbced428624375f8"
RPROVIDES:glibc-langpack-kl:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-km-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-km;unpack=0"
SRC_URI[aarch64_glibc-langpack-km.sha256sum] = "0e2e58748b7ab9efc5a65c6ff414b554ec57751746d82c60877fead1a5d22106"
RPROVIDES:glibc-langpack-km:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kn-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kn;unpack=0"
SRC_URI[aarch64_glibc-langpack-kn.sha256sum] = "d0ecb4b4918a4168536418ae02b8225f69c6f57dfc247047e6b43eae20b6ea1d"
RPROVIDES:glibc-langpack-kn:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ko-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ko;unpack=0"
SRC_URI[aarch64_glibc-langpack-ko.sha256sum] = "f36766cc5be86701f0acc39c3736ab3975326e81d7b9c3a9655cc01e265d3714"
RPROVIDES:glibc-langpack-ko:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kok-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kok;unpack=0"
SRC_URI[aarch64_glibc-langpack-kok.sha256sum] = "8e07adf544dc4c8e3865428ddbbb296b035ed4858ceff31afc5a90e5b448ecb8"
RPROVIDES:glibc-langpack-kok:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ks-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ks;unpack=0"
SRC_URI[aarch64_glibc-langpack-ks.sha256sum] = "dc30b5e176103b8c057e3cd60f075e4f40095e5c050df0eaf761eafb920bf221"
RPROVIDES:glibc-langpack-ks:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ku-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ku;unpack=0"
SRC_URI[aarch64_glibc-langpack-ku.sha256sum] = "37a38c3864da04da99eb138dc1a15282cf933c02acc4bb288bf64b0d59b193ec"
RPROVIDES:glibc-langpack-ku:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kv-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kv;unpack=0"
SRC_URI[aarch64_glibc-langpack-kv.sha256sum] = "fe7872f90be3ca8b964db11f4b9cf99e83d9406fc4e5241d44727cf1c2bacd76"
RPROVIDES:glibc-langpack-kv:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kw-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kw;unpack=0"
SRC_URI[aarch64_glibc-langpack-kw.sha256sum] = "e3c12d6f0958f1bfe267d0ad6f4999a5ac8c1e8df542321044a324a702fbec4e"
RPROVIDES:glibc-langpack-kw:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ky-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ky;unpack=0"
SRC_URI[aarch64_glibc-langpack-ky.sha256sum] = "fda889cc2f1577688f9e54944b777b5b5c551e3b90a90ffd8427cac31e099fed"
RPROVIDES:glibc-langpack-ky:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lb-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lb;unpack=0"
SRC_URI[aarch64_glibc-langpack-lb.sha256sum] = "aaa89893385f3e7179898db2663cf4a37c3081c2fb92b801db38430e0d9c37ec"
RPROVIDES:glibc-langpack-lb:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lg-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lg;unpack=0"
SRC_URI[aarch64_glibc-langpack-lg.sha256sum] = "b7c39d433271f867709c0717e6a290a337fc5050bde18eab9a9181acf2194dd5"
RPROVIDES:glibc-langpack-lg:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-li-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-li;unpack=0"
SRC_URI[aarch64_glibc-langpack-li.sha256sum] = "9c4c8b9069ce66b761f1a6c0bc4544976b80ad4005c455ba89bb5810f7d432d6"
RPROVIDES:glibc-langpack-li:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lij-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lij;unpack=0"
SRC_URI[aarch64_glibc-langpack-lij.sha256sum] = "f08ce6997ed2a2883d95fd178d90699e2543d801a0f6dc6947bf8f6a61ebbcf2"
RPROVIDES:glibc-langpack-lij:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ln-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ln;unpack=0"
SRC_URI[aarch64_glibc-langpack-ln.sha256sum] = "53162c89505d6966b63cb930a8572fa6af5dbb19dc241585aa7c9c4c8ff5b2d0"
RPROVIDES:glibc-langpack-ln:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lo-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lo;unpack=0"
SRC_URI[aarch64_glibc-langpack-lo.sha256sum] = "35000b190bebcbdcdec2670a96b8d9dec8d9603498b84863ce5fa68bfc068c34"
RPROVIDES:glibc-langpack-lo:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lt-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lt;unpack=0"
SRC_URI[aarch64_glibc-langpack-lt.sha256sum] = "28a0b76b329c9169497d9089a67d9272c7217b4f8b7a4a2516923898f2343a58"
RPROVIDES:glibc-langpack-lt:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lv-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lv;unpack=0"
SRC_URI[aarch64_glibc-langpack-lv.sha256sum] = "cc246e2d9aa452815d1eca6c4aafc503858491eb324b17c375c1ecd819cdca00"
RPROVIDES:glibc-langpack-lv:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lzh-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lzh;unpack=0"
SRC_URI[aarch64_glibc-langpack-lzh.sha256sum] = "0ce7d899aa13e567a93d3c587bb27ee9793fc78b37da5bccd8ba2f7785966be1"
RPROVIDES:glibc-langpack-lzh:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mag-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mag;unpack=0"
SRC_URI[aarch64_glibc-langpack-mag.sha256sum] = "a03f22549152107e79a16f752d4866448e1ab8c35f0ac56a470889cf62acb4ce"
RPROVIDES:glibc-langpack-mag:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mai-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mai;unpack=0"
SRC_URI[aarch64_glibc-langpack-mai.sha256sum] = "e1a675e8fb3d1008ce57529fee8fb8e243c0e7873253e6b6b4adf28933954dda"
RPROVIDES:glibc-langpack-mai:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mfe-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mfe;unpack=0"
SRC_URI[aarch64_glibc-langpack-mfe.sha256sum] = "16d4449c5c93a9303a5d9037e85a87068f28849ed8e97cfc27d5a98f8e72c48d"
RPROVIDES:glibc-langpack-mfe:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mg-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mg;unpack=0"
SRC_URI[aarch64_glibc-langpack-mg.sha256sum] = "37b04eb3184948b46e66dac241c4ad97ce01f8c72c677180f80c9c403fe3a35e"
RPROVIDES:glibc-langpack-mg:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mhr-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mhr;unpack=0"
SRC_URI[aarch64_glibc-langpack-mhr.sha256sum] = "ccd3594792122f79bf006e1fbfef05803680f805cbce0bf672cdbb040593034a"
RPROVIDES:glibc-langpack-mhr:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mi-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mi;unpack=0"
SRC_URI[aarch64_glibc-langpack-mi.sha256sum] = "0dc6fc0a8dd1be50a0c925005d85dabafb3020ef68928ce25f4e9b3696ec3b2a"
RPROVIDES:glibc-langpack-mi:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-miq-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-miq;unpack=0"
SRC_URI[aarch64_glibc-langpack-miq.sha256sum] = "da74a77c27a4315c9f8c5cfd179b14a043b2d083be1a1928a970ef359705f163"
RPROVIDES:glibc-langpack-miq:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mjw-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mjw;unpack=0"
SRC_URI[aarch64_glibc-langpack-mjw.sha256sum] = "eb8a88fceac1a24f1f600bb64ba271b3ca6bf137af3ca05d484dbf569a5c2a8d"
RPROVIDES:glibc-langpack-mjw:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mk-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mk;unpack=0"
SRC_URI[aarch64_glibc-langpack-mk.sha256sum] = "427ed469a958bc427f0aab7927dae7c2293b04767712fa3b97a207381220eada"
RPROVIDES:glibc-langpack-mk:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ml-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ml;unpack=0"
SRC_URI[aarch64_glibc-langpack-ml.sha256sum] = "9a33e69a3d792b5b05cd445c09a13be0839ce9187b3c9badce441d4f5add74f5"
RPROVIDES:glibc-langpack-ml:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mn-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mn;unpack=0"
SRC_URI[aarch64_glibc-langpack-mn.sha256sum] = "1788894c798d157eda0d1df5669b76d6d09e8574f95cfcbeac84014509fd1511"
RPROVIDES:glibc-langpack-mn:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mni-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mni;unpack=0"
SRC_URI[aarch64_glibc-langpack-mni.sha256sum] = "5a5d862a993e22ab7929387b2340a6391f64d494d48e72fd404edeb230d83dff"
RPROVIDES:glibc-langpack-mni:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mnw-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mnw;unpack=0"
SRC_URI[aarch64_glibc-langpack-mnw.sha256sum] = "92de5571b69dbff0d062da2ebe29461777f561851c7436af1d08055d715f74bd"
RPROVIDES:glibc-langpack-mnw:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mr-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mr;unpack=0"
SRC_URI[aarch64_glibc-langpack-mr.sha256sum] = "1ff4916b73a77f0f07dfd14c7c126627e3231c8d445981f9f2a1a2e64ccfda3e"
RPROVIDES:glibc-langpack-mr:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ms-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ms;unpack=0"
SRC_URI[aarch64_glibc-langpack-ms.sha256sum] = "8132406639564f04940ccc654f2de8622083aa016fed69d8950fd5f0fce888a2"
RPROVIDES:glibc-langpack-ms:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mt-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mt;unpack=0"
SRC_URI[aarch64_glibc-langpack-mt.sha256sum] = "df6a991f87f126aed0a7fca5a56a0ffb5f3e7f594bb5240803a6a12af4ba5baa"
RPROVIDES:glibc-langpack-mt:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-my-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-my;unpack=0"
SRC_URI[aarch64_glibc-langpack-my.sha256sum] = "79df06de57acaaddf68c04a1440de4b815a36747e2602a77d9293ccbb61235b6"
RPROVIDES:glibc-langpack-my:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nan-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nan;unpack=0"
SRC_URI[aarch64_glibc-langpack-nan.sha256sum] = "536bdc148b325ae9467c8e61b20673ba0d98062d6371db8ec1dfd946768e6a37"
RPROVIDES:glibc-langpack-nan:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nb-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nb;unpack=0"
SRC_URI[aarch64_glibc-langpack-nb.sha256sum] = "b39608a4dde77b6e103bd82750ba17e41064a3b3666c938dd8dc75392ad91e51"
RPROVIDES:glibc-langpack-nb:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nds-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nds;unpack=0"
SRC_URI[aarch64_glibc-langpack-nds.sha256sum] = "becf02056fc71871d197911f0c346de18d1bacde57eb02fa05d42402cb8616fe"
RPROVIDES:glibc-langpack-nds:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ne-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ne;unpack=0"
SRC_URI[aarch64_glibc-langpack-ne.sha256sum] = "386f16020e345d0fd4618cbc9d003789d1de1f328280eb04294217986bd3214d"
RPROVIDES:glibc-langpack-ne:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nhn-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nhn;unpack=0"
SRC_URI[aarch64_glibc-langpack-nhn.sha256sum] = "0a15d960577aa6ea4bccb5b778dcc073032ea310cc24ccd44f7057dcc0086b5c"
RPROVIDES:glibc-langpack-nhn:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-niu-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-niu;unpack=0"
SRC_URI[aarch64_glibc-langpack-niu.sha256sum] = "fa8f9265a6573ba814506f39fca5e4bf7557cfae787e131af1d22ef86bc9839e"
RPROVIDES:glibc-langpack-niu:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nl-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nl;unpack=0"
SRC_URI[aarch64_glibc-langpack-nl.sha256sum] = "e27ae6f34107750b5199829c805378b4ec21e14edfbbd65959032de48718e6c2"
RPROVIDES:glibc-langpack-nl:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nn-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nn;unpack=0"
SRC_URI[aarch64_glibc-langpack-nn.sha256sum] = "a80aa792c975d4dd999aa8368a4573df5458fc6721c29c8d8885066d41af16d6"
RPROVIDES:glibc-langpack-nn:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nr-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nr;unpack=0"
SRC_URI[aarch64_glibc-langpack-nr.sha256sum] = "f11f88117057934a19847738e4d69c92b921d6d294d1d3994948c86135fe8c5c"
RPROVIDES:glibc-langpack-nr:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nso-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nso;unpack=0"
SRC_URI[aarch64_glibc-langpack-nso.sha256sum] = "8a18e89bd440036ca177ea3a7eca800c9b149330eace6b81136f254306a4b1da"
RPROVIDES:glibc-langpack-nso:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-oc-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-oc;unpack=0"
SRC_URI[aarch64_glibc-langpack-oc.sha256sum] = "3e673ef4659200435825f596dc6412db01f82ec1b1e98ea39dc3d62d49670f64"
RPROVIDES:glibc-langpack-oc:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-om-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-om;unpack=0"
SRC_URI[aarch64_glibc-langpack-om.sha256sum] = "ad26fa9ae4c29fdc8789f3ae28ef3168f9c20a721cf4d6d1b264b10362baaff8"
RPROVIDES:glibc-langpack-om:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-or-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-or;unpack=0"
SRC_URI[aarch64_glibc-langpack-or.sha256sum] = "474daf5ae585e576a1890859845d540e1ff53a83355c19f080b8793fa68e914a"
RPROVIDES:glibc-langpack-or:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-os-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-os;unpack=0"
SRC_URI[aarch64_glibc-langpack-os.sha256sum] = "377f07503a3cb6b904fad167efa6c34c6e9113599d00254384e69cd67be7011e"
RPROVIDES:glibc-langpack-os:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pa-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pa;unpack=0"
SRC_URI[aarch64_glibc-langpack-pa.sha256sum] = "2c6a6b4bb30b3fe5b6e33cf4c94ba186e69b34a8b3f917f9c9ac937123d1da02"
RPROVIDES:glibc-langpack-pa:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pap-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pap;unpack=0"
SRC_URI[aarch64_glibc-langpack-pap.sha256sum] = "0e1c92383a3997c594d1b7b1af57e00b3712219225eb46e22d87ffa19f496de6"
RPROVIDES:glibc-langpack-pap:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pl-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pl;unpack=0"
SRC_URI[aarch64_glibc-langpack-pl.sha256sum] = "dd1b82cd307feb1778777c2fd2427d7cd8f0f6aea976bbdb7f1c988a66efb260"
RPROVIDES:glibc-langpack-pl:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ps-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ps;unpack=0"
SRC_URI[aarch64_glibc-langpack-ps.sha256sum] = "1927e18c71cf21e5055dc6ff4953d63a08cfa93a06002ad06ec4216c2db87a36"
RPROVIDES:glibc-langpack-ps:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pt-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pt;unpack=0"
SRC_URI[aarch64_glibc-langpack-pt.sha256sum] = "155cd295275ac1a0823fdb461c71238c520f05f738c8d9289ce3bb3fde09f11c"
RPROVIDES:glibc-langpack-pt:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-quz-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-quz;unpack=0"
SRC_URI[aarch64_glibc-langpack-quz.sha256sum] = "de435f53a180f95c676427353fd2a5ebc05cd9271eeb3235e71061515320b139"
RPROVIDES:glibc-langpack-quz:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-raj-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-raj;unpack=0"
SRC_URI[aarch64_glibc-langpack-raj.sha256sum] = "2570fccbc4eac3567a36d69f81a8a413495963769cf28855e47422bff19afd1a"
RPROVIDES:glibc-langpack-raj:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-rif-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-rif;unpack=0"
SRC_URI[aarch64_glibc-langpack-rif.sha256sum] = "b04fcb999e2f733be43fe07ebd793d20d65da2e499beb00d0f00f947830a79b0"
RPROVIDES:glibc-langpack-rif:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ro-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ro;unpack=0"
SRC_URI[aarch64_glibc-langpack-ro.sha256sum] = "dc096d8666bc792539ea7751514aea4f9447fd7e922a1f4dff65e975be47e24c"
RPROVIDES:glibc-langpack-ro:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ru-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ru;unpack=0"
SRC_URI[aarch64_glibc-langpack-ru.sha256sum] = "8c087ba2fddc35e2a6f79537bdbfb065c0bae19cadf26e727d04dfc302c6f685"
RPROVIDES:glibc-langpack-ru:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-rw-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-rw;unpack=0"
SRC_URI[aarch64_glibc-langpack-rw.sha256sum] = "8cfa6b2aa3c710cdc721156551cd8a35722c049618ad3a404615d6fd8cc837c6"
RPROVIDES:glibc-langpack-rw:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sa-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sa;unpack=0"
SRC_URI[aarch64_glibc-langpack-sa.sha256sum] = "0bb9d4c6ec623a88261803438c1596e69abea4374a8f759691bf55e6725f12a7"
RPROVIDES:glibc-langpack-sa:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sah-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sah;unpack=0"
SRC_URI[aarch64_glibc-langpack-sah.sha256sum] = "21b5d0156e793b6df8f68bfbce59719de4a92d7ddd0b0207f71ff1f2bcab6902"
RPROVIDES:glibc-langpack-sah:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sat-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sat;unpack=0"
SRC_URI[aarch64_glibc-langpack-sat.sha256sum] = "ea7b128a735c23d5ed6a705090cf9deea908d9b01b04b6c3e43cd53b047e84e4"
RPROVIDES:glibc-langpack-sat:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sc-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sc;unpack=0"
SRC_URI[aarch64_glibc-langpack-sc.sha256sum] = "29a3188f4549ddfd366b47a01cfa9fec06e8f269769d5bc6662e3f2189434afc"
RPROVIDES:glibc-langpack-sc:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sd-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sd;unpack=0"
SRC_URI[aarch64_glibc-langpack-sd.sha256sum] = "c5f6cea6e99470af55e98e6c97c2a8cab69e0e8e009cfe3e8c643fe8b2f6c464"
RPROVIDES:glibc-langpack-sd:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-se-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-se;unpack=0"
SRC_URI[aarch64_glibc-langpack-se.sha256sum] = "d9301852e83deb2017765f201eec67ec88f9bfa0b5a775299173901173f98e3b"
RPROVIDES:glibc-langpack-se:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sgs-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sgs;unpack=0"
SRC_URI[aarch64_glibc-langpack-sgs.sha256sum] = "8047e99ed0a22d5b83b9c4cfdb07dd330fca4316212c9ed0a7252086b1fdd700"
RPROVIDES:glibc-langpack-sgs:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-shn-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-shn;unpack=0"
SRC_URI[aarch64_glibc-langpack-shn.sha256sum] = "3ef9bb14d545e437acb15e22b7e162ac5fd73ef96957a8f736fa17b18007340f"
RPROVIDES:glibc-langpack-shn:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-shs-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-shs;unpack=0"
SRC_URI[aarch64_glibc-langpack-shs.sha256sum] = "13f306b7b01ab84e8b8559aacb30c7b283b4c2f765e8391c3111665312ad0fed"
RPROVIDES:glibc-langpack-shs:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-si-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-si;unpack=0"
SRC_URI[aarch64_glibc-langpack-si.sha256sum] = "635e0393ca73afc6861c47efd3b6c96445f431b39fb6784463016225dca28008"
RPROVIDES:glibc-langpack-si:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sid-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sid;unpack=0"
SRC_URI[aarch64_glibc-langpack-sid.sha256sum] = "99c9543fab724568c8569501ac4b18260f84e6f45e7faa8b06eb880a8a89c383"
RPROVIDES:glibc-langpack-sid:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sk-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sk;unpack=0"
SRC_URI[aarch64_glibc-langpack-sk.sha256sum] = "7653fd69d92ead356d02bdffecc31ba643a6c7b004e781b71befd39d1f3ce7d7"
RPROVIDES:glibc-langpack-sk:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sl-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sl;unpack=0"
SRC_URI[aarch64_glibc-langpack-sl.sha256sum] = "a3ea0e9a22fa479ae2d3d80b881941a70cdb4f6792df75b49fe7857d622de39f"
RPROVIDES:glibc-langpack-sl:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sm-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sm;unpack=0"
SRC_URI[aarch64_glibc-langpack-sm.sha256sum] = "312ae8d8bee00f3ffbc9ce9bddcfc3f37a8735df135dd5af37e6a458c144f31c"
RPROVIDES:glibc-langpack-sm:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-so-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-so;unpack=0"
SRC_URI[aarch64_glibc-langpack-so.sha256sum] = "bc75f2b047ac081d35fd7d9fa40bf650618aa3609dfd1948a4870b3ba020e9f8"
RPROVIDES:glibc-langpack-so:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sq-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sq;unpack=0"
SRC_URI[aarch64_glibc-langpack-sq.sha256sum] = "e30cd80c89bde39c86bbac396c9e17d01886f758bf5ec31197b3309a65db259c"
RPROVIDES:glibc-langpack-sq:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sr-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sr;unpack=0"
SRC_URI[aarch64_glibc-langpack-sr.sha256sum] = "025273ed1b63157b5a5e28bd7533fbb99b279eb24a3b9855083d5221708c94ea"
RPROVIDES:glibc-langpack-sr:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ss-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ss;unpack=0"
SRC_URI[aarch64_glibc-langpack-ss.sha256sum] = "4f9854fd67336259431b27d281b2b7e767fb5af964f52bc98d26b4d9de542810"
RPROVIDES:glibc-langpack-ss:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ssy-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ssy;unpack=0"
SRC_URI[aarch64_glibc-langpack-ssy.sha256sum] = "bd01bf9b72b6f60fbea4a57f64c183e1d764c91f7410ce907169543f2569344b"
RPROVIDES:glibc-langpack-ssy:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-st-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-st;unpack=0"
SRC_URI[aarch64_glibc-langpack-st.sha256sum] = "eecc23ae3d6303e9aa7e49ce68cacd7528dba3560820e952dc99f8ff9871e9d1"
RPROVIDES:glibc-langpack-st:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-su-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-su;unpack=0"
SRC_URI[aarch64_glibc-langpack-su.sha256sum] = "47ba9a9a68799f2f2626e1f276f717b6f4c6397f49d730a853d4bce9179d58c4"
RPROVIDES:glibc-langpack-su:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sv-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sv;unpack=0"
SRC_URI[aarch64_glibc-langpack-sv.sha256sum] = "aea088ec4e5585e5c1d10dac322c39db3862918795cfd86892073485f74bc674"
RPROVIDES:glibc-langpack-sv:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sw-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sw;unpack=0"
SRC_URI[aarch64_glibc-langpack-sw.sha256sum] = "5e9765072465d0301081d90aebe7bd9127c28205867fbc2041ddd4f55967559c"
RPROVIDES:glibc-langpack-sw:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-syr-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-syr;unpack=0"
SRC_URI[aarch64_glibc-langpack-syr.sha256sum] = "a61c396e1b59343c137fee7af3669f1cf2ca7ea718b3be9f7667e0f71a8c3a92"
RPROVIDES:glibc-langpack-syr:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-szl-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-szl;unpack=0"
SRC_URI[aarch64_glibc-langpack-szl.sha256sum] = "d1c7efc8822e20abf1167e13ed4ebc9e34d8b11c13db7a523cd89584d27d4b8a"
RPROVIDES:glibc-langpack-szl:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ta-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ta;unpack=0"
SRC_URI[aarch64_glibc-langpack-ta.sha256sum] = "0b5fa2e622c65212f29c2795ea6e1f461af5617bec21389f26025dfb3c516029"
RPROVIDES:glibc-langpack-ta:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tcy-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tcy;unpack=0"
SRC_URI[aarch64_glibc-langpack-tcy.sha256sum] = "ee4c5066e6a78dd44dc412dbd36ebf6d52b05334b1f62d07eb507101354fbc25"
RPROVIDES:glibc-langpack-tcy:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-te-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-te;unpack=0"
SRC_URI[aarch64_glibc-langpack-te.sha256sum] = "cea6331475c72cb2d74f5dcfd90656b5c5f1b8763593458d0b7feeaa96a9e92c"
RPROVIDES:glibc-langpack-te:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tg-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tg;unpack=0"
SRC_URI[aarch64_glibc-langpack-tg.sha256sum] = "32173d7e9fd2585fa4c262a6cc4ea3df27519379df5cecd0950df52b5b430f90"
RPROVIDES:glibc-langpack-tg:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-th-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-th;unpack=0"
SRC_URI[aarch64_glibc-langpack-th.sha256sum] = "735c079d3126bfbb7a419e9b628d1455a715cb73be953cec60dc6c09658280e6"
RPROVIDES:glibc-langpack-th:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-the-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-the;unpack=0"
SRC_URI[aarch64_glibc-langpack-the.sha256sum] = "10cebce4fffc8ccb2328a5d7099f101bf7a4b0d5f27f8f32f68cf0041358c07a"
RPROVIDES:glibc-langpack-the:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ti-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ti;unpack=0"
SRC_URI[aarch64_glibc-langpack-ti.sha256sum] = "e61121659f763e58e358118ebae110d1181d8a5c77ba4040fb28d416efbc742c"
RPROVIDES:glibc-langpack-ti:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tig-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tig;unpack=0"
SRC_URI[aarch64_glibc-langpack-tig.sha256sum] = "359ebb5cd02cc0de25a4e1e0f718f8d430ec349ef7e30e7cc8f00e0b74ba796b"
RPROVIDES:glibc-langpack-tig:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tk-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tk;unpack=0"
SRC_URI[aarch64_glibc-langpack-tk.sha256sum] = "85a02cd1f90b9e39fe3b75e7f631f30bbef19f668f8590ca430acb63d405ff35"
RPROVIDES:glibc-langpack-tk:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tl-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tl;unpack=0"
SRC_URI[aarch64_glibc-langpack-tl.sha256sum] = "88200251c2a1506e81be38ab46e8526e73c565587f4ba5b25feba7e1a3adf679"
RPROVIDES:glibc-langpack-tl:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tn-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tn;unpack=0"
SRC_URI[aarch64_glibc-langpack-tn.sha256sum] = "351e3bd53551aa411ad7641c88cde77a2058e9c83cabd92b294ab7f2f938a623"
RPROVIDES:glibc-langpack-tn:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-to-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-to;unpack=0"
SRC_URI[aarch64_glibc-langpack-to.sha256sum] = "28e916829c1ec250847bcf6452ce6202203c69cc9eb047171ac9a8bcb5bf0a16"
RPROVIDES:glibc-langpack-to:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tok-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tok;unpack=0"
SRC_URI[aarch64_glibc-langpack-tok.sha256sum] = "113e284f372e309cd0c46bac960a5af08d6f3f3eddea324de8c824a7d3ca3c2d"
RPROVIDES:glibc-langpack-tok:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tpi-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tpi;unpack=0"
SRC_URI[aarch64_glibc-langpack-tpi.sha256sum] = "7aa5ac4e75c76a88b4910b7d22c7f44573e0c51e5b0b85533183833df7912f52"
RPROVIDES:glibc-langpack-tpi:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tr-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tr;unpack=0"
SRC_URI[aarch64_glibc-langpack-tr.sha256sum] = "555661c6f2524226842ffff5d58c180e1766516b0d89cc5581e3a338dd19aee8"
RPROVIDES:glibc-langpack-tr:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ts-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ts;unpack=0"
SRC_URI[aarch64_glibc-langpack-ts.sha256sum] = "3e06e34a678619d4f17267d5441b38679b538cb1c25669cb72c78a767f02f214"
RPROVIDES:glibc-langpack-ts:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tt-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tt;unpack=0"
SRC_URI[aarch64_glibc-langpack-tt.sha256sum] = "f4e2d1f48d719a97701193efd9f41810b6ae531527990fc393d348fa20a0e34d"
RPROVIDES:glibc-langpack-tt:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ug-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ug;unpack=0"
SRC_URI[aarch64_glibc-langpack-ug.sha256sum] = "2e13ccf83168a609cd4d018976e0a8b635727b6288000d0b24b1f89fc84378df"
RPROVIDES:glibc-langpack-ug:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-uk-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-uk;unpack=0"
SRC_URI[aarch64_glibc-langpack-uk.sha256sum] = "cfa63d65f91aabf65e8dbd359d95e142d7f3c4c3bf28291f83c68a0c73187248"
RPROVIDES:glibc-langpack-uk:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-unm-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-unm;unpack=0"
SRC_URI[aarch64_glibc-langpack-unm.sha256sum] = "bf60b31f9df86edae8988b6cf021f579870bb38c3879c1a3c8ad42653f1b4c7d"
RPROVIDES:glibc-langpack-unm:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ur-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ur;unpack=0"
SRC_URI[aarch64_glibc-langpack-ur.sha256sum] = "e5e664834fa922afb1be610af48056ceeb613be00565f02feff752e40284809a"
RPROVIDES:glibc-langpack-ur:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-uz-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-uz;unpack=0"
SRC_URI[aarch64_glibc-langpack-uz.sha256sum] = "ba133293071074420ee2eadd0ee576854c4d135d82f3c114889684dbf3f692f1"
RPROVIDES:glibc-langpack-uz:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ve-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ve;unpack=0"
SRC_URI[aarch64_glibc-langpack-ve.sha256sum] = "5255a32b302d44a47cd65f7a9d372bcbc55d4b655073802d729365b659a1ebc8"
RPROVIDES:glibc-langpack-ve:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-vi-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-vi;unpack=0"
SRC_URI[aarch64_glibc-langpack-vi.sha256sum] = "c3a537340233d92f1b1fbc9791ad500d4fc78b44029780e3cb3b291a21c1f128"
RPROVIDES:glibc-langpack-vi:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wa-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wa;unpack=0"
SRC_URI[aarch64_glibc-langpack-wa.sha256sum] = "a3bacd47323d42e6fdc59d274e5e7147e6d446d22a27cefa6322a5132b21c77e"
RPROVIDES:glibc-langpack-wa:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wae-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wae;unpack=0"
SRC_URI[aarch64_glibc-langpack-wae.sha256sum] = "c13486614c2ac678865bb8c9b7f666fd48998a4665f92477b0f58f5d97f378bd"
RPROVIDES:glibc-langpack-wae:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wal-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wal;unpack=0"
SRC_URI[aarch64_glibc-langpack-wal.sha256sum] = "e208d24fcdf7e9c00d34a8b0cf65722913c8fada8d225f16ae0f8326fd7e707a"
RPROVIDES:glibc-langpack-wal:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wo-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wo;unpack=0"
SRC_URI[aarch64_glibc-langpack-wo.sha256sum] = "ec73cba4777b2e66c6c8215e706052b0c87dcd6f835b9d1bea13109dccf108a6"
RPROVIDES:glibc-langpack-wo:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-xh-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-xh;unpack=0"
SRC_URI[aarch64_glibc-langpack-xh.sha256sum] = "a6d2c4941620c54c45cecb87e9c963d1ab504e550cf6877aad1ec7785df9340d"
RPROVIDES:glibc-langpack-xh:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yi-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yi;unpack=0"
SRC_URI[aarch64_glibc-langpack-yi.sha256sum] = "0c454c541d9317ec6719a9a18a3bef6cd3a4402bd3a500e7aca1012152a6ae5c"
RPROVIDES:glibc-langpack-yi:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yo-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yo;unpack=0"
SRC_URI[aarch64_glibc-langpack-yo.sha256sum] = "603015749af8d2c2c46ab40546f52da01ef9689e446033fa6e7d29fd5fda3fdf"
RPROVIDES:glibc-langpack-yo:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yue-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yue;unpack=0"
SRC_URI[aarch64_glibc-langpack-yue.sha256sum] = "bc3a01614e7f0d19f66828e11c4e15e568031be5cba35cff13579a4ea5995339"
RPROVIDES:glibc-langpack-yue:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yuw-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yuw;unpack=0"
SRC_URI[aarch64_glibc-langpack-yuw.sha256sum] = "3d99b48510eef958a1f43dc0eaee101d126a3ea8b8813c915118bea9de573d36"
RPROVIDES:glibc-langpack-yuw:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zgh-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zgh;unpack=0"
SRC_URI[aarch64_glibc-langpack-zgh.sha256sum] = "a15999a5b217975ee84f5d3d52b22b5932cdb6bff35e5955a2da0bc65de2635c"
RPROVIDES:glibc-langpack-zgh:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zh-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zh;unpack=0"
SRC_URI[aarch64_glibc-langpack-zh.sha256sum] = "9bdbdf8a47fd5229fb077b07ed00bdc43a9a55c9f53c2aa7b33c01cf2fae8ac6"
RPROVIDES:glibc-langpack-zh:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zu-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zu;unpack=0"
SRC_URI[aarch64_glibc-langpack-zu.sha256sum] = "276c8486e2672e619936d85038f9875d33a5aac7ca3c071e07175c8d7c89d3e0"
RPROVIDES:glibc-langpack-zu:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-locale-source-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-locale-source;unpack=0"
SRC_URI[aarch64_glibc-locale-source.sha256sum] = "1acc223a5c4c9aba441951466002a61bf786659abde011ef72e9f068ba4d30b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-minimal-langpack-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-minimal-langpack;unpack=0"
SRC_URI[aarch64_glibc-minimal-langpack.sha256sum] = "663ea4b304f2b4155e6db3da6d84603878ae3475e52150a4e6448ded8b57d874"
RPROVIDES:glibc-minimal-langpack:append:aarch64 = " virtual/glibc-langpack_eq_2.39-141.el10.alma.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-nss-devel-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-nss-devel;unpack=0"
SRC_URI[aarch64_glibc-nss-devel.sha256sum] = "8f8b9648e311b44aae48bf2fd3f95a82f7259137f93530f5256182cfe41003cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-static-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-static;unpack=0"
SRC_URI[aarch64_glibc-static.sha256sum] = "9425baab2b64b7299b19ebe5b52f05e0521bb8de4160dd20ee73d03085e496c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-utils-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_glibc-utils;unpack=0"
SRC_URI[aarch64_glibc-utils.sha256sum] = "26afab5b6f4cfa66f976d68beb02ce60410dae892e8922ee04d7501516442af3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnsl-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_libnsl;unpack=0"
SRC_URI[aarch64_libnsl.sha256sum] = "623dc9c58743a6ced1391e47b2c54a3a558811382080471e3722628ef8ace795"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nss_db-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_nss_db;unpack=0"
SRC_URI[aarch64_nss_db.sha256sum] = "3ce39d07a0ba0e7f687995ad52b84b1be972baebdfdc0eb9e71e83605e637ce7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nss_hesiod-2.39-141.el10.alma.1.aarch64.rpm;name=aarch64_nss_hesiod;unpack=0"
SRC_URI[aarch64_nss_hesiod.sha256sum] = "09a395b2bc29c1824c162e4264a8dc964720c2853e6848d9fd1b2d63e5579f8a"

RDEPENDS:glibc = " \
 basesystem \
 glibc-common \
 glibc-gconv-extra \
 libgcc \
 virtual/glibc-langpack_eq_2.39-141.el10.alma.1 \
 "
RDEPENDS:glibc-all-langpacks = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-benchtests = " \
 bash \
 glibc \
 python3 \
 "
RDEPENDS:glibc-common = " \
 bash \
 glibc \
 "
RDEPENDS:glibc-devel = " \
 glibc \
 kernel-headers \
 libxcrypt-devel \
 "
RDEPENDS:glibc-doc = " \
 glibc \
 "
RDEPENDS:glibc-gconv-extra = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-aa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-af = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-agr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ak = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-am = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-an = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-anp = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ar = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-as = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ast = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ayc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-az = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-be = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bem = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ber = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bhb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bho = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-br = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-brx = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-byn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ca = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ce = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-chr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ckb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cmn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-crh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-csb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-da = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-de = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-doi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dsb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-el = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-en = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-eo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-es = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-et = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-eu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ff = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fil = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fur = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ga = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gbm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gd = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gez = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ha = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hak = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-he = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hif = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hne = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hsb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ht = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ia = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-id = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ig = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ik = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-is = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-it = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-iu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ja = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ka = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kab = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-km = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ko = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kok = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ks = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ku = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ky = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-li = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lij = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ln = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lzh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mag = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mai = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mfe = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mhr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-miq = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mjw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ml = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mni = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mnw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ms = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-my = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nan = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nds = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ne = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nhn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-niu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nso = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-oc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-om = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-or = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-os = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pap = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ps = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-quz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-raj = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-rif = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ro = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ru = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-rw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sah = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sat = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sd = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-se = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sgs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-shn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-shs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-si = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sid = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-so = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sq = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ss = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ssy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-st = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-su = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-syr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-szl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ta = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tcy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-te = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-th = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-the = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ti = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tig = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-to = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tok = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tpi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ts = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ug = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-uk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-unm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ur = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-uz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ve = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-vi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wae = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wal = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-xh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yue = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yuw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zgh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-locale-source = " \
 glibc \
 glibc-common \
 gzip \
 "
RDEPENDS:glibc-minimal-langpack = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-nss-devel = " \
 glibc \
 nss_db \
 nss_hesiod \
 "
RDEPENDS:glibc-static = " \
 glibc-devel \
 libxcrypt-static \
 "
RDEPENDS:glibc-utils = " \
 bash \
 gd \
 glibc \
 libpng \
 perl-interpreter \
 zlib-ng-compat \
 "
RDEPENDS:libnsl = " \
 glibc \
 "
RDEPENDS:nss_db = " \
 glibc \
 libselinux \
 "
RDEPENDS:nss_hesiod = " \
 glibc \
 "
