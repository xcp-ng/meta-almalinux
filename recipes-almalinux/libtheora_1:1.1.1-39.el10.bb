# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtheora"
PE = "1"
PV = "1.1.1"
PR = "39.el10"
PACKAGES = " \
 libtheora \
 libtheora-devel \
 theora-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libtheora-1.1.1-39.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d59c751702672463ff305f074ff5d72187e247b083ebb467b46a3a90fa9a69d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtheora-1.1.1-39.el10.x86_64_v2.rpm;name=x86_64_v2_libtheora;unpack=0"
SRC_URI[x86_64_v2_libtheora.sha256sum] = "d05a3efac62fd4a950e48afc3f63c0dbf0ef70a047ef286385ea6cb56e536c7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtheora-devel-1.1.1-39.el10.x86_64_v2.rpm;name=x86_64_v2_libtheora-devel;unpack=0"
SRC_URI[x86_64_v2_libtheora-devel.sha256sum] = "8865527d7355398bdc91cbe201a7ae487d48ac87a07843f2a02ee48cd9b371d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/theora-tools-1.1.1-39.el10.x86_64_v2.rpm;name=x86_64_v2_theora-tools;unpack=0"
SRC_URI[x86_64_v2_theora-tools.sha256sum] = "6afd3906b1032ec232630fd63965c07d97fb12b6d512a2468b7452fea1fe15ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtheora-1.1.1-39.el10.aarch64.rpm;name=aarch64_libtheora;unpack=0"
SRC_URI[aarch64_libtheora.sha256sum] = "b2601286c65edae588f477418293a4665f941b9bb92166dd79000b6004b4e0ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtheora-devel-1.1.1-39.el10.aarch64.rpm;name=aarch64_libtheora-devel;unpack=0"
SRC_URI[aarch64_libtheora-devel.sha256sum] = "d344f9ed4a7af3c82fd98cceccd0323033d7114b1a928b3f13b336f39e829e74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/theora-tools-1.1.1-39.el10.aarch64.rpm;name=aarch64_theora-tools;unpack=0"
SRC_URI[aarch64_theora-tools.sha256sum] = "5b13835a54847ec869d31356f352a332deb3f32310051dbb8d6e9fcade486115"

RDEPENDS:libtheora = " \
 glibc \
 libogg \
 "
RDEPENDS:libtheora-devel = " \
 libogg-devel \
 libtheora \
 libtheora-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:theora-tools = " \
 glibc \
 libogg \
 libpng \
 libtheora \
 libvorbis \
 sdl12-compat \
 "
