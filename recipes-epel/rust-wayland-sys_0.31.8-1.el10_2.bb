# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-sys"
PV = "0.31.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-wayland-sys+client-devel \
 rust-wayland-sys+cursor-devel \
 rust-wayland-sys+default-devel \
 rust-wayland-sys+dlopen-devel \
 rust-wayland-sys+egl-devel \
 rust-wayland-sys+libc-devel \
 rust-wayland-sys+memoffset-devel \
 rust-wayland-sys+once_cell-devel \
 rust-wayland-sys+server-devel \
 rust-wayland-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-sys-0.31.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9510e95bfe12ccbfc6f6d667db7519025f0d1859c921af31ff767c7d4612bd05"

URI_x86_64_v2_rust-wayland-sys+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+client-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+client-devel.sha256sum] = "1d05533409a7e327d1cb4d133b7f86e13f9727c2863b2dfcf59f32bc4f941a8e"

URI_x86_64_v2_rust-wayland-sys+cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+cursor-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+cursor-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+cursor-devel.sha256sum] = "0a9545cb9cd42d34c52f9f37875d9f28e80404b6ea10211885418a38e6a46946"

URI_x86_64_v2_rust-wayland-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+default-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+default-devel.sha256sum] = "7236339afd354000ad657daa4290034bb0876bd5910e8a65f470bc795769748e"

URI_x86_64_v2_rust-wayland-sys+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+dlopen-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+dlopen-devel.sha256sum] = "7d53a656a6de0430f70631cccaa4fb7452acec2f2dce972f04678d1bb57a04f8"

URI_x86_64_v2_rust-wayland-sys+egl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+egl-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+egl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+egl-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+egl-devel.sha256sum] = "ded4f0f05680452bff4ad4de48d922abb9c15e179726c92e0ca1617af8bf2288"

URI_x86_64_v2_rust-wayland-sys+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+libc-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+libc-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+libc-devel.sha256sum] = "a93e3e459a2255b0488ca79213ce1e41e437a610df52d7e5e5588e406fc47df4"

URI_x86_64_v2_rust-wayland-sys+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+memoffset-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+memoffset-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+memoffset-devel.sha256sum] = "73fdd11f4f0ff1ab374eab85ccf7c04c91a93cb9cececa1d23fbc494c963e7a0"

URI_x86_64_v2_rust-wayland-sys+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+once_cell-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+once_cell-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+once_cell-devel.sha256sum] = "28b886b16ea6d0da69874ac7c0e68598791d762fe26e7b75fa3e73002f4efdd2"

URI_x86_64_v2_rust-wayland-sys+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+server-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+server-devel.sha256sum] = "9044a7319d145a3424118f5dc40c81bb4a507c103e89724a3df0f233c5dcea25"

URI_x86_64_v2_rust-wayland-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys-devel-0.31.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys-devel.sha256sum] = "7181675b56dbc9902ee31290e5c4ed2686f355aabb0457a8c4651dc39b8e9faa"

URI_aarch64_rust-wayland-sys+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+client-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-sys+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+client-devel}"
SRC_URI[aarch64_rust-wayland-sys+client-devel.sha256sum] = "f86492c9cacf44d32d713e4e8fad30d754f8d11de616075ef074672356afb438"

URI_aarch64_rust-wayland-sys+cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+cursor-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-sys+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+cursor-devel}"
SRC_URI[aarch64_rust-wayland-sys+cursor-devel.sha256sum] = "bdff9381eaac7fbecdf7d848124e456fddc17f2fe0e47dc7b4822f68298c975c"

URI_aarch64_rust-wayland-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+default-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+default-devel}"
SRC_URI[aarch64_rust-wayland-sys+default-devel.sha256sum] = "b87611a349fff71bd8eadf4beaeb2edec6f2cb4a40cc3a0a870e0ecc93660e6e"

URI_aarch64_rust-wayland-sys+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+dlopen-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-sys+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+dlopen-devel}"
SRC_URI[aarch64_rust-wayland-sys+dlopen-devel.sha256sum] = "1e4881e6a8282c19392457aa00d5bd2b754e6d6f2a0424a39ff49afba4393e5f"

URI_aarch64_rust-wayland-sys+egl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+egl-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-sys+egl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+egl-devel}"
SRC_URI[aarch64_rust-wayland-sys+egl-devel.sha256sum] = "3460dfdb7de7e7c44f3c69cc33e6bac3242fc389edb8fc8b113b02ee241987f8"

URI_aarch64_rust-wayland-sys+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+libc-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+libc-devel}"
SRC_URI[aarch64_rust-wayland-sys+libc-devel.sha256sum] = "ece25acd144a93108825275a7dfa0c9459aac5210f9c1c0b32cc55596750b93a"

URI_aarch64_rust-wayland-sys+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+memoffset-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-sys+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+memoffset-devel}"
SRC_URI[aarch64_rust-wayland-sys+memoffset-devel.sha256sum] = "d515d7cf405c9b98a7dfb18385122f3b8c359a7c3c7456d5ea660129f0bb875b"

URI_aarch64_rust-wayland-sys+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+once_cell-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-sys+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+once_cell-devel}"
SRC_URI[aarch64_rust-wayland-sys+once_cell-devel.sha256sum] = "e3f6300bb2d43ca863658bcb6d876c707fd05ccf9a1706fe71b56583470343a0"

URI_aarch64_rust-wayland-sys+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+server-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-sys+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+server-devel}"
SRC_URI[aarch64_rust-wayland-sys+server-devel.sha256sum] = "66011a8d0985c8c04ef1cc2bff686475162051577b7a3ad9d66d0d03b6db6a00"

URI_aarch64_rust-wayland-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys-devel-0.31.8-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys-devel}"
SRC_URI[aarch64_rust-wayland-sys-devel.sha256sum] = "f4f80f1981bf449dc2e1b5517cfb95fb234a31d5942668f3b1c742bab7bec59f"

RDEPENDS:rust-wayland-sys+client-devel = " \
 cargo \
 rust-dlib+default-devel \
 rust-log+default-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+cursor-devel = " \
 cargo \
 rust-wayland-sys+client-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+default-devel = " \
 cargo \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+dlopen-devel = " \
 cargo \
 rust-wayland-sys+once_cell-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+egl-devel = " \
 cargo \
 rust-wayland-sys+client-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+server-devel = " \
 cargo \
 rust-dlib+default-devel \
 rust-log+default-devel \
 rust-wayland-sys+libc-devel \
 rust-wayland-sys+memoffset-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys-devel = " \
 cargo \
 rust \
 rust-pkg-config+default-devel \
 wayland-devel \
 "
