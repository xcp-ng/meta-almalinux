# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-cpp"
PV = "0.23.4"
PR = "2.el10_1"
PACKAGES = " \
 rust-tree-sitter-cpp+default-devel \
 rust-tree-sitter-cpp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-cpp-0.23.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2568d665e3eafb7a94b38ee10f423b3f623c524e70cc55f64a0ae2868f8b8a63"

URI_x86_64_v2_rust-tree-sitter-cpp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cpp+default-devel-0.23.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cpp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-cpp+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-cpp+default-devel.sha256sum] = "8ecdaa303a5613ede666c4d3903dab0c03677b556d19ca2dd43dd00105249261"

URI_x86_64_v2_rust-tree-sitter-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cpp-devel-0.23.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-cpp-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-cpp-devel.sha256sum] = "4d51c3bf23f23f2d45c78b0f9758757add36821f2bc0e92de3c5b596793b7bb7"

URI_aarch64_rust-tree-sitter-cpp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cpp+default-devel-0.23.4-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-cpp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-cpp+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-cpp+default-devel.sha256sum] = "3c3e1803f868d6aa3ad0169df69ec7bda41aa45e99b736dc6dc97406cfbfd447"

URI_aarch64_rust-tree-sitter-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cpp-devel-0.23.4-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-cpp-devel}"
SRC_URI[aarch64_rust-tree-sitter-cpp-devel.sha256sum] = "0d7541b14e59fe35f04e8e12725911e901f58fb34a3d1b068f2164e72db3c706"

RDEPENDS:rust-tree-sitter-cpp+default-devel = " \
 cargo \
 rust-tree-sitter-cpp-devel \
 "
RDEPENDS:rust-tree-sitter-cpp-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
