# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jq"
PV = "1.7.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-jq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jq-1.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ace4521471ca7de553c9feb3e6f01268ee25b7904c6a3e035bd992494a8f8d37"

URI_x86_64_v2_python3-jq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jq-1.7.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-jq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jq}"
SRC_URI[x86_64_v2_python3-jq.sha256sum] = "09c9db4642841399f5cba98e146beb271da0b95553f4de66185c0f9f78619d0a"

URI_aarch64_python3-jq = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jq-1.7.0-1.el10_3.aarch64.rpm;name=aarch64_python3-jq;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jq}"
SRC_URI[aarch64_python3-jq.sha256sum] = "e40dc1034d62b0f76744f41206f579ac0f9310123a52b732765852853c73ef8c"

RDEPENDS:python3-jq = " \
 glibc \
 jq \
 python3 \
 "
