# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam"
PV = "0.8.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam+alloc-devel \
 rust-crossbeam+crossbeam-channel-devel \
 rust-crossbeam+crossbeam-deque-devel \
 rust-crossbeam+crossbeam-epoch-devel \
 rust-crossbeam+crossbeam-queue-devel \
 rust-crossbeam+default-devel \
 rust-crossbeam+nightly-devel \
 rust-crossbeam+std-devel \
 rust-crossbeam-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-0.8.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d0b0f1e088fd3da06947c882502aacd1483a6f916eb06e9ecad4021b0142af1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+alloc-devel-0.8.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+alloc-devel.sha256sum] = "77849f597ab96cf76e15102b34379b102bc0c5959408250b343f5ffb52ec3a89"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-channel-devel-0.8.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-channel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-channel-devel.sha256sum] = "7c2c0a73358448188525a83d1461655c183a380ac2e71050991c594b37bb99a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-deque-devel-0.8.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-deque-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-deque-devel.sha256sum] = "4a86e607a831dae0439478609e3c31f9036b11511b4ac5d0806cb84ce22ef2c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-epoch-devel-0.8.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-epoch-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-epoch-devel.sha256sum] = "cda791e10861c90b498e17d4d98b78b533da400f699d31181861440b1313ffc3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+crossbeam-queue-devel-0.8.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+crossbeam-queue-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+crossbeam-queue-devel.sha256sum] = "08e95ae1a0d83390aaf237be5ab989b5407c77207e78244df26222029e9f0a91"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+default-devel-0.8.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+default-devel.sha256sum] = "23662e27093c8caf8dc1cbb6d7ec79a24161a23d42f54215777f4632dfa88bbb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+nightly-devel-0.8.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+nightly-devel.sha256sum] = "3cf76e99be45f14abead6245f11bce312508e6c9eb85c8376333f0eb8afa9005"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam+std-devel-0.8.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam+std-devel.sha256sum] = "deee016ca2f795bc07166781952112e3c543aa381709f2fc00bd71f3540421dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-devel-0.8.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-devel.sha256sum] = "775e67d7644a09cde2a001b1c4f5e4747365572098e3a7ede6bcc99c58f9a491"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+alloc-devel-0.8.5-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+alloc-devel.sha256sum] = "e115f28a93c37c8cd342ef25fb63880f50ecb6816ee16931d1433b7297f54ddb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-channel-devel-0.8.5-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-channel-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+crossbeam-channel-devel.sha256sum] = "5efd9b8937b86cb43b5d91e83d7df372c95989d83b8802defffe86d03cf8e641"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-deque-devel-0.8.5-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-deque-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+crossbeam-deque-devel.sha256sum] = "69ac3965373cfcb836a6cef6891f10b8a43fb626ba6bd17220f2d671d8afad38"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-epoch-devel-0.8.5-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-epoch-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+crossbeam-epoch-devel.sha256sum] = "5d948b83b3251280980a4808743f277196dc0d5937439bb4aa0205ad8586dd10"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+crossbeam-queue-devel-0.8.5-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam+crossbeam-queue-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+crossbeam-queue-devel.sha256sum] = "09d82a7f56b85276522d242dd2e83257d410bac6871a24a8e48b36362f9c1445"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+default-devel-0.8.5-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+default-devel.sha256sum] = "3775ea91c03a124c431b442a0d05c6cc529939ca2fe353dd3b140faa0e95aeb6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+nightly-devel-0.8.5-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+nightly-devel.sha256sum] = "3ca16c4788ee2b6b687e17e46d4de0be6701d08096e92a5ca6425230e43ae206"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam+std-devel-0.8.5-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam+std-devel.sha256sum] = "11be41c722c79d56f7aafa3ca5071ed52899f640f69875b018fa9ec08ea613f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-devel-0.8.5-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-devel.sha256sum] = "a8e13d41cac4a6c90302c2e1bc3a7af8d48c18dbc4fb072f457429a122beedcf"

RDEPENDS:rust-crossbeam+alloc-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-channel-devel = " \
 cargo \
 rust-crossbeam-channel-devel \
 rust-crossbeam-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-deque-devel = " \
 cargo \
 rust-crossbeam-deque-devel \
 rust-crossbeam-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-epoch-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam+crossbeam-queue-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam+default-devel = " \
 cargo \
 rust-crossbeam+std-devel \
 rust-crossbeam-devel \
 "
RDEPENDS:rust-crossbeam+nightly-devel = " \
 cargo \
 rust-crossbeam-devel \
 rust-crossbeam-epoch+nightly-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-queue+nightly-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam+std-devel = " \
 cargo \
 rust-crossbeam+alloc-devel \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 rust-crossbeam-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
