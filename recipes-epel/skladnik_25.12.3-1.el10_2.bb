# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skladnik"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 skladnik \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/skladnik-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1ef361915a9cda8191c5f3e63b5987b20aa73a45371b6fa7bb3e2fc96bec4a3"

URI_x86_64_v2_skladnik = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skladnik-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skladnik;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skladnik}"
SRC_URI[x86_64_v2_skladnik.sha256sum] = "d72d7bc09a71690ad3c6c3e6d63e6cce8ff1d977f042ccd6bb1afd58daff273a"

URI_aarch64_skladnik = "${EPEL_MIRROR}/aarch64/Packages/s/skladnik-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_skladnik;unpack=0"
SRC_URI:append = " ${URI_aarch64_skladnik}"
SRC_URI[aarch64_skladnik.sha256sum] = "63738c62d5a3928abac43d31c2785a841be4034facad8bbbcc395e43fe8e9bce"

RDEPENDS:skladnik = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
