# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbus-broker"
PV = "36"
PR = "4.el10"
PACKAGES = " \
 dbus-broker \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dbus-broker-36-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c47b755daad35ef1f6ba10cd02ff64205737b4a95702366ff2e34c8371c9ea0b"

URI_x86_64_v2_dbus-broker = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-broker-36-4.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-broker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-broker}"
SRC_URI[x86_64_v2_dbus-broker.sha256sum] = "7a30a0029bc42452d98f01a136150ac404a4f88e05b0280aebfaa70edb08655f"

URI_aarch64_dbus-broker = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-broker-36-4.el10.aarch64.rpm;name=aarch64_dbus-broker;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-broker}"
SRC_URI[aarch64_dbus-broker.sha256sum] = "9cf221e2cd68c84d06597d8bdb40fc1f1eeb96d6ea1756c0cd226091a4ae282b"

RDEPENDS:dbus-broker = " \
 audit-libs \
 bash \
 dbus-common \
 expat \
 glibc \
 libcap-ng \
 libgcc \
 libselinux \
 systemd-libs \
 "
