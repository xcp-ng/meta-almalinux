# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgoldrunner"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kgoldrunner \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgoldrunner-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59e03b0c6715053d6d2293bb8219073d93cd4fd6336aa9bca5af84eeabecf102"

URI_x86_64_v2_kgoldrunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgoldrunner-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgoldrunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgoldrunner}"
SRC_URI[x86_64_v2_kgoldrunner.sha256sum] = "5a6b3a4a22845274aff3e3b629c00cfd79812f58008d74bf34be6962e01e8eb4"

URI_aarch64_kgoldrunner = "${EPEL_MIRROR}/aarch64/Packages/k/kgoldrunner-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kgoldrunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgoldrunner}"
SRC_URI[aarch64_kgoldrunner.sha256sum] = "d44067d0b464e218579eb93af44a2ca4c1225f383cc1500442050cdca2003c3c"

RDEPENDS:kgoldrunner = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
