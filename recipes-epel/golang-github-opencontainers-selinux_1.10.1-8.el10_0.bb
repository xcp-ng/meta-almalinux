# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-opencontainers-selinux"
PV = "1.10.1"
PR = "8.el10_0"
PACKAGES = " \
 golang-github-opencontainers-selinux-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-opencontainers-selinux-1.10.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc1fd052d646b8e095283c339d3f3a343477362a4e3860b4802e0b02d882dadf"

URI_x86_64_v2_golang-github-opencontainers-selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-opencontainers-selinux-devel-1.10.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-opencontainers-selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-opencontainers-selinux-devel}"
SRC_URI[x86_64_v2_golang-github-opencontainers-selinux-devel.sha256sum] = "ae8a976eacf6ff762ade363ccea29ef542560948221d7c6e6aedd8fcf6ab6d2e"

URI_aarch64_golang-github-opencontainers-selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-opencontainers-selinux-devel-1.10.1-8.el10_0.noarch.rpm;name=aarch64_golang-github-opencontainers-selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-opencontainers-selinux-devel}"
SRC_URI[aarch64_golang-github-opencontainers-selinux-devel.sha256sum] = "7fde536d7afce04c5df15046f4d1403355888e35302361ab75b8c6d3b66394e8"

RDEPENDS:golang-github-opencontainers-selinux-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
