# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gfal2-python"
PV = "1.13.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-gfal2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gfal2-python-1.13.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e705003898fc2dd9e112e986f8b327c234aacae7fe6843cd56f5dff4b920471"

URI_x86_64_v2_python3-gfal2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gfal2-1.13.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-gfal2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gfal2}"
SRC_URI[x86_64_v2_python3-gfal2.sha256sum] = "d6330ed48abfefd2730b0d457873af38f05d0acc9542d769054ee69c5a1e9172"

URI_aarch64_python3-gfal2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gfal2-1.13.1-1.el10_0.aarch64.rpm;name=aarch64_python3-gfal2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gfal2}"
SRC_URI[aarch64_python3-gfal2.sha256sum] = "b44d3e45f8a12540f42089a7cce08b2d4746fc2325635f3f938f0c305e1ff873"

RDEPENDS:python3-gfal2 = " \
 boost-python3 \
 gfal2 \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
