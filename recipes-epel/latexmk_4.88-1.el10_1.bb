# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "latexmk"
PV = "4.88"
PR = "1.el10_1"
PACKAGES = " \
 latexmk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/latexmk-4.88-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0091ad50c3d11bc279ca64f4b75dfe030eba3d3ccf0674dc52dc49546edc29be"

URI_x86_64_v2_latexmk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/latexmk-4.88-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_latexmk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_latexmk}"
SRC_URI[x86_64_v2_latexmk.sha256sum] = "4d053be2cba4c0139c8ecce4f4da924ac1defab36eec154e8d50bd825b39d6da"

URI_aarch64_latexmk = "${EPEL_MIRROR}/aarch64/Packages/l/latexmk-4.88-1.el10_1.noarch.rpm;name=aarch64_latexmk;unpack=0"
SRC_URI:append = " ${URI_aarch64_latexmk}"
SRC_URI[aarch64_latexmk.sha256sum] = "15a97fd8e8afde27ca41e0389f5085ecebb8380044576e7a4cfce54a5f35450b"

RDEPENDS:latexmk = " \
 ghostscript-tools-dvipdf \
 perl-Digest-MD5 \
 perl-Encode \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-FileHandle \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-Unicode-Normalize \
 perl-interpreter \
 perl-libs \
 perl-sigtrap \
 texlive-latex \
 xdg-utils \
 "
