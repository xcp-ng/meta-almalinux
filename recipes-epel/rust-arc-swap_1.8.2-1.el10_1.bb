# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arc-swap"
PV = "1.8.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-arc-swap+default-devel \
 rust-arc-swap+experimental-strategies-devel \
 rust-arc-swap+experimental-thread-local-devel \
 rust-arc-swap+internal-test-strategies-devel \
 rust-arc-swap+serde-devel \
 rust-arc-swap+weak-devel \
 rust-arc-swap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arc-swap-1.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60bcd1b866dd51c141df014c6c9fa4f80a1412ea655d1fac60b0cc8062ae938d"

URI_x86_64_v2_rust-arc-swap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+default-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+default-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+default-devel.sha256sum] = "cd0eafd0b1f03cac1d980d9232d44552165db9134b06d874fd6a7e42cf0d660c"

URI_x86_64_v2_rust-arc-swap+experimental-strategies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+experimental-strategies-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+experimental-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+experimental-strategies-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+experimental-strategies-devel.sha256sum] = "e54c03485c7cdbc5cb13bce2043d4e53e5d6359cd112a5037176d3ec324331bd"

URI_x86_64_v2_rust-arc-swap+experimental-thread-local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+experimental-thread-local-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+experimental-thread-local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+experimental-thread-local-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+experimental-thread-local-devel.sha256sum] = "fb8d319c75a8bc2c845dd7242b6cdf5e02e4c8758ccc3ae7441ca1247e4e5d0d"

URI_x86_64_v2_rust-arc-swap+internal-test-strategies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+internal-test-strategies-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+internal-test-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+internal-test-strategies-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+internal-test-strategies-devel.sha256sum] = "e6af6679fd00ff92ab0938bf0c82708e5670050838729f7f558e37634490babb"

URI_x86_64_v2_rust-arc-swap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+serde-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+serde-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+serde-devel.sha256sum] = "a907dbda30d27aec8b25d8e1b8b096e55c746ab176f8fa9ab00c1a8c044e7a44"

URI_x86_64_v2_rust-arc-swap+weak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+weak-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+weak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+weak-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+weak-devel.sha256sum] = "e2930871f12b73a62007d21d93cb26df82b2c140e979cf6f72a8a5ac028407a1"

URI_x86_64_v2_rust-arc-swap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap-devel}"
SRC_URI[x86_64_v2_rust-arc-swap-devel.sha256sum] = "332f55dff1d47ac7dbd18d29aafc778304a49eb1aa7c57a344573c1a40929067"

URI_aarch64_rust-arc-swap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+default-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-arc-swap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+default-devel}"
SRC_URI[aarch64_rust-arc-swap+default-devel.sha256sum] = "2aad03bd0c0fdb0da30ee8f5546164d8c5fdf3920bd10bf5946202c76629bc02"

URI_aarch64_rust-arc-swap+experimental-strategies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+experimental-strategies-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-arc-swap+experimental-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+experimental-strategies-devel}"
SRC_URI[aarch64_rust-arc-swap+experimental-strategies-devel.sha256sum] = "2f25d2be5697a3bda4d00c996551141405153f974f4c953b94210ed6fc3abeec"

URI_aarch64_rust-arc-swap+experimental-thread-local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+experimental-thread-local-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-arc-swap+experimental-thread-local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+experimental-thread-local-devel}"
SRC_URI[aarch64_rust-arc-swap+experimental-thread-local-devel.sha256sum] = "f6326d56ab6484cda7925961180f79584d826303df7f850589e483d135a6fa8a"

URI_aarch64_rust-arc-swap+internal-test-strategies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+internal-test-strategies-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-arc-swap+internal-test-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+internal-test-strategies-devel}"
SRC_URI[aarch64_rust-arc-swap+internal-test-strategies-devel.sha256sum] = "b55beaf259e32a878586942021c3308285a29b85a6a6e50ceaf587ea10183d9b"

URI_aarch64_rust-arc-swap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+serde-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-arc-swap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+serde-devel}"
SRC_URI[aarch64_rust-arc-swap+serde-devel.sha256sum] = "a830de7e0ef0292361a2c98e2f2796590f0f7cc2d07c5c4f668885af88eb94ed"

URI_aarch64_rust-arc-swap+weak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+weak-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-arc-swap+weak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+weak-devel}"
SRC_URI[aarch64_rust-arc-swap+weak-devel.sha256sum] = "c97040a81ec1d6271f4c9d60195550710507fd34613c645ff9ba50ee383dd1b7"

URI_aarch64_rust-arc-swap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-arc-swap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap-devel}"
SRC_URI[aarch64_rust-arc-swap-devel.sha256sum] = "d1af3e9484717a5d628afa2b2ea4c31e50174d055da180aaaefe5eda5b5e745d"

RDEPENDS:rust-arc-swap+default-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+experimental-strategies-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+experimental-thread-local-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+internal-test-strategies-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+serde-devel = " \
 cargo \
 rust-arc-swap-devel \
 rust-serde+default-devel \
 rust-serde+rc-devel \
 "
RDEPENDS:rust-arc-swap+weak-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap-devel = " \
 bash \
 cargo \
 rust-rustversion+default-devel \
 "
