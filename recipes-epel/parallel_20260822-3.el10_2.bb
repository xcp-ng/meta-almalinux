# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parallel"
PV = "20260822"
PR = "3.el10_2"
PACKAGES = " \
 parallel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/parallel-20260822-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "608eab90936d13d736e01cd253d811c54484d5fb69d944eeeddb9a5d8f5497f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parallel-20260822-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_parallel;unpack=0"
SRC_URI[x86_64_v2_parallel.sha256sum] = "1326f0285d443e8d77ef151dded57d81386b9ee3b8767a3ac0c95febfa38c563"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/parallel-20260822-3.el10_2.noarch.rpm;name=aarch64_parallel;unpack=0"
SRC_URI[aarch64_parallel.sha256sum] = "75558b93c7d062a42eb12778a0993dac8d5a545b34754ab0c4c09fd478e71f91"

RDEPENDS:parallel = " \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Symbol \
 perl-Thread-Queue \
 perl-interpreter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
