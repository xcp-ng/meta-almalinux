# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qt3d"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qt3d \
 qt5-qt3d-devel \
 qt5-qt3d-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qt3d-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c86465f780b69ff8476105c292fd435ed0fd785ec3a56563e9d0cd48459b8301"

URI_x86_64_v2_qt5-qt3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qt3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d}"
SRC_URI[x86_64_v2_qt5-qt3d.sha256sum] = "4fbf52bcff758c7682fd7466d20861bbfd115f843a9701f9ec40e86479a54bc4"

URI_x86_64_v2_qt5-qt3d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qt3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d-devel}"
SRC_URI[x86_64_v2_qt5-qt3d-devel.sha256sum] = "76f45c107aced879d06af07866e2b45ae8d697a308800789e1654a1175fea2b3"

URI_x86_64_v2_qt5-qt3d-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qt3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d-examples}"
SRC_URI[x86_64_v2_qt5-qt3d-examples.sha256sum] = "5e983fb61ae6d8397524b66255b8316c95fc67c36a9d1e3805e55e7946c5852d"

URI_aarch64_qt5-qt3d = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qt3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d}"
SRC_URI[aarch64_qt5-qt3d.sha256sum] = "ace6b5e6f76a51805d4cccc639a1541c287bb9997ebec70fefe01a5cbd6cae39"

URI_aarch64_qt5-qt3d-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qt3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d-devel}"
SRC_URI[aarch64_qt5-qt3d-devel.sha256sum] = "afa135e1d69e0d5204254aa0b9e5e662f9e29acf5a9332809d33e68b00444fdc"

URI_aarch64_qt5-qt3d-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qt3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d-examples}"
SRC_URI[aarch64_qt5-qt3d-examples.sha256sum] = "ddf00d4cd12ee4176abb6eb43601b8c848c0bb3200aa4fb0f9912c342b6e7364"

RDEPENDS:qt5-qt3d = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtimageformats \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qt3d-devel = " \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qt3d \
 qt5-qt3d-devel \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qt3d-examples = " \
 glibc \
 libstdc++ \
 qt5-qt3d \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
