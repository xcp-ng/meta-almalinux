# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-valyala-bytebufferpool"
PV = "1.0.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-valyala-bytebufferpool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-valyala-bytebufferpool-1.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3c05f426ff8ca529db0f9bf94a8065011ebf98979c544f535e9c156603369b6"

URI_x86_64_v2_golang-github-valyala-bytebufferpool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-valyala-bytebufferpool-devel-1.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-valyala-bytebufferpool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-valyala-bytebufferpool-devel}"
SRC_URI[x86_64_v2_golang-github-valyala-bytebufferpool-devel.sha256sum] = "3bc097b2154a3aa169b6864fc8a23b9c41f97b8b0e0f5e2e25c84519d502bc64"

URI_aarch64_golang-github-valyala-bytebufferpool-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-valyala-bytebufferpool-devel-1.0.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-valyala-bytebufferpool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-valyala-bytebufferpool-devel}"
SRC_URI[aarch64_golang-github-valyala-bytebufferpool-devel.sha256sum] = "55a2a295fe9c819fe73bcad92c2bf69e70d4f9b08493517439ae60176243a380"

RDEPENDS:golang-github-valyala-bytebufferpool-devel = " \
 go-filesystem \
 "
