# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipblaslt"
PV = "6.4.3"
PR = "3.el10_1"
PACKAGES:x86_64_v2 = " \
 hipblaslt \
 hipblaslt-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipblaslt-6.4.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a1a80e0b88c55dae603d2ca07da72968e0fa142a54b69efd980dc96aba8b50f"

URI_x86_64_v2_hipblaslt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblaslt-6.4.3-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblaslt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblaslt}"
SRC_URI[x86_64_v2_hipblaslt.sha256sum] = "db8770223a4c3df53d63e25a1fc2e9fecbc6782acdcb5d6f07e368bf118c1a04"

URI_x86_64_v2_hipblaslt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblaslt-devel-6.4.3-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblaslt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblaslt-devel}"
SRC_URI[x86_64_v2_hipblaslt-devel.sha256sum] = "990fe28ff1b63381a8a6c4b3bfb199e4e7eb87782c5eafeef7922cb65ab542dd"

RDEPENDS:hipblaslt = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:hipblaslt-devel = " \
 cmake-filesystem \
 hipblaslt \
 "
