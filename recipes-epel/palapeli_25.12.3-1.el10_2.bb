# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "palapeli"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 palapeli \
 palapeli-devel \
 palapeli-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/palapeli-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c09d28420dca92c8ad6b9a4a0df910ceb97d56492594fe9dee300bd6542459c3"

URI_x86_64_v2_palapeli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_palapeli}"
SRC_URI[x86_64_v2_palapeli.sha256sum] = "aff748e53824248831db86f953bfbb01163af36dfd2b9e0e0e2a0ad90e930574"

URI_x86_64_v2_palapeli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_palapeli-devel}"
SRC_URI[x86_64_v2_palapeli-devel.sha256sum] = "49eb2ddb09f545b43ba2eb1bc851e458faa4e3f4ada64f676975acc30ee3cd4f"

URI_x86_64_v2_palapeli-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_palapeli-libs}"
SRC_URI[x86_64_v2_palapeli-libs.sha256sum] = "a4fc6f20af8adca4a5f3ed4910a0b2bf07928558fad6041d939b95fa930db499"

URI_aarch64_palapeli = "${EPEL_MIRROR}/aarch64/Packages/p/palapeli-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_palapeli;unpack=0"
SRC_URI:append = " ${URI_aarch64_palapeli}"
SRC_URI[aarch64_palapeli.sha256sum] = "09e3107d4136bbe32be2dabccac75ccd42fedd4f84f62609fb18512492e4bd01"

URI_aarch64_palapeli-devel = "${EPEL_MIRROR}/aarch64/Packages/p/palapeli-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_palapeli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_palapeli-devel}"
SRC_URI[aarch64_palapeli-devel.sha256sum] = "90046189a757d5b3a00c8ba2581ef8fdc7fe13c98487b1b07f943be1d7d21e35"

URI_aarch64_palapeli-libs = "${EPEL_MIRROR}/aarch64/Packages/p/palapeli-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_palapeli-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_palapeli-libs}"
SRC_URI[aarch64_palapeli-libs.sha256sum] = "c755771ee18cc02e143bfea5d9a58bf4885f64e0dff11203988e970a810359b2"

RDEPENDS:palapeli = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 palapeli-libs \
 qhull \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:palapeli-devel = " \
 cmake-filesystem \
 palapeli-libs \
 "
RDEPENDS:palapeli-libs = " \
 glibc \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 libstdc++ \
 palapeli \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
