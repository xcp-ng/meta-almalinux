# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kconfig"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kconfig \
 kf6-kconfig-devel \
 kf6-kconfig-doc \
 kf6-kconfig-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kconfig-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cfafa7d8a2a354313b7cf236e68f19e45547cbef1926d5a56e05658b5bd64cd"

URI_x86_64_v2_kf6-kconfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig}"
SRC_URI[x86_64_v2_kf6-kconfig.sha256sum] = "2cc821a7b6d92d466a1b7e149919f8537b70754b4e19f886117ea0d86ea42308"

URI_x86_64_v2_kf6-kconfig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-devel}"
SRC_URI[x86_64_v2_kf6-kconfig-devel.sha256sum] = "b5abd3dd031863f8024ea0cc7ceab9aef70cb6f5ff591d0df973863299be05da"

URI_x86_64_v2_kf6-kconfig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-doc}"
SRC_URI[x86_64_v2_kf6-kconfig-doc.sha256sum] = "759180e92b2732b5f4ab935f303010794d90a630f560bbc693eae34b68024411"

URI_x86_64_v2_kf6-kconfig-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfig-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfig-html}"
SRC_URI[x86_64_v2_kf6-kconfig-html.sha256sum] = "c1f59b8af0e4f3199848bd6d61f9d78252395569a99a2dc6c50f4ef628206e08"

URI_aarch64_kf6-kconfig = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig}"
SRC_URI[aarch64_kf6-kconfig.sha256sum] = "5ea93d25d11d12cd1fa7ea9d4721937a2cccf7854e1b7921102f294abf8f0708"

URI_aarch64_kf6-kconfig-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-devel}"
SRC_URI[aarch64_kf6-kconfig-devel.sha256sum] = "30aed5f8a742d40871cfa223a963f41607f5579eba563bc156574e7ed2105248"

URI_aarch64_kf6-kconfig-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kconfig-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-doc}"
SRC_URI[aarch64_kf6-kconfig-doc.sha256sum] = "e1cb377878833fb8b7233ee254fd71236f917d30ffdc472d3a0c49dc33ea9e1e"

URI_aarch64_kf6-kconfig-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kconfig-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfig-html}"
SRC_URI[aarch64_kf6-kconfig-html.sha256sum] = "2519a285aaab375b00a16a13afb6e46b0dec6ab3c3e92415c8ac96a99438a2b8"

RDEPENDS:kf6-kconfig = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kconfig-devel = " \
 cmake-filesystem \
 kf6-kconfig \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kconfig-doc = " \
 "
RDEPENDS:kf6-kconfig-html = " \
 "
