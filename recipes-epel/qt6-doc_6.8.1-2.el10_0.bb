# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-doc"
PV = "6.8.1"
PR = "2.el10_0"
PACKAGES = " \
 qt6-doc \
 qt6-doc-devel \
 qt6-doc-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-doc-6.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6818612b9bf1488da84a484789ecd1c402b4367c592088defb8ffa13d3989b5d"

URI_x86_64_v2_qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-doc-6.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doc}"
SRC_URI[x86_64_v2_qt6-doc.sha256sum] = "2de06c7aa45982bf35adbcfc0f740139f53fdeee37257f3df950dc75734455f8"

URI_x86_64_v2_qt6-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-doc-devel-6.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt6-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doc-devel}"
SRC_URI[x86_64_v2_qt6-doc-devel.sha256sum] = "6d37f9ca03103457ab4d76d36e749ce866f40811109a1dc73b19db5bb2115357"

URI_x86_64_v2_qt6-doc-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-doc-html-6.8.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt6-doc-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doc-html}"
SRC_URI[x86_64_v2_qt6-doc-html.sha256sum] = "802a4c6e712dd83008d255a06d6d003f00e5b3acd5e8b4109c3087bc892cc4ba"

URI_aarch64_qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-doc-6.8.1-2.el10_0.noarch.rpm;name=aarch64_qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doc}"
SRC_URI[aarch64_qt6-doc.sha256sum] = "08c932a53295f857005c23a4e86ce18d0ae9553812bd5831d1d893db41343ea0"

URI_aarch64_qt6-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-doc-devel-6.8.1-2.el10_0.noarch.rpm;name=aarch64_qt6-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doc-devel}"
SRC_URI[aarch64_qt6-doc-devel.sha256sum] = "4cb5ecce7d6f603427705655c45222377dec34ebf81e9933c3f2a15a0abe9a44"

URI_aarch64_qt6-doc-html = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-doc-html-6.8.1-2.el10_0.noarch.rpm;name=aarch64_qt6-doc-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doc-html}"
SRC_URI[aarch64_qt6-doc-html.sha256sum] = "8cefe78e83c1cf3e229cbcfc84eaa67f3dad6d4ecbf068509d8dacf4486cf45e"

RDEPENDS:qt6-doc = " \
 "
RDEPENDS:qt6-doc-devel = " \
 "
RDEPENDS:qt6-doc-html = " \
 "
