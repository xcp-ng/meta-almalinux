# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-TabularDisplay"
PV = "1.38"
PR = "33.el10_3"
PACKAGES = " \
 perl-Text-TabularDisplay \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-TabularDisplay-1.38-33.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "185727554c04784170595ccc2f99e017b463cbf4571fcac7b8a6626c79093121"

URI_x86_64_v2_perl-Text-TabularDisplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-TabularDisplay-1.38-33.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-TabularDisplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-TabularDisplay}"
SRC_URI[x86_64_v2_perl-Text-TabularDisplay.sha256sum] = "764859f1586eb792fb8f070224ace8d2e7ca640009d720d4c49271f5f74c6709"

URI_aarch64_perl-Text-TabularDisplay = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-TabularDisplay-1.38-33.el10_3.noarch.rpm;name=aarch64_perl-Text-TabularDisplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-TabularDisplay}"
SRC_URI[aarch64_perl-Text-TabularDisplay.sha256sum] = "9e9383b9aa2aa1fe005c09e2e725254f622d102b39ae04a9da6dc78b2a7bae4c"

RDEPENDS:perl-Text-TabularDisplay = " \
 perl-libs \
 perl-vars \
 "
