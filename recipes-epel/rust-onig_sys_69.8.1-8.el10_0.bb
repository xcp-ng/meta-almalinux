# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onig_sys"
PV = "69.8.1"
PR = "8.el10_0"
PACKAGES = " \
 rust-onig_sys+bindgen-devel \
 rust-onig_sys+default-devel \
 rust-onig_sys+generate-devel \
 rust-onig_sys+posix-api-devel \
 rust-onig_sys+print-debug-devel \
 rust-onig_sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onig_sys-69.8.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d91dcb8a25e15c5ad93b061308d426d0bca5ef1ef5adfa36a8a67004c174e80b"

URI_x86_64_v2_rust-onig_sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys+bindgen-devel-69.8.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-onig_sys+bindgen-devel.sha256sum] = "b30dfb087ea76ac3ea8f0c9fa3969308cf558ad7bad9de37f47c29cbe329c949"

URI_x86_64_v2_rust-onig_sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys+default-devel-69.8.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys+default-devel}"
SRC_URI[x86_64_v2_rust-onig_sys+default-devel.sha256sum] = "9782ccb14065c8ec081aa69ccc29e4d4c5349b5285932095cddca82d064222a0"

URI_x86_64_v2_rust-onig_sys+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys+generate-devel-69.8.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys+generate-devel}"
SRC_URI[x86_64_v2_rust-onig_sys+generate-devel.sha256sum] = "a810f7df316cf63e8a8e81eb7c166264f7d54c25931ff7ed8112d41cead84fa5"

URI_x86_64_v2_rust-onig_sys+posix-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys+posix-api-devel-69.8.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys+posix-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys+posix-api-devel}"
SRC_URI[x86_64_v2_rust-onig_sys+posix-api-devel.sha256sum] = "cf75b59b3d133aeb393795e5742cdd07b27bd257be40a53ddeb5fd1c25465f2e"

URI_x86_64_v2_rust-onig_sys+print-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys+print-debug-devel-69.8.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys+print-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys+print-debug-devel}"
SRC_URI[x86_64_v2_rust-onig_sys+print-debug-devel.sha256sum] = "b4d566961d9a107981fe442c888492ea4e31aff5b2e57074667d76ed966d101e"

URI_x86_64_v2_rust-onig_sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys-devel-69.8.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys-devel}"
SRC_URI[x86_64_v2_rust-onig_sys-devel.sha256sum] = "28b8034210a00372592d0b5b90661a2ad983b362ef5276cef5b0b21412c54299"

URI_aarch64_rust-onig_sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys+bindgen-devel-69.8.1-8.el10_0.noarch.rpm;name=aarch64_rust-onig_sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys+bindgen-devel}"
SRC_URI[aarch64_rust-onig_sys+bindgen-devel.sha256sum] = "433ea1f61da1bcb286cb888e19d136bf9427c48fee3f8300e77df870a3060463"

URI_aarch64_rust-onig_sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys+default-devel-69.8.1-8.el10_0.noarch.rpm;name=aarch64_rust-onig_sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys+default-devel}"
SRC_URI[aarch64_rust-onig_sys+default-devel.sha256sum] = "26e2373fab479b24ed0e521d07354b7367a3b8c63336f66296e25891e8414161"

URI_aarch64_rust-onig_sys+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys+generate-devel-69.8.1-8.el10_0.noarch.rpm;name=aarch64_rust-onig_sys+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys+generate-devel}"
SRC_URI[aarch64_rust-onig_sys+generate-devel.sha256sum] = "3b1c8ac8c0d75f97bf407e444de59541254605405c95ce9626aadff141e7a8ca"

URI_aarch64_rust-onig_sys+posix-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys+posix-api-devel-69.8.1-8.el10_0.noarch.rpm;name=aarch64_rust-onig_sys+posix-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys+posix-api-devel}"
SRC_URI[aarch64_rust-onig_sys+posix-api-devel.sha256sum] = "f900687ac496dc0f00be38b1a0e637671f0f18babcb2c31951bcd5887acfe52f"

URI_aarch64_rust-onig_sys+print-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys+print-debug-devel-69.8.1-8.el10_0.noarch.rpm;name=aarch64_rust-onig_sys+print-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys+print-debug-devel}"
SRC_URI[aarch64_rust-onig_sys+print-debug-devel.sha256sum] = "6bc8940eab295e4bcbe3e2978446455e0ede867226c5724dfdcc6bfffe5a5192"

URI_aarch64_rust-onig_sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys-devel-69.8.1-8.el10_0.noarch.rpm;name=aarch64_rust-onig_sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys-devel}"
SRC_URI[aarch64_rust-onig_sys-devel.sha256sum] = "1b61f3fe3991fa9afa4755e55e8153e1613bf88b86076e06aae854f90b56a41a"

RDEPENDS:rust-onig_sys+bindgen-devel = " \
 cargo \
 rust-onig_sys-devel \
 "
RDEPENDS:rust-onig_sys+default-devel = " \
 cargo \
 rust-onig_sys+generate-devel \
 rust-onig_sys-devel \
 "
RDEPENDS:rust-onig_sys+generate-devel = " \
 cargo \
 rust-onig_sys+bindgen-devel \
 rust-onig_sys-devel \
 "
RDEPENDS:rust-onig_sys+posix-api-devel = " \
 cargo \
 rust-onig_sys-devel \
 "
RDEPENDS:rust-onig_sys+print-debug-devel = " \
 cargo \
 rust-onig_sys-devel \
 "
RDEPENDS:rust-onig_sys-devel = " \
 cargo \
 oniguruma-devel \
 rust-bindgen+default-devel \
 rust-bindgen+runtime-devel \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 "
