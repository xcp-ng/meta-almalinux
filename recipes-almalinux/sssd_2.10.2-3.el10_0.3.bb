# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sssd"
PV = "2.10.2"
PR = "3.el10_0.3"
PACKAGES = " \
 libipa_hbac \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_nss_idmap \
 libsss_nss_idmap-devel \
 libsss_sudo \
 python3-libipa_hbac \
 python3-libsss_nss_idmap \
 python3-sss \
 python3-sss-murmur \
 python3-sssdconfig \
 sssd \
 sssd-ad \
 sssd-client \
 sssd-common \
 sssd-common-pac \
 sssd-dbus \
 sssd-idp \
 sssd-ipa \
 sssd-kcm \
 sssd-krb5 \
 sssd-krb5-common \
 sssd-ldap \
 sssd-nfs-idmap \
 sssd-passkey \
 sssd-proxy \
 sssd-tools \
 sssd-winbind-idmap \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sssd-2.10.2-3.el10_0.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeacd71f0caa22c693037d1aea1029605e2cbbfbc39cb89695b4c30d057e75e8"

URI_x86_64_v2_libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libipa_hbac-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libipa_hbac}"
SRC_URI[x86_64_v2_libipa_hbac.sha256sum] = "0ccc24ef2b7298812d0a8dae07bf7fd98c60e7e1f3d4642b08f0e43206ce10fd"

URI_x86_64_v2_libsss_autofs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_autofs-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_libsss_autofs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_autofs}"
SRC_URI[x86_64_v2_libsss_autofs.sha256sum] = "8ae8ffda6e70858f23aa1135e128a537ecb49775f0ad741f5589041af753ce41"

URI_x86_64_v2_libsss_certmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_certmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_libsss_certmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_certmap}"
SRC_URI[x86_64_v2_libsss_certmap.sha256sum] = "44c358f9ae73ae016b61a74fb8ca31954e5b7a7a86345aab71d3ee498afd7b34"

URI_x86_64_v2_libsss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_idmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_libsss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_idmap}"
SRC_URI[x86_64_v2_libsss_idmap.sha256sum] = "46c8f7153f801f8a011c1df88e93650c3978bfd3a864f05a13676a36b573bddb"

URI_x86_64_v2_libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_nss_idmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_nss_idmap}"
SRC_URI[x86_64_v2_libsss_nss_idmap.sha256sum] = "893fd8bf0d5afa58f7200e78e10900a21b0b0eac8f08c9b65ec112b992db29a8"

URI_x86_64_v2_libsss_nss_idmap-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsss_nss_idmap-devel-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_libsss_nss_idmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_nss_idmap-devel}"
SRC_URI[x86_64_v2_libsss_nss_idmap-devel.sha256sum] = "668af90b89bd80512721db3ef674af45ff40bdd4560334646810278c7101eab0"

URI_x86_64_v2_libsss_sudo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsss_sudo-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_libsss_sudo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsss_sudo}"
SRC_URI[x86_64_v2_libsss_sudo.sha256sum] = "7628e92337b4e0557e5c4d43eabc3814ea16555c879746805900b1cd08245540"

URI_x86_64_v2_python3-libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libipa_hbac-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3-libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libipa_hbac}"
SRC_URI[x86_64_v2_python3-libipa_hbac.sha256sum] = "b0580905b19bab36cdd864993db4b001aac9d5c8bbb80359ff1e0dfbb41a8c4e"

URI_x86_64_v2_python3-libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libsss_nss_idmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3-libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libsss_nss_idmap}"
SRC_URI[x86_64_v2_python3-libsss_nss_idmap.sha256sum] = "4e9bf91686ae432ca5054c5eb6fbe307bcd574fe1b224d7779f2c108903ba4fb"

URI_x86_64_v2_python3-sss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sss-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3-sss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sss}"
SRC_URI[x86_64_v2_python3-sss.sha256sum] = "33b9cd2998be2f695f10a174450e60d267f83241921e93b092f39f9ef1ee76db"

URI_x86_64_v2_python3-sss-murmur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sss-murmur-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_python3-sss-murmur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sss-murmur}"
SRC_URI[x86_64_v2_python3-sss-murmur.sha256sum] = "261527c796ae347dca2287abedbf8215a89dc1e7315ff8ed2c7c1bb0c322a957"

URI_x86_64_v2_python3-sssdconfig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-sssdconfig-2.10.2-3.el10_0.3.noarch.rpm;name=x86_64_v2_python3-sssdconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sssdconfig}"
SRC_URI[x86_64_v2_python3-sssdconfig.sha256sum] = "7e4b26aee2e7453221b25613fc7c72167e8d99db2244de831ad5ed00854f4a83"

URI_x86_64_v2_sssd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd}"
SRC_URI[x86_64_v2_sssd.sha256sum] = "4fd2a02830f644d5028c19db16c7f37af22cb9c48f4ed959c398bc73b8bc784e"

URI_x86_64_v2_sssd-ad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ad-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-ad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ad}"
SRC_URI[x86_64_v2_sssd-ad.sha256sum] = "43d9c3eedb091e97c48526978d0ab25898d69d3a19e160b08afdb992a3ce59d1"

URI_x86_64_v2_sssd-client = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-client-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-client}"
SRC_URI[x86_64_v2_sssd-client.sha256sum] = "01afa96d31030b405aafc19cbdfdeeb4d0d443be4aff74795d6fe7da265ed6ea"

URI_x86_64_v2_sssd-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-common-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-common}"
SRC_URI[x86_64_v2_sssd-common.sha256sum] = "d08d4093dad956987889289aae46ab71159e196a171ce3fd455627cdefabdf69"

URI_x86_64_v2_sssd-common-pac = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-common-pac-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-common-pac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-common-pac}"
SRC_URI[x86_64_v2_sssd-common-pac.sha256sum] = "0627b8581eec4814423a1557815a643d5cc1a01500d2548f519617cfaaeaf8fe"

URI_x86_64_v2_sssd-dbus = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-dbus-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-dbus}"
SRC_URI[x86_64_v2_sssd-dbus.sha256sum] = "af61b555f6c002a351a75416c77aa84ad9659e235c7d48e66d8027294994d041"

URI_x86_64_v2_sssd-idp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sssd-idp-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-idp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-idp}"
SRC_URI[x86_64_v2_sssd-idp.sha256sum] = "60dafab87c3d9d16a285deaa107118d106e52d30e54ef6350447a2bbf65f783a"

URI_x86_64_v2_sssd-ipa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ipa-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-ipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ipa}"
SRC_URI[x86_64_v2_sssd-ipa.sha256sum] = "36664ee667f42bcb99ea0e6072ffb80a9b3fa59f7870ec9ad72bdb47991996a8"

URI_x86_64_v2_sssd-kcm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-kcm-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-kcm}"
SRC_URI[x86_64_v2_sssd-kcm.sha256sum] = "9d6db052d36d5b666d8d07c57b847a10b3b9f3935b5b2381ec7ca57fbe2cd5ed"

URI_x86_64_v2_sssd-krb5 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-krb5-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-krb5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-krb5}"
SRC_URI[x86_64_v2_sssd-krb5.sha256sum] = "ce79fcf4e02b80efb57e318f4f0c9957eb55aa8c1043f2f01ee669daab49169a"

URI_x86_64_v2_sssd-krb5-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-krb5-common-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-krb5-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-krb5-common}"
SRC_URI[x86_64_v2_sssd-krb5-common.sha256sum] = "7287ba21c8e90061d8cec48c16c715fc48288424ed2157ad62a6f804c824f16a"

URI_x86_64_v2_sssd-ldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-ldap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-ldap}"
SRC_URI[x86_64_v2_sssd-ldap.sha256sum] = "33344fa271581a8d0bc37ba447fccdc45c4b3be09e4f14ac85396bffeadbdbde"

URI_x86_64_v2_sssd-nfs-idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-nfs-idmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-nfs-idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-nfs-idmap}"
SRC_URI[x86_64_v2_sssd-nfs-idmap.sha256sum] = "3b85c4652dd8cf01bc50242c1f0ae5b25ec4c1dc3b414989bfc6ca897c27b507"

URI_x86_64_v2_sssd-passkey = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-passkey-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-passkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-passkey}"
SRC_URI[x86_64_v2_sssd-passkey.sha256sum] = "6959c92b6b7722d5e21a89679dff09f34b64c88a34f2046aa5b7d8e3cf9c3b37"

URI_x86_64_v2_sssd-proxy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-proxy-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-proxy}"
SRC_URI[x86_64_v2_sssd-proxy.sha256sum] = "e3a4430f559f8538281e8177e6502b6bf4db9985a8a74fdcb34a13e0a94f001c"

URI_x86_64_v2_sssd-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-tools-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-tools}"
SRC_URI[x86_64_v2_sssd-tools.sha256sum] = "493e8fef3574afaacc7d635ff5c8fe2a78a32b634db2833296ce8be3f8fd78ea"

URI_x86_64_v2_sssd-winbind-idmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sssd-winbind-idmap-2.10.2-3.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_sssd-winbind-idmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sssd-winbind-idmap}"
SRC_URI[x86_64_v2_sssd-winbind-idmap.sha256sum] = "6d07eb417b3ee06451bbe79a3dca3e211d4f54a81c51e91dc22e375281a13680"

URI_aarch64_libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libipa_hbac-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_aarch64_libipa_hbac}"
SRC_URI[aarch64_libipa_hbac.sha256sum] = "4a4b7ad94e9faf2ed495cdb094a06f6cd69dc2b11a1bb3f3ebd91030f20fc70d"

URI_aarch64_libsss_autofs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_autofs-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_libsss_autofs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_autofs}"
SRC_URI[aarch64_libsss_autofs.sha256sum] = "3abfffd74e3e87847cbe011fa34de806bc18fba0c9a75434432803fc57189d3e"

URI_aarch64_libsss_certmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_certmap-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_libsss_certmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_certmap}"
SRC_URI[aarch64_libsss_certmap.sha256sum] = "e07828a94c9701046795ba75867095933ba2802fcfdc984454ad08d359816997"

URI_aarch64_libsss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_idmap-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_libsss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_idmap}"
SRC_URI[aarch64_libsss_idmap.sha256sum] = "e599a164e6c0e4e4d86376a8d4cb551f5552d0cb8ab50fcf74dffe754a1a0cd5"

URI_aarch64_libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_nss_idmap-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_nss_idmap}"
SRC_URI[aarch64_libsss_nss_idmap.sha256sum] = "5ba4ed28f5a95d34e711a428dbae3d93a216191e357116dde04ec813f79ce34a"

URI_aarch64_libsss_nss_idmap-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsss_nss_idmap-devel-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_libsss_nss_idmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_nss_idmap-devel}"
SRC_URI[aarch64_libsss_nss_idmap-devel.sha256sum] = "80f094a742673ea418bae6c40225eb8ac386d13d2a53cf3fd5ea10cda2a03c54"

URI_aarch64_libsss_sudo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsss_sudo-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_libsss_sudo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsss_sudo}"
SRC_URI[aarch64_libsss_sudo.sha256sum] = "6011eeae3496d00d1d418524c75fa168f3641afdfc71bbd9ae6a30cb8c6167c2"

URI_aarch64_python3-libipa_hbac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libipa_hbac-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_python3-libipa_hbac;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libipa_hbac}"
SRC_URI[aarch64_python3-libipa_hbac.sha256sum] = "586839983a4127523b52b8b62bf6acca7215f0234454294984044733c54006a5"

URI_aarch64_python3-libsss_nss_idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libsss_nss_idmap-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_python3-libsss_nss_idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libsss_nss_idmap}"
SRC_URI[aarch64_python3-libsss_nss_idmap.sha256sum] = "05050d4aeec3e4bb106e55cad0687de00d2a25a34da63aeb9f57d3bc926fcabd"

URI_aarch64_python3-sss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sss-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_python3-sss;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sss}"
SRC_URI[aarch64_python3-sss.sha256sum] = "efcd46179fcb08c9070de48f9f68d4541fa591be4be24cd8b817f6bc404ce670"

URI_aarch64_python3-sss-murmur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sss-murmur-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_python3-sss-murmur;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sss-murmur}"
SRC_URI[aarch64_python3-sss-murmur.sha256sum] = "b0cecd4211603a93e415bbbc19b16e1e233522d68077e30d83b46c48554b476e"

URI_aarch64_python3-sssdconfig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-sssdconfig-2.10.2-3.el10_0.3.noarch.rpm;name=aarch64_python3-sssdconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sssdconfig}"
SRC_URI[aarch64_python3-sssdconfig.sha256sum] = "7e4b26aee2e7453221b25613fc7c72167e8d99db2244de831ad5ed00854f4a83"

URI_aarch64_sssd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd}"
SRC_URI[aarch64_sssd.sha256sum] = "00871b16cf43b36210457038b3ac0bf5ad675b025d7089317690701f28c5a870"

URI_aarch64_sssd-ad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ad-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-ad;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ad}"
SRC_URI[aarch64_sssd-ad.sha256sum] = "4d0e11478dde5bfe5ab98ccea15c5cf274afdf941e51b93ad526bcbcf2f182a6"

URI_aarch64_sssd-client = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-client-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-client}"
SRC_URI[aarch64_sssd-client.sha256sum] = "57fb56e68876e6e7c924154f9f767dd6d3886395aef90dc4251efe6a17a37319"

URI_aarch64_sssd-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-common-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-common}"
SRC_URI[aarch64_sssd-common.sha256sum] = "f489c95ea91f359c93f3b01afe7cd9ee5eac9ee7cf17bb854dfffa19cab69d5f"

URI_aarch64_sssd-common-pac = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-common-pac-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-common-pac;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-common-pac}"
SRC_URI[aarch64_sssd-common-pac.sha256sum] = "a328c577660291edcf211ea7b18806efe1c32edfafe04289f05f76129e9bf9a7"

URI_aarch64_sssd-dbus = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-dbus-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-dbus}"
SRC_URI[aarch64_sssd-dbus.sha256sum] = "8e596ba44002a6cc64e3d801356a3024f649970133a75162646b8ebdcdbd144e"

URI_aarch64_sssd-idp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sssd-idp-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-idp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-idp}"
SRC_URI[aarch64_sssd-idp.sha256sum] = "9fe4e7e136bb8412367b9185f6b031f11600c4243a82b6042da503337a3271c2"

URI_aarch64_sssd-ipa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ipa-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-ipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ipa}"
SRC_URI[aarch64_sssd-ipa.sha256sum] = "841810f83364e14ae5af794eb5a7eda55cda8c5b9ce981689a47ab169efcb900"

URI_aarch64_sssd-kcm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-kcm-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-kcm}"
SRC_URI[aarch64_sssd-kcm.sha256sum] = "ce174bc5ade22433d02f6e24eb50aa9835395abad740c80e708ff113ecb2fc96"

URI_aarch64_sssd-krb5 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-krb5-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-krb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-krb5}"
SRC_URI[aarch64_sssd-krb5.sha256sum] = "5e489dc79241385411436a5e2a2ebaf8f2ea3d3317e80e6f34c4f8e2fe5619ab"

URI_aarch64_sssd-krb5-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-krb5-common-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-krb5-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-krb5-common}"
SRC_URI[aarch64_sssd-krb5-common.sha256sum] = "12585e9bf1a62f9251fce932640ce8336d7bfc5692d9251ef1f831e6a94c559a"

URI_aarch64_sssd-ldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-ldap-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-ldap}"
SRC_URI[aarch64_sssd-ldap.sha256sum] = "d36f96578138c54c98b3d5b940b5ac0852c503199bbfa15fad3a0b043aaada14"

URI_aarch64_sssd-nfs-idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-nfs-idmap-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-nfs-idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-nfs-idmap}"
SRC_URI[aarch64_sssd-nfs-idmap.sha256sum] = "10ac6ac720a355ed26989e6705b92f913598a4f8f554fed1cfb469059f874197"

URI_aarch64_sssd-passkey = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-passkey-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-passkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-passkey}"
SRC_URI[aarch64_sssd-passkey.sha256sum] = "ec2697e64113f858b5508decea1e44e4db8fd0cac2cb479442c72f4dc93936af"

URI_aarch64_sssd-proxy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-proxy-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-proxy}"
SRC_URI[aarch64_sssd-proxy.sha256sum] = "d67c678de7251b6cf2583672c89da18dffdaff6e18ba6ada01f8731dde8799ab"

URI_aarch64_sssd-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-tools-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-tools}"
SRC_URI[aarch64_sssd-tools.sha256sum] = "306ae36daa627ee47c3c29a618cd58727f9a1e922ea0928871524541d388cb1e"

URI_aarch64_sssd-winbind-idmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sssd-winbind-idmap-2.10.2-3.el10_0.3.aarch64.rpm;name=aarch64_sssd-winbind-idmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_sssd-winbind-idmap}"
SRC_URI[aarch64_sssd-winbind-idmap.sha256sum] = "e3c53c7771f86e36ed3e8238a4c2eec21cfed4c75695ff7f619118c2dca96c1b"

RDEPENDS:libipa_hbac = " \
 glibc \
 libunistring \
 "
RDEPENDS:libsss_autofs = " \
 glibc \
 "
RDEPENDS:libsss_certmap = " \
 glibc \
 libtalloc \
 openssl-libs \
 "
RDEPENDS:libsss_idmap = " \
 glibc \
 "
RDEPENDS:libsss_nss_idmap = " \
 glibc \
 "
RDEPENDS:libsss_nss_idmap-devel = " \
 libsss_nss_idmap \
 pkgconf-pkg-config \
 "
RDEPENDS:libsss_sudo = " \
 glibc \
 "
RDEPENDS:python3-libipa_hbac = " \
 glibc \
 libipa_hbac \
 libunistring \
 python3 \
 "
RDEPENDS:python3-libsss_nss_idmap = " \
 glibc \
 libsss_nss_idmap \
 python3 \
 "
RDEPENDS:python3-sss = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcap \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 python3 \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:python3-sss-murmur = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-sssdconfig = " \
 python3 \
 "
RDEPENDS:sssd = " \
 shadow-utils \
 sssd-ad \
 sssd-common \
 sssd-ipa \
 sssd-krb5 \
 sssd-ldap \
 sssd-proxy \
 "
RDEPENDS:sssd-ad = " \
 cyrus-sasl-lib \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsmbclient \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-client = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 libcom_err \
 libsss_idmap \
 libsss_nss_idmap \
 pam-libs \
 "
RDEPENDS:sssd-common = " \
 bash \
 c-ares \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libnl3 \
 libref_array \
 libselinux \
 libsss_autofs \
 libsss_certmap \
 libsss_idmap \
 libsss_sudo \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 p11-kit \
 pam-libs \
 pcre2 \
 popt \
 shadow-utils \
 sssd-client \
 sssd-nfs-idmap \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
RDEPENDS:sssd-common-pac = " \
 glibc \
 libldb \
 libselinux \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 popt \
 samba-client-libs \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-dbus = " \
 bash \
 dbus-libs \
 glibc \
 libdhash \
 libldb \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 popt \
 sssd-common \
 systemd \
 systemd-libs \
 "
RDEPENDS:sssd-idp = " \
 glibc \
 jansson \
 krb5-libs \
 libcom_err \
 libjose \
 libtalloc \
 popt \
 sssd-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:sssd-ipa = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libipa_hbac \
 libldb \
 libref_array \
 libselinux \
 libsemanage \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 samba-client-libs \
 sssd-common \
 sssd-common-pac \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-kcm = " \
 bash \
 glibc \
 krb5-libs \
 libdhash \
 libldb \
 libselinux \
 libtalloc \
 libtevent \
 libuuid \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd \
 systemd-libs \
 "
RDEPENDS:sssd-krb5 = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-krb5-common = " \
 cyrus-sasl-gssapi \
 glibc \
 jansson \
 krb5-libs \
 libcap \
 libtalloc \
 popt \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-ldap = " \
 dbus-libs \
 glibc \
 keyutils-libs \
 krb5-libs \
 libbasicobjects \
 libcap \
 libcollection \
 libcom_err \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libsss_idmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openldap \
 openssl-libs \
 pcre2 \
 popt \
 sssd-common \
 sssd-krb5-common \
 systemd-libs \
 "
RDEPENDS:sssd-nfs-idmap = " \
 glibc \
 libnfsidmap \
 "
RDEPENDS:sssd-passkey = " \
 acl \
 glibc \
 jansson \
 krb5-libs \
 libcom_err \
 libfido2 \
 libtalloc \
 openssl-libs \
 popt \
 sssd-common \
 "
RDEPENDS:sssd-proxy = " \
 dbus-libs \
 glibc \
 libbasicobjects \
 libcap \
 libcollection \
 libdhash \
 libini_config \
 libldb \
 libref_array \
 libselinux \
 libsss_certmap \
 libtalloc \
 libtdb \
 libtevent \
 libunistring \
 openssl-libs \
 pam-libs \
 pcre2 \
 popt \
 sssd-common \
 systemd-libs \
 "
RDEPENDS:sssd-tools = " \
 bash \
 glibc \
 libdhash \
 libldb \
 libref_array \
 libsss_certmap \
 libtalloc \
 pam-libs \
 popt \
 python3 \
 python3-sss \
 python3-sssdconfig \
 python3-systemd \
 sssd-common \
 sssd-dbus \
 "
RDEPENDS:sssd-winbind-idmap = " \
 glibc \
 libsss_idmap \
 libsss_nss_idmap \
 libtalloc \
 "
