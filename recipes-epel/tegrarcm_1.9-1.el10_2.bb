# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tegrarcm"
PV = "1.9"
PR = "1.el10_2"
PACKAGES = " \
 tegrarcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tegrarcm-1.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7780b2721f33cdfd7aac7360e2b288f6ad46912bb0739e251439367546985679"

URI_x86_64_v2_tegrarcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tegrarcm-1.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tegrarcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tegrarcm}"
SRC_URI[x86_64_v2_tegrarcm.sha256sum] = "29b02556902b8f7c6bd192e64ba93363d66da0a890330362aaef1ca6e3e39fe5"

URI_aarch64_tegrarcm = "${EPEL_MIRROR}/aarch64/Packages/t/tegrarcm-1.9-1.el10_2.aarch64.rpm;name=aarch64_tegrarcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_tegrarcm}"
SRC_URI[aarch64_tegrarcm.sha256sum] = "07dc6d35efe817e73edbf64781d821ca15c4a6c4f168c1dd1d5c1acfea560d38"

RDEPENDS:tegrarcm = " \
 cryptopp \
 glibc \
 libgcc \
 libstdc++ \
 libusb1 \
 "
