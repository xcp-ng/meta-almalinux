# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "texlive-extension"
PE = "13"
PV = "20240311"
PR = "10.el10_2"
PACKAGES = " \
 texlive-adobemapping \
 texlive-ascmac \
 texlive-atenddvi \
 texlive-auto-pst-pdf \
 texlive-babel-french \
 texlive-babel-german \
 texlive-bibunits \
 texlive-boondox \
 texlive-chemformula \
 texlive-chemgreek \
 texlive-chktex \
 texlive-cjk \
 texlive-cjkpunct \
 texlive-convbkmk \
 texlive-ctex \
 texlive-ctie \
 texlive-cweb \
 texlive-ellipse \
 texlive-emulateapj \
 texlive-everyhook \
 texlive-fandol \
 texlive-filemod \
 texlive-fltpoint \
 texlive-fontaxes \
 texlive-german \
 texlive-germbib \
 texlive-gincltex \
 texlive-glossaries-english \
 texlive-glossaries-french \
 texlive-glossaries-german \
 texlive-hyphen-german \
 texlive-ieeetran \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-kantlipsum \
 texlive-lacheck \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-lipsum \
 texlive-listingsutf8 \
 texlive-ltablex \
 texlive-luatexja \
 texlive-mdframed \
 texlive-media9 \
 texlive-mhchem \
 texlive-newtx \
 texlive-nomencl \
 texlive-ntheorem \
 texlive-ocgx2 \
 texlive-opensans \
 texlive-pgfplots \
 texlive-picinpar \
 texlive-pict2e \
 texlive-picture \
 texlive-platex \
 texlive-platex-tools \
 texlive-ps2eps \
 texlive-ptex \
 texlive-ptex-base \
 texlive-ptex-fonts \
 texlive-revtex4 \
 texlive-selinput \
 texlive-sidecap \
 texlive-siunitx \
 texlive-slantsc \
 texlive-standalone \
 texlive-sttools \
 texlive-supertabular \
 texlive-tcolorbox \
 texlive-tie \
 texlive-tikzfill \
 texlive-ttfutils \
 texlive-units \
 texlive-uplatex \
 texlive-uptex \
 texlive-uptex-base \
 texlive-uptex-fonts \
 texlive-web \
 texlive-xcjk2uni \
 texlive-xecjk \
 texlive-xltabular \
 texlive-xpinyin \
 texlive-zhmetrics \
 texlive-zhmetrics-uptex \
 texlive-zhnumber \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/texlive-extension-20240311-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d14e8763750da5fd88780a468d2749aba4b85ee8b24a15dad74da1b382238a17"

URI_x86_64_v2_texlive-adobemapping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-adobemapping-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-adobemapping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-adobemapping}"
SRC_URI[x86_64_v2_texlive-adobemapping.sha256sum] = "7a91a3607e1298573ac1917d7ca6582dcd81f49fc7db7fc0b3d093fa609f62b5"

URI_x86_64_v2_texlive-ascmac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ascmac-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ascmac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ascmac}"
SRC_URI[x86_64_v2_texlive-ascmac.sha256sum] = "f30f776ef8ba8cdbb7dc2af8427e6ee2ef4f9331910bca10d32126b774602d6a"

URI_x86_64_v2_texlive-atenddvi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-atenddvi-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-atenddvi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-atenddvi}"
SRC_URI[x86_64_v2_texlive-atenddvi.sha256sum] = "bc5f11ecd408b5fd775a3699da5217337c4f08f3eff198809659781eed62ceda"

URI_x86_64_v2_texlive-auto-pst-pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-auto-pst-pdf-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-auto-pst-pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-auto-pst-pdf}"
SRC_URI[x86_64_v2_texlive-auto-pst-pdf.sha256sum] = "9114e68b38197c8b014620cc6a43b1819667d9bee4f0e44b33446f4240a9f4a7"

URI_x86_64_v2_texlive-babel-french = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-babel-french-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-babel-french;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel-french}"
SRC_URI[x86_64_v2_texlive-babel-french.sha256sum] = "2a44fd8fa135de6a30cc34455ea649980ed0a95bbf32a87e680d2c8471c73199"

URI_x86_64_v2_texlive-babel-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-babel-german-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-babel-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel-german}"
SRC_URI[x86_64_v2_texlive-babel-german.sha256sum] = "7ea76d95731180bca0d1412df9e43f0a5572590efab479fa261585f78dc49374"

URI_x86_64_v2_texlive-bibunits = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-bibunits-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-bibunits;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bibunits}"
SRC_URI[x86_64_v2_texlive-bibunits.sha256sum] = "d1edd26b32ccd1dbb78b0d56f98cd61ccab4c390733c588bcebbb390b6dedb84"

URI_x86_64_v2_texlive-boondox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-boondox-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-boondox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-boondox}"
SRC_URI[x86_64_v2_texlive-boondox.sha256sum] = "0c0f97b9f1bacdcd5af2e0870e41ffc1a36cd8999b64f07484b6b64415d51455"

URI_x86_64_v2_texlive-chemformula = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chemformula-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-chemformula;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chemformula}"
SRC_URI[x86_64_v2_texlive-chemformula.sha256sum] = "dd2d7716acbb3a7294f31dfa3a580b75bb568bda3e743766d65fb489356fb6c3"

URI_x86_64_v2_texlive-chemgreek = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chemgreek-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-chemgreek;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chemgreek}"
SRC_URI[x86_64_v2_texlive-chemgreek.sha256sum] = "35db3d05f659a7d132dc980d3968ef18310afb86f6bc9bfa788c4c9ffa4ac20f"

URI_x86_64_v2_texlive-chktex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-chktex-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-chktex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chktex}"
SRC_URI[x86_64_v2_texlive-chktex.sha256sum] = "f68ed51d156c153736bb137e4a5b2ab10b01fdfe8ce0e122843caa44b2067ece"

URI_x86_64_v2_texlive-cjk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cjk-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-cjk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cjk}"
SRC_URI[x86_64_v2_texlive-cjk.sha256sum] = "e1c842f28b41676fd09714c74cf79d1f75f5aeefc88e91ace282786fc258ee09"

URI_x86_64_v2_texlive-cjkpunct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cjkpunct-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-cjkpunct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cjkpunct}"
SRC_URI[x86_64_v2_texlive-cjkpunct.sha256sum] = "c535188a3e3430a3f7d4511b814769b5678b6db82edbcb179ca61fe0612d55da"

URI_x86_64_v2_texlive-convbkmk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-convbkmk-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-convbkmk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-convbkmk}"
SRC_URI[x86_64_v2_texlive-convbkmk.sha256sum] = "eb50aef190270888312c810241c983040afa333786a6dda7559327e9f5225c25"

URI_x86_64_v2_texlive-ctex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ctex-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ctex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctex}"
SRC_URI[x86_64_v2_texlive-ctex.sha256sum] = "984d3349b5dfbdb6d8b3d8f7626f62b35d8aa7919c6f1819acd598b01b70f560"

URI_x86_64_v2_texlive-ctie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ctie-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ctie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctie}"
SRC_URI[x86_64_v2_texlive-ctie.sha256sum] = "89dd60dcf1010170630a2a5f945fd1b06a760281e48178604f415eb9d5804cf5"

URI_x86_64_v2_texlive-cweb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-cweb-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-cweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cweb}"
SRC_URI[x86_64_v2_texlive-cweb.sha256sum] = "d68020c6a000ce92aada7a497abd71de15d751868fa30a0155e09314ff9f2825"

URI_x86_64_v2_texlive-ellipse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ellipse-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ellipse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ellipse}"
SRC_URI[x86_64_v2_texlive-ellipse.sha256sum] = "cee59523e9be7956efbbb84dd34243b4ba4578d85d0be2757a6b511ed7527c2c"

URI_x86_64_v2_texlive-emulateapj = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-emulateapj-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-emulateapj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-emulateapj}"
SRC_URI[x86_64_v2_texlive-emulateapj.sha256sum] = "c6ff6d953bf9df406dd1af38ae76b110ca6b025d5a3ef20a538586c0859059db"

URI_x86_64_v2_texlive-everyhook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-everyhook-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-everyhook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-everyhook}"
SRC_URI[x86_64_v2_texlive-everyhook.sha256sum] = "e873e98432d4158ae2df63b53370348a2a632321b35b7eb8bb876d2e8524dc1a"

URI_x86_64_v2_texlive-fandol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fandol-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fandol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fandol}"
SRC_URI[x86_64_v2_texlive-fandol.sha256sum] = "8d4854a4cafe43593707f8c87f5b79b522bb0e6aeda1166e45cba4969777a1d4"

URI_x86_64_v2_texlive-filemod = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-filemod-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-filemod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-filemod}"
SRC_URI[x86_64_v2_texlive-filemod.sha256sum] = "78a437f785785768214fb1bdc976bad5860a0de009cddd2e4f1a130277b4b05d"

URI_x86_64_v2_texlive-fltpoint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fltpoint-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fltpoint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fltpoint}"
SRC_URI[x86_64_v2_texlive-fltpoint.sha256sum] = "f4ef452aab21075f7fd324c92ef54c7847ed7e0a6a474548b5b61278808d4a41"

URI_x86_64_v2_texlive-fontaxes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-fontaxes-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-fontaxes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontaxes}"
SRC_URI[x86_64_v2_texlive-fontaxes.sha256sum] = "2c8e1554d2d96653293715fc7107e261c92fd314ef201bfb55bdf22fd678dfd9"

URI_x86_64_v2_texlive-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-german-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-german}"
SRC_URI[x86_64_v2_texlive-german.sha256sum] = "18045ac53d2f5c9f791202ef764998394837dd8538f09ac221495060f5b791cf"

URI_x86_64_v2_texlive-germbib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-germbib-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-germbib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-germbib}"
SRC_URI[x86_64_v2_texlive-germbib.sha256sum] = "4581a702763d3e811efd36c748524e0dd3793afb6d27d5e05487eead26f00f24"

URI_x86_64_v2_texlive-gincltex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-gincltex-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-gincltex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-gincltex}"
SRC_URI[x86_64_v2_texlive-gincltex.sha256sum] = "7b6c2f7cd47711065e3387d79f2a2f34adff36029231173fe1b1eeec53ae0ca7"

URI_x86_64_v2_texlive-glossaries-english = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-english-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-english;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-english}"
SRC_URI[x86_64_v2_texlive-glossaries-english.sha256sum] = "87df4cff1a55c0b4611a3aaba1e3725696d73ae4095c523de171cf0de375c7ec"

URI_x86_64_v2_texlive-glossaries-french = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-french-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-french;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-french}"
SRC_URI[x86_64_v2_texlive-glossaries-french.sha256sum] = "5011fc0f494179c3fa83c703a2974c4703ba0bf810748d7058924521e5e9ea5c"

URI_x86_64_v2_texlive-glossaries-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-glossaries-german-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-glossaries-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glossaries-german}"
SRC_URI[x86_64_v2_texlive-glossaries-german.sha256sum] = "981b080bbf524df4b38b60a165eff2f87356dd24af7ec62906ab21639bef48b3"

URI_x86_64_v2_texlive-hyphen-german = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-hyphen-german-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-hyphen-german;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyphen-german}"
SRC_URI[x86_64_v2_texlive-hyphen-german.sha256sum] = "5fcac79ab394f0c57e8e854a79d7aa6bba41d54f68e1e3695222a14624d842ad"

URI_x86_64_v2_texlive-ieeetran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ieeetran-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ieeetran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ieeetran}"
SRC_URI[x86_64_v2_texlive-ieeetran.sha256sum] = "947555ff438352c8c012d3a655283130ada71d856ab2ded1518f2050a5603b58"

URI_x86_64_v2_texlive-ipaex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ipaex-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ipaex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ipaex}"
SRC_URI[x86_64_v2_texlive-ipaex.sha256sum] = "8aba2a89715087815737a0fd80ffeb39d73ccd8c75652671d0ca3e44087e9710"

URI_x86_64_v2_texlive-japanese-otf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-japanese-otf-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-japanese-otf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-japanese-otf}"
SRC_URI[x86_64_v2_texlive-japanese-otf.sha256sum] = "22a2e1ee4eea9b283fca1761313fc68229817f359eb8c750fea9b341d5772aad"

URI_x86_64_v2_texlive-kantlipsum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-kantlipsum-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-kantlipsum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kantlipsum}"
SRC_URI[x86_64_v2_texlive-kantlipsum.sha256sum] = "ee66988d3b3dbec7bc4cf9b24c3173bb647079a06b00ebaeb1b8101b40180ab4"

URI_x86_64_v2_texlive-lacheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-lacheck-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-lacheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lacheck}"
SRC_URI[x86_64_v2_texlive-lacheck.sha256sum] = "9329195a4a7581c99f9b3374f3a2b0f746d9494092d5b6672eb8dd42b2feb7f5"

URI_x86_64_v2_texlive-latex-base-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-latex-base-dev-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-latex-base-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex-base-dev}"
SRC_URI[x86_64_v2_texlive-latex-base-dev.sha256sum] = "8829157739ae11a4c0f3c49d340ee096f3a32a85a40ac422cf575afdb93297bc"
RPROVIDES:texlive-latex-base-dev:x86_64_v2 = "virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_"

URI_x86_64_v2_texlive-latex-firstaid-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-latex-firstaid-dev-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-latex-firstaid-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex-firstaid-dev}"
SRC_URI[x86_64_v2_texlive-latex-firstaid-dev.sha256sum] = "85cbb954901298496ab7452df6ef9bdeb1846c91c211af69dee6df4d49eb67df"

URI_x86_64_v2_texlive-lipsum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-lipsum-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-lipsum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lipsum}"
SRC_URI[x86_64_v2_texlive-lipsum.sha256sum] = "af5f949273b779adf1b514bf49d723980e348b2a6d9ca13fee14221c8847f53c"

URI_x86_64_v2_texlive-listingsutf8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-listingsutf8-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-listingsutf8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-listingsutf8}"
SRC_URI[x86_64_v2_texlive-listingsutf8.sha256sum] = "0ea4a0ff0cc11eda0406ac029c76ae51e13d6a70ae80a12178cbec5416184c02"

URI_x86_64_v2_texlive-ltablex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ltablex-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ltablex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ltablex}"
SRC_URI[x86_64_v2_texlive-ltablex.sha256sum] = "9b92e9c51cfb199835bddb10cc8cbdcd486fb6eda51f03a9d2b0ea4ec432a5c9"

URI_x86_64_v2_texlive-luatexja = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-luatexja-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-luatexja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luatexja}"
SRC_URI[x86_64_v2_texlive-luatexja.sha256sum] = "e8b2b2ed3b5ec72d20c6eb88c574d0e57ab05ff872502a351c5a3fc924ac852c"

URI_x86_64_v2_texlive-mdframed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-mdframed-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-mdframed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mdframed}"
SRC_URI[x86_64_v2_texlive-mdframed.sha256sum] = "9c97709b45d1cd52625efc9d950a130d4898201004b15b274d21ef2f0696fe2b"

URI_x86_64_v2_texlive-media9 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-media9-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-media9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-media9}"
SRC_URI[x86_64_v2_texlive-media9.sha256sum] = "f9c3ab415a44f3a55a94d32247a87da07ab634dadd48a85ee222b23e95cb2695"

URI_x86_64_v2_texlive-mhchem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-mhchem-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-mhchem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mhchem}"
SRC_URI[x86_64_v2_texlive-mhchem.sha256sum] = "fed235f499186f30d336c2ae95cb3e72b89129a9d08715ab53ae9108e8f867f0"

URI_x86_64_v2_texlive-newtx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-newtx-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-newtx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-newtx}"
SRC_URI[x86_64_v2_texlive-newtx.sha256sum] = "6088f761913b034b26eaeda72d82ad368767ff48f71d2aa3dd7bec0ad62aaaff"

URI_x86_64_v2_texlive-nomencl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-nomencl-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-nomencl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-nomencl}"
SRC_URI[x86_64_v2_texlive-nomencl.sha256sum] = "2cc0983b5f119ec796bf7c15190fc7e4456c46f50e13d490ddec5cccf0d0497c"

URI_x86_64_v2_texlive-ntheorem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ntheorem-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ntheorem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ntheorem}"
SRC_URI[x86_64_v2_texlive-ntheorem.sha256sum] = "cf8904b17a1aa02193cdf23767e2bcf83b81e14f253757f1f6a83666b009343e"

URI_x86_64_v2_texlive-ocgx2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ocgx2-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ocgx2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ocgx2}"
SRC_URI[x86_64_v2_texlive-ocgx2.sha256sum] = "9cd2313dc9aabc44cfd24f698a4c36420ac5f7ea3300a6b34f4997a304eacfbe"

URI_x86_64_v2_texlive-opensans = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-opensans-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-opensans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-opensans}"
SRC_URI[x86_64_v2_texlive-opensans.sha256sum] = "5d0f005575df79bcfcc1d876dd6b8f0b4a3723a117e8a2d6551daa88a165a5ce"

URI_x86_64_v2_texlive-pgfplots = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-pgfplots-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-pgfplots;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pgfplots}"
SRC_URI[x86_64_v2_texlive-pgfplots.sha256sum] = "bbe0d2f3aeb6a879dba1bb958d675fecb950badb2d1926df176aef819b0dade3"

URI_x86_64_v2_texlive-picinpar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-picinpar-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-picinpar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-picinpar}"
SRC_URI[x86_64_v2_texlive-picinpar.sha256sum] = "d22c47d8e26ec4b1c0e883e9f4a694cca90f8cda354451ccae50a87fd29f9603"

URI_x86_64_v2_texlive-pict2e = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-pict2e-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-pict2e;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pict2e}"
SRC_URI[x86_64_v2_texlive-pict2e.sha256sum] = "5ff230353d7f29f37af152bf5edb2186584732b22188365379877dc1701ae54c"

URI_x86_64_v2_texlive-picture = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-picture-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-picture;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-picture}"
SRC_URI[x86_64_v2_texlive-picture.sha256sum] = "1d5d1d2ea08ed430ab895832cf7c7c8a9c8ac7812d5eb07653e8e6de07f8b242"

URI_x86_64_v2_texlive-platex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-platex-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-platex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-platex}"
SRC_URI[x86_64_v2_texlive-platex.sha256sum] = "a5a2aa7e0225986ea604eb6c7aa207e8fac493027774d9c4c02a02d38e12f9d4"

URI_x86_64_v2_texlive-platex-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-platex-tools-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-platex-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-platex-tools}"
SRC_URI[x86_64_v2_texlive-platex-tools.sha256sum] = "aa65ec2d29cd62f85bb5d3c4220e430460c3bd5f6da4e697cf7d3ad97f370086"

URI_x86_64_v2_texlive-ps2eps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ps2eps-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ps2eps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ps2eps}"
SRC_URI[x86_64_v2_texlive-ps2eps.sha256sum] = "3397f35b6377161e1ad06928e00da41967270fbbf6c4c055c69526e47c82bfb2"

URI_x86_64_v2_texlive-ptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex}"
SRC_URI[x86_64_v2_texlive-ptex.sha256sum] = "69547ea9792c9370d9e5f1fdccd897cce6afdb3c265ddfdffda79bfa45814604"

URI_x86_64_v2_texlive-ptex-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-base-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ptex-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex-base}"
SRC_URI[x86_64_v2_texlive-ptex-base.sha256sum] = "2464a1d0ee50aac41ffd659f1dfc26359ccae89fb523222808b93becaa739e2b"

URI_x86_64_v2_texlive-ptex-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ptex-fonts-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-ptex-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptex-fonts}"
SRC_URI[x86_64_v2_texlive-ptex-fonts.sha256sum] = "fafbb56e2c708466bdaa74319d07f416d46755898722a73dfc99fc7b95dc81d1"

URI_x86_64_v2_texlive-revtex4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-revtex4-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-revtex4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-revtex4}"
SRC_URI[x86_64_v2_texlive-revtex4.sha256sum] = "b5188f81c89c6a121570659a92ab2c9858511258dcfa8312708db7a0fa7c151e"

URI_x86_64_v2_texlive-selinput = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-selinput-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-selinput;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-selinput}"
SRC_URI[x86_64_v2_texlive-selinput.sha256sum] = "87fd77bc2801e6bc5b8e04b8572be079e6b93ab932896e729f3a5e2ff724adba"

URI_x86_64_v2_texlive-sidecap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-sidecap-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-sidecap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sidecap}"
SRC_URI[x86_64_v2_texlive-sidecap.sha256sum] = "04d091328342b5700ff0b4985e5196088e9d8e762566b5801767e267a5e947ba"

URI_x86_64_v2_texlive-siunitx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-siunitx-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-siunitx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-siunitx}"
SRC_URI[x86_64_v2_texlive-siunitx.sha256sum] = "b8529390b3041f42f66baeaa922f28652cc8d740ff9b61bc3233ae8a00834358"

URI_x86_64_v2_texlive-slantsc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-slantsc-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-slantsc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-slantsc}"
SRC_URI[x86_64_v2_texlive-slantsc.sha256sum] = "1d7b9849c0c5f5b7f9cecfad4ffdc3b51085397415dc32e3d71bee6fbdd0d913"

URI_x86_64_v2_texlive-standalone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-standalone-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-standalone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-standalone}"
SRC_URI[x86_64_v2_texlive-standalone.sha256sum] = "3331871ef3900329bd85b99a72eac3b9590b05e4bda4982a40578825af5a32c7"

URI_x86_64_v2_texlive-sttools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-sttools-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-sttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sttools}"
SRC_URI[x86_64_v2_texlive-sttools.sha256sum] = "7ef417c1fdf26811a336ff261fb176ef67572aeb3da63cfd3c40650462e1c5c7"

URI_x86_64_v2_texlive-supertabular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-supertabular-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-supertabular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-supertabular}"
SRC_URI[x86_64_v2_texlive-supertabular.sha256sum] = "f04bfe805b3e6d290d8eee155fe00926592ddb9a0328236c44f6f5f9baf56e2b"

URI_x86_64_v2_texlive-tcolorbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tcolorbox-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-tcolorbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tcolorbox}"
SRC_URI[x86_64_v2_texlive-tcolorbox.sha256sum] = "28723745442c3f8b0fa446dd6b13d3da97063aec75c3f4d4ff97deb2ab5c7e74"

URI_x86_64_v2_texlive-tie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tie-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-tie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tie}"
SRC_URI[x86_64_v2_texlive-tie.sha256sum] = "1534d46e9fd19b946b69aafe1025373afc787f82892c37bc822aa3fd7964e919"

URI_x86_64_v2_texlive-tikzfill = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-tikzfill-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-tikzfill;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tikzfill}"
SRC_URI[x86_64_v2_texlive-tikzfill.sha256sum] = "0c191679b2eb8d18d63b0a7124384dc2c8639b37082a246fd931de496a2f599d"

URI_x86_64_v2_texlive-ttfutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-ttfutils-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-ttfutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ttfutils}"
SRC_URI[x86_64_v2_texlive-ttfutils.sha256sum] = "b77006ee4ffa629a2bea1ae8e15dd360806597e32ac274f090c01db7cbca26ae"

URI_x86_64_v2_texlive-units = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-units-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-units;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-units}"
SRC_URI[x86_64_v2_texlive-units.sha256sum] = "c0b3a7b62deffa8dade36ec8cbe727931f10f417c2705f4809e9c32c57270027"

URI_x86_64_v2_texlive-uplatex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uplatex-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uplatex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uplatex}"
SRC_URI[x86_64_v2_texlive-uplatex.sha256sum] = "88b45e3e7131b64498fa0eb08c4cd9894f73cb59eff3f1ffc2c5407438471789"

URI_x86_64_v2_texlive-uptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-uptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex}"
SRC_URI[x86_64_v2_texlive-uptex.sha256sum] = "8b158cecad3f2db280e4ebad55fe38bdcee62090a2b188b23e1134de2f8c7138"

URI_x86_64_v2_texlive-uptex-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-base-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uptex-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex-base}"
SRC_URI[x86_64_v2_texlive-uptex-base.sha256sum] = "6a93894f3f11b135fa8e3bfcd61ee5d5f6191b456c56e03b43f19285a54e071f"

URI_x86_64_v2_texlive-uptex-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-uptex-fonts-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-uptex-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uptex-fonts}"
SRC_URI[x86_64_v2_texlive-uptex-fonts.sha256sum] = "cb18d27d92fbf8c33028155154f1e52e33f393553679b49448d9d36e0fb32e97"

URI_x86_64_v2_texlive-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-web-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-web}"
SRC_URI[x86_64_v2_texlive-web.sha256sum] = "024e15c277a2e2efa37f731b5940adc96a3119973b7aef024deb7c5257dff489"

URI_x86_64_v2_texlive-xcjk2uni = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xcjk2uni-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xcjk2uni;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xcjk2uni}"
SRC_URI[x86_64_v2_texlive-xcjk2uni.sha256sum] = "d91b16cd6d7eb2c6bd584a63613f0d8f09a6363ebf9911b4c8edc51d4cd990a5"

URI_x86_64_v2_texlive-xecjk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xecjk-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xecjk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xecjk}"
SRC_URI[x86_64_v2_texlive-xecjk.sha256sum] = "84dee446d860cb7f5ff0cc84f129bcaaf7e6ecb5a6215d3f4f6473df596c0cbd"

URI_x86_64_v2_texlive-xltabular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xltabular-20240311-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_texlive-xltabular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xltabular}"
SRC_URI[x86_64_v2_texlive-xltabular.sha256sum] = "7e92c6fff335aad3ae4b84846844ee70ff189a56e5507d73c2dab47b90211aa6"

URI_x86_64_v2_texlive-xpinyin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-xpinyin-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-xpinyin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xpinyin}"
SRC_URI[x86_64_v2_texlive-xpinyin.sha256sum] = "e1b06a4f16a193de63de3b744567227f81254b651856a9975e42312eb9d6d780"

URI_x86_64_v2_texlive-zhmetrics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhmetrics-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhmetrics}"
SRC_URI[x86_64_v2_texlive-zhmetrics.sha256sum] = "ab514a4423ca693ac6bcbaf1e82bd0730837f40c6d031457042b4b8a85866ac4"

URI_x86_64_v2_texlive-zhmetrics-uptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhmetrics-uptex-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhmetrics-uptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhmetrics-uptex}"
SRC_URI[x86_64_v2_texlive-zhmetrics-uptex.sha256sum] = "a8d0015e0cee4e9fbd3e0df9882c71438e4601370846b9c3e3778944d7f09a57"

URI_x86_64_v2_texlive-zhnumber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/texlive-zhnumber-20240311-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_texlive-zhnumber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zhnumber}"
SRC_URI[x86_64_v2_texlive-zhnumber.sha256sum] = "5e63d9517f2b8286d1934098fbee9d710eb78ec6bed40ddecfe5136be5a4564f"

URI_aarch64_texlive-adobemapping = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-adobemapping-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-adobemapping;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-adobemapping}"
SRC_URI[aarch64_texlive-adobemapping.sha256sum] = "6b664fad3497971a733e86ae695112dd309242e494801594ec3e2cfee2c8bc37"

URI_aarch64_texlive-ascmac = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ascmac-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-ascmac;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ascmac}"
SRC_URI[aarch64_texlive-ascmac.sha256sum] = "ab31f2b1da098624d3b698fc6cb2ffae2ce65e5d449fbb04b03062160ce9793c"

URI_aarch64_texlive-atenddvi = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-atenddvi-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-atenddvi;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-atenddvi}"
SRC_URI[aarch64_texlive-atenddvi.sha256sum] = "5f804955b63b3440e84f90a6d4d37fc07d9b50a65deec187ef050da597a2a784"

URI_aarch64_texlive-auto-pst-pdf = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-auto-pst-pdf-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-auto-pst-pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-auto-pst-pdf}"
SRC_URI[aarch64_texlive-auto-pst-pdf.sha256sum] = "74f6062885fec94d85e96ca4cb87c8910d221f9a66c9610458103ae85f4e8954"

URI_aarch64_texlive-babel-french = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-babel-french-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-babel-french;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel-french}"
SRC_URI[aarch64_texlive-babel-french.sha256sum] = "f21ba05ea90177fba9a412b56fa982f62c3ad54e4fef6c6693d38eb787d4be31"

URI_aarch64_texlive-babel-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-babel-german-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-babel-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel-german}"
SRC_URI[aarch64_texlive-babel-german.sha256sum] = "a298f887d17a9bc0c3c592b162bcff017a6373eeccd1568e118ab6c39c4abdb9"

URI_aarch64_texlive-bibunits = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-bibunits-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-bibunits;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bibunits}"
SRC_URI[aarch64_texlive-bibunits.sha256sum] = "e39beefb12d5b18d4059b3f8c15f4d35f1a55aa0008b42a82a906992fe89ee9c"

URI_aarch64_texlive-boondox = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-boondox-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-boondox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-boondox}"
SRC_URI[aarch64_texlive-boondox.sha256sum] = "67e79c9d190750dfa19073b8a718356d807b7cbb985f57df69b513d6ea39f7a6"

URI_aarch64_texlive-chemformula = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chemformula-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-chemformula;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chemformula}"
SRC_URI[aarch64_texlive-chemformula.sha256sum] = "0027fc43c6c938049e938693be966a41317d004821bede9784f373cb765e3167"

URI_aarch64_texlive-chemgreek = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chemgreek-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-chemgreek;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chemgreek}"
SRC_URI[aarch64_texlive-chemgreek.sha256sum] = "d375c279033b4ec3edf3b2dc16fec1cca47ae501861259c2f26a69dda683de77"

URI_aarch64_texlive-chktex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-chktex-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-chktex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chktex}"
SRC_URI[aarch64_texlive-chktex.sha256sum] = "2e6bf9276e14f565d90e32b6a565c13175e7aee38d19ee4c6b0c42673a5619da"

URI_aarch64_texlive-cjk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cjk-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-cjk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cjk}"
SRC_URI[aarch64_texlive-cjk.sha256sum] = "d953d82af476f46a9fa6bc52f3105b6743810f26ceee94781a1a6c07a6428fe2"

URI_aarch64_texlive-cjkpunct = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cjkpunct-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-cjkpunct;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cjkpunct}"
SRC_URI[aarch64_texlive-cjkpunct.sha256sum] = "3c65f18a63e672cfa7b815811c7daa809d910b5aa72ea5495f41604fa4a7c967"

URI_aarch64_texlive-convbkmk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-convbkmk-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-convbkmk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-convbkmk}"
SRC_URI[aarch64_texlive-convbkmk.sha256sum] = "91c167858d947ce35e6d9ce93851a81a0a86db2571b44136a9ab1fba06b521bc"

URI_aarch64_texlive-ctex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ctex-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-ctex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctex}"
SRC_URI[aarch64_texlive-ctex.sha256sum] = "a7c073bd7cf67f38571c459cc043ce61daf64cd0e2b7780f1403470fa55bbacd"

URI_aarch64_texlive-ctie = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ctie-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-ctie;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctie}"
SRC_URI[aarch64_texlive-ctie.sha256sum] = "7b6abd8ee901551da9fcbcd84c3eea17eea3868c025ad4ef75c9ab73c3260af9"

URI_aarch64_texlive-cweb = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-cweb-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-cweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cweb}"
SRC_URI[aarch64_texlive-cweb.sha256sum] = "3739621c16003e1e334da25d4c02481d423ff8233c77b6e42a5a46e817541b2e"

URI_aarch64_texlive-ellipse = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ellipse-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-ellipse;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ellipse}"
SRC_URI[aarch64_texlive-ellipse.sha256sum] = "8bfa67dd9ab2ef2659c43c76e7be4ceabb0ed718916baf432333ed38dddba099"

URI_aarch64_texlive-emulateapj = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-emulateapj-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-emulateapj;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-emulateapj}"
SRC_URI[aarch64_texlive-emulateapj.sha256sum] = "f00839100ab176e66fe980d09d77baa2f6d4f7f8d6d05d6d4d8dc313e978385b"

URI_aarch64_texlive-everyhook = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-everyhook-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-everyhook;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-everyhook}"
SRC_URI[aarch64_texlive-everyhook.sha256sum] = "8e8357e26bec34297a1ddd6d1ba0736b349f72e67a44d90ebf0f7056d1211e5b"

URI_aarch64_texlive-fandol = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fandol-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-fandol;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fandol}"
SRC_URI[aarch64_texlive-fandol.sha256sum] = "4ea404a672a48f8bcac4f7d7367da7a0e839aaac053ac0dcecadfc97f68881ef"

URI_aarch64_texlive-filemod = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-filemod-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-filemod;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-filemod}"
SRC_URI[aarch64_texlive-filemod.sha256sum] = "0c6255465a6150abfdb916c21617d195fc0a390b389cca216b865d4ee6bf4797"

URI_aarch64_texlive-fltpoint = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fltpoint-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-fltpoint;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fltpoint}"
SRC_URI[aarch64_texlive-fltpoint.sha256sum] = "f6b9a5473e6433c4a4113a644281c68673da3324ac6307f4cc586cfe50f3518c"

URI_aarch64_texlive-fontaxes = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-fontaxes-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-fontaxes;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontaxes}"
SRC_URI[aarch64_texlive-fontaxes.sha256sum] = "189a3540e74cada363b1d125fd55bb5a62999d315db04a421fc697699e2b7bd1"

URI_aarch64_texlive-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-german-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-german}"
SRC_URI[aarch64_texlive-german.sha256sum] = "e82b37011694791f84013536aee36e01288c7a51bfb7377260bf69f54649fc73"

URI_aarch64_texlive-germbib = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-germbib-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-germbib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-germbib}"
SRC_URI[aarch64_texlive-germbib.sha256sum] = "be690b3745b1a84c658a354334c4870143e54c97f6c9ffd46c05bff773dae26f"

URI_aarch64_texlive-gincltex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-gincltex-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-gincltex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-gincltex}"
SRC_URI[aarch64_texlive-gincltex.sha256sum] = "3ec4fd4e6c1d0754034c40d49135327e769ab0d47e03ee454f805d13ef6c0dbe"

URI_aarch64_texlive-glossaries-english = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-english-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-glossaries-english;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-english}"
SRC_URI[aarch64_texlive-glossaries-english.sha256sum] = "99f628911e7a04501f9964f82b3ff4e301f4fc4cbfd95f5dc8182a0787cb0a6a"

URI_aarch64_texlive-glossaries-french = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-french-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-glossaries-french;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-french}"
SRC_URI[aarch64_texlive-glossaries-french.sha256sum] = "074f659c93ff64922af772ec7113948080e3f3bd72cf4e5695a918609fd1bca8"

URI_aarch64_texlive-glossaries-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-glossaries-german-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-glossaries-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glossaries-german}"
SRC_URI[aarch64_texlive-glossaries-german.sha256sum] = "31c2019daab017bd7bfee39061117ea4eb3ffeda03f669dde4755d3caf64b0f1"

URI_aarch64_texlive-hyphen-german = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-hyphen-german-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-hyphen-german;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyphen-german}"
SRC_URI[aarch64_texlive-hyphen-german.sha256sum] = "94ab5611d13a3eafd4bc410966a8990aa1fb495f68282090600ac9a7fbfb3aaa"

URI_aarch64_texlive-ieeetran = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ieeetran-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-ieeetran;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ieeetran}"
SRC_URI[aarch64_texlive-ieeetran.sha256sum] = "1f09dff1180028f065f5b9990f2705ec53f31e35edde70296883fa4b0a6cc48f"

URI_aarch64_texlive-ipaex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ipaex-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-ipaex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ipaex}"
SRC_URI[aarch64_texlive-ipaex.sha256sum] = "fc7905b4184252be420f7f82fa015ef1cd82a1ed649ab7a96524c94dff6d4759"

URI_aarch64_texlive-japanese-otf = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-japanese-otf-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-japanese-otf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-japanese-otf}"
SRC_URI[aarch64_texlive-japanese-otf.sha256sum] = "c2e243ce7e82b2e3683a428fadbdb563d4ee616bf7be5e700efb96582bee2401"

URI_aarch64_texlive-kantlipsum = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-kantlipsum-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-kantlipsum;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kantlipsum}"
SRC_URI[aarch64_texlive-kantlipsum.sha256sum] = "c68d79869f068e1f9f2109690ca3545c8e48bd354b31bbf2eef797f333ded588"

URI_aarch64_texlive-lacheck = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-lacheck-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-lacheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lacheck}"
SRC_URI[aarch64_texlive-lacheck.sha256sum] = "406e5eea37bc5df457399b0ba6ab40cd2ff0db528b904cac73b92803f884c420"

URI_aarch64_texlive-latex-base-dev = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-latex-base-dev-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-latex-base-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex-base-dev}"
SRC_URI[aarch64_texlive-latex-base-dev.sha256sum] = "1217ff321b28d16815e8d341858f265e30a7480f46bcd5e23799aeb6ec24d882"
RPROVIDES:texlive-latex-base-dev:aarch64 = "virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_"

URI_aarch64_texlive-latex-firstaid-dev = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-latex-firstaid-dev-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-latex-firstaid-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex-firstaid-dev}"
SRC_URI[aarch64_texlive-latex-firstaid-dev.sha256sum] = "d9515ef14c587f76a0090b23f31e1b7a5da16871246339eb602a88d83eaff190"

URI_aarch64_texlive-lipsum = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-lipsum-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-lipsum;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lipsum}"
SRC_URI[aarch64_texlive-lipsum.sha256sum] = "fea31503b4146acd6a93d36d025e23b3fe7d4549e95ca5c31a3ff082ffd02a43"

URI_aarch64_texlive-listingsutf8 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-listingsutf8-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-listingsutf8;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-listingsutf8}"
SRC_URI[aarch64_texlive-listingsutf8.sha256sum] = "16b2997446b1140ea1eea8d00a78377724db4177e94a9b3f12a42846555717ef"

URI_aarch64_texlive-ltablex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ltablex-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-ltablex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ltablex}"
SRC_URI[aarch64_texlive-ltablex.sha256sum] = "1eb6fee72573af339b6eca95fe48e10ca3d2d62f3a16fab8b7e3eda2c82ca3e3"

URI_aarch64_texlive-luatexja = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-luatexja-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-luatexja;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luatexja}"
SRC_URI[aarch64_texlive-luatexja.sha256sum] = "ae078b982d2f93852b085839a927cdf4f1ee81de2098a845cd606df66e4ee09e"

URI_aarch64_texlive-mdframed = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-mdframed-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-mdframed;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mdframed}"
SRC_URI[aarch64_texlive-mdframed.sha256sum] = "46729f7829099c1363d64826d53f3f6e87af59d7692f0bae0fa82cba2264ba8d"

URI_aarch64_texlive-media9 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-media9-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-media9;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-media9}"
SRC_URI[aarch64_texlive-media9.sha256sum] = "ffec375473d6ce2bb82d1243b63ac81c8c7cd57f258561bd49a89d6a3d0671a6"

URI_aarch64_texlive-mhchem = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-mhchem-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-mhchem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mhchem}"
SRC_URI[aarch64_texlive-mhchem.sha256sum] = "8b3ae39b56b6c06575c2857a59baf68a4cd9afe9c93ecd9e3ee7e66398baa925"

URI_aarch64_texlive-newtx = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-newtx-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-newtx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-newtx}"
SRC_URI[aarch64_texlive-newtx.sha256sum] = "e74ae3809713b2b07ba77e8f13f99fac209d8802d09e2add0764266a1aa95e25"

URI_aarch64_texlive-nomencl = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-nomencl-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-nomencl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-nomencl}"
SRC_URI[aarch64_texlive-nomencl.sha256sum] = "8d895f8023f7185cd1ab0bf8ba088e790f0a5ec5d462ffac5e3c3231d67da685"

URI_aarch64_texlive-ntheorem = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ntheorem-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-ntheorem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ntheorem}"
SRC_URI[aarch64_texlive-ntheorem.sha256sum] = "ab2353e2f52a2a712472e5f5ba3e0f5b4160eb3e13ad3072b6905a6e53e21a67"

URI_aarch64_texlive-ocgx2 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ocgx2-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-ocgx2;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ocgx2}"
SRC_URI[aarch64_texlive-ocgx2.sha256sum] = "2ef4b1ce93a855559954efa6e2d3cb2f897ffd1962f766ed166b31754dacd8e2"

URI_aarch64_texlive-opensans = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-opensans-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-opensans;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-opensans}"
SRC_URI[aarch64_texlive-opensans.sha256sum] = "90533150048ab7feeef56e2faab78565899e5d50a05a02799fc6de516e5158fe"

URI_aarch64_texlive-pgfplots = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-pgfplots-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-pgfplots;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pgfplots}"
SRC_URI[aarch64_texlive-pgfplots.sha256sum] = "db07009cfb40416ab6092fc023ef7f908606467152d8301c31b389a2a4690fa3"

URI_aarch64_texlive-picinpar = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-picinpar-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-picinpar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-picinpar}"
SRC_URI[aarch64_texlive-picinpar.sha256sum] = "7c6160bf430fef72ff967df2d9648eeb724dfe19b577a52e996b17211e21bfd1"

URI_aarch64_texlive-pict2e = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-pict2e-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-pict2e;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pict2e}"
SRC_URI[aarch64_texlive-pict2e.sha256sum] = "4cb2125131dff983249557c88093e1a7123c788a6c538d2ed34cfc61d30a3ac2"

URI_aarch64_texlive-picture = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-picture-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-picture;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-picture}"
SRC_URI[aarch64_texlive-picture.sha256sum] = "9fd30b6e762ea7c46878d451541cd9c722eb463a2e6711aa388db158b3652cb8"

URI_aarch64_texlive-platex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-platex-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-platex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-platex}"
SRC_URI[aarch64_texlive-platex.sha256sum] = "75e82c53b7ecd1ab49a384ab040a89bbf971d6c4aee13a6089a5be303dadb215"

URI_aarch64_texlive-platex-tools = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-platex-tools-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-platex-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-platex-tools}"
SRC_URI[aarch64_texlive-platex-tools.sha256sum] = "3f58ed55c7ae92b5966509c5785ca2233d7ac995b82ed8df3a5952c08391a3bf"

URI_aarch64_texlive-ps2eps = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ps2eps-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-ps2eps;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ps2eps}"
SRC_URI[aarch64_texlive-ps2eps.sha256sum] = "96d9715353c3c47af75166637b3c4457d1073054e7ec1ef53a783dc81f0ebf01"

URI_aarch64_texlive-ptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-ptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex}"
SRC_URI[aarch64_texlive-ptex.sha256sum] = "95a32c4e2ba24e8c26867397b56ac4e0564e566c3d6c2495e070597a87b7e324"

URI_aarch64_texlive-ptex-base = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-base-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-ptex-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex-base}"
SRC_URI[aarch64_texlive-ptex-base.sha256sum] = "85f1a46fe6db04d8941e04ea892b4ccbc60cf91f5aa917b9f207c4ef39a9c3a4"

URI_aarch64_texlive-ptex-fonts = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ptex-fonts-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-ptex-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptex-fonts}"
SRC_URI[aarch64_texlive-ptex-fonts.sha256sum] = "736cf910e853dbcbb5e98bc339270b67df0f79ededb69d16743d6af8d4facb74"

URI_aarch64_texlive-revtex4 = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-revtex4-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-revtex4;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-revtex4}"
SRC_URI[aarch64_texlive-revtex4.sha256sum] = "7bfdb28cf7926109b556c5ac5b5bf44bb721520790e2a086d3f6f53a3a67c461"

URI_aarch64_texlive-selinput = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-selinput-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-selinput;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-selinput}"
SRC_URI[aarch64_texlive-selinput.sha256sum] = "707d2bf34125c408d35b57ef82dfb01ee866aac44b05ecad04aa5a4ed616f6c1"

URI_aarch64_texlive-sidecap = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-sidecap-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-sidecap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sidecap}"
SRC_URI[aarch64_texlive-sidecap.sha256sum] = "2fa66b1e1e7a4011c21fa76dd1804b8593ea075a105f46e7dcff1f57c7bfa36e"

URI_aarch64_texlive-siunitx = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-siunitx-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-siunitx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-siunitx}"
SRC_URI[aarch64_texlive-siunitx.sha256sum] = "3b1be96a09fa30480bce08a608e5045e0c88d62b528a3d8558015e54a0cdf374"

URI_aarch64_texlive-slantsc = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-slantsc-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-slantsc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-slantsc}"
SRC_URI[aarch64_texlive-slantsc.sha256sum] = "36a12cc985dd8b60cc6aa525091d581cac66f79ff90f4dae9191a891405a6e85"

URI_aarch64_texlive-standalone = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-standalone-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-standalone;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-standalone}"
SRC_URI[aarch64_texlive-standalone.sha256sum] = "3175688a9180d1b6692332fbdde2c8878bac0f354c4bc96956edf7445624b961"

URI_aarch64_texlive-sttools = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-sttools-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-sttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sttools}"
SRC_URI[aarch64_texlive-sttools.sha256sum] = "7c34ec07a0c5aaa2e2daf7fa43ac11bc57290fc6456fbd7ffdd47911280cb770"

URI_aarch64_texlive-supertabular = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-supertabular-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-supertabular;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-supertabular}"
SRC_URI[aarch64_texlive-supertabular.sha256sum] = "7a0988206f0578f6412b9c6f104cefd0eabb4721eeab63a8100f158abfc583a1"

URI_aarch64_texlive-tcolorbox = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tcolorbox-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-tcolorbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tcolorbox}"
SRC_URI[aarch64_texlive-tcolorbox.sha256sum] = "ccee54431ccb63ddbd6c933e0bb0dee13cde922e830eb12b0e6ae8745e075de7"

URI_aarch64_texlive-tie = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tie-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-tie;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tie}"
SRC_URI[aarch64_texlive-tie.sha256sum] = "c874d3f5a496e28efb6c2cc028661599a1ac7d177bd52e6a0ffa73aafb87b631"

URI_aarch64_texlive-tikzfill = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-tikzfill-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-tikzfill;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tikzfill}"
SRC_URI[aarch64_texlive-tikzfill.sha256sum] = "5ec4e1ec3a9cee9dc89230999659222e372af9f815fdf06b659394e52937a656"

URI_aarch64_texlive-ttfutils = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-ttfutils-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-ttfutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ttfutils}"
SRC_URI[aarch64_texlive-ttfutils.sha256sum] = "158e28ad62875d5741095048cd042e8319e5cff2c3e5226ebffb2871bc8e8c17"

URI_aarch64_texlive-units = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-units-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-units;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-units}"
SRC_URI[aarch64_texlive-units.sha256sum] = "f2ed450eb3c3e36f84d09f66b4aeba55cc092e0a4a816fbbc26c877ad7677bed"

URI_aarch64_texlive-uplatex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uplatex-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-uplatex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uplatex}"
SRC_URI[aarch64_texlive-uplatex.sha256sum] = "9ca761d7a4c6dd418ddfe7798925154b28f802cdfa6f8f4a5cd1edf18cdad62f"

URI_aarch64_texlive-uptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-uptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex}"
SRC_URI[aarch64_texlive-uptex.sha256sum] = "a8a06f3881d28a36b604e6360fe63ff7e2d2200b3f631e7116458346ad159b09"

URI_aarch64_texlive-uptex-base = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-base-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-uptex-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex-base}"
SRC_URI[aarch64_texlive-uptex-base.sha256sum] = "7c2a2d657fbf271d291a4a2260cc4238c1c6677ca0b8a440958bf72c8d3789a6"

URI_aarch64_texlive-uptex-fonts = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-uptex-fonts-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-uptex-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uptex-fonts}"
SRC_URI[aarch64_texlive-uptex-fonts.sha256sum] = "3c59fce863fb82a6219fddc75459be4f5ca346186852d7aa47601e0205208edc"

URI_aarch64_texlive-web = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-web-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-web}"
SRC_URI[aarch64_texlive-web.sha256sum] = "2ecd0d47e38f4cf6e1e8cd91fb7a12ea99dd406955bcfb389707e5c9989c84c9"

URI_aarch64_texlive-xcjk2uni = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xcjk2uni-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-xcjk2uni;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xcjk2uni}"
SRC_URI[aarch64_texlive-xcjk2uni.sha256sum] = "e37c07ba9c7842effa56889a817b740f43cb26e1be5e78cee9819258f0c01981"

URI_aarch64_texlive-xecjk = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xecjk-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-xecjk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xecjk}"
SRC_URI[aarch64_texlive-xecjk.sha256sum] = "528590e3f9eb5cc95ac0646794765db6c209d50c1fe572dce8ede084eba1757e"

URI_aarch64_texlive-xltabular = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xltabular-20240311-10.el10_2.aarch64.rpm;name=aarch64_texlive-xltabular;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xltabular}"
SRC_URI[aarch64_texlive-xltabular.sha256sum] = "0ec0dcc1ce887c3594237b540555efcd58fe1d60ef479d41dc9e1bb5ec443bde"

URI_aarch64_texlive-xpinyin = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-xpinyin-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-xpinyin;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xpinyin}"
SRC_URI[aarch64_texlive-xpinyin.sha256sum] = "626dbe7e14a9c7013128aa8e02dd29b8119ab5512dd2224caac94c207ec23aa1"

URI_aarch64_texlive-zhmetrics = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhmetrics-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-zhmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhmetrics}"
SRC_URI[aarch64_texlive-zhmetrics.sha256sum] = "69cf1aa9991d2764c73f1346502e8cf9f9d7076b8b823692d3c47ffc93071163"

URI_aarch64_texlive-zhmetrics-uptex = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhmetrics-uptex-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-zhmetrics-uptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhmetrics-uptex}"
SRC_URI[aarch64_texlive-zhmetrics-uptex.sha256sum] = "cebeec0fdda8a1af2c623a0be928880b3f89c6111d0d4df5914e7a5833064e94"

URI_aarch64_texlive-zhnumber = "${EPEL_MIRROR}/aarch64/Packages/t/texlive-zhnumber-20240311-10.el10_2.noarch.rpm;name=aarch64_texlive-zhnumber;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zhnumber}"
SRC_URI[aarch64_texlive-zhnumber.sha256sum] = "d66c4ebaf1db83c67339370c15ff8aab19c125eb08677ab0c888449252719572"

RDEPENDS:texlive-adobemapping = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ascmac = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-atenddvi = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-auto-pst-pdf = " \
 texlive-base \
 texlive-ifplatform \
 texlive-iftex \
 texlive-kpathsea \
 texlive-xkeyval \
 "
RDEPENDS:texlive-babel-french = " \
 texlive-base \
 texlive-carlisle \
 texlive-graphics \
 texlive-kpathsea \
 texlive-luatexbase \
 "
RDEPENDS:texlive-babel-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bibunits = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-boondox = " \
 texlive-base \
 texlive-kpathsea \
 texlive-xkeyval \
 "
RDEPENDS:texlive-chemformula = " \
 texlive-amsmath \
 texlive-base \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-pgf \
 texlive-units \
 texlive-xfrac \
 "
RDEPENDS:texlive-chemgreek = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-chktex = " \
 bash \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-cjk = " \
 texlive-arphic \
 texlive-base \
 texlive-cns \
 texlive-garuda-c90 \
 texlive-graphics \
 texlive-iftex \
 texlive-kpathsea \
 texlive-norasi-c90 \
 texlive-uhc \
 texlive-ulem \
 texlive-wadalab \
 virtual/tex_fontenc.sty_ \
 virtual/tex_inputenc.sty_ \
 "
RDEPENDS:texlive-cjkpunct = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-convbkmk = " \
 ruby \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ctex = " \
 texlive-adobemapping \
 texlive-atbegshi \
 texlive-base \
 texlive-beamer \
 texlive-cjk \
 texlive-cjkpunct \
 texlive-count1to \
 texlive-ctex \
 texlive-ec \
 texlive-epstopdf-pkg \
 texlive-etoolbox \
 texlive-everyhook \
 texlive-everysel \
 texlive-fancyhdr \
 texlive-fandol \
 texlive-fontspec \
 texlive-hyperref \
 texlive-iftex \
 texlive-infwarerr \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex \
 texlive-ltxcmds \
 texlive-luatexja \
 texlive-mptopdf \
 texlive-multitoc \
 texlive-pdftexcmds \
 texlive-platex-tools \
 texlive-svn-prov \
 texlive-tipa \
 texlive-tools \
 texlive-ttfutils \
 texlive-ulem \
 texlive-uplatex \
 texlive-xcjk2uni \
 texlive-xecjk \
 texlive-xetex \
 texlive-xkeyval \
 texlive-xpinyin \
 texlive-xunicode \
 texlive-zhmetrics \
 texlive-zhmetrics-uptex \
 texlive-zhnumber \
 virtual/tex_fix-cm.sty_ \
 "
RDEPENDS:texlive-ctie = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-cweb = " \
 glibc \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Pod-Usage \
 perl-libs \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-lib \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ellipse = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-emulateapj = " \
 texlive-amsfonts \
 texlive-base \
 texlive-epsf \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 virtual/tex_latexsym.sty_ \
 "
RDEPENDS:texlive-everyhook = " \
 texlive-base \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-svn-prov \
 "
RDEPENDS:texlive-fandol = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-filemod = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pdftexcmds \
 "
RDEPENDS:texlive-fltpoint = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fontaxes = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-germbib = " \
 texlive-base \
 texlive-german \
 texlive-kpathsea \
 "
RDEPENDS:texlive-gincltex = " \
 texlive-adjustbox \
 texlive-base \
 texlive-kpathsea \
 texlive-svn-prov \
 "
RDEPENDS:texlive-glossaries-english = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-glossaries-french = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-glossaries-german = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyphen-german = " \
 bash \
 texlive-base \
 texlive-dehyph \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-kpathsea \
 virtual/coreutils \
 "
RDEPENDS:texlive-ieeetran = " \
 texlive-base \
 texlive-kpathsea \
 texlive-newtx \
 "
RDEPENDS:texlive-ipaex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-japanese-otf = " \
 texlive-base \
 texlive-japanese-otf \
 texlive-kpathsea \
 "
RDEPENDS:texlive-kantlipsum = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-lacheck = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex-base-dev = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex-firstaid-dev = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lipsum = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-listingsutf8 = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ltablex = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-luatexja = " \
 texlive-ascmac \
 texlive-atbegshi \
 texlive-base \
 texlive-everyhook \
 texlive-everysel \
 texlive-filehook \
 texlive-fontspec \
 texlive-footmisc \
 texlive-iftex \
 texlive-infwarerr \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-listings \
 texlive-ltxcmds \
 texlive-luaotfload \
 texlive-luatexbase \
 texlive-luatexja \
 texlive-pdftexcmds \
 texlive-sttools \
 texlive-unicode-math \
 texlive-xkeyval \
 texlive-xunicode \
 "
RDEPENDS:texlive-mdframed = " \
 texlive-amsmath \
 texlive-base \
 texlive-bera \
 texlive-booktabs \
 texlive-csquotes \
 texlive-enumitem \
 texlive-eso-pic \
 texlive-etoolbox \
 texlive-fontspec \
 texlive-geometry \
 texlive-graphics \
 texlive-hypdoc \
 texlive-iftex \
 texlive-kantlipsum \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-lipsum \
 texlive-listings \
 texlive-microtype \
 texlive-needspace \
 texlive-ntheorem \
 texlive-pgf \
 texlive-selinput \
 texlive-tools \
 texlive-xcolor \
 texlive-zref \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-media9 = " \
 texlive-atbegshi \
 texlive-atenddvi \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-ocgx2 \
 texlive-pdftexcmds \
 texlive-pgf \
 "
RDEPENDS:texlive-mhchem = " \
 texlive-amsmath \
 texlive-babel \
 texlive-base \
 texlive-chemgreek \
 texlive-graphics \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-oberdiek \
 texlive-pgf \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-newtx = " \
 texlive-amsmath \
 texlive-base \
 texlive-boondox \
 texlive-fontaxes \
 texlive-iftex \
 texlive-kastrup \
 texlive-kpathsea \
 texlive-xkeyval \
 virtual/tex_fontenc.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-nomencl = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ntheorem = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-ocgx2 = " \
 texlive-atenddvi \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-l3packages \
 texlive-media9 \
 texlive-pgf \
 "
RDEPENDS:texlive-opensans = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-slantsc \
 "
RDEPENDS:texlive-pgfplots = " \
 bash \
 texlive-base \
 texlive-graphics \
 texlive-hyperref \
 texlive-kpathsea \
 texlive-listings \
 texlive-luatex \
 texlive-luatexbase \
 texlive-pgf \
 texlive-tools \
 "
RDEPENDS:texlive-picinpar = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pict2e = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-picture = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-platex = " \
 texlive-atbegshi \
 texlive-atveryend \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-everyshi \
 texlive-firstaid \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-latex-fonts \
 texlive-ptex \
 texlive-ptex-fonts \
 texlive-tex-ini-files \
 texlive-unicode-data \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-platex-tools = " \
 texlive-base \
 texlive-kpathsea \
 texlive-platex \
 "
RDEPENDS:texlive-ps2eps = " \
 glibc \
 perl-Getopt-Long \
 perl-POSIX \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-ptex = " \
 cairo \
 glibc \
 gmp \
 libpng \
 mpfr \
 pixman \
 texlive-adobemapping \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-ptex-base \
 texlive-ptex-fonts \
 texlive-tex \
 virtual/coreutils \
 virtual/tex_oldlfont.sty_ \
 virtual/tex_shortvrb.sty_ \
 virtual/texlive-latex \
 zlib-ng-compat \
 "
RDEPENDS:texlive-ptex-base = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ptex-fonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-revtex4 = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 texlive-natbib \
 texlive-url \
 "
RDEPENDS:texlive-selinput = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sidecap = " \
 texlive-base \
 texlive-kpathsea \
 texlive-ragged2e \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-siunitx = " \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-tools \
 texlive-translator \
 "
RDEPENDS:texlive-slantsc = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-standalone = " \
 texlive-adjustbox \
 texlive-base \
 texlive-currfile \
 texlive-filemod \
 texlive-gincltex \
 texlive-iftex \
 texlive-kpathsea \
 texlive-multido \
 texlive-pgf \
 texlive-pstricks \
 texlive-varwidth \
 texlive-xkeyval \
 "
RDEPENDS:texlive-sttools = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-supertabular = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tcolorbox = " \
 texlive-base \
 texlive-environ \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-listingsutf8 \
 texlive-pdfcol \
 texlive-pgf \
 texlive-tikzfill \
 texlive-tools \
 "
RDEPENDS:texlive-tie = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-tikzfill = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ttfutils = " \
 freetype \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-units = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-uplatex = " \
 texlive-atbegshi \
 texlive-atveryend \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-everyshi \
 texlive-firstaid \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex-base-dev \
 texlive-latex-firstaid-dev \
 texlive-latex-fonts \
 texlive-platex \
 texlive-tex-ini-files \
 texlive-unicode-data \
 texlive-uptex \
 texlive-uptex-fonts \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-uptex = " \
 cairo \
 glibc \
 gmp \
 libicu \
 libpng \
 mpfr \
 pixman \
 texlive-base \
 texlive-convbkmk \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-ipaex \
 texlive-japanese-otf \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-ptex-base \
 texlive-uptex-base \
 texlive-uptex-fonts \
 zlib-ng-compat \
 "
RDEPENDS:texlive-uptex-base = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-uptex-fonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-web = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-xcjk2uni = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 "
RDEPENDS:texlive-xecjk = " \
 texlive-base \
 texlive-cjk \
 texlive-environ \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-listings \
 texlive-tools \
 texlive-ulem \
 texlive-xunicode \
 "
RDEPENDS:texlive-xltabular = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xpinyin = " \
 texlive-base \
 texlive-cjk \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-xcjk2uni \
 texlive-xecjk \
 "
RDEPENDS:texlive-zhmetrics = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zhmetrics-uptex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zhnumber = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/tex_alltt.sty_ rpm/virtual/tex_article.cls_ rpm/virtual/tex_doc.sty_ rpm/virtual/tex_exscale.sty_ rpm/virtual/tex_fix-cm.sty_ rpm/virtual/tex_fixltx2e.sty_ rpm/virtual/tex_flafter.sty_ rpm/virtual/tex_fontenc.sty_ rpm/virtual/tex_ifthen.sty_ rpm/virtual/tex_inputenc.sty_ rpm/virtual/tex_latexsym.sty_ rpm/virtual/tex_makeidx.sty_ rpm/virtual/tex_oldlfont.sty_ rpm/virtual/tex_shortvrb.sty_ rpm/virtual/tex_t1cmr.fd_ rpm/virtual/tex_textcomp.sty_"

PROVIDES:append:aarch64 = " rpm/virtual/tex_alltt.sty_ rpm/virtual/tex_article.cls_ rpm/virtual/tex_doc.sty_ rpm/virtual/tex_exscale.sty_ rpm/virtual/tex_fix-cm.sty_ rpm/virtual/tex_fixltx2e.sty_ rpm/virtual/tex_flafter.sty_ rpm/virtual/tex_fontenc.sty_ rpm/virtual/tex_ifthen.sty_ rpm/virtual/tex_inputenc.sty_ rpm/virtual/tex_latexsym.sty_ rpm/virtual/tex_makeidx.sty_ rpm/virtual/tex_oldlfont.sty_ rpm/virtual/tex_shortvrb.sty_ rpm/virtual/tex_t1cmr.fd_ rpm/virtual/tex_textcomp.sty_"
