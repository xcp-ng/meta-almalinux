# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Exporter-Tiny"
PV = "1.006002"
PR = "7.el10"
PACKAGES = " \
 perl-Exporter-Tiny \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Exporter-Tiny-1.006002-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a2284e4a1a9ae5fcfd244ae2907fdb199d29448c69eea01f9d929d3f15e3e6a"

URI_x86_64_v2_perl-Exporter-Tiny = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Exporter-Tiny-1.006002-7.el10.noarch.rpm;name=x86_64_v2_perl-Exporter-Tiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Exporter-Tiny}"
SRC_URI[x86_64_v2_perl-Exporter-Tiny.sha256sum] = "33475d272936f28913a9cd2301c347ad0cb0bc68f330fad356b6c849dc510ad7"

URI_aarch64_perl-Exporter-Tiny = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Exporter-Tiny-1.006002-7.el10.noarch.rpm;name=aarch64_perl-Exporter-Tiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Exporter-Tiny}"
SRC_URI[aarch64_perl-Exporter-Tiny.sha256sum] = "33475d272936f28913a9cd2301c347ad0cb0bc68f330fad356b6c849dc510ad7"

RDEPENDS:perl-Exporter-Tiny = " \
 perl-Carp \
 perl-Exporter-Tiny \
 perl-libs \
 "
