# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gulrak-filesystem"
PV = "1.5.14"
PR = "8.el10_0"
PACKAGES = " \
 gulrak-filesystem-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gulrak-filesystem-1.5.14-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7ea47a6262e3890174b4798baf427759eaf2aee5a333686da630fc5964a5ed3"

URI_x86_64_v2_gulrak-filesystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gulrak-filesystem-devel-1.5.14-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gulrak-filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gulrak-filesystem-devel}"
SRC_URI[x86_64_v2_gulrak-filesystem-devel.sha256sum] = "ba75938e8c87465895c6284b7915e158790cd63263f8a42f97be936fa90b98ae"

URI_aarch64_gulrak-filesystem-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gulrak-filesystem-devel-1.5.14-8.el10_0.aarch64.rpm;name=aarch64_gulrak-filesystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gulrak-filesystem-devel}"
SRC_URI[aarch64_gulrak-filesystem-devel.sha256sum] = "bdfa7b7a6d534a51433f004d2afbd5cca8713a92f418bf703181d4eccdfc4a38"

RDEPENDS:gulrak-filesystem-devel = " \
 cmake-filesystem \
 "
