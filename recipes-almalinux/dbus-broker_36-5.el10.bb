# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbus-broker"
PV = "36"
PR = "5.el10"
PACKAGES = " \
 dbus-broker \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dbus-broker-36-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d7a929cfd19a2df84df5a2b4d8683d5abe59fcd2b6e4faa244a1dec7d62bf43a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-broker-36-5.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-broker;unpack=0"
SRC_URI[x86_64_v2_dbus-broker.sha256sum] = "5834cb7b2e1e82f040c8d43366a388c84103f65466c279208f8c8b1a7591437f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-broker-36-5.el10.aarch64.rpm;name=aarch64_dbus-broker;unpack=0"
SRC_URI[aarch64_dbus-broker.sha256sum] = "b2291c5df04755715d1383a0884ba53247d89faaa9666c56254e2d0c4807299c"

RDEPENDS:dbus-broker = " \
 audit-libs \
 bash \
 dbus-common \
 expat \
 glibc \
 libcap-ng \
 libgcc \
 libselinux \
 systemd-libs \
 "
