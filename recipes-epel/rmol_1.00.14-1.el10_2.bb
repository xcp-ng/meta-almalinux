# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rmol"
PV = "1.00.14"
PR = "1.el10_2"
PACKAGES = " \
 python3-rmol \
 rmol \
 rmol-devel \
 rmol-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rmol-1.00.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f288e3d99df5f7e66a8d1fb9078523822837be4c91973545229c3a82a57a340"

URI_x86_64_v2_python3-rmol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rmol-1.00.14-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rmol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rmol}"
SRC_URI[x86_64_v2_python3-rmol.sha256sum] = "7a5299d86de672213cb3613b6f2873c3c596206d86e8a43f669c3864b26f2717"

URI_x86_64_v2_rmol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rmol-1.00.14-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rmol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rmol}"
SRC_URI[x86_64_v2_rmol.sha256sum] = "7becd7ace56b2a3f9cae83072e54b60a13081c82a0bf85fb75f4c5e973a018e7"

URI_x86_64_v2_rmol-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rmol-devel-1.00.14-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rmol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rmol-devel}"
SRC_URI[x86_64_v2_rmol-devel.sha256sum] = "3d117df987dc569ba4f6869e945037927d40c85a762894df87e72d505edd181c"

URI_x86_64_v2_rmol-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rmol-doc-1.00.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rmol-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rmol-doc}"
SRC_URI[x86_64_v2_rmol-doc.sha256sum] = "28c491717b893ec90cdea1375a76e5d30b8395d9f14bce3cdbcccf20f0ea1c3d"

URI_aarch64_python3-rmol = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rmol-1.00.14-1.el10_2.aarch64.rpm;name=aarch64_python3-rmol;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rmol}"
SRC_URI[aarch64_python3-rmol.sha256sum] = "5e73bc44f2188c818e6feb9ee8193f07fc4673663958436b22681d62b06b821b"

URI_aarch64_rmol = "${EPEL_MIRROR}/aarch64/Packages/r/rmol-1.00.14-1.el10_2.aarch64.rpm;name=aarch64_rmol;unpack=0"
SRC_URI:append = " ${URI_aarch64_rmol}"
SRC_URI[aarch64_rmol.sha256sum] = "a6f6af273e48fa99cf73c704ef1b7a0b4b5121ad528bd3bb3974891f72bb5719"

URI_aarch64_rmol-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rmol-devel-1.00.14-1.el10_2.aarch64.rpm;name=aarch64_rmol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rmol-devel}"
SRC_URI[aarch64_rmol-devel.sha256sum] = "b77b832627556ee11872f5c8df1f739300dde58089be3f0ebdb678a8a42d5817"

URI_aarch64_rmol-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rmol-doc-1.00.14-1.el10_2.noarch.rpm;name=aarch64_rmol-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rmol-doc}"
SRC_URI[aarch64_rmol-doc.sha256sum] = "d62330b6396d3ba5c22683497b781e0ec813b270a33c747939c293fec4eff059"

RDEPENDS:python3-rmol = " \
 bash \
 boost-python3 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 rmol \
 stdair \
 "
RDEPENDS:rmol = " \
 bash \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 stdair \
 "
RDEPENDS:rmol-devel = " \
 bash \
 cmake-filesystem \
 pkgconf-pkg-config \
 rmol \
 "
RDEPENDS:rmol-doc = " \
 "
