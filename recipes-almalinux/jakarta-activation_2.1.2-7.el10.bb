# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jakarta-activation"
PV = "2.1.2"
PR = "7.el10"
PACKAGES = " \
 jakarta-activation \
 jakarta-activation-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jakarta-activation-2.1.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6a555a97017c52efdcc87b9404c8ddd0a9ae083b4f36f5e8915dcb7c717b89f"

URI_x86_64_v2_jakarta-activation = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jakarta-activation-2.1.2-7.el10.noarch.rpm;name=x86_64_v2_jakarta-activation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jakarta-activation}"
SRC_URI[x86_64_v2_jakarta-activation.sha256sum] = "47b7607d0f4a80aca613756d22ca6fb400bc8629d69589a4af8fba813cbf8b6d"

URI_x86_64_v2_jakarta-activation-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jakarta-activation-javadoc-2.1.2-7.el10.noarch.rpm;name=x86_64_v2_jakarta-activation-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jakarta-activation-javadoc}"
SRC_URI[x86_64_v2_jakarta-activation-javadoc.sha256sum] = "c856c3c3d878d410a1448114f5ae520cc2431112f97d9cdd73f901fca910b344"

URI_aarch64_jakarta-activation = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jakarta-activation-2.1.2-7.el10.noarch.rpm;name=aarch64_jakarta-activation;unpack=0"
SRC_URI:append = " ${URI_aarch64_jakarta-activation}"
SRC_URI[aarch64_jakarta-activation.sha256sum] = "47b7607d0f4a80aca613756d22ca6fb400bc8629d69589a4af8fba813cbf8b6d"

URI_aarch64_jakarta-activation-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jakarta-activation-javadoc-2.1.2-7.el10.noarch.rpm;name=aarch64_jakarta-activation-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jakarta-activation-javadoc}"
SRC_URI[aarch64_jakarta-activation-javadoc.sha256sum] = "c856c3c3d878d410a1448114f5ae520cc2431112f97d9cdd73f901fca910b344"

RDEPENDS:jakarta-activation = " \
 javapackages-filesystem \
 "
RDEPENDS:jakarta-activation-javadoc = " \
 javapackages-filesystem \
 "
