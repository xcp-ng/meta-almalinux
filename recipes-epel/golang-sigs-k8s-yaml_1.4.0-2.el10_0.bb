# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-sigs-k8s-yaml"
PV = "1.4.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-sigs-k8s-yaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-sigs-k8s-yaml-1.4.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "844ab9d33b46c8f873a94b9eb65da8815d2d4f9f3e52d6929a6c8e29c1c7195f"

URI_x86_64_v2_golang-sigs-k8s-yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-sigs-k8s-yaml-devel-1.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-sigs-k8s-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-sigs-k8s-yaml-devel}"
SRC_URI[x86_64_v2_golang-sigs-k8s-yaml-devel.sha256sum] = "825a2d79f735fb5ca581afe8e576c7586f981b65cd11c58259406eb9c9c6adba"

URI_aarch64_golang-sigs-k8s-yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-sigs-k8s-yaml-devel-1.4.0-2.el10_0.noarch.rpm;name=aarch64_golang-sigs-k8s-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-sigs-k8s-yaml-devel}"
SRC_URI[aarch64_golang-sigs-k8s-yaml-devel.sha256sum] = "7b7d2704f50c02ae9082166b42eb1198dcfabae7ef138c314803d92145806ba7"

RDEPENDS:golang-sigs-k8s-yaml-devel = " \
 go-filesystem \
 "
