# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ppmd-rust"
PV = "1.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ppmd-rust+default-devel \
 rust-ppmd-rust-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ppmd-rust-1.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a450856080e16c268f93be4cdbb1d20baa3d44d0e3e0b3d83d7c62813131ce4e"

URI_x86_64_v2_rust-ppmd-rust+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppmd-rust+default-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppmd-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppmd-rust+default-devel}"
SRC_URI[x86_64_v2_rust-ppmd-rust+default-devel.sha256sum] = "79b57c454764fe81a59f832bb926689855224a5676746b7bbfed8db1731da487"

URI_x86_64_v2_rust-ppmd-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ppmd-rust-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ppmd-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ppmd-rust-devel}"
SRC_URI[x86_64_v2_rust-ppmd-rust-devel.sha256sum] = "935cdbccd19182febc266bd719063d2d4c41ddeb68e6179dd43ceb84a301719f"

URI_aarch64_rust-ppmd-rust+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppmd-rust+default-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-ppmd-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppmd-rust+default-devel}"
SRC_URI[aarch64_rust-ppmd-rust+default-devel.sha256sum] = "845b303831417c83d7d6146be508872b1af9e4ad03d208641faf32fcd80d4b80"

URI_aarch64_rust-ppmd-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ppmd-rust-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-ppmd-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ppmd-rust-devel}"
SRC_URI[aarch64_rust-ppmd-rust-devel.sha256sum] = "ceea86f8d1f88525dbce2e07cfb5c14328f083ceca42aca62a105bd4ccfc48f4"

RDEPENDS:rust-ppmd-rust+default-devel = " \
 cargo \
 rust-ppmd-rust-devel \
 "
RDEPENDS:rust-ppmd-rust-devel = " \
 cargo \
 rust \
 "
