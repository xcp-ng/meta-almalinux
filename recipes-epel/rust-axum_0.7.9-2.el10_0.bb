# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum"
PV = "0.7.9"
PR = "2.el10_0"
PACKAGES = " \
 rust-axum+default-devel \
 rust-axum+form-devel \
 rust-axum+http1-devel \
 rust-axum+http2-devel \
 rust-axum+json-devel \
 rust-axum+macros-devel \
 rust-axum+matched-path-devel \
 rust-axum+multipart-devel \
 rust-axum+original-uri-devel \
 rust-axum+query-devel \
 rust-axum+tokio-devel \
 rust-axum+tower-http-devel \
 rust-axum+tower-log-devel \
 rust-axum+tracing-devel \
 rust-axum+ws-devel \
 rust-axum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-0.7.9-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10959ff18757f6a1c275eda5547e14e334b3def206174767b2b9ccb8d524c19c"

URI_x86_64_v2_rust-axum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+default-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+default-devel}"
SRC_URI[x86_64_v2_rust-axum+default-devel.sha256sum] = "238d7b8b13c1545aeb1fd418d0d1c13abf9503b1e14e244d806c1e89c4769030"

URI_x86_64_v2_rust-axum+form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+form-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+form-devel}"
SRC_URI[x86_64_v2_rust-axum+form-devel.sha256sum] = "f02f30f810cc9afc319a84cc24f59d2e90db9cbef168ffd7b578455ddf1b73f1"

URI_x86_64_v2_rust-axum+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+http1-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+http1-devel}"
SRC_URI[x86_64_v2_rust-axum+http1-devel.sha256sum] = "9dc2f605535b5f283236924b43293a18209623bc46a88e491f8e36d3455e3c11"

URI_x86_64_v2_rust-axum+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+http2-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+http2-devel}"
SRC_URI[x86_64_v2_rust-axum+http2-devel.sha256sum] = "b857eb9021857f21c18fa17c402bc658d43b9192d7c4bc31edc81329079b738d"

URI_x86_64_v2_rust-axum+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+json-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+json-devel}"
SRC_URI[x86_64_v2_rust-axum+json-devel.sha256sum] = "4b7adf1d5e1b713c4828a243b6052f0fca339227b6326a10d3357885921ec665"

URI_x86_64_v2_rust-axum+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+macros-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+macros-devel}"
SRC_URI[x86_64_v2_rust-axum+macros-devel.sha256sum] = "24aac0027141e6460fef06dc156af6878eeeda84d841f9beb5e5a49139708d5d"

URI_x86_64_v2_rust-axum+matched-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+matched-path-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+matched-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+matched-path-devel}"
SRC_URI[x86_64_v2_rust-axum+matched-path-devel.sha256sum] = "91430bd835244dcc24015b16b66933c6bef8ff2fef70672d741dabbf2a4a4621"

URI_x86_64_v2_rust-axum+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+multipart-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+multipart-devel}"
SRC_URI[x86_64_v2_rust-axum+multipart-devel.sha256sum] = "b22bce87f28fef9f0d6095f7320a53b0bf71bfe2fdb92151ee6c808a2c734182"

URI_x86_64_v2_rust-axum+original-uri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+original-uri-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+original-uri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+original-uri-devel}"
SRC_URI[x86_64_v2_rust-axum+original-uri-devel.sha256sum] = "b5be30173aa1f24674a229cead879a86a37f20839c6afbb8e4230571d4c5e7a0"

URI_x86_64_v2_rust-axum+query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+query-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+query-devel}"
SRC_URI[x86_64_v2_rust-axum+query-devel.sha256sum] = "b4a607e9b841c3db90ebb6f8f563c6fd7ae8676a34f7de579ea212eb6eb09119"

URI_x86_64_v2_rust-axum+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tokio-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tokio-devel}"
SRC_URI[x86_64_v2_rust-axum+tokio-devel.sha256sum] = "d0eb79daa8cd3122b1055045e76c0c6b11f1b7cd5373afa51623272ad601a2f7"

URI_x86_64_v2_rust-axum+tower-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tower-http-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tower-http-devel}"
SRC_URI[x86_64_v2_rust-axum+tower-http-devel.sha256sum] = "2fb5a947c0843cc9d6428af3c20ae2ef4d899de3c92d7356370b9913822ce134"

URI_x86_64_v2_rust-axum+tower-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tower-log-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tower-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tower-log-devel}"
SRC_URI[x86_64_v2_rust-axum+tower-log-devel.sha256sum] = "604b712650329d174d3170a7747b11f0602afe615c273acd201c6ee5b017ed1f"

URI_x86_64_v2_rust-axum+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tracing-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tracing-devel}"
SRC_URI[x86_64_v2_rust-axum+tracing-devel.sha256sum] = "3a97d8fc4a16e6ccc35524515652bb05e20f15a3d57128544cf58ac28a31ae14"

URI_x86_64_v2_rust-axum+ws-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+ws-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+ws-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+ws-devel}"
SRC_URI[x86_64_v2_rust-axum+ws-devel.sha256sum] = "35d6d446263bcf2d561f26176fa128c12cd58a5c8cbfec8e09eb04416ca655eb"

URI_x86_64_v2_rust-axum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-devel-0.7.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-devel}"
SRC_URI[x86_64_v2_rust-axum-devel.sha256sum] = "ca64b97a8b5abb052187a8a60042162d7a6a6dc692d4e60dd5af012876c8de86"

URI_aarch64_rust-axum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+default-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+default-devel}"
SRC_URI[aarch64_rust-axum+default-devel.sha256sum] = "a510009e0f919c100b0e20536775dce211c70e0aa727b3c16a44649887213c2f"

URI_aarch64_rust-axum+form-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+form-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+form-devel}"
SRC_URI[aarch64_rust-axum+form-devel.sha256sum] = "a0eea3e6c04485cb1ddb9fa8655efb010e3d69eee2fda1aecd0e927708f280b6"

URI_aarch64_rust-axum+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+http1-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+http1-devel}"
SRC_URI[aarch64_rust-axum+http1-devel.sha256sum] = "3fd0c778c61e04f9f0127bf002853300dafa77b108316508d5beffbadf7f50e0"

URI_aarch64_rust-axum+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+http2-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+http2-devel}"
SRC_URI[aarch64_rust-axum+http2-devel.sha256sum] = "fe3f86dbcc608a347fd822e70066182a68f4bc115f3473cd6ad7b4da81c1f365"

URI_aarch64_rust-axum+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+json-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+json-devel}"
SRC_URI[aarch64_rust-axum+json-devel.sha256sum] = "1924c09712a9888cd3fb57cb58ccb99964ec772e6257ee423bd9da4f323cdf47"

URI_aarch64_rust-axum+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+macros-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+macros-devel}"
SRC_URI[aarch64_rust-axum+macros-devel.sha256sum] = "dfb2b76e93d832a499f7c882438bff7f03d4b535e6f448ba490c7c7b61690e61"

URI_aarch64_rust-axum+matched-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+matched-path-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+matched-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+matched-path-devel}"
SRC_URI[aarch64_rust-axum+matched-path-devel.sha256sum] = "e0fa626c6bbb85aede57215533984cf39657521660bca3226460c2a913e91387"

URI_aarch64_rust-axum+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+multipart-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+multipart-devel}"
SRC_URI[aarch64_rust-axum+multipart-devel.sha256sum] = "f123d78e2056d20319c649ddf3896bbcdd2bf1afcf53c79f4a21e41ebe582d0e"

URI_aarch64_rust-axum+original-uri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+original-uri-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+original-uri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+original-uri-devel}"
SRC_URI[aarch64_rust-axum+original-uri-devel.sha256sum] = "b91fa1cf8107ac4a7d9c7e193238eb788b70492994fa25e954b2da7757af65ca"

URI_aarch64_rust-axum+query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+query-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+query-devel}"
SRC_URI[aarch64_rust-axum+query-devel.sha256sum] = "39361bc848a919cf84ca37c1481d4dc318d6c1aa3454c26b1a4a676caf6baabd"

URI_aarch64_rust-axum+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tokio-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tokio-devel}"
SRC_URI[aarch64_rust-axum+tokio-devel.sha256sum] = "4b238d495b6c8f51cc7c12b805289ceef2674faf5814b781f5343d4f512c386f"

URI_aarch64_rust-axum+tower-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tower-http-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tower-http-devel}"
SRC_URI[aarch64_rust-axum+tower-http-devel.sha256sum] = "080da1deabdc265f22defd998a432d6d9abfdc0334950e67fcedd70d3e138196"

URI_aarch64_rust-axum+tower-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tower-log-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+tower-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tower-log-devel}"
SRC_URI[aarch64_rust-axum+tower-log-devel.sha256sum] = "ecb6f07b720062e5843849f1a1d0f53e60caebb3c7b89b49c6884c8ca566a02a"

URI_aarch64_rust-axum+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tracing-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tracing-devel}"
SRC_URI[aarch64_rust-axum+tracing-devel.sha256sum] = "0b9b0b7e486a33247222b42d09c2701ef68efeefc3d72df2fc47cb62fffebd92"

URI_aarch64_rust-axum+ws-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+ws-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum+ws-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+ws-devel}"
SRC_URI[aarch64_rust-axum+ws-devel.sha256sum] = "d2fb46ab2360e232494bdc6b291b6f53de28956dc74480bec5228bd6327ccfae"

URI_aarch64_rust-axum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-devel-0.7.9-2.el10_0.noarch.rpm;name=aarch64_rust-axum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-devel}"
SRC_URI[aarch64_rust-axum-devel.sha256sum] = "c9cdadc20b6d5a195c50e77154128a2e10ad9dfe34470eb990dde9ef7bf0d716"

RDEPENDS:rust-axum+default-devel = " \
 cargo \
 rust-axum+form-devel \
 rust-axum+http1-devel \
 rust-axum+json-devel \
 rust-axum+matched-path-devel \
 rust-axum+original-uri-devel \
 rust-axum+query-devel \
 rust-axum+tokio-devel \
 rust-axum+tower-log-devel \
 rust-axum+tracing-devel \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+form-devel = " \
 cargo \
 rust-axum-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-axum+http1-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 "
RDEPENDS:rust-axum+http2-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper+default-devel \
 rust-hyper+http2-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 "
RDEPENDS:rust-axum+json-devel = " \
 cargo \
 rust-axum-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-serde_path_to_error+default-devel \
 "
RDEPENDS:rust-axum+macros-devel = " \
 cargo \
 rust-axum-devel \
 rust-axum-macros+default-devel \
 "
RDEPENDS:rust-axum+matched-path-devel = " \
 cargo \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+multipart-devel = " \
 cargo \
 rust-axum-devel \
 rust-multer+default-devel \
 "
RDEPENDS:rust-axum+original-uri-devel = " \
 cargo \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+query-devel = " \
 cargo \
 rust-axum-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-axum+tokio-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-tokio+default-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 rust-tower+make-devel \
 "
RDEPENDS:rust-axum+tower-http-devel = " \
 cargo \
 rust-axum-devel \
 rust-tower-http+add-extension-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+default-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+util-devel \
 rust-tower-http+validate-request-devel \
 "
RDEPENDS:rust-axum+tower-log-devel = " \
 cargo \
 rust-axum-devel \
 rust-tower+log-devel \
 "
RDEPENDS:rust-axum+tracing-devel = " \
 cargo \
 rust-axum-core+tracing-devel \
 rust-axum-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-axum+ws-devel = " \
 cargo \
 rust-axum+tokio-devel \
 rust-axum-devel \
 rust-base64+default-devel \
 rust-hyper+default-devel \
 rust-sha1+default-devel \
 rust-tokio-tungstenite+default-devel \
 "
RDEPENDS:rust-axum-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-axum-core+default-devel \
 rust-bytes+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-itoa+default-devel \
 rust-matchit0.7+default-devel \
 rust-memchr+default-devel \
 rust-mime+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-rustversion+default-devel \
 rust-serde+default-devel \
 rust-sync_wrapper+default-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
