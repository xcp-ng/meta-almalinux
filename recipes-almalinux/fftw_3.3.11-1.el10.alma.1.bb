# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fftw"
PV = "3.3.11"
PR = "1.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 fftw \
 fftw-devel \
 fftw-doc \
 fftw-libs \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
 fftw-libs-single \
 fftw-openmpi-devel \
 fftw-openmpi-libs \
 fftw-openmpi-libs-double \
 fftw-openmpi-libs-long \
 fftw-openmpi-libs-single \
 fftw-openmpi-static \
 fftw-static \
"
PACKAGES:aarch64 = " \
 fftw \
 fftw-devel \
 fftw-doc \
 fftw-libs \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-single \
 fftw-openmpi-devel \
 fftw-openmpi-libs \
 fftw-openmpi-libs-double \
 fftw-openmpi-libs-long \
 fftw-openmpi-libs-single \
 fftw-openmpi-static \
 fftw-static \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fftw-3.3.11-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "76c9f9d3630a5571da13856e4624ba27963c8f229d1ded4587d5bb91d61211d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw;unpack=0"
SRC_URI[x86_64_v2_fftw.sha256sum] = "115f76d9447cfb5ea071f79bda348c3907a8f922f2689f26aaa1ee0f1b239b9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-devel-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-devel;unpack=0"
SRC_URI[x86_64_v2_fftw-devel.sha256sum] = "c1d419d67cfa556ebeaec69dd40db65930c39d60126140c75b880f506dd91c79"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fftw-doc-3.3.11-1.el10.alma.1.noarch.rpm;name=x86_64_v2_fftw-doc;unpack=0"
SRC_URI[x86_64_v2_fftw-doc.sha256sum] = "689f6d968a67f22dc5af193387c911e5bb6014b133d869673427c523a4eb7ce4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-libs;unpack=0"
SRC_URI[x86_64_v2_fftw-libs.sha256sum] = "496b7fe67b3043b9f7246385520f1d4b721c77063798e4fea7055604a7d19710"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-double-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-double;unpack=0"
SRC_URI[x86_64_v2_fftw-libs-double.sha256sum] = "27f6e2c595777eee6653c425d89bcf485c44534da825253916c31d06bd4ced4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-long-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-long;unpack=0"
SRC_URI[x86_64_v2_fftw-libs-long.sha256sum] = "21d5b4c68d59a5dab134b40b38dd72b66c18d47c32ec316621dccf0a55bc035b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-quad-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-quad;unpack=0"
SRC_URI[x86_64_v2_fftw-libs-quad.sha256sum] = "66c9648b3f546613932ad3f96e58e966c1b5e007d9f72af79cbc03207750941d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-single-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-single;unpack=0"
SRC_URI[x86_64_v2_fftw-libs-single.sha256sum] = "b03ddc10359962d6b9fc3142085df5121da284dba138284a46cb58615739cfbe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-devel-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-devel;unpack=0"
SRC_URI[x86_64_v2_fftw-openmpi-devel.sha256sum] = "f8408dc7c7ee20f3eabb2a1fdb314e4bb0f910cf98d133d81a830c753416746b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs;unpack=0"
SRC_URI[x86_64_v2_fftw-openmpi-libs.sha256sum] = "77e9f36d83a6acb5989f80e56e54a48aa44a2538a5d7b90608566d1af91c3afb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-double-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs-double;unpack=0"
SRC_URI[x86_64_v2_fftw-openmpi-libs-double.sha256sum] = "eb699cfc90567d96dd20595b64de90cd54ec48d7421369bb80216f8e18c527de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-long-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs-long;unpack=0"
SRC_URI[x86_64_v2_fftw-openmpi-libs-long.sha256sum] = "05f21ad9110f95a49eafe68ede1e2a9a61e9b6e514278c6e91b6892fe6f2f2b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-single-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs-single;unpack=0"
SRC_URI[x86_64_v2_fftw-openmpi-libs-single.sha256sum] = "99804e89a1abf259e347ca7e0712f51643407c233c5063863a252e2e441416ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-static-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-static;unpack=0"
SRC_URI[x86_64_v2_fftw-openmpi-static.sha256sum] = "bcec13d1de3138ea5f03ce9370c38cb3c6a639753dc395b5489a6d79b45b8803"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-static-3.3.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-static;unpack=0"
SRC_URI[x86_64_v2_fftw-static.sha256sum] = "7c1455ac9bee3dccd8a8a6fb71430e0aafcec44399512a2a7525fc9feb1d71e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw;unpack=0"
SRC_URI[aarch64_fftw.sha256sum] = "f3f071deb754db845f9815a82492a9ddc5f43d42f4a535e81fae20498d9adf1a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-devel-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-devel;unpack=0"
SRC_URI[aarch64_fftw-devel.sha256sum] = "5d1bc9f1fac64164b83a0c9fd4657b15679bc84f072fd0f1ffd22b260dddc707"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fftw-doc-3.3.11-1.el10.alma.1.noarch.rpm;name=aarch64_fftw-doc;unpack=0"
SRC_URI[aarch64_fftw-doc.sha256sum] = "689f6d968a67f22dc5af193387c911e5bb6014b133d869673427c523a4eb7ce4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-libs;unpack=0"
SRC_URI[aarch64_fftw-libs.sha256sum] = "acbcbbd2e51536784b3e318fc1235e9c45385ddc095aa6d4949b699d693b4e81"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-double-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-libs-double;unpack=0"
SRC_URI[aarch64_fftw-libs-double.sha256sum] = "c0477a86a27e9d3e01a8c64b4f38103115e84254c9400e151a1d1a8e0638bf6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-long-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-libs-long;unpack=0"
SRC_URI[aarch64_fftw-libs-long.sha256sum] = "848da4cfe4c11969a22dbd70b90bb67a5d09516b88da3f7154e534c179d60aa5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-single-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-libs-single;unpack=0"
SRC_URI[aarch64_fftw-libs-single.sha256sum] = "05ffeb56a93a9a76bf47c50deebe892b28f2774ef218418b02f02b991bf69461"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-devel-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-devel;unpack=0"
SRC_URI[aarch64_fftw-openmpi-devel.sha256sum] = "59d453f0d0b368b0ede100dd03322b1bf8d71770fa0874e7c2947e5def9870d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-libs;unpack=0"
SRC_URI[aarch64_fftw-openmpi-libs.sha256sum] = "3fc70c7a1d96becf15bb51036e26e17468b9b7e12cc9824d9579d7a12f90efa1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-double-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-libs-double;unpack=0"
SRC_URI[aarch64_fftw-openmpi-libs-double.sha256sum] = "8049520a48d30c93d3626f6d45fab2a0ac2555f5665bca57497d84d888aca8a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-long-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-libs-long;unpack=0"
SRC_URI[aarch64_fftw-openmpi-libs-long.sha256sum] = "d76040a36284f50679e77bf8dc6b18add5de0ac9fc8717e6631d101de0ccf852"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-single-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-libs-single;unpack=0"
SRC_URI[aarch64_fftw-openmpi-libs-single.sha256sum] = "d95f64aa7c86014f19d2dd1425580dd362feafced140241fd57485370e5979c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-static-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-static;unpack=0"
SRC_URI[aarch64_fftw-openmpi-static.sha256sum] = "06d0106fec67e5e1b54431f8a4b15368fcaaa9778a4f6d2cfaf15a9dd991445f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-static-3.3.11-1.el10.alma.1.aarch64.rpm;name=aarch64_fftw-static;unpack=0"
SRC_URI[aarch64_fftw-static.sha256sum] = "afa51d923f3dbabf4391e1114eb50e8f0e17787a2e797fd0c6562d1fb18ff1c5"

RDEPENDS:fftw:x86_64_v2 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
 fftw-libs-single \
 glibc \
"
RDEPENDS:fftw:aarch64 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-single \
 glibc \
"
RDEPENDS:fftw-devel = " \
 fftw \
 fftw-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:fftw-doc = " \
 "
RDEPENDS:fftw-libs:x86_64_v2 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
 fftw-libs-single \
"
RDEPENDS:fftw-libs:aarch64 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-single \
"
RDEPENDS:fftw-libs-double = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:fftw-libs-long = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:fftw-libs-quad = " \
 glibc \
 libgcc \
 libgomp \
 libquadmath \
 "
RDEPENDS:fftw-libs-single = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:fftw-openmpi-devel = " \
 fftw-devel \
 fftw-openmpi-libs \
 openmpi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:fftw-openmpi-libs = " \
 fftw-openmpi-libs-double \
 fftw-openmpi-libs-long \
 fftw-openmpi-libs-single \
 "
RDEPENDS:fftw-openmpi-libs-double = " \
 fftw-libs-double \
 glibc \
 openmpi \
 "
RDEPENDS:fftw-openmpi-libs-long = " \
 fftw-libs-long \
 glibc \
 openmpi \
 "
RDEPENDS:fftw-openmpi-libs-single = " \
 fftw-libs-single \
 glibc \
 openmpi \
 "
RDEPENDS:fftw-openmpi-static = " \
 fftw-openmpi-devel \
 fftw-static \
 "
RDEPENDS:fftw-static = " \
 fftw-devel \
 "
