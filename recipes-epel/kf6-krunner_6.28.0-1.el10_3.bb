# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-krunner"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-krunner \
 kf6-krunner-devel \
 kf6-krunner-doc \
 kf6-krunner-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-krunner-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "706ef74c8f65d5d9e611154877c3a726ef88d1eeafa1005b493387f107e0af20"

URI_x86_64_v2_kf6-krunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-krunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner}"
SRC_URI[x86_64_v2_kf6-krunner.sha256sum] = "2ba8e2451c640edc3053a8833bb6ee397d6c65593abb01f6497118ff81310da9"

URI_x86_64_v2_kf6-krunner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-krunner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-devel}"
SRC_URI[x86_64_v2_kf6-krunner-devel.sha256sum] = "3199f8f24ccca7cf7581950454817f4749a4625d0da819e85579680fb3152edf"

URI_x86_64_v2_kf6-krunner-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-krunner-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-doc}"
SRC_URI[x86_64_v2_kf6-krunner-doc.sha256sum] = "5b1c98561eb84cf5efe34424abdc055d102034907a6a6cb81f039be4dcaeec22"

URI_x86_64_v2_kf6-krunner-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-krunner-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-html}"
SRC_URI[x86_64_v2_kf6-krunner-html.sha256sum] = "e8d7852c8c67504a4f2c0c903d95efdfa11a47755e0d0acbaceb574be0f09737"

URI_aarch64_kf6-krunner = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-krunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner}"
SRC_URI[aarch64_kf6-krunner.sha256sum] = "d4657cb5255297dcddae7ad44960d33ef7f4cfd4e2ec7b49f26bbe4a70d0a8be"

URI_aarch64_kf6-krunner-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-krunner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-devel}"
SRC_URI[aarch64_kf6-krunner-devel.sha256sum] = "21aba8285fbebfb74c87f56c127de204fb573078f117c45a3fbd8b59538ba8f5"

URI_aarch64_kf6-krunner-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-krunner-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-doc}"
SRC_URI[aarch64_kf6-krunner-doc.sha256sum] = "f739eeb56e4066a4ba53d3dfc6c6e48d1f1fdbf1c5d9026a9aa9159c1e3e2ea6"

URI_aarch64_kf6-krunner-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-krunner-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-html}"
SRC_URI[aarch64_kf6-krunner-html.sha256sum] = "4046ec7278613d220dfb7f6ca8977ea555d53159ef667fb4ae1727e76157d23d"

RDEPENDS:kf6-krunner = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-krunner-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-krunner \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-krunner-doc = " \
 "
RDEPENDS:kf6-krunner-html = " \
 "
