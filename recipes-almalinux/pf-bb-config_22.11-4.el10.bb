# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pf-bb-config"
PV = "22.11"
PR = "4.el10"
PACKAGES = " \
 pf-bb-config \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pf-bb-config-22.11-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd0e1fc1b43e780b7ac4a25dec589319041f09c4f2adca22a1da3ba62ddf303e"

URI_x86_64_v2_pf-bb-config = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pf-bb-config-22.11-4.el10.x86_64_v2.rpm;name=x86_64_v2_pf-bb-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pf-bb-config}"
SRC_URI[x86_64_v2_pf-bb-config.sha256sum] = "7826f6f47af6fdb48688e05aa532bd2782fed7a93a2022b42145bae209bffc56"

URI_aarch64_pf-bb-config = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pf-bb-config-22.11-4.el10.aarch64.rpm;name=aarch64_pf-bb-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_pf-bb-config}"
SRC_URI[aarch64_pf-bb-config.sha256sum] = "e66d29a60f92f0c8fbd860dd41a3c21194c6b9ee384987bbc4b8f453dadd1652"

RDEPENDS:pf-bb-config = " \
 glibc \
 "
