# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typetag"
PV = "0.2.21"
PR = "1.el10_2"
PACKAGES = " \
 rust-typetag+default-devel \
 rust-typetag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typetag-0.2.21-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "603cf8335475faf0b13878ccf4401694165c4f3cf6af89e87e6f19e47d63ef75"

URI_x86_64_v2_rust-typetag+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag+default-devel-0.2.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag+default-devel}"
SRC_URI[x86_64_v2_rust-typetag+default-devel.sha256sum] = "2d883da8aeab0e3eb660e6f6319e82fd604189fa9d79c0e3338b14ae9996fd67"

URI_x86_64_v2_rust-typetag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-devel-0.2.21-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag-devel}"
SRC_URI[x86_64_v2_rust-typetag-devel.sha256sum] = "e47f8c4747148e725220efdfc9d69f814bed24699456462833799609693e76f3"

URI_aarch64_rust-typetag+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag+default-devel-0.2.21-1.el10_2.noarch.rpm;name=aarch64_rust-typetag+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag+default-devel}"
SRC_URI[aarch64_rust-typetag+default-devel.sha256sum] = "b0cf9726d790d19a4a0c5bacecfa430e0150609a75b8112d094e6b5990deece1"

URI_aarch64_rust-typetag-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-devel-0.2.21-1.el10_2.noarch.rpm;name=aarch64_rust-typetag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag-devel}"
SRC_URI[aarch64_rust-typetag-devel.sha256sum] = "db7752351d9029fde97a6c235e7b167e35eeac179e4f4ad85f47250f1ee36ab4"

RDEPENDS:rust-typetag+default-devel = " \
 cargo \
 rust-typetag-devel \
 "
RDEPENDS:rust-typetag-devel = " \
 cargo \
 rust \
 rust-erased-serde+alloc-devel \
 rust-erased-serde-devel \
 rust-inventory+default-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-typetag-impl+default-devel \
 "
