# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cross-binutils"
PV = "2.41"
PR = "2.el10_0"
PACKAGES = " \
 binutils-aarch64-linux-gnu \
 binutils-alpha-linux-gnu \
 binutils-arc-linux-gnu \
 binutils-arm-linux-gnu \
 binutils-avr32-linux-gnu \
 binutils-bfin-linux-gnu \
 binutils-c6x-linux-gnu \
 binutils-cris-linux-gnu \
 binutils-frv-linux-gnu \
 binutils-h8300-linux-gnu \
 binutils-hppa-linux-gnu \
 binutils-hppa64-linux-gnu \
 binutils-ia64-linux-gnu \
 binutils-loongarch64-linux-gnu \
 binutils-m32r-linux-gnu \
 binutils-m68k-linux-gnu \
 binutils-metag-linux-gnu \
 binutils-microblaze-linux-gnu \
 binutils-mips64-linux-gnu \
 binutils-mn10300-linux-gnu \
 binutils-nios2-linux-gnu \
 binutils-openrisc-linux-gnu \
 binutils-powerpc64-linux-gnu \
 binutils-powerpc64le-linux-gnu \
 binutils-ppc64-linux-gnu \
 binutils-ppc64le-linux-gnu \
 binutils-riscv64-linux-gnu \
 binutils-s390x-linux-gnu \
 binutils-score-linux-gnu \
 binutils-sh-linux-gnu \
 binutils-sparc64-linux-gnu \
 binutils-tile-linux-gnu \
 binutils-x86_64-linux-gnu \
 binutils-xtensa-linux-gnu \
 cross-binutils-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cross-binutils-2.41-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a19bae9a1dd5c614f903faf77fbe205307e5a2a09230fa4085f677fd769edf3a"

URI_x86_64_v2_binutils-aarch64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-aarch64-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-aarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-aarch64-linux-gnu}"
SRC_URI[x86_64_v2_binutils-aarch64-linux-gnu.sha256sum] = "8ad807969f0365b23e8e1625050cd3d584520a243c5a77bdf0a78ed10b7f5ee5"

URI_x86_64_v2_binutils-alpha-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-alpha-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-alpha-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-alpha-linux-gnu}"
SRC_URI[x86_64_v2_binutils-alpha-linux-gnu.sha256sum] = "bfa703518b629f335fa6e96e8f8699b955b3fdfa5611f931ac01837e315da5b8"

URI_x86_64_v2_binutils-arc-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-arc-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-arc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-arc-linux-gnu}"
SRC_URI[x86_64_v2_binutils-arc-linux-gnu.sha256sum] = "17aa4c7083ea13eff639840fcdb4738bebcad771d8c1b6c4b87e1a2507b7be28"

URI_x86_64_v2_binutils-arm-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-arm-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-arm-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-arm-linux-gnu}"
SRC_URI[x86_64_v2_binutils-arm-linux-gnu.sha256sum] = "868ce1363e3e2d6c1965803e95159f7e0ab3ef10890eb615cf9e13715a5fda91"

URI_x86_64_v2_binutils-avr32-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-avr32-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-avr32-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-avr32-linux-gnu}"
SRC_URI[x86_64_v2_binutils-avr32-linux-gnu.sha256sum] = "b330a3051effd37e7896d3ff2281f594aaa4f572f81ad64825dea6e8736d8cf3"

URI_x86_64_v2_binutils-bfin-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-bfin-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-bfin-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-bfin-linux-gnu}"
SRC_URI[x86_64_v2_binutils-bfin-linux-gnu.sha256sum] = "4ad125f7ef0045eb50f1494e1c719a396e2e6d0f7a1884a39ed6753e591e900e"

URI_x86_64_v2_binutils-c6x-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-c6x-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-c6x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-c6x-linux-gnu}"
SRC_URI[x86_64_v2_binutils-c6x-linux-gnu.sha256sum] = "746355dd99b66f25c5edce172b08aa3e344b0d8674af81c90680ecca65c6ffa5"

URI_x86_64_v2_binutils-cris-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-cris-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-cris-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-cris-linux-gnu}"
SRC_URI[x86_64_v2_binutils-cris-linux-gnu.sha256sum] = "d73e097efcf655f5f8bc9081fab7c4028c950f884d03a50b533c3748ddeca42d"

URI_x86_64_v2_binutils-frv-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-frv-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-frv-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-frv-linux-gnu}"
SRC_URI[x86_64_v2_binutils-frv-linux-gnu.sha256sum] = "b23f08210266aaf6b69f7b99c956071ed7189abbb6a636bc8d8501ea89cfb494"

URI_x86_64_v2_binutils-h8300-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-h8300-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-h8300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-h8300-linux-gnu}"
SRC_URI[x86_64_v2_binutils-h8300-linux-gnu.sha256sum] = "ff969f3e547a602978e39e7191bcb63974c6814d28b28881bdaadb4b54783f01"

URI_x86_64_v2_binutils-hppa-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-hppa-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-hppa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-hppa-linux-gnu}"
SRC_URI[x86_64_v2_binutils-hppa-linux-gnu.sha256sum] = "619dc70be473a4ba364ac8d5d849bbb7b3729924f51638d5ab44161be53bd807"

URI_x86_64_v2_binutils-hppa64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-hppa64-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-hppa64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-hppa64-linux-gnu}"
SRC_URI[x86_64_v2_binutils-hppa64-linux-gnu.sha256sum] = "982b32a289f288838c112acef80f39585a69d94fd1e39c9374826e03f8a2b64b"

URI_x86_64_v2_binutils-ia64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-ia64-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-ia64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-ia64-linux-gnu}"
SRC_URI[x86_64_v2_binutils-ia64-linux-gnu.sha256sum] = "337424508e27aae170371c7554e80a8cd5127688d0e600c4d3e9e630ec3132b0"

URI_x86_64_v2_binutils-loongarch64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-loongarch64-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-loongarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-loongarch64-linux-gnu}"
SRC_URI[x86_64_v2_binutils-loongarch64-linux-gnu.sha256sum] = "4fd337481fd8bd976cfeb612f904e95e0d500e34ff58f6903beeb0de89c38326"

URI_x86_64_v2_binutils-m32r-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-m32r-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-m32r-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-m32r-linux-gnu}"
SRC_URI[x86_64_v2_binutils-m32r-linux-gnu.sha256sum] = "eb4433549be590e53a26a4ff062954fa0c3a38969b3b834164ec086662bb6598"

URI_x86_64_v2_binutils-m68k-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-m68k-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-m68k-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-m68k-linux-gnu}"
SRC_URI[x86_64_v2_binutils-m68k-linux-gnu.sha256sum] = "aa294b89e492549c4fe1e30acd7cceb1581e80b7f94624f9be29d6660144ebf4"

URI_x86_64_v2_binutils-metag-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-metag-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-metag-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-metag-linux-gnu}"
SRC_URI[x86_64_v2_binutils-metag-linux-gnu.sha256sum] = "369d2ccc92af59c8a0c2f2f6c42d360b0d9c1dee6f6b5ec3cd621126f9d626f0"

URI_x86_64_v2_binutils-microblaze-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-microblaze-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-microblaze-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-microblaze-linux-gnu}"
SRC_URI[x86_64_v2_binutils-microblaze-linux-gnu.sha256sum] = "c02228fb5ddc82b77084791f8de24a1486cdfc434219410f83b03d7ccbee6b49"

URI_x86_64_v2_binutils-mips64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-mips64-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-mips64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-mips64-linux-gnu}"
SRC_URI[x86_64_v2_binutils-mips64-linux-gnu.sha256sum] = "5725c9aa5388263cf4b78bc9c4eb796b0872dd8d8a4aa8f141617ba92bc6e59f"

URI_x86_64_v2_binutils-mn10300-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-mn10300-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-mn10300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-mn10300-linux-gnu}"
SRC_URI[x86_64_v2_binutils-mn10300-linux-gnu.sha256sum] = "17241951cb4a5c619beae8613dfe869b03fe7faf047fec81c5e9a6eb9126f6aa"

URI_x86_64_v2_binutils-nios2-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-nios2-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-nios2-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-nios2-linux-gnu}"
SRC_URI[x86_64_v2_binutils-nios2-linux-gnu.sha256sum] = "a5ab5de02de6d4d97b976888c61589c99633680763de13d30dcb30760e9b6332"

URI_x86_64_v2_binutils-openrisc-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-openrisc-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-openrisc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-openrisc-linux-gnu}"
SRC_URI[x86_64_v2_binutils-openrisc-linux-gnu.sha256sum] = "e6598cf3b1a998686cecb7a45d16518fbb578708ac63590f7e7f176290bdb45c"

URI_x86_64_v2_binutils-powerpc64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-powerpc64-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-powerpc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-powerpc64-linux-gnu}"
SRC_URI[x86_64_v2_binutils-powerpc64-linux-gnu.sha256sum] = "b44110007267b16d55a79f925a223a082157ee09c6dd7e50ff645b144da8f59b"

URI_x86_64_v2_binutils-powerpc64le-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-powerpc64le-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-powerpc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-powerpc64le-linux-gnu}"
SRC_URI[x86_64_v2_binutils-powerpc64le-linux-gnu.sha256sum] = "8ff9c547be1a9eaa71bcdd79467f51cd5e120f8eb484e249a1905b4ad2ca1390"

URI_x86_64_v2_binutils-ppc64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-ppc64-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-ppc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-ppc64-linux-gnu}"
SRC_URI[x86_64_v2_binutils-ppc64-linux-gnu.sha256sum] = "83e191f665409d78049faa93c6e8de3084d16444f0a1fbd1934704052fa6406b"

URI_x86_64_v2_binutils-ppc64le-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-ppc64le-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-ppc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-ppc64le-linux-gnu}"
SRC_URI[x86_64_v2_binutils-ppc64le-linux-gnu.sha256sum] = "1ad2b1dc47c6650524a3c78ebb5a84968d86420289bd1b6aa984e55cfd606218"

URI_x86_64_v2_binutils-riscv64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-riscv64-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-riscv64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-riscv64-linux-gnu}"
SRC_URI[x86_64_v2_binutils-riscv64-linux-gnu.sha256sum] = "41ae6ff04ff75f2b4dddca4ebd558318b1b24be69f2e487265e2795c31e1cdfc"

URI_x86_64_v2_binutils-s390x-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-s390x-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-s390x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-s390x-linux-gnu}"
SRC_URI[x86_64_v2_binutils-s390x-linux-gnu.sha256sum] = "562f4357f34acf589547395c9b2929d0652696e71e32bc3a21a87aac32db9c0e"

URI_x86_64_v2_binutils-score-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-score-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-score-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-score-linux-gnu}"
SRC_URI[x86_64_v2_binutils-score-linux-gnu.sha256sum] = "d9872a0be4537f8582dce163393b7ca4c3e19e06dbe50a1a63d73ebc86ebf527"

URI_x86_64_v2_binutils-sh-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-sh-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-sh-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-sh-linux-gnu}"
SRC_URI[x86_64_v2_binutils-sh-linux-gnu.sha256sum] = "957c22cc12ff23b90589ebb46a1c2c5e69174057df5ea0885b22e8f73eca74bd"

URI_x86_64_v2_binutils-sparc64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-sparc64-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-sparc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-sparc64-linux-gnu}"
SRC_URI[x86_64_v2_binutils-sparc64-linux-gnu.sha256sum] = "e275a25c36fc8067b574354dba89c39a12f2db6acd350e28d0009e0bd7384c10"

URI_x86_64_v2_binutils-tile-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-tile-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-tile-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-tile-linux-gnu}"
SRC_URI[x86_64_v2_binutils-tile-linux-gnu.sha256sum] = "41236da44604f90ead2bad5795d7a0064e88b7596bbc0d5bcf2bf150e6789c12"

URI_x86_64_v2_binutils-x86_64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-x86_64-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-x86_64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-x86_64-linux-gnu}"
SRC_URI[x86_64_v2_binutils-x86_64-linux-gnu.sha256sum] = "26d746ba594f1d56a0873de46e259ea2d92684f6144f25480631125735437259"

URI_x86_64_v2_binutils-xtensa-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/binutils-xtensa-linux-gnu-2.41-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_binutils-xtensa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-xtensa-linux-gnu}"
SRC_URI[x86_64_v2_binutils-xtensa-linux-gnu.sha256sum] = "60319699e7a4e6b2f3fd324cd12457b79210e31597496af3ddcea7d5de73b199"

URI_x86_64_v2_cross-binutils-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cross-binutils-common-2.41-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cross-binutils-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cross-binutils-common}"
SRC_URI[x86_64_v2_cross-binutils-common.sha256sum] = "310ab562eac77135b26a022877d68def191b3ed25325e84b2c6cddf5d26b38e8"

URI_aarch64_binutils-aarch64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-aarch64-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-aarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-aarch64-linux-gnu}"
SRC_URI[aarch64_binutils-aarch64-linux-gnu.sha256sum] = "0072dde12777f00aa981a3573a04cf69c80b6d96bf236fdedb9824294a3c4c72"

URI_aarch64_binutils-alpha-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-alpha-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-alpha-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-alpha-linux-gnu}"
SRC_URI[aarch64_binutils-alpha-linux-gnu.sha256sum] = "0810b7187b724ebf701980893007cdfda368e3da7d01349cb9cd281b42684422"

URI_aarch64_binutils-arc-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-arc-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-arc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-arc-linux-gnu}"
SRC_URI[aarch64_binutils-arc-linux-gnu.sha256sum] = "440193c24142edca6b427e8ae0ffa2cfce638f9dd70e17dbbfcffc891b9782d7"

URI_aarch64_binutils-arm-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-arm-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-arm-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-arm-linux-gnu}"
SRC_URI[aarch64_binutils-arm-linux-gnu.sha256sum] = "c8a287564402139b0dcab3f1546849aaf5ad2b51bf405720709554e70d582e32"

URI_aarch64_binutils-avr32-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-avr32-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-avr32-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-avr32-linux-gnu}"
SRC_URI[aarch64_binutils-avr32-linux-gnu.sha256sum] = "cb1600db3171c88e117640d27c9546be63b8b16795b26d44d527c213912b9e02"

URI_aarch64_binutils-bfin-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-bfin-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-bfin-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-bfin-linux-gnu}"
SRC_URI[aarch64_binutils-bfin-linux-gnu.sha256sum] = "3d6cb4e64e6fcabacc3e6e8eb61f414c8f656a6e148dd1022fc80f8b598c53c9"

URI_aarch64_binutils-c6x-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-c6x-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-c6x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-c6x-linux-gnu}"
SRC_URI[aarch64_binutils-c6x-linux-gnu.sha256sum] = "01a0fed5c6f365c61e852a93627e26ecad5dc8678e621c7ef6f72c5d0771d8ed"

URI_aarch64_binutils-cris-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-cris-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-cris-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-cris-linux-gnu}"
SRC_URI[aarch64_binutils-cris-linux-gnu.sha256sum] = "ee2e03a9efb3302e338571c45212942455df55f957826a855a05f8e9b42e702b"

URI_aarch64_binutils-frv-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-frv-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-frv-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-frv-linux-gnu}"
SRC_URI[aarch64_binutils-frv-linux-gnu.sha256sum] = "eff7d61da85946ef64d0b475cb50167bcfb9d5d73aef9bc707aeaa370523ecc0"

URI_aarch64_binutils-h8300-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-h8300-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-h8300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-h8300-linux-gnu}"
SRC_URI[aarch64_binutils-h8300-linux-gnu.sha256sum] = "327905797acdef0af1f33d6c75813f6e48fb2c59d872b2efc985f94bde777695"

URI_aarch64_binutils-hppa-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-hppa-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-hppa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-hppa-linux-gnu}"
SRC_URI[aarch64_binutils-hppa-linux-gnu.sha256sum] = "d4caa028eeb819b38c9702a9c89ab2167f0c826d6e57380c2727104710c25710"

URI_aarch64_binutils-hppa64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-hppa64-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-hppa64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-hppa64-linux-gnu}"
SRC_URI[aarch64_binutils-hppa64-linux-gnu.sha256sum] = "1e73d09f269bf9b68970ed566b8d76bec7df688108b70133042f111387fde4e0"

URI_aarch64_binutils-ia64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-ia64-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-ia64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-ia64-linux-gnu}"
SRC_URI[aarch64_binutils-ia64-linux-gnu.sha256sum] = "77294361432f3544f1567a213cdd2aa9bd32371f06b0cb823e9b61a2fbadc3dc"

URI_aarch64_binutils-loongarch64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-loongarch64-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-loongarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-loongarch64-linux-gnu}"
SRC_URI[aarch64_binutils-loongarch64-linux-gnu.sha256sum] = "b8548c062e29b2e6fa2fd5ae5d85c9be22a45208d649965e7791f98af680591a"

URI_aarch64_binutils-m32r-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-m32r-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-m32r-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-m32r-linux-gnu}"
SRC_URI[aarch64_binutils-m32r-linux-gnu.sha256sum] = "1f29f39197755bacecd08bf558aa3ef646cb6ee55d9593d60984e2f7ee4b21f6"

URI_aarch64_binutils-m68k-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-m68k-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-m68k-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-m68k-linux-gnu}"
SRC_URI[aarch64_binutils-m68k-linux-gnu.sha256sum] = "5257752acddf637abadab124296f34f2223a2ed24dc1241015f902ed229421a8"

URI_aarch64_binutils-metag-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-metag-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-metag-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-metag-linux-gnu}"
SRC_URI[aarch64_binutils-metag-linux-gnu.sha256sum] = "7b2e901c6643fccfe7c215f8996bf7c7d1aaad875f0a480bd1935659dc2aed15"

URI_aarch64_binutils-microblaze-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-microblaze-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-microblaze-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-microblaze-linux-gnu}"
SRC_URI[aarch64_binutils-microblaze-linux-gnu.sha256sum] = "3d724ecc2dcd4af0c740627906eca46e9c6e0c04a2f6e09503a737834d4e1d77"

URI_aarch64_binutils-mips64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-mips64-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-mips64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-mips64-linux-gnu}"
SRC_URI[aarch64_binutils-mips64-linux-gnu.sha256sum] = "f8b19f9510741c20f07f8c51a3625136655c349196ad687b7084e227f1636c45"

URI_aarch64_binutils-mn10300-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-mn10300-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-mn10300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-mn10300-linux-gnu}"
SRC_URI[aarch64_binutils-mn10300-linux-gnu.sha256sum] = "b3033d57f06d73b3448b61c0b9e48a0b79548d534f042edcba3396bd82a062ad"

URI_aarch64_binutils-nios2-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-nios2-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-nios2-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-nios2-linux-gnu}"
SRC_URI[aarch64_binutils-nios2-linux-gnu.sha256sum] = "d4aeeec6df30fbff1b21fdde5957b071c625fd218ef9a83b8a968759f782b91f"

URI_aarch64_binutils-openrisc-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-openrisc-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-openrisc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-openrisc-linux-gnu}"
SRC_URI[aarch64_binutils-openrisc-linux-gnu.sha256sum] = "ade393f3b5c03aa38a7bcdffbed012d3aa9781d07fadaebbba04f55347c8e54f"

URI_aarch64_binutils-powerpc64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-powerpc64-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-powerpc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-powerpc64-linux-gnu}"
SRC_URI[aarch64_binutils-powerpc64-linux-gnu.sha256sum] = "3e2ae269fa4295b2010db8496759a50f038f2db77a2972f1dda9152638d8ffba"

URI_aarch64_binutils-powerpc64le-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-powerpc64le-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-powerpc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-powerpc64le-linux-gnu}"
SRC_URI[aarch64_binutils-powerpc64le-linux-gnu.sha256sum] = "2675738de22cafc71bed3374cde54c8f31ac221dffddb605792ffe39f304a228"

URI_aarch64_binutils-ppc64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-ppc64-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-ppc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-ppc64-linux-gnu}"
SRC_URI[aarch64_binutils-ppc64-linux-gnu.sha256sum] = "5efadec261e4a09ef11cb940a7957d608ddf01f5c0f37c9347ac64493cad4177"

URI_aarch64_binutils-ppc64le-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-ppc64le-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-ppc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-ppc64le-linux-gnu}"
SRC_URI[aarch64_binutils-ppc64le-linux-gnu.sha256sum] = "de2a10ceeb153151910176256e2e26cc99e2884f67c52d43643e3d4ade24fa3c"

URI_aarch64_binutils-riscv64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-riscv64-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-riscv64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-riscv64-linux-gnu}"
SRC_URI[aarch64_binutils-riscv64-linux-gnu.sha256sum] = "b3ac6f3d4994f68b29bf9d31eeb4376f795378c5917a11c1b9fb780887afa1ca"

URI_aarch64_binutils-s390x-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-s390x-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-s390x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-s390x-linux-gnu}"
SRC_URI[aarch64_binutils-s390x-linux-gnu.sha256sum] = "7988cc1f45375ba9379a9d113a434b6adbb43a7d5dbe64293c0a77747707933d"

URI_aarch64_binutils-score-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-score-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-score-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-score-linux-gnu}"
SRC_URI[aarch64_binutils-score-linux-gnu.sha256sum] = "55d8b20c1d656396127c38371e735564290863f474c87d8faabc772c0760a1cd"

URI_aarch64_binutils-sh-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-sh-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-sh-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-sh-linux-gnu}"
SRC_URI[aarch64_binutils-sh-linux-gnu.sha256sum] = "619b201369f1198c7dff102e1f0cc12d3a1563a2c4a202f52892b277d640a87c"

URI_aarch64_binutils-sparc64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-sparc64-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-sparc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-sparc64-linux-gnu}"
SRC_URI[aarch64_binutils-sparc64-linux-gnu.sha256sum] = "2a7bb77707921fc8cb874958ee8e221bfdbdee9d5cdcc2f19dd34699e5b97cb3"

URI_aarch64_binutils-tile-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-tile-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-tile-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-tile-linux-gnu}"
SRC_URI[aarch64_binutils-tile-linux-gnu.sha256sum] = "d23c17b56ea9f03bb4ef003b5c866350a99516eac7e9ee5cc7e0e6075f6f07a7"

URI_aarch64_binutils-x86_64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-x86_64-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-x86_64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-x86_64-linux-gnu}"
SRC_URI[aarch64_binutils-x86_64-linux-gnu.sha256sum] = "5de63e547c43c28847043eb3087e4f3b71bcb9af85d6ac9521bdab3cbcf345ad"

URI_aarch64_binutils-xtensa-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/b/binutils-xtensa-linux-gnu-2.41-2.el10_0.aarch64.rpm;name=aarch64_binutils-xtensa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-xtensa-linux-gnu}"
SRC_URI[aarch64_binutils-xtensa-linux-gnu.sha256sum] = "d5aca07be032a54ca9fa2928f174d0107ba6a7124659f23eac67c4a31614ed2d"

URI_aarch64_cross-binutils-common = "${EPEL_MIRROR}/aarch64/Packages/c/cross-binutils-common-2.41-2.el10_0.noarch.rpm;name=aarch64_cross-binutils-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_cross-binutils-common}"
SRC_URI[aarch64_cross-binutils-common.sha256sum] = "2fc98fa300d1cb70a022d58e75e457e5c1df49e7f738ff2d1db1e6a857249894"

RDEPENDS:binutils-aarch64-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-alpha-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-arc-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-arm-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-avr32-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-bfin-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-c6x-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-cris-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-frv-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-h8300-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-hppa-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-hppa64-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-ia64-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-loongarch64-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-m32r-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-m68k-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-metag-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-microblaze-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-mips64-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-mn10300-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-nios2-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-openrisc-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-powerpc64-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-powerpc64le-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-ppc64-linux-gnu = " \
 binutils-powerpc64-linux-gnu \
 "
RDEPENDS:binutils-ppc64le-linux-gnu = " \
 binutils-powerpc64le-linux-gnu \
 "
RDEPENDS:binutils-riscv64-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-s390x-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-score-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-sh-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-sparc64-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-tile-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-x86_64-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:binutils-xtensa-linux-gnu = " \
 cross-binutils-common \
 glibc \
 "
RDEPENDS:cross-binutils-common = " \
 "
