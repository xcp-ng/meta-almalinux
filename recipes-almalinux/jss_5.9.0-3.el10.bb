# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jss"
PV = "5.9.0"
PR = "3.el10"
PACKAGES = " \
 idm-jss \
 idm-jss-tomcat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jss-5.9.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74ac7ef4ad8ddff7130c8fe131636169c8c04736568d8546040bd753eb3b7c8e"

URI_x86_64_v2_idm-jss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-jss-5.9.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_idm-jss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-jss}"
SRC_URI[x86_64_v2_idm-jss.sha256sum] = "9f4bc3dc036bbb8e96e3dbb1f8bb83b81693be62bde3f1e09a134f2c5be05b9f"

URI_x86_64_v2_idm-jss-tomcat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-jss-tomcat-5.9.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_idm-jss-tomcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-jss-tomcat}"
SRC_URI[x86_64_v2_idm-jss-tomcat.sha256sum] = "809b5e1c0ab88777029da21ebd1bed6eb49d343d0a5313bfed4fa7af658989fb"

URI_aarch64_idm-jss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-jss-5.9.0-3.el10.aarch64.rpm;name=aarch64_idm-jss;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-jss}"
SRC_URI[aarch64_idm-jss.sha256sum] = "cbd63f1a44266a00f3fcf14a0ce07115a72411b0d49e35d011a23b2bbbe006e6"

URI_aarch64_idm-jss-tomcat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-jss-tomcat-5.9.0-3.el10.aarch64.rpm;name=aarch64_idm-jss-tomcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-jss-tomcat}"
SRC_URI[aarch64_idm-jss-tomcat.sha256sum] = "0b16b4ae199a17f864de05099a8b800830fd6f927ca33764a82028468503d269"

RDEPENDS:idm-jss = " \
 apache-commons-lang3 \
 glibc \
 java-21-openjdk-headless \
 javapackages-filesystem \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 slf4j \
 slf4j-jdk14 \
 "
RDEPENDS:idm-jss-tomcat = " \
 idm-jss \
 javapackages-filesystem \
 tomcat9-lib \
 virtual/mvn_org.apache.tomcat_tomcat-catalina_ \
 virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 \
 virtual/mvn_org.apache.tomcat_tomcat-coyote_ \
 virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 \
 virtual/mvn_org.apache.tomcat_tomcat-juli_ \
 virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62 \
 "
