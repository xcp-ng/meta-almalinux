# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-basic-toml"
PV = "0.1.10"
PR = "2.el10_2"
PACKAGES = " \
 rust-basic-toml+default-devel \
 rust-basic-toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-basic-toml-0.1.10-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c58b10e4d593111dedf91c9e333d181152ae2084cd0135d19508ab9bcee362a5"

URI_x86_64_v2_rust-basic-toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-basic-toml+default-devel-0.1.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-basic-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-basic-toml+default-devel}"
SRC_URI[x86_64_v2_rust-basic-toml+default-devel.sha256sum] = "f9e9450fb15c44f5f00f7995b8c57b366cbde41933b6cc71f900f438292764ef"

URI_x86_64_v2_rust-basic-toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-basic-toml-devel-0.1.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-basic-toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-basic-toml-devel}"
SRC_URI[x86_64_v2_rust-basic-toml-devel.sha256sum] = "d62415d879dd17db919e4cb647d0124bdf387a71249f57e3990a16710cea27ec"

URI_aarch64_rust-basic-toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-basic-toml+default-devel-0.1.10-2.el10_2.noarch.rpm;name=aarch64_rust-basic-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-basic-toml+default-devel}"
SRC_URI[aarch64_rust-basic-toml+default-devel.sha256sum] = "0f00bc8d5f385f3f01608a48eee334e588423843eb32aa63e3e16a643e3b2395"

URI_aarch64_rust-basic-toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-basic-toml-devel-0.1.10-2.el10_2.noarch.rpm;name=aarch64_rust-basic-toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-basic-toml-devel}"
SRC_URI[aarch64_rust-basic-toml-devel.sha256sum] = "032ae894d1bd48527cc0ca1706f2792c45d82c085516e1c97b7b385a097b3894"

RDEPENDS:rust-basic-toml+default-devel = " \
 cargo \
 rust-basic-toml-devel \
 "
RDEPENDS:rust-basic-toml-devel = " \
 cargo \
 rust-serde+default-devel \
 "
