# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-test"
PV = "0.4.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-tokio-test+default-devel \
 rust-tokio-test-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-test-0.4.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d616c3a5d5b93eda5b07b76ddb1bfba12fd157697fdaec1e5e974472ce34e85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-test+default-devel-0.4.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-test+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-test+default-devel.sha256sum] = "f927df477885d8647a42076a06ad03709b20c70cd962532e41b458511dd8c94e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-test-devel-0.4.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-test-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-test-devel.sha256sum] = "4a6b276e20863636a1cbcc5849db6def87f1258d08641aea88833eab2a7686db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-test+default-devel-0.4.6-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-test+default-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-test+default-devel.sha256sum] = "850f678d64be7bd560bf2eaf974095bc926a140dea31985b7d3b29db354bef32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-test-devel-0.4.6-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-test-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-test-devel.sha256sum] = "0651c8b6bdcf180acd7f7c7e855fb94b1dbe558b674d4b94fc3cbad9cd62ee5d"

RDEPENDS:rust-tokio-test+default-devel = " \
 cargo \
 rust-tokio-test-devel \
 "
RDEPENDS:rust-tokio-test-devel = " \
 cargo \
 rust \
 rust-futures-core+default-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+test-util-devel \
 rust-tokio+time-devel \
 rust-tokio-stream+default-devel \
 "
