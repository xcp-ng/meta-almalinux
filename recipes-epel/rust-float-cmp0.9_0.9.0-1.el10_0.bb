# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-float-cmp0.9"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-float-cmp0.9+default-devel \
 rust-float-cmp0.9+num-traits-devel \
 rust-float-cmp0.9+ratio-devel \
 rust-float-cmp0.9+std-devel \
 rust-float-cmp0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-float-cmp0.9-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62702128234aefdf55881e298d17417176345ac4ade0567f05089ee3f9c8f15b"

URI_x86_64_v2_rust-float-cmp0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-cmp0.9+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-cmp0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-cmp0.9+default-devel}"
SRC_URI[x86_64_v2_rust-float-cmp0.9+default-devel.sha256sum] = "b3242dd43be131fea4e58b59e8ee6e4ed8cc75f22af2487854a852657de56659"

URI_x86_64_v2_rust-float-cmp0.9+num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-cmp0.9+num-traits-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-cmp0.9+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-cmp0.9+num-traits-devel}"
SRC_URI[x86_64_v2_rust-float-cmp0.9+num-traits-devel.sha256sum] = "82c1b339b89c57c9f069ee515bfc92bbed9498101669bc35a422d3a3d8074998"

URI_x86_64_v2_rust-float-cmp0.9+ratio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-cmp0.9+ratio-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-cmp0.9+ratio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-cmp0.9+ratio-devel}"
SRC_URI[x86_64_v2_rust-float-cmp0.9+ratio-devel.sha256sum] = "94c5c36589b81cd11a5b6bf69a309133bfc77461bfe5108e690a5fb2e3e07ba2"

URI_x86_64_v2_rust-float-cmp0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-cmp0.9+std-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-cmp0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-cmp0.9+std-devel}"
SRC_URI[x86_64_v2_rust-float-cmp0.9+std-devel.sha256sum] = "cd7470ba69d230d73fdb63afb5111047a87f8425258438c4fb9cc28d1fb258b0"

URI_x86_64_v2_rust-float-cmp0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-float-cmp0.9-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-float-cmp0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-float-cmp0.9-devel}"
SRC_URI[x86_64_v2_rust-float-cmp0.9-devel.sha256sum] = "4469d2855bd011c7e8a1daedc91079988cc6a4eb4863ce58723833eb4f827f62"

URI_aarch64_rust-float-cmp0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-cmp0.9+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-float-cmp0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-cmp0.9+default-devel}"
SRC_URI[aarch64_rust-float-cmp0.9+default-devel.sha256sum] = "503b5e5d3e0d45cc6bbd422ecb08b0ab4e8a2b072524332523c7e611c0878784"

URI_aarch64_rust-float-cmp0.9+num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-cmp0.9+num-traits-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-float-cmp0.9+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-cmp0.9+num-traits-devel}"
SRC_URI[aarch64_rust-float-cmp0.9+num-traits-devel.sha256sum] = "9f5c94a4743953dc28d147a302c6a2e9af01d4e7015ec0036753c46850a140b3"

URI_aarch64_rust-float-cmp0.9+ratio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-cmp0.9+ratio-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-float-cmp0.9+ratio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-cmp0.9+ratio-devel}"
SRC_URI[aarch64_rust-float-cmp0.9+ratio-devel.sha256sum] = "5c215dfddbc5e2d7cc64127fbd5bac60391d7a252fef9118d4a9df40a7d2decb"

URI_aarch64_rust-float-cmp0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-cmp0.9+std-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-float-cmp0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-cmp0.9+std-devel}"
SRC_URI[aarch64_rust-float-cmp0.9+std-devel.sha256sum] = "308c21c2307afa21ddd813b137a63a50159ce498e1b6798fe415580a2842d50e"

URI_aarch64_rust-float-cmp0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-float-cmp0.9-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-float-cmp0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-float-cmp0.9-devel}"
SRC_URI[aarch64_rust-float-cmp0.9-devel.sha256sum] = "601af0cdc77d29d5bc1644de6fcd8cbee877976b25b100ffacf31e4f1f90d88d"

RDEPENDS:rust-float-cmp0.9+default-devel = " \
 cargo \
 rust-float-cmp0.9+ratio-devel \
 rust-float-cmp0.9-devel \
 "
RDEPENDS:rust-float-cmp0.9+num-traits-devel = " \
 cargo \
 rust-float-cmp0.9-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-float-cmp0.9+ratio-devel = " \
 cargo \
 rust-float-cmp0.9+num-traits-devel \
 rust-float-cmp0.9-devel \
 "
RDEPENDS:rust-float-cmp0.9+std-devel = " \
 cargo \
 rust-float-cmp0.9-devel \
 "
RDEPENDS:rust-float-cmp0.9-devel = " \
 cargo \
 "
