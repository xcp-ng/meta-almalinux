# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qmplay2"
PV = "25.01.19"
PR = "1.el10_0"
PACKAGES = " \
 qmplay2 \
 qmplay2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qmplay2-25.01.19-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d91e775b33614e4f30696912782b3072be90590519ff41829c2c854002b398ea"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - qmplay2: libavcodec.so.61()(64bit)
# - qmplay2: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - qmplay2: libavdevice.so.61()(64bit)
# - qmplay2: libavdevice.so.61(LIBAVDEVICE_61)(64bit)
# - qmplay2: libavfilter.so.10()(64bit)
# - qmplay2: libavfilter.so.10(LIBAVFILTER_10)(64bit)
# - qmplay2: libavformat.so.61()(64bit)
# - qmplay2: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - qmplay2: libavutil.so.59()(64bit)
# - qmplay2: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - qmplay2: libswresample.so.5()(64bit)
# - qmplay2: libswresample.so.5(LIBSWRESAMPLE_5)(64bit)
# - qmplay2: libswscale.so.8()(64bit)
# - qmplay2: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_qmplay2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmplay2-25.01.19-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmplay2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qmplay2}"
SRC_URI[x86_64_v2_qmplay2.sha256sum] = "fea0154822d229bcca06a29167caa9bf43be304da267054e75394122a4cf963d"

URI_x86_64_v2_qmplay2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmplay2-devel-25.01.19-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmplay2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qmplay2-devel}"
SRC_URI[x86_64_v2_qmplay2-devel.sha256sum] = "cdc5e9de340161ab461fc02d95e917c4f8b331a6f0a8b76af53670bd57a14c59"

URI_aarch64_qmplay2 = "${EPEL_MIRROR}/aarch64/Packages/q/qmplay2-25.01.19-1.el10_0.aarch64.rpm;name=aarch64_qmplay2;unpack=0"
SRC_URI:append = " ${URI_aarch64_qmplay2}"
SRC_URI[aarch64_qmplay2.sha256sum] = "621624f4c887182b4726330bc51af01589474329d942c31e52d5726f80418ce7"

URI_aarch64_qmplay2-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qmplay2-devel-25.01.19-1.el10_0.aarch64.rpm;name=aarch64_qmplay2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qmplay2-devel}"
SRC_URI[aarch64_qmplay2-devel.sha256sum] = "07fea59a99243ea3140985a42d3f7db5ba8f6e1fdf5f94b69d6f93494c9b9736"

RDEPENDS:qmplay2:x86_64_v2 = " \
 alsa-lib \
 game-music-emu \
 glibc \
 hicolor-icon-theme \
 kde-filesystem \
 libX11 \
 libXv \
 libass \
 libcddb \
 libcdio \
 libgcc \
 libglvnd-egl \
 libglvnd-opengl \
 libsidplayfp \
 libstdc++ \
 libva \
 pipewire-libs \
 pulseaudio-libs \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 rubberband \
 shared-mime-info \
 taglib \
"
RDEPENDS:qmplay2:aarch64 = " \
 alsa-lib \
 game-music-emu \
 glibc \
 hicolor-icon-theme \
 kde-filesystem \
 libX11 \
 libXv \
 libass \
 libavcodec-free \
 libavdevice-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libcddb \
 libcdio \
 libgcc \
 libglvnd-egl \
 libglvnd-opengl \
 libsidplayfp \
 libstdc++ \
 libswresample-free \
 libswscale-free \
 libva \
 pipewire-libs \
 pulseaudio-libs \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 rubberband \
 shared-mime-info \
 taglib \
"
RDEPENDS:qmplay2-devel = " \
 qmplay2 \
 "
