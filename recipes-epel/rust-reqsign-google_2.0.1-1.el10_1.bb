# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-google"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-reqsign-google+default-devel \
 rust-reqsign-google-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-google-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3326f2e0de0ee299d398a63af2ad1c25ba626c86775ee24cf23d6eda215771d"

URI_x86_64_v2_rust-reqsign-google+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-google+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-google+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-google+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-google+default-devel.sha256sum] = "0006e2ff07123733ea42de2544ea5ecde7a5628b4c48d530a77bc7a244baa93c"

URI_x86_64_v2_rust-reqsign-google-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-google-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-google-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-google-devel}"
SRC_URI[x86_64_v2_rust-reqsign-google-devel.sha256sum] = "47778dc950fb388939f13ec9da2d78b932d7e521443383393d3101b213eae16f"

URI_aarch64_rust-reqsign-google+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-google+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-google+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-google+default-devel}"
SRC_URI[aarch64_rust-reqsign-google+default-devel.sha256sum] = "c85bf06a98d99824aa7547162c724e8acdc227a880c6bf1bf26d2ae84781e039"

URI_aarch64_rust-reqsign-google-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-google-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-google-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-google-devel}"
SRC_URI[aarch64_rust-reqsign-google-devel.sha256sum] = "d3f35d05df8ca568abaa5cb7a90fd8c0637ae8932da1e2d47f01e29f983c47e2"

RDEPENDS:rust-reqsign-google+default-devel = " \
 cargo \
 rust-reqsign-google-devel \
 "
RDEPENDS:rust-reqsign-google-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-jsonwebtoken+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-rand0.8+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqwest-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-sha2+default-devel \
 rust-sha2+oid-devel \
 "
