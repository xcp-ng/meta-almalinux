# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcachegrind"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kcachegrind \
 kcachegrind-converters \
 qcachegrind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcachegrind-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "725ffc84602e693bd26c517378946acbcd2e6530e380c9a6fd1a34f3e85d6308"

URI_x86_64_v2_kcachegrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcachegrind-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcachegrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcachegrind}"
SRC_URI[x86_64_v2_kcachegrind.sha256sum] = "852acf423473c5e3fb61a23963111a7c8883885356f5197d02b107eb46eecbd3"

URI_x86_64_v2_kcachegrind-converters = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcachegrind-converters-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcachegrind-converters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcachegrind-converters}"
SRC_URI[x86_64_v2_kcachegrind-converters.sha256sum] = "be364a37e14e3975f4e5f1f1cf00af3097e29cbf2943de733b7a1dbb517a4fbd"

URI_x86_64_v2_qcachegrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcachegrind-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcachegrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcachegrind}"
SRC_URI[x86_64_v2_qcachegrind.sha256sum] = "83f01662a4b166f024f4f8e070440dd32b8f6a7078117a6a4ac74b31d465458d"

URI_aarch64_kcachegrind = "${EPEL_MIRROR}/aarch64/Packages/k/kcachegrind-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kcachegrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcachegrind}"
SRC_URI[aarch64_kcachegrind.sha256sum] = "84c4816c2a2051cd3ef3657bc019b67fcec7eb74567b5796ad59fa59f943b99a"

URI_aarch64_kcachegrind-converters = "${EPEL_MIRROR}/aarch64/Packages/k/kcachegrind-converters-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kcachegrind-converters;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcachegrind-converters}"
SRC_URI[aarch64_kcachegrind-converters.sha256sum] = "fe192688782b48322a6aed88e8e71be5100ba7234f7dfedc898ab44bfc53f72e"

URI_aarch64_qcachegrind = "${EPEL_MIRROR}/aarch64/Packages/q/qcachegrind-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_qcachegrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcachegrind}"
SRC_URI[aarch64_qcachegrind.sha256sum] = "979823fe2118a3b63c9b45cabc5953f33626f7a71641c621a8311219dd744988"

RDEPENDS:kcachegrind = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcachegrind-converters = " \
 kcachegrind \
 perl-Getopt-Std \
 perl-IO \
 perl-interpreter \
 perl-libs \
 php-cli \
 python3 \
 "
RDEPENDS:qcachegrind = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
