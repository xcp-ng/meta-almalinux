# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssl-ibmca"
PV = "2.5.0"
PR = "2.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssl-ibmca-2.5.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bb4b5b1616eec53d4809f1c98b69e8ca575a6a2ba5fd87c6e554b5fc17d282b"

