# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bpaf_derive"
PV = "0.5.17"
PR = "1.el10_0"
PACKAGES = " \
 rust-bpaf_derive+default-devel \
 rust-bpaf_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bpaf_derive-0.5.17-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2d0b792924a2ca682a920d6b21e71b4757a11b67ba38f4f3ade2cf25e0740e8"

URI_x86_64_v2_rust-bpaf_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf_derive+default-devel-0.5.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bpaf_derive+default-devel.sha256sum] = "efe56554c52cd80c97846a0d9ececf77715817400b32c7033d7d1d2092396a3d"

URI_x86_64_v2_rust-bpaf_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf_derive-devel-0.5.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf_derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf_derive-devel.sha256sum] = "259666d414d0c22847fba0361d4ccf113269acf161ce6d80c79df2e44b03a0a5"

URI_aarch64_rust-bpaf_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf_derive+default-devel-0.5.17-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf_derive+default-devel}"
SRC_URI[aarch64_rust-bpaf_derive+default-devel.sha256sum] = "dfa5fc2db9a385f7d19c1262403ee8c779cdd6eb2ef48e2784aea89603bccef0"

URI_aarch64_rust-bpaf_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf_derive-devel-0.5.17-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf_derive-devel}"
SRC_URI[aarch64_rust-bpaf_derive-devel.sha256sum] = "9a96c1f46a24d50fe320deef638aef7db8bcd82694ececed5a71d8c2cb1dc60c"

RDEPENDS:rust-bpaf_derive+default-devel = " \
 cargo \
 rust-bpaf_derive-devel \
 "
RDEPENDS:rust-bpaf_derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-mut-devel \
 "
