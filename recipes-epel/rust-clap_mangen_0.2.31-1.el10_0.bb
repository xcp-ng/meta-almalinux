# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_mangen"
PV = "0.2.31"
PR = "1.el10_0"
PACKAGES = " \
 rust-clap_mangen+debug-devel \
 rust-clap_mangen+default-devel \
 rust-clap_mangen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_mangen-0.2.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "835e661ae28acae14d0250816b3195ae4cbc5bec22a212398c61f59e47487f3c"

URI_x86_64_v2_rust-clap_mangen+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen+debug-devel-0.2.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen+debug-devel.sha256sum] = "110c1e87597466441447abe0d65f347b06b619be73ad729399161bb2264034dc"

URI_x86_64_v2_rust-clap_mangen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen+default-devel-0.2.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen+default-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen+default-devel.sha256sum] = "7bf15de850894da4b08c487159a385cc75f5fbf4f07219c3b20f8f89f1014db5"

URI_x86_64_v2_rust-clap_mangen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen-devel-0.2.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen-devel.sha256sum] = "94314c1577e554e8ced113e25bc2ab13b12d0babda4137e4e0422aa07caaf2ed"

URI_aarch64_rust-clap_mangen+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen+debug-devel-0.2.31-1.el10_0.noarch.rpm;name=aarch64_rust-clap_mangen+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen+debug-devel}"
SRC_URI[aarch64_rust-clap_mangen+debug-devel.sha256sum] = "bf776bf7e897de6254ad332d8b6cb9b411ce6d40016db1378a5e8f445969b753"

URI_aarch64_rust-clap_mangen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen+default-devel-0.2.31-1.el10_0.noarch.rpm;name=aarch64_rust-clap_mangen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen+default-devel}"
SRC_URI[aarch64_rust-clap_mangen+default-devel.sha256sum] = "32acbb98c6f07389fef6b7fea7336303ac671cc74284707fc064e79be5e77387"

URI_aarch64_rust-clap_mangen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen-devel-0.2.31-1.el10_0.noarch.rpm;name=aarch64_rust-clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen-devel}"
SRC_URI[aarch64_rust-clap_mangen-devel.sha256sum] = "7ba74e271b54159dac032dfaf08f145a3e9ec521d2d011a1f0bcb5732e281f98"

RDEPENDS:rust-clap_mangen+debug-devel = " \
 cargo \
 rust-clap+debug-devel \
 rust-clap_mangen-devel \
 "
RDEPENDS:rust-clap_mangen+default-devel = " \
 cargo \
 rust-clap_mangen-devel \
 "
RDEPENDS:rust-clap_mangen-devel = " \
 cargo \
 rust \
 rust-clap+env-devel \
 rust-clap+std-devel \
 rust-clap-devel \
 rust-roff+default-devel \
 "
