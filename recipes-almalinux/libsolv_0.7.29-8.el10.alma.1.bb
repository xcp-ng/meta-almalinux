# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsolv"
PV = "0.7.29"
PR = "8.el10.alma.1"
PACKAGES = " \
 libsolv \
 libsolv-devel \
 libsolv-tools \
 libsolv-tools-base \
 python3-solv \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsolv-0.7.29-8.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7bfddd66f9f01a33061f58d20810e54856aa441002005277bbcddc17bd67971"

URI_x86_64_v2_libsolv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsolv-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libsolv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv}"
SRC_URI[x86_64_v2_libsolv.sha256sum] = "17cefd3b88cc592cb7952c371f711ba71f136f4695e741cc279d54c046a6441b"

URI_x86_64_v2_libsolv-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-devel-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libsolv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv-devel}"
SRC_URI[x86_64_v2_libsolv-devel.sha256sum] = "0f5749b7123344710ee52abe5f6df8c24e8cd2a66183b46a73e23900d12d2740"

URI_x86_64_v2_libsolv-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-tools-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libsolv-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv-tools}"
SRC_URI[x86_64_v2_libsolv-tools.sha256sum] = "fcaeb7eafa4c17d9570c2122b881c5cabbb3115cb184fd3e10f696c0f3e94fb0"

URI_x86_64_v2_libsolv-tools-base = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsolv-tools-base-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libsolv-tools-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsolv-tools-base}"
SRC_URI[x86_64_v2_libsolv-tools-base.sha256sum] = "6565c0fa13110d0f3132245fe2c0eb9a5fb3169bc29363bbd3339f7b9b3261f8"

URI_x86_64_v2_python3-solv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-solv-0.7.29-8.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-solv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-solv}"
SRC_URI[x86_64_v2_python3-solv.sha256sum] = "fe1df769658e843e072cac8633172d2a5f2656144cc42f131cd717da4cf5d9b1"

URI_aarch64_libsolv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsolv-0.7.29-8.el10.alma.1.aarch64.rpm;name=aarch64_libsolv;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv}"
SRC_URI[aarch64_libsolv.sha256sum] = "74739c0e6fc5c4ff27de50d44e74c649fe382594b45f78a3a50e2c28ed32a378"

URI_aarch64_libsolv-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-devel-0.7.29-8.el10.alma.1.aarch64.rpm;name=aarch64_libsolv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv-devel}"
SRC_URI[aarch64_libsolv-devel.sha256sum] = "22992b87b61595565f2e1c1039f6f5c47d6faa79daf638a0590ae49842be083b"

URI_aarch64_libsolv-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-tools-0.7.29-8.el10.alma.1.aarch64.rpm;name=aarch64_libsolv-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv-tools}"
SRC_URI[aarch64_libsolv-tools.sha256sum] = "e98a90be98cfef38f9ab15eb5e3b2d41462070cdaab2c0440b4b312609ee0388"

URI_aarch64_libsolv-tools-base = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsolv-tools-base-0.7.29-8.el10.alma.1.aarch64.rpm;name=aarch64_libsolv-tools-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsolv-tools-base}"
SRC_URI[aarch64_libsolv-tools-base.sha256sum] = "fcb8b804259f4a42ab01fc21b7bbd659f1ef30ba5fa8b11eab13e372335afc5c"

URI_aarch64_python3-solv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-solv-0.7.29-8.el10.alma.1.aarch64.rpm;name=aarch64_python3-solv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-solv}"
SRC_URI[aarch64_python3-solv.sha256sum] = "09ff1a25daac4024af313577ce48001a19310be74bc1a759864210fd4e095aa9"

RDEPENDS:libsolv = " \
 bzip2-libs \
 glibc \
 libxml2 \
 libzstd \
 openssl-libs \
 rpm-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:libsolv-devel = " \
 libsolv \
 libsolv-devel \
 pkgconf-pkg-config \
 rpm-devel \
 "
RDEPENDS:libsolv-tools = " \
 findutils \
 glibc \
 libsolv \
 libsolv-tools-base \
 "
RDEPENDS:libsolv-tools-base = " \
 glibc \
 libsolv \
 rpm-libs \
 "
RDEPENDS:python3-solv = " \
 glibc \
 libsolv \
 python3 \
 "
