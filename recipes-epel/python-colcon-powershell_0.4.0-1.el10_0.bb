# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-powershell"
PV = "0.4.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-powershell \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-powershell-0.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4765ad80b97d2b6d5cf0b0ae59f82b84c580230727d3813ecda91d7f29da979c"

URI_x86_64_v2_python3-colcon-powershell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-powershell-0.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-powershell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-powershell}"
SRC_URI[x86_64_v2_python3-colcon-powershell.sha256sum] = "f291e1fcd34160f158514c4159400f2682c6a0019f59e9f5e1cab211991bb1ee"

URI_aarch64_python3-colcon-powershell = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-powershell-0.4.0-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-powershell;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-powershell}"
SRC_URI[aarch64_python3-colcon-powershell.sha256sum] = "e65c770fbf24208a1942d1d5bb229dc8852b22c11a269534042b53994390065b"

RDEPENDS:python3-colcon-powershell = " \
 python3 \
 python3-colcon-core \
 "
