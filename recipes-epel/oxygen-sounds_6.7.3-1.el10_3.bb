# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oxygen-sounds"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 oxygen-sounds \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oxygen-sounds-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28ed227930b8435002601dcf76e9fecb8f1904e5d33f91b4b6c627e3e39ca893"

URI_x86_64_v2_oxygen-sounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-sounds-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-sounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxygen-sounds}"
SRC_URI[x86_64_v2_oxygen-sounds.sha256sum] = "d40ab350604a3acd064c7043712faa367f2a655fd6eb080e8ab423e763ccdf72"

URI_aarch64_oxygen-sounds = "${EPEL_MIRROR}/aarch64/Packages/o/oxygen-sounds-6.7.3-1.el10_3.noarch.rpm;name=aarch64_oxygen-sounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxygen-sounds}"
SRC_URI[aarch64_oxygen-sounds.sha256sum] = "2c3ec73edaf329920f704bc4aea4b6f0673ba18c22006ece902ef565001e1519"

RDEPENDS:oxygen-sounds = " \
 "
