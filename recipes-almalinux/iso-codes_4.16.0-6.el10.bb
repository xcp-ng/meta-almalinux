# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iso-codes"
PV = "4.16.0"
PR = "6.el10"
PACKAGES = " \
 iso-codes \
 iso-codes-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/iso-codes-4.16.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f37828f488f0d8face64a7d6169e716c46e05b7b85653e36644f31bd082a18a5"

URI_x86_64_v2_iso-codes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iso-codes-4.16.0-6.el10.noarch.rpm;name=x86_64_v2_iso-codes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iso-codes}"
SRC_URI[x86_64_v2_iso-codes.sha256sum] = "e0747ff8aeb0fb0d5acd8923bfeed507f1234ff867733e46caf57bcb0f98a35d"

URI_x86_64_v2_iso-codes-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iso-codes-devel-4.16.0-6.el10.noarch.rpm;name=x86_64_v2_iso-codes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iso-codes-devel}"
SRC_URI[x86_64_v2_iso-codes-devel.sha256sum] = "970193ea22babb8b9922cbd0a958325a4bd55f72aeee368ad787732e4b8a8ad2"

URI_aarch64_iso-codes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iso-codes-4.16.0-6.el10.noarch.rpm;name=aarch64_iso-codes;unpack=0"
SRC_URI:append = " ${URI_aarch64_iso-codes}"
SRC_URI[aarch64_iso-codes.sha256sum] = "e0747ff8aeb0fb0d5acd8923bfeed507f1234ff867733e46caf57bcb0f98a35d"

URI_aarch64_iso-codes-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iso-codes-devel-4.16.0-6.el10.noarch.rpm;name=aarch64_iso-codes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iso-codes-devel}"
SRC_URI[aarch64_iso-codes-devel.sha256sum] = "970193ea22babb8b9922cbd0a958325a4bd55f72aeee368ad787732e4b8a8ad2"

RDEPENDS:iso-codes = " \
 xml-common \
 "
RDEPENDS:iso-codes-devel = " \
 iso-codes \
 pkgconf-pkg-config \
 "
