# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfdump"
PV = "1.7.6"
PR = "1.el10_0"
PACKAGES = " \
 nfdump \
 nfdump-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nfdump-1.7.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "949f11bd6170a68310b89bfbeaa15e5502c62e9ec30478f4a5bc749962aee8c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nfdump-1.7.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nfdump;unpack=0"
SRC_URI[x86_64_v2_nfdump.sha256sum] = "d7ddca70af6a2f8712c6289e4997c7e66871c231778337705605b933efca191b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nfdump-libs-1.7.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nfdump-libs;unpack=0"
SRC_URI[x86_64_v2_nfdump-libs.sha256sum] = "9434ee4721d672740e44e18354870b75ef6119939a9c299b17dd48265818cdac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nfdump-1.7.6-1.el10_0.aarch64.rpm;name=aarch64_nfdump;unpack=0"
SRC_URI[aarch64_nfdump.sha256sum] = "88d17ea7db785b502c46bd2f68adef6f2f634374e038d8d4192f5e398242eda8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nfdump-libs-1.7.6-1.el10_0.aarch64.rpm;name=aarch64_nfdump-libs;unpack=0"
SRC_URI[aarch64_nfdump-libs.sha256sum] = "68773db8aef957b14b2b8e09055989b2e1f461a35433a284e318ab234f57b9e2"

RDEPENDS:nfdump = " \
 glibc \
 libpcap \
 nfdump-libs \
 rrdtool \
 "
RDEPENDS:nfdump-libs:x86_64_v2 = " \
 bzip2-libs \
 glibc \
 libzstd \
 rrdtool \
"
RDEPENDS:nfdump-libs:aarch64 = " \
 bzip2-libs \
 glibc \
 libatomic \
 libzstd \
 rrdtool \
"
