# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-gtk-config"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kde-gtk-config \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-gtk-config-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e008753eba605bdc100750c333683482ff10b9108578bc6279a33f759d1fe3ac"

URI_x86_64_v2_kde-gtk-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-gtk-config-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-gtk-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-gtk-config}"
SRC_URI[x86_64_v2_kde-gtk-config.sha256sum] = "b86035caa0b8d88312d465ad3bb1f109d97b52940b86bf37896e1293984c1aab"

URI_aarch64_kde-gtk-config = "${EPEL_MIRROR}/aarch64/Packages/k/kde-gtk-config-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kde-gtk-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-gtk-config}"
SRC_URI[aarch64_kde-gtk-config.sha256sum] = "62480446d870eb0de6b67aeaf83156774b1b3fdf4f000c7170addde242f95af9"

RDEPENDS:kde-gtk-config = " \
 bash \
 breeze-gtk-common \
 glib2 \
 glibc \
 gtk3 \
 kde-cli-tools \
 kdecoration \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
