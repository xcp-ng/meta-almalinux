# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keychecker"
PV = "1.0"
PR = "24.el10_2"
PACKAGES = " \
 keychecker \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/keychecker-1.0-24.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e2a1b279b847b98f0bfc8d0fbd6f57b0c7829b72615160e9ecf2e39f2a483314"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keychecker-1.0-24.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_keychecker;unpack=0"
SRC_URI[x86_64_v2_keychecker.sha256sum] = "2b2e07e6ae05ef6476879f327f72a5084597811587cb544b3df8d060ba981671"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/keychecker-1.0-24.el10_2.noarch.rpm;name=aarch64_keychecker;unpack=0"
SRC_URI[aarch64_keychecker.sha256sum] = "0005ca1d6360fae943d7007866b11d23efe17277953dd93f7cab75633342f77a"

RDEPENDS:keychecker = " \
 python3 \
 python3-rpm \
 "
