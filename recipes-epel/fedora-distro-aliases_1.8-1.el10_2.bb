# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-distro-aliases"
PV = "1.8"
PR = "1.el10_2"
PACKAGES = " \
 python3-fedora-distro-aliases \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-distro-aliases-1.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9c46e358662eb798736bb3bd7f82f4cb468ad00db80c252b32635fbd0e14af0"

URI_x86_64_v2_python3-fedora-distro-aliases = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fedora-distro-aliases-1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fedora-distro-aliases;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fedora-distro-aliases}"
SRC_URI[x86_64_v2_python3-fedora-distro-aliases.sha256sum] = "2e28ae4201f6da8aa5a8f7c6bc63d624219180c27ced000fb123357aa04a051a"

URI_aarch64_python3-fedora-distro-aliases = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fedora-distro-aliases-1.8-1.el10_2.noarch.rpm;name=aarch64_python3-fedora-distro-aliases;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fedora-distro-aliases}"
SRC_URI[aarch64_python3-fedora-distro-aliases.sha256sum] = "558c2749a09aa45a2440cc5cb8e082e241a4c193d74ec94b3e11797b82f28da1"

RDEPENDS:python3-fedora-distro-aliases = " \
 python3 \
 python3-munch \
 python3-requests \
 "
