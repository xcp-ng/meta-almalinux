# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_pipe"
PV = "1.2.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-os_pipe+default-devel \
 rust-os_pipe+io_safety-devel \
 rust-os_pipe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_pipe-1.2.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50b41b99fba3560e003567bd54192602dd14a26feafc29e027c517f6e29f9ce4"

URI_x86_64_v2_rust-os_pipe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_pipe+default-devel-1.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_pipe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_pipe+default-devel}"
SRC_URI[x86_64_v2_rust-os_pipe+default-devel.sha256sum] = "82e405398185fe84f081084ad258d8c89b15f0193e630419b76b684098852933"

URI_x86_64_v2_rust-os_pipe+io_safety-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_pipe+io_safety-devel-1.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_pipe+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_pipe+io_safety-devel}"
SRC_URI[x86_64_v2_rust-os_pipe+io_safety-devel.sha256sum] = "245acbd5bccc26c00c51a9d4f82c2aa8210abdad43289966eb45de4c01d4016d"

URI_x86_64_v2_rust-os_pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_pipe-devel-1.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_pipe-devel}"
SRC_URI[x86_64_v2_rust-os_pipe-devel.sha256sum] = "d78327c7ac44560f2d783090033f693f3741539fa3b432f48e6e087f44f104b7"

URI_aarch64_rust-os_pipe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_pipe+default-devel-1.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-os_pipe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_pipe+default-devel}"
SRC_URI[aarch64_rust-os_pipe+default-devel.sha256sum] = "c5f55afafe6a372bc4aa671cefb8ca86be7add91590aaa596c49bc843782fa85"

URI_aarch64_rust-os_pipe+io_safety-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_pipe+io_safety-devel-1.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-os_pipe+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_pipe+io_safety-devel}"
SRC_URI[aarch64_rust-os_pipe+io_safety-devel.sha256sum] = "67ae5bfd77847ce9a6ed7e915f5f2fb929f201d51a4a307f2519578c597aa4f8"

URI_aarch64_rust-os_pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_pipe-devel-1.2.3-1.el10_2.noarch.rpm;name=aarch64_rust-os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_pipe-devel}"
SRC_URI[aarch64_rust-os_pipe-devel.sha256sum] = "c40c05f2b02b6e51b670299c4c491bf9e95e3e7a32356f4235595df1ba73d84a"

RDEPENDS:rust-os_pipe+default-devel = " \
 cargo \
 rust-os_pipe-devel \
 "
RDEPENDS:rust-os_pipe+io_safety-devel = " \
 cargo \
 rust-os_pipe-devel \
 "
RDEPENDS:rust-os_pipe-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
