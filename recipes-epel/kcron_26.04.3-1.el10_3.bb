# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcron"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kcron \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcron-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "469df93b878969a32ce4f3a862a7be83a7edd4cdc0a2a8e55c5dcbff93e9337a"

URI_x86_64_v2_kcron = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcron-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcron}"
SRC_URI[x86_64_v2_kcron.sha256sum] = "33cb15e55fc1ec9176d4d8bc8b2f4f91a9adc4fad0b586ca97e888cd1cce7f4c"

URI_aarch64_kcron = "${EPEL_MIRROR}/aarch64/Packages/k/kcron-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kcron;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcron}"
SRC_URI[aarch64_kcron.sha256sum] = "9447861377e4466a1af18b902d68d8bad5314e7b86dc98b3d1c3e7cdc7c82409"

RDEPENDS:kcron = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
