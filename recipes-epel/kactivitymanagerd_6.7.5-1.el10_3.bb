# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kactivitymanagerd"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kactivitymanagerd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kactivitymanagerd-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "efff3ab283d403fb976a7dee78c8536c887c49190bcd6fcb8c50ce41942acb92"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kactivitymanagerd-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kactivitymanagerd;unpack=0"
SRC_URI[x86_64_v2_kactivitymanagerd.sha256sum] = "f00c06666ffa5ed849b9e2496117cf80535d05285ff22e4625850ce25c7388dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kactivitymanagerd-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kactivitymanagerd;unpack=0"
SRC_URI[aarch64_kactivitymanagerd.sha256sum] = "adea32acb6bafa3ba2ed6a8d5558c73e89d496617eeafffc6b9e3c836960ac56"

RDEPENDS:kactivitymanagerd = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
