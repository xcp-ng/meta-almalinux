# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blake3"
PV = "1.8.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-blake3+default-devel \
 rust-blake3+mmap-devel \
 rust-blake3+neon-devel \
 rust-blake3+rayon-devel \
 rust-blake3+serde-devel \
 rust-blake3+std-devel \
 rust-blake3+zeroize-devel \
 rust-blake3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blake3-1.8.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00375c8b2afce75fdabb9359749c648bc38d4c74652693f07177b25bd8286122"

URI_x86_64_v2_rust-blake3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+default-devel-1.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+default-devel}"
SRC_URI[x86_64_v2_rust-blake3+default-devel.sha256sum] = "37a1470e531584b14194ecfe5b0d24bcf83145b481ef96179f6b9892965a2175"

URI_x86_64_v2_rust-blake3+mmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+mmap-devel-1.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+mmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+mmap-devel}"
SRC_URI[x86_64_v2_rust-blake3+mmap-devel.sha256sum] = "533315b0b8099d1521197e5ea43dc71799805ccd0f143a66a2401a2c69530521"

URI_x86_64_v2_rust-blake3+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+neon-devel-1.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+neon-devel}"
SRC_URI[x86_64_v2_rust-blake3+neon-devel.sha256sum] = "d80108ff91364b5f2a90a73616df0d97e378b40b548eaf27847ccfb053426b83"

URI_x86_64_v2_rust-blake3+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+rayon-devel-1.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+rayon-devel}"
SRC_URI[x86_64_v2_rust-blake3+rayon-devel.sha256sum] = "6fe8096666cae5732a906e13d712e144c65dd45e8e44f872d83c1b5abc44bd1a"

URI_x86_64_v2_rust-blake3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+serde-devel-1.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+serde-devel}"
SRC_URI[x86_64_v2_rust-blake3+serde-devel.sha256sum] = "174c508c22dcdddf273300d0958dcb7d3c5feb5955ff6b7e95d303a1d36c70b9"

URI_x86_64_v2_rust-blake3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+std-devel-1.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+std-devel}"
SRC_URI[x86_64_v2_rust-blake3+std-devel.sha256sum] = "17d2dfd79c9e869d103dec3e3068da5e1ef9c61088095e86b75ede86261859f7"

URI_x86_64_v2_rust-blake3+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+zeroize-devel-1.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+zeroize-devel}"
SRC_URI[x86_64_v2_rust-blake3+zeroize-devel.sha256sum] = "c1d78043554e654ce3a016f2e958777ea5fdebc71172ca7e2b46eabd98171305"

URI_x86_64_v2_rust-blake3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3-devel-1.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3-devel}"
SRC_URI[x86_64_v2_rust-blake3-devel.sha256sum] = "5239a81e1cb425feafd5b8166497584de5a7009f181cabd163f91c3884082747"

URI_aarch64_rust-blake3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+default-devel-1.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+default-devel}"
SRC_URI[aarch64_rust-blake3+default-devel.sha256sum] = "f89dc5cbd4faac292baea52b37553065cec51681511431c10186fa211294ae2f"

URI_aarch64_rust-blake3+mmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+mmap-devel-1.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+mmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+mmap-devel}"
SRC_URI[aarch64_rust-blake3+mmap-devel.sha256sum] = "1485e1b893aa7fcbda7f20325a2d3b3af7358fae00ad5b9908ee0dc709e74633"

URI_aarch64_rust-blake3+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+neon-devel-1.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+neon-devel}"
SRC_URI[aarch64_rust-blake3+neon-devel.sha256sum] = "180d9ab76475f14a4a83498fb7ced26698b99138fe5d0d6b2099bdede10ebd01"

URI_aarch64_rust-blake3+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+rayon-devel-1.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+rayon-devel}"
SRC_URI[aarch64_rust-blake3+rayon-devel.sha256sum] = "7131b1cf236ab819b4bd601f92fd793fefa47dd75f7e7fa3d9d764434d86057c"

URI_aarch64_rust-blake3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+serde-devel-1.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+serde-devel}"
SRC_URI[aarch64_rust-blake3+serde-devel.sha256sum] = "9616b910cf8a313889c36174481ab38ef456c36c35963709b7cfd94a62106ec4"

URI_aarch64_rust-blake3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+std-devel-1.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+std-devel}"
SRC_URI[aarch64_rust-blake3+std-devel.sha256sum] = "44dd4a3492e70fbcbe7071d200ff95100ab8253caabc507a8e0c2d985eaa0e5b"

URI_aarch64_rust-blake3+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+zeroize-devel-1.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+zeroize-devel}"
SRC_URI[aarch64_rust-blake3+zeroize-devel.sha256sum] = "ae84caa1955ed9a843843f319e3f1cb6a9e81a859e9b7255c079ec7e733746ec"

URI_aarch64_rust-blake3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3-devel-1.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-blake3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3-devel}"
SRC_URI[aarch64_rust-blake3-devel.sha256sum] = "957288ab290473379badb86f1bb84e8417cc2af31209c9b654b17a5441e565e5"

RDEPENDS:rust-blake3+default-devel = " \
 cargo \
 rust-blake3+std-devel \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+mmap-devel = " \
 cargo \
 rust-blake3+std-devel \
 rust-blake3-devel \
 rust-memmap2+default-devel \
 "
RDEPENDS:rust-blake3+neon-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+rayon-devel = " \
 cargo \
 rust-blake3-devel \
 rust-rayon-core+default-devel \
 "
RDEPENDS:rust-blake3+serde-devel = " \
 cargo \
 rust-blake3-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-blake3+std-devel = " \
 cargo \
 rust-blake3-devel \
 rust-constant_time_eq+std-devel \
 "
RDEPENDS:rust-blake3+zeroize-devel = " \
 cargo \
 rust-arrayvec+zeroize-devel \
 rust-blake3-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-blake3-devel = " \
 cargo \
 python3 \
 rust-arrayref+default-devel \
 rust-arrayvec-devel \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-constant_time_eq-devel \
 rust-cpufeatures+default-devel \
 "
