# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktexttemplate"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-ktexttemplate \
 kf6-ktexttemplate-devel \
 kf6-ktexttemplate-doc \
 kf6-ktexttemplate-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ktexttemplate-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e34e22ddb83ba251a6863e91c365cf6f270714b38882b2603c39e6c7e061908c"

URI_x86_64_v2_kf6-ktexttemplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexttemplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate}"
SRC_URI[x86_64_v2_kf6-ktexttemplate.sha256sum] = "00f228818e063408268a4d370909d42949ff819022fd8ce5a5806ebdfa99fee9"

URI_x86_64_v2_kf6-ktexttemplate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexttemplate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-devel}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-devel.sha256sum] = "c71b9c18a226bd49f6de7527d81393de9308356a54d6dd146a78a948756947a3"

URI_x86_64_v2_kf6-ktexttemplate-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexttemplate-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-doc}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-doc.sha256sum] = "7698645e6871bb010845b72ce2e0472c6b9a12aac03f014158a7c96a58110496"

URI_x86_64_v2_kf6-ktexttemplate-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexttemplate-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-html}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-html.sha256sum] = "ec3ebc7d5f39226167c78c31ee546cd0219b200ef6aac4695c9d14d7e4c79422"

URI_aarch64_kf6-ktexttemplate = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktexttemplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate}"
SRC_URI[aarch64_kf6-ktexttemplate.sha256sum] = "b28e8aa4454d538ad995d5566c83bf5468de68d0adc18b5b14342777ef481703"

URI_aarch64_kf6-ktexttemplate-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktexttemplate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-devel}"
SRC_URI[aarch64_kf6-ktexttemplate-devel.sha256sum] = "cae0f13f6fbe4fc7d241c48ad104afb4ea058925884070035efc2707e19a35dd"

URI_aarch64_kf6-ktexttemplate-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktexttemplate-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-doc}"
SRC_URI[aarch64_kf6-ktexttemplate-doc.sha256sum] = "5a99994f6702a88607ce60f941fc6a1d6e2a8684e8807ce90d368249b07c1747"

URI_aarch64_kf6-ktexttemplate-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktexttemplate-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-html}"
SRC_URI[aarch64_kf6-ktexttemplate-html.sha256sum] = "8f8980d83f669c74da7ef57fcaacbb28235801a29feec9d335679fcbe938c493"

RDEPENDS:kf6-ktexttemplate = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-ktexttemplate-devel = " \
 cmake-filesystem \
 kf6-ktexttemplate \
 "
RDEPENDS:kf6-ktexttemplate-doc = " \
 "
RDEPENDS:kf6-ktexttemplate-html = " \
 "
