# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crash"
PV = "8.0.6"
PR = "1.el10.alma.1"
PACKAGES = " \
 crash \
 crash-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crash-8.0.6-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "774b41b3d29840fa7abb5fd8d8858960791dfda44b6a96762326ab53fec5e2d2"

URI_x86_64_v2_crash = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crash-8.0.6-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_crash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crash}"
SRC_URI[x86_64_v2_crash.sha256sum] = "9e1f91e44893c68a7ba9fe0d4f0b95f8d26a468a4a2782b1984d87fa429c5770"

URI_x86_64_v2_crash-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/crash-devel-8.0.6-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_crash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crash-devel}"
SRC_URI[x86_64_v2_crash-devel.sha256sum] = "11a7e97a97e13f6f8b685411a04ac48b0b50b31bfad710d6f5d870d5a55536c1"

URI_aarch64_crash = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crash-8.0.6-1.el10.alma.1.aarch64.rpm;name=aarch64_crash;unpack=0"
SRC_URI:append = " ${URI_aarch64_crash}"
SRC_URI[aarch64_crash.sha256sum] = "08cc67ccfe7ec9d084c60e0b7b6ef0461e6dee3d328b7644a91ff74505970a39"

URI_aarch64_crash-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/crash-devel-8.0.6-1.el10.alma.1.aarch64.rpm;name=aarch64_crash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_crash-devel}"
SRC_URI[aarch64_crash-devel.sha256sum] = "0ab3100b4651fc90fcd0614aa9b4750d5d687de526430be7b1e904a6a58dc6d9"

RDEPENDS:crash = " \
 binutils \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lzo \
 ncurses-libs \
 snappy \
 "
RDEPENDS:crash-devel = " \
 crash \
 zlib-ng-compat-devel \
 "
