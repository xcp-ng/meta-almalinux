# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-actix-rt"
PV = "2.15.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-actix-rt+actix-macros-devel \
 rust-actix-rt+default-devel \
 rust-actix-rt+macros-devel \
 rust-actix-rt+net-devel \
 rust-actix-rt+signal-devel \
 rust-actix-rt-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-actix-rt-2.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a6f9b08a827e55abd4c10baf49e7be57b4bb453fd8f8a9e9917fac71adf5c16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+actix-macros-devel-2.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+actix-macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt+actix-macros-devel.sha256sum] = "e4759cf4a09794fdf296009e363ac6ebf7ca43772015e503b8b81bf50e1596ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+default-devel-2.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt+default-devel.sha256sum] = "5fe24f9a5835400a6d7d7537713c69501ba6ff3a34af51080cf823822a1cbd87"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+macros-devel-2.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt+macros-devel.sha256sum] = "d47e9de75f6154e2e016f37ae941957c8e54730721b9b155a1d5cec41a70a9b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+net-devel-2.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+net-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt+net-devel.sha256sum] = "53056f66b3416b4b92be26fa382ca2c0a43510f9190a83db074f65fc751fc096"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+signal-devel-2.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+signal-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt+signal-devel.sha256sum] = "2ecb96b30a599654d6694ad597a3612c652529ff08afe549cfb6255e98d4ba20"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt-devel-2.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt-devel.sha256sum] = "acef23785456a0b656fde28e9c57c8b503d21c88084305696a7977cfef5fa39a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+actix-macros-devel-2.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-actix-rt+actix-macros-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt+actix-macros-devel.sha256sum] = "5dda674a0a167fcdfe7e7ff0bb196a4177c704c4781682c0bc439d9b03c454a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+default-devel-2.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-actix-rt+default-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt+default-devel.sha256sum] = "acf87cb690e08e2e7e802a1a0363aa2773d4c8fa7b40741eb0afa9a5a6749e3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+macros-devel-2.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-actix-rt+macros-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt+macros-devel.sha256sum] = "b47bcdc83f8a6e305ec460bc31e171c03835079e06eb06ee5256e55b1d8bc083"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+net-devel-2.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-actix-rt+net-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt+net-devel.sha256sum] = "44e3207b8cf9f9f85b0a2b6d128710fd232a4d3a6c6ef5601f4934816aa98a2c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+signal-devel-2.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-actix-rt+signal-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt+signal-devel.sha256sum] = "58d571b19fc3399ec378d5515f5a574a54041ab25b48c083b8b09c7cd843241f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt-devel-2.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-actix-rt-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt-devel.sha256sum] = "f709788792431d5f382587528fb9c27ced53fe494cb5396469e00d7d3a1b6b55"

RDEPENDS:rust-actix-rt+actix-macros-devel = " \
 cargo \
 rust-actix-macros+default-devel \
 rust-actix-rt-devel \
 "
RDEPENDS:rust-actix-rt+default-devel = " \
 cargo \
 rust-actix-rt+macros-devel \
 rust-actix-rt+net-devel \
 rust-actix-rt+signal-devel \
 rust-actix-rt-devel \
 "
RDEPENDS:rust-actix-rt+macros-devel = " \
 cargo \
 rust-actix-rt+actix-macros-devel \
 rust-actix-rt-devel \
 "
RDEPENDS:rust-actix-rt+net-devel = " \
 cargo \
 rust-actix-rt-devel \
 rust-tokio+net-devel \
 "
RDEPENDS:rust-actix-rt+signal-devel = " \
 cargo \
 rust-actix-rt-devel \
 rust-tokio+signal-devel \
 "
RDEPENDS:rust-actix-rt-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 "
