# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-databake-derive"
PV = "0.1.8"
PR = "2.el10_0"
PACKAGES = " \
 rust-databake-derive+default-devel \
 rust-databake-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-databake-derive-0.1.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e93c419d023f43eb1cfb0c7533ee63a4189f834deecd7cdd2dc17276bac0967c"

URI_x86_64_v2_rust-databake-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-derive+default-devel-0.1.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-derive+default-devel}"
SRC_URI[x86_64_v2_rust-databake-derive+default-devel.sha256sum] = "c2a816c232b335f43a044877d2d53666008f16aa108ba823266f2e9bb8908f20"

URI_x86_64_v2_rust-databake-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-derive-devel-0.1.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-derive-devel}"
SRC_URI[x86_64_v2_rust-databake-derive-devel.sha256sum] = "c10619b43b3566214b5228a6b0a868ec726f11fc75e5812915d45c49006ca6a0"

URI_aarch64_rust-databake-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-derive+default-devel-0.1.8-2.el10_0.noarch.rpm;name=aarch64_rust-databake-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-derive+default-devel}"
SRC_URI[aarch64_rust-databake-derive+default-devel.sha256sum] = "38e53e21540e6458b8b224f7f4b5154c30c4bd02783902d1d0ad5f150c445834"

URI_aarch64_rust-databake-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-derive-devel-0.1.8-2.el10_0.noarch.rpm;name=aarch64_rust-databake-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-derive-devel}"
SRC_URI[aarch64_rust-databake-derive-devel.sha256sum] = "48298ddc9f0e6830b2ec2c510e7a910631a8f4e3630ee62670ac5519da23e9b4"

RDEPENDS:rust-databake-derive+default-devel = " \
 cargo \
 rust-databake-derive-devel \
 "
RDEPENDS:rust-databake-derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-synstructure+default-devel \
 "
