# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-compact_str"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-compact_str+arbitrary-devel \
 rust-compact_str+bytes-devel \
 rust-compact_str+default-devel \
 rust-compact_str+proptest-devel \
 rust-compact_str+quickcheck-devel \
 rust-compact_str+rkyv-devel \
 rust-compact_str+serde-devel \
 rust-compact_str+smallvec-devel \
 rust-compact_str+std-devel \
 rust-compact_str+zeroize-devel \
 rust-compact_str-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-compact_str-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b29807e5a0b336e7c08474e660d719730a2a47d7625583e4600a365d5ae54f4"

URI_x86_64_v2_rust-compact_str+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+arbitrary-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-compact_str+arbitrary-devel.sha256sum] = "fe65f17a5c0bafa102418a97f23dc124e60d855de8a602145ea5865a04fc224f"

URI_x86_64_v2_rust-compact_str+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+bytes-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+bytes-devel}"
SRC_URI[x86_64_v2_rust-compact_str+bytes-devel.sha256sum] = "2b6bc2ac237934508f397200ed97b5310f57546622d00d5922890fb5eef1f2b0"

URI_x86_64_v2_rust-compact_str+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+default-devel}"
SRC_URI[x86_64_v2_rust-compact_str+default-devel.sha256sum] = "20feaa5c7e5a90a16d71d931def83eef842efd995f072184a19ef1fa660cc782"

URI_x86_64_v2_rust-compact_str+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+proptest-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+proptest-devel}"
SRC_URI[x86_64_v2_rust-compact_str+proptest-devel.sha256sum] = "af287ec9f3a896fd8420cc8cb8dd5da2b348520b4c3267f3ab9d45e05ae37aeb"

URI_x86_64_v2_rust-compact_str+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+quickcheck-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-compact_str+quickcheck-devel.sha256sum] = "624b67c658e7e6b0755542e1beb60f6b88aedbc9a9a0b6bfd2d046be8c93f926"

URI_x86_64_v2_rust-compact_str+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+rkyv-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+rkyv-devel}"
SRC_URI[x86_64_v2_rust-compact_str+rkyv-devel.sha256sum] = "d787a135acee13ef4843ed4108a6f49da886c1c0dab761dab51aff4c39464be1"

URI_x86_64_v2_rust-compact_str+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+serde-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+serde-devel}"
SRC_URI[x86_64_v2_rust-compact_str+serde-devel.sha256sum] = "5326a3dc6344b717886c6ece5d37dced0b79ec639adedf890144d5908412da9b"

URI_x86_64_v2_rust-compact_str+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+smallvec-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+smallvec-devel}"
SRC_URI[x86_64_v2_rust-compact_str+smallvec-devel.sha256sum] = "c44ef85550433d4be22892e8375dbe54a112908bac31b49794848def0af6c32f"

URI_x86_64_v2_rust-compact_str+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+std-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+std-devel}"
SRC_URI[x86_64_v2_rust-compact_str+std-devel.sha256sum] = "d00ee0fa24d851ca40ab71a00d8e5642e1e0e6f27ab764e18e0e94345e07a58b"

URI_x86_64_v2_rust-compact_str+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str+zeroize-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str+zeroize-devel}"
SRC_URI[x86_64_v2_rust-compact_str+zeroize-devel.sha256sum] = "32f56a4db56c1d6f0a5c39d502234bb3ea2881f6512fa9a1fd6ee89aa994b4f6"

URI_x86_64_v2_rust-compact_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-compact_str-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-compact_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-compact_str-devel}"
SRC_URI[x86_64_v2_rust-compact_str-devel.sha256sum] = "f0a1b5a9342da31f26cc403d208d3862704f71b580469e6088398606a132b5f7"

URI_aarch64_rust-compact_str+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+arbitrary-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+arbitrary-devel}"
SRC_URI[aarch64_rust-compact_str+arbitrary-devel.sha256sum] = "cbf7e4abc1ed7e6f1661a0b1eb2d9ba00ba19f45977d9ebdef8e5e3ed9a48377"

URI_aarch64_rust-compact_str+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+bytes-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+bytes-devel}"
SRC_URI[aarch64_rust-compact_str+bytes-devel.sha256sum] = "975bfecbed2f37b595c5024cd09876566a5c26b2833a11b0246d9c88d784edaa"

URI_aarch64_rust-compact_str+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+default-devel}"
SRC_URI[aarch64_rust-compact_str+default-devel.sha256sum] = "2e4d35aa3b4ae4e3aecd6d9f5e37a72932a53053219017e3db31c593016ed755"

URI_aarch64_rust-compact_str+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+proptest-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+proptest-devel}"
SRC_URI[aarch64_rust-compact_str+proptest-devel.sha256sum] = "f487b7591757c3287c845cb211b167a5d03a37a051d9b3ec6c0d3762c9bdad58"

URI_aarch64_rust-compact_str+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+quickcheck-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+quickcheck-devel}"
SRC_URI[aarch64_rust-compact_str+quickcheck-devel.sha256sum] = "b9e00256da87aa1156510dd0e25b4523dc7c2c59ffb70992e842d2e6cb5efb89"

URI_aarch64_rust-compact_str+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+rkyv-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+rkyv-devel}"
SRC_URI[aarch64_rust-compact_str+rkyv-devel.sha256sum] = "9c4ca4aac2b61c587b3671a2accc9b2851fc0f51633e0482876877270fda599d"

URI_aarch64_rust-compact_str+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+serde-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+serde-devel}"
SRC_URI[aarch64_rust-compact_str+serde-devel.sha256sum] = "006d6f5d10f3dcc15d3a6e481448ff5eadb9d85fc0cd9f03cd85eadf8ec9e0dd"

URI_aarch64_rust-compact_str+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+smallvec-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+smallvec-devel}"
SRC_URI[aarch64_rust-compact_str+smallvec-devel.sha256sum] = "11ded6ac682ad2f9bf709a492f9aaf4d8042afff9ba32f8b245e1dd101afad2a"

URI_aarch64_rust-compact_str+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+std-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+std-devel}"
SRC_URI[aarch64_rust-compact_str+std-devel.sha256sum] = "9ce0892fddca0bb92ef39c9483d476109117e573bae2be6349374cb884192907"

URI_aarch64_rust-compact_str+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str+zeroize-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str+zeroize-devel}"
SRC_URI[aarch64_rust-compact_str+zeroize-devel.sha256sum] = "1ee433f4e53f368829e8b2c961b973742b344a9f93a68e921a3623d9c3a38b05"

URI_aarch64_rust-compact_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-compact_str-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-compact_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-compact_str-devel}"
SRC_URI[aarch64_rust-compact_str-devel.sha256sum] = "1ca997844b7df50c63942402ff8e4cb9aceab195787fede61fa04f37c1d0b84f"

RDEPENDS:rust-compact_str+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+default-devel = " \
 cargo \
 rust-compact_str+std-devel \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+proptest-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-compact_str+quickcheck-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-compact_str+rkyv-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-compact_str+serde-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-compact_str+smallvec-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
RDEPENDS:rust-compact_str+std-devel = " \
 cargo \
 rust-compact_str-devel \
 "
RDEPENDS:rust-compact_str+zeroize-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-compact_str-devel = " \
 cargo \
 rust-castaway+alloc-devel \
 rust-castaway-devel \
 rust-cfg-if+default-devel \
 rust-itoa+default-devel \
 rust-rustversion+default-devel \
 rust-ryu+default-devel \
 rust-static_assertions+default-devel \
 "
