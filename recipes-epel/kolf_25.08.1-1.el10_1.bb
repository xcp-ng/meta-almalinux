# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kolf"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kolf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kolf-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35749032de2a8d512742239fe3eb5b75bdf4d4a812dacf4f5e9bea0548b467c4"

URI_x86_64_v2_kolf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolf-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolf}"
SRC_URI[x86_64_v2_kolf.sha256sum] = "b471b1bab7ae537a2db3c5674061f79c22af66d53e3187439c5587d7b23ce78b"

URI_aarch64_kolf = "${EPEL_MIRROR}/aarch64/Packages/k/kolf-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kolf;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolf}"
SRC_URI[aarch64_kolf.sha256sum] = "728f34bb28751deaa1fcf41f03ff2082d6914199eec1b7d29e25e5fc01dedcfc"

RDEPENDS:kolf = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
