# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-once_cell"
PV = "1.21.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-once_cell+alloc-devel \
 rust-once_cell+atomic-polyfill-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell+default-devel \
 rust-once_cell+parking_lot-devel \
 rust-once_cell+portable-atomic-devel \
 rust-once_cell+race-devel \
 rust-once_cell+std-devel \
 rust-once_cell+unstable-devel \
 rust-once_cell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-once_cell-1.21.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c717f00be7328295092a48694416f2b6dc1625d73f8b4a77df59494c8c858a6e"

URI_x86_64_v2_rust-once_cell+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+alloc-devel-1.21.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+alloc-devel}"
SRC_URI[x86_64_v2_rust-once_cell+alloc-devel.sha256sum] = "ac6e0c2e7cd57483c521418e1c35dff23ccdb80b3a8957823f1b5066b038b563"

URI_x86_64_v2_rust-once_cell+atomic-polyfill-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+atomic-polyfill-devel-1.21.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+atomic-polyfill-devel}"
SRC_URI[x86_64_v2_rust-once_cell+atomic-polyfill-devel.sha256sum] = "0a615ad72ab9e3284935d557851c5ca53c683d405fc06c6f511256d708e52911"

URI_x86_64_v2_rust-once_cell+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+critical-section-devel-1.21.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+critical-section-devel}"
SRC_URI[x86_64_v2_rust-once_cell+critical-section-devel.sha256sum] = "978a6f02b95cfeeb30c7d07c30d925bf8d7e50d562b64fbbb2c67fb087cd1cab"

URI_x86_64_v2_rust-once_cell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+default-devel-1.21.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+default-devel}"
SRC_URI[x86_64_v2_rust-once_cell+default-devel.sha256sum] = "fd7ee172c5f42018d0d499f19a05f554f7caed7fe80d35fa2c20dce681059f7e"

URI_x86_64_v2_rust-once_cell+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+parking_lot-devel-1.21.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-once_cell+parking_lot-devel.sha256sum] = "14939bb6959f3a4e6f14e3138a2da704fc5c3a95c447483af3dd57b0d36743b0"

URI_x86_64_v2_rust-once_cell+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+portable-atomic-devel-1.21.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-once_cell+portable-atomic-devel.sha256sum] = "99fe7562294b90108f2d0c51c86a9dd078d6df49b7c9689b1ded93585ad0a5ad"

URI_x86_64_v2_rust-once_cell+race-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+race-devel-1.21.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+race-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+race-devel}"
SRC_URI[x86_64_v2_rust-once_cell+race-devel.sha256sum] = "4260e05f3a6cfa4bd38b3d0eaabb218ecdde7e3c5fa281cfe5a1fe6480a67864"

URI_x86_64_v2_rust-once_cell+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+std-devel-1.21.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+std-devel}"
SRC_URI[x86_64_v2_rust-once_cell+std-devel.sha256sum] = "39cf6f09ba9d4a767b78dad099a029bd6db44283849967131db79dfda9d24690"

URI_x86_64_v2_rust-once_cell+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+unstable-devel-1.21.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+unstable-devel}"
SRC_URI[x86_64_v2_rust-once_cell+unstable-devel.sha256sum] = "5c3012c4540e56d6457811d53be0228742262ef783d08f013420571c9274a611"

URI_x86_64_v2_rust-once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell-devel-1.21.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell-devel}"
SRC_URI[x86_64_v2_rust-once_cell-devel.sha256sum] = "a27d97a3723662fbd3e32f1fb8f2df0b3409f85857f39fad3ad24f65ea1ff981"

URI_aarch64_rust-once_cell+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+alloc-devel-1.21.4-1.el10_3.noarch.rpm;name=aarch64_rust-once_cell+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+alloc-devel}"
SRC_URI[aarch64_rust-once_cell+alloc-devel.sha256sum] = "9629bd46b06b071100c747c7fccd0dffbfa9603a778671c90f36e3169cab0db1"

URI_aarch64_rust-once_cell+atomic-polyfill-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+atomic-polyfill-devel-1.21.4-1.el10_3.noarch.rpm;name=aarch64_rust-once_cell+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+atomic-polyfill-devel}"
SRC_URI[aarch64_rust-once_cell+atomic-polyfill-devel.sha256sum] = "c5661ca54a2d230280a221cbdb63a4703b3da1e6dea04c1b534554fb525673eb"

URI_aarch64_rust-once_cell+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+critical-section-devel-1.21.4-1.el10_3.noarch.rpm;name=aarch64_rust-once_cell+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+critical-section-devel}"
SRC_URI[aarch64_rust-once_cell+critical-section-devel.sha256sum] = "20adf60e203cdf9f7af850d11f0eea39fff0d6a58f9faf11e4d186c314e978fa"

URI_aarch64_rust-once_cell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+default-devel-1.21.4-1.el10_3.noarch.rpm;name=aarch64_rust-once_cell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+default-devel}"
SRC_URI[aarch64_rust-once_cell+default-devel.sha256sum] = "bd5d9ffcaa856b9f8c9c8978d960564dd570c9002234af41679cd72b56bc2af7"

URI_aarch64_rust-once_cell+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+parking_lot-devel-1.21.4-1.el10_3.noarch.rpm;name=aarch64_rust-once_cell+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+parking_lot-devel}"
SRC_URI[aarch64_rust-once_cell+parking_lot-devel.sha256sum] = "5507687a281781a2a11cc322ba3950fec2bce8d042f907925c872d169771aa65"

URI_aarch64_rust-once_cell+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+portable-atomic-devel-1.21.4-1.el10_3.noarch.rpm;name=aarch64_rust-once_cell+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+portable-atomic-devel}"
SRC_URI[aarch64_rust-once_cell+portable-atomic-devel.sha256sum] = "358c812973066e1d236a73192208cf57af3531f4b518f1a7156dac17b051106c"

URI_aarch64_rust-once_cell+race-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+race-devel-1.21.4-1.el10_3.noarch.rpm;name=aarch64_rust-once_cell+race-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+race-devel}"
SRC_URI[aarch64_rust-once_cell+race-devel.sha256sum] = "ddf939c4c8d98621a266bddec3fd71f9f18051511f80b4cdef29772bd837d963"

URI_aarch64_rust-once_cell+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+std-devel-1.21.4-1.el10_3.noarch.rpm;name=aarch64_rust-once_cell+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+std-devel}"
SRC_URI[aarch64_rust-once_cell+std-devel.sha256sum] = "aa85e82e7c7893f21210e474131bb39c061a74a55f5ac7f15120331db062c783"

URI_aarch64_rust-once_cell+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+unstable-devel-1.21.4-1.el10_3.noarch.rpm;name=aarch64_rust-once_cell+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+unstable-devel}"
SRC_URI[aarch64_rust-once_cell+unstable-devel.sha256sum] = "856b3a19981192885906a6baf1769ba203cbf91ed5cee6a7105950f8855805de"

URI_aarch64_rust-once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell-devel-1.21.4-1.el10_3.noarch.rpm;name=aarch64_rust-once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell-devel}"
SRC_URI[aarch64_rust-once_cell-devel.sha256sum] = "bf13d0f6fb3a0dbd0948c3cb10b67846eea706b855ac9bbfb803d1b2a4c1fecc"

RDEPENDS:rust-once_cell+alloc-devel = " \
 cargo \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+atomic-polyfill-devel = " \
 cargo \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+critical-section-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-once_cell+portable-atomic-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+default-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+parking_lot-devel = " \
 cargo \
 rust-once_cell-devel \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-once_cell+portable-atomic-devel = " \
 cargo \
 rust-once_cell-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-once_cell+race-devel = " \
 cargo \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+std-devel = " \
 cargo \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+unstable-devel = " \
 cargo \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell-devel = " \
 cargo \
 rust \
 "
