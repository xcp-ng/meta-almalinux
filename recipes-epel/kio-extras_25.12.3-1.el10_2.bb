# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-extras"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kio-extras \
 kio-extras-devel \
 kio-extras-info \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-extras-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0aee1c98b4919c0cffd2e86f41b106fa907dafca3ec8c459a8e2883411928d0"

URI_x86_64_v2_kio-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-extras}"
SRC_URI[x86_64_v2_kio-extras.sha256sum] = "9dda0bea82fe706ba30335ddcfe8fd62e582a1fc3147b38ad5635f182d3aa1fe"

URI_x86_64_v2_kio-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-extras-devel}"
SRC_URI[x86_64_v2_kio-extras-devel.sha256sum] = "1dfe02cb31ea59e998b34ce788941762182a3a73f338c717c9d7f32a3ef22837"

URI_x86_64_v2_kio-extras-info = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-info-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras-info;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-extras-info}"
SRC_URI[x86_64_v2_kio-extras-info.sha256sum] = "feb8885550b41f97d255fb763149650bf8493c080fcf69bcecbf488f6cbfa419"

URI_aarch64_kio-extras = "${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kio-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-extras}"
SRC_URI[aarch64_kio-extras.sha256sum] = "98b780b90119be9ff58dd56e218c3771a441294f8830d4bcf629015deda29cb8"

URI_aarch64_kio-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kio-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-extras-devel}"
SRC_URI[aarch64_kio-extras-devel.sha256sum] = "ba4e703abec15ba096c53ad0665182c7fd181bbd7e78da54dc8554deb4b31b32"

URI_aarch64_kio-extras-info = "${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-info-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kio-extras-info;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-extras-info}"
SRC_URI[aarch64_kio-extras-info.sha256sum] = "9e7dac09036c5996354151ec159db1cc3870a3dea1e259fd88ec14548f5ac76f"

RDEPENDS:kio-extras = " \
 bash \
 glibc \
 kdsoap-ws-discovery-client \
 kdsoap6 \
 kf6-karchive \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-solid \
 kf6-syntax-highlighting \
 libXcursor \
 libgcc \
 libimobiledevice \
 libkexiv2-qt6 \
 libmtp \
 libplist \
 libproxy \
 libsmbclient \
 libssh \
 libstdc++ \
 libtirpc \
 openexr-libs \
 plasma-activities \
 plasma-activities-stats \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 taglib \
 "
RDEPENDS:kio-extras-devel = " \
 cmake-filesystem \
 kio-extras \
 "
RDEPENDS:kio-extras-info = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 "
