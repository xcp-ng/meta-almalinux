# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Builder-Compiler"
PV = "0.037"
PR = "1.el10_3"
PACKAGES = " \
 perl-ExtUtils-Builder-Compiler \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-Builder-Compiler-0.037-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9dbb6ca72c6841148ca59dea880f147f49db95efe829e74444950f77df72f354"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-Builder-Compiler-0.037-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Builder-Compiler;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Builder-Compiler.sha256sum] = "02630a0f4a1d1361bf516aa452fc805079aa508d4bb2b6895eaa6525109a8799"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-Builder-Compiler-0.037-1.el10_3.noarch.rpm;name=aarch64_perl-ExtUtils-Builder-Compiler;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Builder-Compiler.sha256sum] = "be65226a418f5ead1082c5891e02579ec066a7cbbf8cf44c064d154e18c97cc5"

RDEPENDS:perl-ExtUtils-Builder-Compiler = " \
 perl-Carp \
 perl-DynaLoader \
 perl-ExtUtils-Builder \
 perl-ExtUtils-Builder-Compiler \
 perl-ExtUtils-Config \
 perl-File-Basename \
 perl-File-Temp \
 perl-PathTools \
 perl-Perl-OSType \
 perl-libs \
 perl-parent \
 perl-sort \
 "
