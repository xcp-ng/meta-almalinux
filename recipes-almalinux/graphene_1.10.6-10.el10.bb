# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "graphene"
PV = "1.10.6"
PR = "10.el10"
PACKAGES = " \
 graphene \
 graphene-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/graphene-1.10.6-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0406f469ef8d83e6b9c2d53cc694e9039c9f6d0f23b93ae14a071ea93ac9b3b"

URI_x86_64_v2_graphene = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphene-1.10.6-10.el10.x86_64_v2.rpm;name=x86_64_v2_graphene;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphene}"
SRC_URI[x86_64_v2_graphene.sha256sum] = "ead551cacc2bb6e608691f4a81489d1beb1f6423d683859467618ed7be034041"

URI_x86_64_v2_graphene-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/graphene-devel-1.10.6-10.el10.x86_64_v2.rpm;name=x86_64_v2_graphene-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_graphene-devel}"
SRC_URI[x86_64_v2_graphene-devel.sha256sum] = "2f1c8656313546ed05604bcd35fccc5666ac4eb35fa531ea241a0adaf2fa9dea"

URI_aarch64_graphene = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/graphene-1.10.6-10.el10.aarch64.rpm;name=aarch64_graphene;unpack=0"
SRC_URI:append = " ${URI_aarch64_graphene}"
SRC_URI[aarch64_graphene.sha256sum] = "9f98e94e416bc7377e2e23ad09c1cd8693d00607c836f55e97fb8c51f9fe0501"

URI_aarch64_graphene-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/graphene-devel-1.10.6-10.el10.aarch64.rpm;name=aarch64_graphene-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_graphene-devel}"
SRC_URI[aarch64_graphene-devel.sha256sum] = "c5c7a2781b13ccfc7ac2381804cedf1b3fad1d3e0eed5852affd8748e08e2963"

RDEPENDS:graphene = " \
 glib2 \
 glibc \
 "
RDEPENDS:graphene-devel = " \
 glib2-devel \
 graphene \
 graphene-devel \
 pkgconf-pkg-config \
 "
