# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snap"
PV = "1.1.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-snap+default-devel \
 rust-snap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snap-1.1.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f6f66bb65b1cef8e9c561e998dcea1acdc4387a79e7f895e3e5715087ca2196"

URI_x86_64_v2_rust-snap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snap+default-devel-1.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snap+default-devel}"
SRC_URI[x86_64_v2_rust-snap+default-devel.sha256sum] = "4d33bde85f81e73c8977e1c62a19f959af99f1b3bb5b24a03dfccdfb2f6edc7e"

URI_x86_64_v2_rust-snap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snap-devel-1.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snap-devel}"
SRC_URI[x86_64_v2_rust-snap-devel.sha256sum] = "d72bc3522eb94df7254ffaf410e9c7f6074484969707aba3516daaf7c235c79e"

URI_aarch64_rust-snap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snap+default-devel-1.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-snap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snap+default-devel}"
SRC_URI[aarch64_rust-snap+default-devel.sha256sum] = "ee88333b31dd0281108c9f7fb7267c43856e86db868b892f4a3ad3f0b201e264"

URI_aarch64_rust-snap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snap-devel-1.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-snap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snap-devel}"
SRC_URI[aarch64_rust-snap-devel.sha256sum] = "adb1f1cac794b238ccd4848b2ade5c79a94f0a049257ccb8a75f1de841d1d271"

RDEPENDS:rust-snap+default-devel = " \
 cargo \
 rust-snap-devel \
 "
RDEPENDS:rust-snap-devel = " \
 cargo \
 "
