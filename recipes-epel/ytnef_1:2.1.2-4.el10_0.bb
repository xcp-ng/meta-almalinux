# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ytnef"
PE = "1"
PV = "2.1.2"
PR = "4.el10_0"
PACKAGES = " \
 libytnef \
 libytnef-devel \
 ytnef \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/ytnef-2.1.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01516abb8616629f697d058370cad3fa38c3612dd56d82a35200a6ae920e047e"

URI_x86_64_v2_libytnef = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libytnef-2.1.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libytnef;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libytnef}"
SRC_URI[x86_64_v2_libytnef.sha256sum] = "1a60daae28120889caa9bf1ff278485c1ada10aaa5f676a57e218b8e6f916e4d"

URI_x86_64_v2_libytnef-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libytnef-devel-2.1.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libytnef-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libytnef-devel}"
SRC_URI[x86_64_v2_libytnef-devel.sha256sum] = "509e00972ecacfe1d46e50dd5f1e25b8de3f8f64e3d923735074e47f82f61b0e"

URI_x86_64_v2_ytnef = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ytnef-2.1.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ytnef;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ytnef}"
SRC_URI[x86_64_v2_ytnef.sha256sum] = "3daa6858667dacec9a9ae73c2cdb44e3aa46463a41380670e4c39d2f096a3c7b"

URI_aarch64_libytnef = "${EPEL_MIRROR}/aarch64/Packages/l/libytnef-2.1.2-4.el10_0.aarch64.rpm;name=aarch64_libytnef;unpack=0"
SRC_URI:append = " ${URI_aarch64_libytnef}"
SRC_URI[aarch64_libytnef.sha256sum] = "b401655e4d707ea07db8543d0e565c39b8612a0132892abe604319509fd5c409"

URI_aarch64_libytnef-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libytnef-devel-2.1.2-4.el10_0.aarch64.rpm;name=aarch64_libytnef-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libytnef-devel}"
SRC_URI[aarch64_libytnef-devel.sha256sum] = "3025c51954e6b4cab943e88bfff339611d121eb7fa6f5459fcbff829fff3cfe1"

URI_aarch64_ytnef = "${EPEL_MIRROR}/aarch64/Packages/y/ytnef-2.1.2-4.el10_0.aarch64.rpm;name=aarch64_ytnef;unpack=0"
SRC_URI:append = " ${URI_aarch64_ytnef}"
SRC_URI[aarch64_ytnef.sha256sum] = "fc9edd5bccc493eb3e2fb05b93e81cd9ade3a9dcb6e33d32990f8465031f8277"

RDEPENDS:libytnef = " \
 glibc \
 "
RDEPENDS:libytnef-devel = " \
 libytnef \
 pkgconf-pkg-config \
 "
RDEPENDS:ytnef = " \
 glibc \
 libytnef \
 perl-Data-Dumper \
 perl-File-Path \
 perl-MIME-tools \
 perl-MailTools \
 perl-interpreter \
 perl-libs \
 "
