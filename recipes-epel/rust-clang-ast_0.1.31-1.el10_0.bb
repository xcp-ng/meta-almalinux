# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clang-ast"
PV = "0.1.31"
PR = "1.el10_0"
PACKAGES = " \
 rust-clang-ast+default-devel \
 rust-clang-ast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clang-ast-0.1.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f3d51acda14900e7166a17f4d6ce5e288554c1762d3d2cbac7918c1f804acd2"

URI_x86_64_v2_rust-clang-ast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-ast+default-devel-0.1.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-ast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-ast+default-devel}"
SRC_URI[x86_64_v2_rust-clang-ast+default-devel.sha256sum] = "9d00c65ba859efd1d4653c192958c1bf97a02a11a9eb55be73a4bf1768bba968"

URI_x86_64_v2_rust-clang-ast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-ast-devel-0.1.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-ast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clang-ast-devel}"
SRC_URI[x86_64_v2_rust-clang-ast-devel.sha256sum] = "6a232ade7b38e5c24468d18d021a606cacb0f6e0474bb3849cbca93f5b7078ee"

URI_aarch64_rust-clang-ast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-ast+default-devel-0.1.31-1.el10_0.noarch.rpm;name=aarch64_rust-clang-ast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-ast+default-devel}"
SRC_URI[aarch64_rust-clang-ast+default-devel.sha256sum] = "e0139515cc74313e58b0def2a4c3e9cb99193c1f514c1e67b7319e8fb31d71d2"

URI_aarch64_rust-clang-ast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-ast-devel-0.1.31-1.el10_0.noarch.rpm;name=aarch64_rust-clang-ast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clang-ast-devel}"
SRC_URI[aarch64_rust-clang-ast-devel.sha256sum] = "fe507deb74ddcf7232583067fe753d58dc184da95d6b874c130c98b06199f026"

RDEPENDS:rust-clang-ast+default-devel = " \
 cargo \
 rust-clang-ast-devel \
 "
RDEPENDS:rust-clang-ast-devel = " \
 cargo \
 rust-foldhash+default-devel \
 rust-serde+default-devel \
 "
