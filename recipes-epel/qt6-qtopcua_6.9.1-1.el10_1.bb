# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtopcua"
PV = "6.9.1"
PR = "1.el10_1"
PACKAGES = " \
 qt6-qtopcua \
 qt6-qtopcua-devel \
 qt6-qtopcua-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtopcua-6.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eeea250bf49b7b5216b569ee203fc7c6168a66e357dabb2308560c7802ea165e"

URI_x86_64_v2_qt6-qtopcua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtopcua-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtopcua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtopcua}"
SRC_URI[x86_64_v2_qt6-qtopcua.sha256sum] = "bcb968346af74f2b6fc78be9e95f413ffd4afb8ed8f2d9f8028104d0f1a3e71e"

URI_x86_64_v2_qt6-qtopcua-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtopcua-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtopcua-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtopcua-devel}"
SRC_URI[x86_64_v2_qt6-qtopcua-devel.sha256sum] = "28085d2c7943d4c9f6eaaa5081b238a1e843c7aaf1809f131944d82daef0474a"

URI_x86_64_v2_qt6-qtopcua-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtopcua-examples-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtopcua-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtopcua-examples}"
SRC_URI[x86_64_v2_qt6-qtopcua-examples.sha256sum] = "8645e53a51668f2dd1a6c499e094f4de31998a087168ccf1f13733a5b15e751f"

URI_aarch64_qt6-qtopcua = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtopcua-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtopcua;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtopcua}"
SRC_URI[aarch64_qt6-qtopcua.sha256sum] = "02ebd5b1e4be5673a18c486ef1f41c71473aba93c850e8d33b586a16d47a9ed1"

URI_aarch64_qt6-qtopcua-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtopcua-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtopcua-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtopcua-devel}"
SRC_URI[aarch64_qt6-qtopcua-devel.sha256sum] = "27dba4e45ea7ecef131de7257472cbe8ce47fa4814183509f6fa15a388c3f120"

URI_aarch64_qt6-qtopcua-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtopcua-examples-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtopcua-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtopcua-examples}"
SRC_URI[aarch64_qt6-qtopcua-examples.sha256sum] = "00f2cbe78f0558478e936aa67c4f8213ac0de8d297f6c09e9abaa13dbe5e3366"

RDEPENDS:qt6-qtopcua = " \
 glibc \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtopcua-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtopcua \
 qt6-qtopcua-devel \
 "
RDEPENDS:qt6-qtopcua-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtopcua \
 qt6-qtopcua-devel \
 "
