# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmd"
PV = "1.1.0"
PR = "5.el10_0"
PACKAGES = " \
 libmd \
 libmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmd-1.1.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91ae922fb45f30836587da2195ab696f7dc285097fa9d3405f8acef0356f5e74"

URI_x86_64_v2_libmd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmd-1.1.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmd}"
SRC_URI[x86_64_v2_libmd.sha256sum] = "ce1cd1fa571a94b0181d3002a828feb6438d67aba2afe449aec59deb45f27193"

URI_x86_64_v2_libmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmd-devel-1.1.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmd-devel}"
SRC_URI[x86_64_v2_libmd-devel.sha256sum] = "d4b5963839744909afb6bd2a86bf0b2043040c6b8ba338537f7c486e54fa368b"

URI_aarch64_libmd = "${EPEL_MIRROR}/aarch64/Packages/l/libmd-1.1.0-5.el10_0.aarch64.rpm;name=aarch64_libmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmd}"
SRC_URI[aarch64_libmd.sha256sum] = "9b484c128b280ef2521983e9c58c91c4413a3f64d8b92247a5555fe19a95bbbe"

URI_aarch64_libmd-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmd-devel-1.1.0-5.el10_0.aarch64.rpm;name=aarch64_libmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmd-devel}"
SRC_URI[aarch64_libmd-devel.sha256sum] = "f9057295fdc4c89c66652657bba8e9375446d6db8def78b2d082767f1f01cea8"

RDEPENDS:libmd = " \
 glibc \
 "
RDEPENDS:libmd-devel = " \
 libmd \
 pkgconf-pkg-config \
 "
