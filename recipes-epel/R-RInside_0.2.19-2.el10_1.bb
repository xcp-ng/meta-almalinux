# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-RInside"
PV = "0.2.19"
PR = "2.el10_1"
PACKAGES = " \
 R-RInside \
 R-RInside-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-RInside-0.2.19-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2024190a11972b58d9980eeea7d91ba33126a425d47556ed65af010ab6765545"

URI_x86_64_v2_R-RInside = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-RInside-0.2.19-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-RInside;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-RInside}"
SRC_URI[x86_64_v2_R-RInside.sha256sum] = "9cd96226c6a398e81a57c025c9e11584d2aba3636061d29b988e76f8956c5650"

URI_x86_64_v2_R-RInside-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-RInside-examples-0.2.19-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-RInside-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-RInside-examples}"
SRC_URI[x86_64_v2_R-RInside-examples.sha256sum] = "6ba39a0631e9a58e3b82e45f008b7f4e5a0dba0b424c9a064e81e85fb88718b0"

URI_aarch64_R-RInside = "${EPEL_MIRROR}/aarch64/Packages/r/R-RInside-0.2.19-2.el10_1.aarch64.rpm;name=aarch64_R-RInside;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-RInside}"
SRC_URI[aarch64_R-RInside.sha256sum] = "4850ea2e8bca5c66e01cec233e00b9b600e86a10dd74979134ae1fcdb9d6e39e"

URI_aarch64_R-RInside-examples = "${EPEL_MIRROR}/aarch64/Packages/r/R-RInside-examples-0.2.19-2.el10_1.aarch64.rpm;name=aarch64_R-RInside-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-RInside-examples}"
SRC_URI[aarch64_R-RInside-examples.sha256sum] = "7ebb42521c71383a69f4aa4d2b6ea5478011991dbbb15fcfb4885be28543bf1d"

RDEPENDS:R-RInside = " \
 R-Rcpp \
 R-core \
 R-core-devel \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:R-RInside-examples = " \
 R-RInside \
 "
