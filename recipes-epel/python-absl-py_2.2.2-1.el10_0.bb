# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-absl-py"
PV = "2.2.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-absl-py \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-absl-py-2.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72bf00b861a963773d184a5d5db38d7edd3796d62654c92cb1289917f0100081"

URI_x86_64_v2_python3-absl-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-absl-py-2.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-absl-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-absl-py}"
SRC_URI[x86_64_v2_python3-absl-py.sha256sum] = "4bb63440993f9c5618cffaa2f48ecd3b0e3aa80b849f6572c193500d331ea542"

URI_aarch64_python3-absl-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-absl-py-2.2.2-1.el10_0.noarch.rpm;name=aarch64_python3-absl-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-absl-py}"
SRC_URI[aarch64_python3-absl-py.sha256sum] = "e2d05c8c39f1a0e37e0db2ccb9ab86103c77fe7c0f13245eb2aa03d1755f4612"

RDEPENDS:python3-absl-py = " \
 python3 \
 "
