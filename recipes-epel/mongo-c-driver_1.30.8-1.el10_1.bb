# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mongo-c-driver"
PV = "1.30.8"
PR = "1.el10_1"
PACKAGES = " \
 libbson \
 libbson-devel \
 mongo-c-driver \
 mongo-c-driver-devel \
 mongo-c-driver-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mongo-c-driver-1.30.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af44e98dde393a899f9f44d814286f41a9c6a623f2e74b13b1f16e453b9bee30"

URI_x86_64_v2_libbson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbson-1.30.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbson}"
SRC_URI[x86_64_v2_libbson.sha256sum] = "ad00d502f6e8768cd4ddc3a138f4d01cf66d84ba7757cd9ea5d05b778a1fe9b2"

URI_x86_64_v2_libbson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbson-devel-1.30.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbson-devel}"
SRC_URI[x86_64_v2_libbson-devel.sha256sum] = "dd95868bbf3231f883bbbcff4ce0cf09baf2c9d71d7f1123d8c3fc0afc144c0e"

URI_x86_64_v2_mongo-c-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-1.30.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mongo-c-driver}"
SRC_URI[x86_64_v2_mongo-c-driver.sha256sum] = "01b1c1812a59c3dd4bb03762eab73f450a26be641540ffb2783175a93c402b6c"

URI_x86_64_v2_mongo-c-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-devel-1.30.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mongo-c-driver-devel}"
SRC_URI[x86_64_v2_mongo-c-driver-devel.sha256sum] = "5947228e0495a310a912d2a17ff51d5c694ae7209fea541f4711f7319b71312c"

URI_x86_64_v2_mongo-c-driver-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-libs-1.30.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mongo-c-driver-libs}"
SRC_URI[x86_64_v2_mongo-c-driver-libs.sha256sum] = "b01e5e0214dcec2fab032d9a8fd73af73fcb144f95053f4663a195938a601e46"

URI_aarch64_libbson = "${EPEL_MIRROR}/aarch64/Packages/l/libbson-1.30.8-1.el10_1.aarch64.rpm;name=aarch64_libbson;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbson}"
SRC_URI[aarch64_libbson.sha256sum] = "8c1d52bfecfc6ff52c2cb85024c3f6e79108b6a43fa6ad276a1699ce5a5d879b"

URI_aarch64_libbson-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libbson-devel-1.30.8-1.el10_1.aarch64.rpm;name=aarch64_libbson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbson-devel}"
SRC_URI[aarch64_libbson-devel.sha256sum] = "72d72d01d49910dbab1a644572f3ecf3574e1e9a12118ecb01337b4b0bd905b7"

URI_aarch64_mongo-c-driver = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-1.30.8-1.el10_1.aarch64.rpm;name=aarch64_mongo-c-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver}"
SRC_URI[aarch64_mongo-c-driver.sha256sum] = "8b6c0f69b7caf511b9461f4fc67fe1d7ccaa12bea4471a076811ece7461f5df3"

URI_aarch64_mongo-c-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-devel-1.30.8-1.el10_1.aarch64.rpm;name=aarch64_mongo-c-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver-devel}"
SRC_URI[aarch64_mongo-c-driver-devel.sha256sum] = "ece4243a1a1aa892a2dbe73183c07eb9b8f0d0509e2a9e510006bbfb90adf324"

URI_aarch64_mongo-c-driver-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-libs-1.30.8-1.el10_1.aarch64.rpm;name=aarch64_mongo-c-driver-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver-libs}"
SRC_URI[aarch64_mongo-c-driver-libs.sha256sum] = "03fd4d5564d5870302c6ca3a5dc6cb0424338d9d5293d2d581975522ff0530f2"

RDEPENDS:libbson = " \
 glibc \
 "
RDEPENDS:libbson-devel = " \
 cmake-filesystem \
 libbson \
 pkgconf-pkg-config \
 "
RDEPENDS:mongo-c-driver = " \
 glibc \
 mongo-c-driver-libs \
 "
RDEPENDS:mongo-c-driver-devel = " \
 cmake-filesystem \
 libbson-devel \
 libmongocrypt-devel \
 libzstd-devel \
 mongo-c-driver \
 mongo-c-driver-devel \
 mongo-c-driver-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:mongo-c-driver-libs = " \
 cyrus-sasl-lib \
 glibc \
 libbson \
 libmongocrypt \
 libzstd \
 openssl-libs \
 snappy \
 utf8proc \
 zlib-ng-compat \
 "
