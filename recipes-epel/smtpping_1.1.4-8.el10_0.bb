# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smtpping"
PV = "1.1.4"
PR = "8.el10_0"
PACKAGES = " \
 smtpping \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/smtpping-1.1.4-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c120605c49ff336889ab91d4a71a517865aff5cb90c42db454f723e0b66210d6"

URI_x86_64_v2_smtpping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/smtpping-1.1.4-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_smtpping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_smtpping}"
SRC_URI[x86_64_v2_smtpping.sha256sum] = "5d72c4affdf56efeb40c8454c0efbd48ad3378fc565a9ce25daae1c986a22f6f"

URI_aarch64_smtpping = "${EPEL_MIRROR}/aarch64/Packages/s/smtpping-1.1.4-8.el10_0.aarch64.rpm;name=aarch64_smtpping;unpack=0"
SRC_URI:append = " ${URI_aarch64_smtpping}"
SRC_URI[aarch64_smtpping.sha256sum] = "e49da0fdfa22970c0ffa76b85abd557fe079d8fb449bf95cd87bf486b480ede6"

RDEPENDS:smtpping = " \
 glibc \
 libgcc \
 libstdc++ \
 "
