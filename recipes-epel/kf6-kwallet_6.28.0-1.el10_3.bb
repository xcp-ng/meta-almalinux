# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwallet"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kwallet \
 kf6-kwallet-devel \
 kf6-kwallet-doc \
 kf6-kwallet-html \
 kf6-kwallet-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwallet-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cdcf34be9fe2a3f7f10045109a85a9edc3adde67cb16b599a6a1de3dc1cee6b"

URI_x86_64_v2_kf6-kwallet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet}"
SRC_URI[x86_64_v2_kf6-kwallet.sha256sum] = "1d08f3b962ee21f8e38882749c81a4b59d0a4915029d4a68d0425504c7455412"

URI_x86_64_v2_kf6-kwallet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-devel}"
SRC_URI[x86_64_v2_kf6-kwallet-devel.sha256sum] = "8e52d15e89776b15d49b00b640e024424325d77e3a24d31c044973214cdb4b75"

URI_x86_64_v2_kf6-kwallet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwallet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-doc}"
SRC_URI[x86_64_v2_kf6-kwallet-doc.sha256sum] = "dce305c0d7f14685d4c6ae0f6a7cd95970c1896d31618f773f95e42ab00ef706"

URI_x86_64_v2_kf6-kwallet-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwallet-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-html}"
SRC_URI[x86_64_v2_kf6-kwallet-html.sha256sum] = "e46d9b5d8e2087deeb50d3c32d67f5f3a5a575fd79a0b159a69af3946c562a42"

URI_x86_64_v2_kf6-kwallet-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-libs-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-libs}"
SRC_URI[x86_64_v2_kf6-kwallet-libs.sha256sum] = "1c2a2218d3b064cc10b76b9a048297ec77afeb0baf3b84d9d0d50fe8a95881e6"

URI_aarch64_kf6-kwallet = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwallet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet}"
SRC_URI[aarch64_kf6-kwallet.sha256sum] = "6b8765d0213ec6a139984b3c9c7c383fb360f8cabae92825a182b8f8f24c45b7"

URI_aarch64_kf6-kwallet-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwallet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-devel}"
SRC_URI[aarch64_kf6-kwallet-devel.sha256sum] = "34e37bffa53b2db3a02d51e34f780686844f73e664cd6bd0fc3a9226c36aeac8"

URI_aarch64_kf6-kwallet-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwallet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-doc}"
SRC_URI[aarch64_kf6-kwallet-doc.sha256sum] = "0bee1f51f81a3a830233dd1e2c9448825dafc2d10fb9b8c16362d8862708d25d"

URI_aarch64_kf6-kwallet-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwallet-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-html}"
SRC_URI[aarch64_kf6-kwallet-html.sha256sum] = "9a85ac9a7ef607f2d752e911b158f99529b00bef61f464f19ba2726077b726c9"

URI_aarch64_kf6-kwallet-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-libs-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwallet-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-libs}"
SRC_URI[aarch64_kf6-kwallet-libs.sha256sum] = "084a3c11f00162015f3e046b1eaba47eb9dd40f11ac2bfbc1aa995713510ba54"

RDEPENDS:kf6-kwallet = " \
 glib2 \
 glibc \
 gpgme2pp \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libgcc \
 libsecret \
 libstdc++ \
 pinentry-gnome3 \
 qca-qt6 \
 qca-qt6-ossl \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwallet-devel = " \
 cmake-filesystem \
 kf6-kwallet-libs \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kwallet-doc = " \
 "
RDEPENDS:kf6-kwallet-html = " \
 "
RDEPENDS:kf6-kwallet-libs = " \
 glibc \
 gpgme2pp \
 kf6-kconfig \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwallet \
 kf6-kwidgetsaddons \
 libgcrypt \
 libstdc++ \
 qt6-qtbase \
 "
