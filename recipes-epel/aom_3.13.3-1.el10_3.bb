# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aom"
PV = "3.13.3"
PR = "1.el10_3"
PACKAGES = " \
 aom \
 libaom \
 libaom-devel \
 libaom-devel-docs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/aom-3.13.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3d4763e71406d2d0318245cc845655f9d4483dba6572fdc7a8ddbc0454316798"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aom-3.13.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aom;unpack=0"
SRC_URI[x86_64_v2_aom.sha256sum] = "1555fe5dc30598083196af8d58c79629fbe9bc53a1982ee989394a2b38866567"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-3.13.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom;unpack=0"
SRC_URI[x86_64_v2_libaom.sha256sum] = "922ca8c80a820f3dd9ae7efa898f789e0168de44c2d17f64b311d666ca84f731"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-devel-3.13.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom-devel;unpack=0"
SRC_URI[x86_64_v2_libaom-devel.sha256sum] = "2fa0cad5e5960ead3cb1137068290975004f5a56ed69f8ed9679d626db1583ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaom-devel-docs-3.13.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaom-devel-docs;unpack=0"
SRC_URI[x86_64_v2_libaom-devel-docs.sha256sum] = "07c19c4f48982ef148fbc194bca34b96d0b5a82eb8d02353e3bae1d57427c20f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/aom-3.13.3-1.el10_3.aarch64.rpm;name=aarch64_aom;unpack=0"
SRC_URI[aarch64_aom.sha256sum] = "c6ea4dfde971e1604ee58a30a814370c71804aac0d76cda7c24eca23a51eb2b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libaom-3.13.3-1.el10_3.aarch64.rpm;name=aarch64_libaom;unpack=0"
SRC_URI[aarch64_libaom.sha256sum] = "d7c879e3daca6b8f4fdb7edfe47e2e1ce0768bd338fe37da86d2c9954d80a672"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libaom-devel-3.13.3-1.el10_3.aarch64.rpm;name=aarch64_libaom-devel;unpack=0"
SRC_URI[aarch64_libaom-devel.sha256sum] = "33e5c694fc58fb3158ffb86ac5b7f6ca1374fb43a175f181ff601607f6968a46"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libaom-devel-docs-3.13.3-1.el10_3.aarch64.rpm;name=aarch64_libaom-devel-docs;unpack=0"
SRC_URI[aarch64_libaom-devel-docs.sha256sum] = "5dc47a8dea27c1d3e5394d92032d6bfc30ac9b06e27240af0d5aefac0ff115f7"

RDEPENDS:aom = " \
 glibc \
 libaom \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libaom:x86_64_v2 = " \
 glibc \
 libvmaf \
"
RDEPENDS:libaom:aarch64 = " \
 glibc \
"
RDEPENDS:libaom-devel:x86_64_v2 = " \
 aom \
 cmake-filesystem \
 libaom \
 libvmaf-devel \
 pkgconf-pkg-config \
"
RDEPENDS:libaom-devel:aarch64 = " \
 aom \
 cmake-filesystem \
 libaom \
 pkgconf-pkg-config \
"
RDEPENDS:libaom-devel-docs = " \
 libaom-devel \
 "
