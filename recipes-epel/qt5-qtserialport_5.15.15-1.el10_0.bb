# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtserialport"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtserialport \
 qt5-qtserialport-devel \
 qt5-qtserialport-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtserialport-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0120dbc57b812b52d81f03fd09e0b3c868590e742ad0ddbb55597bde631ce2d"

URI_x86_64_v2_qt5-qtserialport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport}"
SRC_URI[x86_64_v2_qt5-qtserialport.sha256sum] = "4523f1f519f2fb260a67fd9fd896e6e91bf49f0d441de94b9281d4d453ad83a9"

URI_x86_64_v2_qt5-qtserialport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport-devel}"
SRC_URI[x86_64_v2_qt5-qtserialport-devel.sha256sum] = "e1e6fd87f600e102abfbe432dd8f462776b4dc77f005a810abc69781e966c7eb"

URI_x86_64_v2_qt5-qtserialport-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialport-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialport-examples}"
SRC_URI[x86_64_v2_qt5-qtserialport-examples.sha256sum] = "5160321578dd8bac9e9553d4a514d08a56d8e7defb8496919d9ade80aee4b6ad"

URI_aarch64_qt5-qtserialport = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtserialport;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport}"
SRC_URI[aarch64_qt5-qtserialport.sha256sum] = "4710fbd60065dc2124b1a43c2da867224963bcbd6d8964e58462d847875031cd"

URI_aarch64_qt5-qtserialport-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtserialport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport-devel}"
SRC_URI[aarch64_qt5-qtserialport-devel.sha256sum] = "088ca4f78d1ad69721df5b629aae76041297433da567408a49fa74d31b160051"

URI_aarch64_qt5-qtserialport-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialport-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtserialport-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialport-examples}"
SRC_URI[aarch64_qt5-qtserialport-examples.sha256sum] = "8132f6be9f02e52313635c32fd49bfefe838da7703bce7d18bbe28892bd6c483"

RDEPENDS:qt5-qtserialport = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 systemd-libs \
 "
RDEPENDS:qt5-qtserialport-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtserialport \
 "
RDEPENDS:qt5-qtserialport-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtserialport \
 "
