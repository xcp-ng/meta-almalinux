# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gn"
PV = "2574^20260920.127dd2a6d582"
PR = "1.el10_3"
PACKAGES = " \
 gn \
 gn-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gn-2574^20260920.127dd2a6d582-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df35b75ae2d68b85268638e9176fb2e1c4d1ca4f10682f2ed3735cab19ad6423"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-2574^20260920.127dd2a6d582-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gn;unpack=0"
SRC_URI[x86_64_v2_gn.sha256sum] = "529176625b335c01e45f53cdfd8b2b6dd0adc0204d2568fd12637058ebcec146"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-doc-2574^20260920.127dd2a6d582-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_gn-doc;unpack=0"
SRC_URI[x86_64_v2_gn-doc.sha256sum] = "db88d81a3027c259f06f307249cd60c54e7df678b0da46726482a1dc40538a4d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gn-2574^20260920.127dd2a6d582-1.el10_3.aarch64.rpm;name=aarch64_gn;unpack=0"
SRC_URI[aarch64_gn.sha256sum] = "dbe3eb811d86876a8dfbab76561eea94b4589c2422aad8dcfa4adaec9aaee94d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gn-doc-2574^20260920.127dd2a6d582-1.el10_3.noarch.rpm;name=aarch64_gn-doc;unpack=0"
SRC_URI[aarch64_gn-doc.sha256sum] = "8c3f9a6901b3e5b8500e26235666667eef19efdb8669a5f769e541610524245a"

RDEPENDS:gn = " \
 emacs-filesystem \
 glibc \
 libstdc++ \
 python3 \
 vim-filesystem \
 "
RDEPENDS:gn-doc = " \
 "
