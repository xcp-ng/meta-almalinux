# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-pathspec"
PV = "0.13.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-pathspec+default-devel \
 rust-gix-pathspec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-pathspec-0.13.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb4bec1e5de81b3668e19f4352683bda8c68376b33182645949bdd4effad980b"

URI_x86_64_v2_rust-gix-pathspec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pathspec+default-devel-0.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pathspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pathspec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-pathspec+default-devel.sha256sum] = "194c506b140ef15643648094989881816b1fcb3857414ef1cf66237abf5316c4"

URI_x86_64_v2_rust-gix-pathspec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pathspec-devel-0.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pathspec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pathspec-devel}"
SRC_URI[x86_64_v2_rust-gix-pathspec-devel.sha256sum] = "55929308b17d50c1f67460019c3702525fb1ec713eb3e02db684a1e6368e58f6"

URI_aarch64_rust-gix-pathspec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pathspec+default-devel-0.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pathspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pathspec+default-devel}"
SRC_URI[aarch64_rust-gix-pathspec+default-devel.sha256sum] = "4c1fcd67c5e88a60c19602a330484e838d7cb9d14996b5ae90e7725dee291d7a"

URI_aarch64_rust-gix-pathspec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pathspec-devel-0.13.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pathspec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pathspec-devel}"
SRC_URI[aarch64_rust-gix-pathspec-devel.sha256sum] = "c651bf76e567409050877477aabb1ec6ff9b6b1aab412704360eab9f2ad9bed3"

RDEPENDS:rust-gix-pathspec+default-devel = " \
 cargo \
 rust-gix-pathspec-devel \
 "
RDEPENDS:rust-gix-pathspec-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-attributes+default-devel \
 rust-gix-config-value+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-thiserror+default-devel \
 "
