# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qat-zstd-plugin"
PV = "1.0.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 qat-zstd-plugin \
 qat-zstd-plugin-devel \
 qat-zstd-plugin-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qat-zstd-plugin-1.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1546af75e57840d7b5dd5a98ed1d25ca880decc3f68107e477856486fbfa5204"

URI_x86_64_v2_qat-zstd-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qat-zstd-plugin-1.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qat-zstd-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qat-zstd-plugin}"
SRC_URI[x86_64_v2_qat-zstd-plugin.sha256sum] = "3604a90599135b3ccdf8b1f446bed95ff268658a7c9e9aa5866c9337594adf8c"

URI_x86_64_v2_qat-zstd-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qat-zstd-plugin-devel-1.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qat-zstd-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qat-zstd-plugin-devel}"
SRC_URI[x86_64_v2_qat-zstd-plugin-devel.sha256sum] = "fd7272c0a0f6fd989111d77700b72bef54a275973b0d9d06712796bd1201d167"

URI_x86_64_v2_qat-zstd-plugin-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qat-zstd-plugin-static-1.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qat-zstd-plugin-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qat-zstd-plugin-static}"
SRC_URI[x86_64_v2_qat-zstd-plugin-static.sha256sum] = "6a6324010aea9f89665d1d812e89b379b980412d3d4cb13a74b68cacf841f0c5"

RDEPENDS:qat-zstd-plugin = " \
 glibc \
 numactl-libs \
 qatlib \
 "
RDEPENDS:qat-zstd-plugin-devel = " \
 qat-zstd-plugin \
 "
RDEPENDS:qat-zstd-plugin-static = " \
 qat-zstd-plugin-devel \
 "
