# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ruzstd"
PV = "0.8.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-ruzstd+default-devel \
 rust-ruzstd+dict_builder-devel \
 rust-ruzstd+hash-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ruzstd-0.8.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2bb1938cadbbb512e47558f13a9a109ee142471473e1f2f8752e46c34d830a60"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+default-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ruzstd+default-devel.sha256sum] = "6eb9139c487e1cbb24ea786ee5015ab472ff570360d015df2772d9230f92bf84"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+dict_builder-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+dict_builder-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ruzstd+dict_builder-devel.sha256sum] = "680d4ec8ee0507ee4c8ce2eaeffa0c2efa85a762b9b23499c6c27dc258c42209"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+hash-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ruzstd+hash-devel.sha256sum] = "8e199c7040f8f77b6fcab8c746a12b923e927a9162c0097b25e94bb1cac15f8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+std-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ruzstd+std-devel.sha256sum] = "9802ab397049b36704d914ae1b9260a8299e26f76f1ff290c919694c05f18d05"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ruzstd-devel.sha256sum] = "1a96f7dc808b785431ef45a18fbe33313980ac405592870b26c0d6eafbf65c29"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+default-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-ruzstd+default-devel;unpack=0"
SRC_URI[aarch64_rust-ruzstd+default-devel.sha256sum] = "8f9089e0387c362002c335a854ccfd5a186c439c94034535f4b8bfad882e6790"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+dict_builder-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-ruzstd+dict_builder-devel;unpack=0"
SRC_URI[aarch64_rust-ruzstd+dict_builder-devel.sha256sum] = "d30b6d6f8d9f11a2f442dcc795c24202feffd3237211fd197408096b0e53235b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+hash-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-ruzstd+hash-devel;unpack=0"
SRC_URI[aarch64_rust-ruzstd+hash-devel.sha256sum] = "86a25623870d97a718354a067e3a76d761ec21f9e3732a71e8c20882b5648d90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+std-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-ruzstd+std-devel;unpack=0"
SRC_URI[aarch64_rust-ruzstd+std-devel.sha256sum] = "0a7502ee804a99b551dbe3e2503bfd75672dc5ba8de1b72dc9df4cdea2af4dbf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-ruzstd-devel;unpack=0"
SRC_URI[aarch64_rust-ruzstd-devel.sha256sum] = "7340d1ea8d2f3c15923be3b2c80088b01f8b819401c484d15b5a318f1c28e6a4"

RDEPENDS:rust-ruzstd+default-devel = " \
 cargo \
 rust-ruzstd+hash-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd+dict_builder-devel = " \
 cargo \
 rust-fastrand+default-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd+hash-devel = " \
 cargo \
 rust-ruzstd-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-ruzstd+std-devel = " \
 cargo \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd-devel = " \
 cargo \
 rust \
 "
