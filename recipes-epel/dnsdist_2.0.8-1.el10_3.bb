# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsdist"
PV = "2.0.8"
PR = "1.el10_3"
PACKAGES = " \
 dnsdist \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dnsdist-2.0.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f4e0682037db1332a665258dd9cfb6783b4ff22538e1bdd488e38ad0fbdaa03a"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dnsdist: libcap.so.2()(64bit)

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnsdist-2.0.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnsdist;unpack=0"
SRC_URI[x86_64_v2_dnsdist.sha256sum] = "03f8e0b2e99e119481b95179d70c156ac128dc79028035e7e587721a2aac17c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dnsdist-2.0.8-1.el10_3.aarch64.rpm;name=aarch64_dnsdist;unpack=0"
SRC_URI[aarch64_dnsdist.sha256sum] = "87cc164fe1369c87d124700821f858440758bd800d3f9315ef68f86e9c25c0a6"

RDEPENDS:dnsdist:x86_64_v2 = " \
 bash \
 fstrm \
 glibc \
 libcap \
 libedit \
 libgcc \
 libnghttp2 \
 libsodium \
 libstdc++ \
 lmdb-libs \
 luajit \
 openssl-libs \
 re2 \
 shadow-utils \
 systemd \
 systemd-libs \
 tinycdb \
"
RDEPENDS:dnsdist:aarch64 = " \
 bash \
 fstrm \
 glibc \
 libedit \
 libgcc \
 libnghttp2 \
 libsodium \
 libstdc++ \
 lmdb-libs \
 luajit \
 openssl-libs \
 re2 \
 shadow-utils \
 systemd \
 systemd-libs \
 tinycdb \
"
