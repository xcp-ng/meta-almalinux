# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-installed-package-information"
PV = "0.2.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-installed-package-information \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-installed-package-information-0.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a331775fa758675b42561c1da38de934e82afa470f782b4974924ab6219be038"

URI_x86_64_v2_python3-colcon-installed-package-information = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-installed-package-information-0.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-installed-package-information;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-installed-package-information}"
SRC_URI[x86_64_v2_python3-colcon-installed-package-information.sha256sum] = "e504aa4d10dea456a9ea64fabbc9a569332239406523ca13b15220d4aa312752"

URI_aarch64_python3-colcon-installed-package-information = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-installed-package-information-0.2.1-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-installed-package-information;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-installed-package-information}"
SRC_URI[aarch64_python3-colcon-installed-package-information.sha256sum] = "12b00fe654c02ae5b2b5d66d488d381033ebd2987ddb3c5c6e48c90c1310e841"

RDEPENDS:python3-colcon-installed-package-information = " \
 python3 \
 python3-colcon-core \
 "
