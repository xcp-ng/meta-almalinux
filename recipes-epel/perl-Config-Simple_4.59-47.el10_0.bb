# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Config-Simple"
PV = "4.59"
PR = "47.el10_0"
PACKAGES = " \
 perl-Config-Simple \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Config-Simple-4.59-47.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7db8677dc5001e44428044df984a4d554b6cd59b0d2f347795b12b463cea2262"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Config-Simple-4.59-47.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Config-Simple;unpack=0"
SRC_URI[x86_64_v2_perl-Config-Simple.sha256sum] = "dc9ace0668a0fd478aa1581d07af04f04bafb81ae3c400231a8324393f9e5992"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Config-Simple-4.59-47.el10_0.noarch.rpm;name=aarch64_perl-Config-Simple;unpack=0"
SRC_URI[aarch64_perl-Config-Simple.sha256sum] = "4c10f33d0c9e2007ab0b5a1a3b073dad8bf4ee872ffd31a054c03536442fec48"

RDEPENDS:perl-Config-Simple = " \
 perl-AutoLoader \
 perl-Carp \
 perl-Data-Dumper \
 perl-Fcntl \
 perl-Text-ParseWords \
 perl-libs \
 perl-vars \
 "
