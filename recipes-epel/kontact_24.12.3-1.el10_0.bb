# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontact"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kontact \
 kontact-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontact-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "459c21435e75df5669a45e1ae396f9d0e2c5d82993aa57c3bc07fb14c02cfc13"

URI_x86_64_v2_kontact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontact-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontact}"
SRC_URI[x86_64_v2_kontact.sha256sum] = "0c378d4bd7daca54946c683005afd036e465aaf77cc4ab9fda3ffb1ecfd123e8"

URI_x86_64_v2_kontact-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontact-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontact-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontact-libs}"
SRC_URI[x86_64_v2_kontact-libs.sha256sum] = "df9b22c9e0f20c4724cf5078d7d36af4110e646416c4369af3868113abb539af"

URI_aarch64_kontact = "${EPEL_MIRROR}/aarch64/Packages/k/kontact-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kontact;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontact}"
SRC_URI[aarch64_kontact.sha256sum] = "4562d0a686109e228fe1eb9c11e541e6b1b8a8ff4798adba6ef72684d0198326"

URI_aarch64_kontact-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kontact-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kontact-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontact-libs}"
SRC_URI[aarch64_kontact-libs.sha256sum] = "de040959d1dc9abf8e79cdc175e9a47ea76567858e63af63468241a1975af789"

RDEPENDS:kontact = " \
 glibc \
 kaddressbook \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kxmlgui \
 kmail \
 kontact-libs \
 kontactinterface \
 korganizer \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kontact-libs = " \
 glibc \
 grantleetheme \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontact \
 kontactinterface \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
