# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cucumber-messages"
PV = "27.0.2"
PR = "1.el10_0"
PACKAGES = " \
 cucumber-messages-cpp-devel \
 cucumber-messages-cpp-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cucumber-messages-27.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "662e1d1ec74469b9a27b481f39560a61dafa5b15f2cd671a795469a92600ea98"

URI_x86_64_v2_cucumber-messages-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cucumber-messages-cpp-devel-27.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cucumber-messages-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cucumber-messages-cpp-devel}"
SRC_URI[x86_64_v2_cucumber-messages-cpp-devel.sha256sum] = "20b607b4c1e02db9998bb9d1cecdd5e09b80a30191a9e0510df3259dac8502cd"

URI_x86_64_v2_cucumber-messages-cpp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cucumber-messages-cpp-libs-27.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cucumber-messages-cpp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cucumber-messages-cpp-libs}"
SRC_URI[x86_64_v2_cucumber-messages-cpp-libs.sha256sum] = "2da6b97aec7ce938bfa970ebc2be17123e547dad4e3cbf1fe9a8f64cfcedefec"

URI_aarch64_cucumber-messages-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cucumber-messages-cpp-devel-27.0.2-1.el10_0.aarch64.rpm;name=aarch64_cucumber-messages-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cucumber-messages-cpp-devel}"
SRC_URI[aarch64_cucumber-messages-cpp-devel.sha256sum] = "9c79c4dded6e18171e258e97a0da81b1828a53c0d2bd6b610285a15af564d85f"

URI_aarch64_cucumber-messages-cpp-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cucumber-messages-cpp-libs-27.0.2-1.el10_0.aarch64.rpm;name=aarch64_cucumber-messages-cpp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cucumber-messages-cpp-libs}"
SRC_URI[aarch64_cucumber-messages-cpp-libs.sha256sum] = "dc95d3f5de0e61f08a299a9927098e7529542479374ab51dfd7c3f4f8abf8c30"

RDEPENDS:cucumber-messages-cpp-devel = " \
 cmake-filesystem \
 cucumber-messages-cpp-libs \
 "
RDEPENDS:cucumber-messages-cpp-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 "
