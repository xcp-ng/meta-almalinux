# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "toilet"
PV = "0.3"
PR = "17.el10_0"
PACKAGES = " \
 toilet \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/toilet-0.3-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cf7a2038287f849b6e6524cf4bd9bc74fb2e0c01a57063b6b8a4d84dd20bc3c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/toilet-0.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_toilet;unpack=0"
SRC_URI[x86_64_v2_toilet.sha256sum] = "2a9b437f3430a7f98762024f9c8e4ae303e83ede41a5f8f883e9d4d2d9dcc1c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/toilet-0.3-17.el10_0.aarch64.rpm;name=aarch64_toilet;unpack=0"
SRC_URI[aarch64_toilet.sha256sum] = "33f458665e26cc63ffd76377ce8e7c56c7b1c8f3897ce9db38e5e8f6af01453c"

RDEPENDS:toilet = " \
 glibc \
 libcaca \
 "
