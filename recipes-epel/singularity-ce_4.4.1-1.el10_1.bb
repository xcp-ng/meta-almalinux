# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "singularity-ce"
PV = "4.4.1"
PR = "1.el10_1"
PACKAGES = " \
 singularity-ce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/singularity-ce-4.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d10cb4665e87e087f1277ff2fb254f34259445dbf1ce504ea6c8c3ed7c54dcee"

URI_x86_64_v2_singularity-ce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/singularity-ce-4.4.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_singularity-ce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_singularity-ce}"
SRC_URI[x86_64_v2_singularity-ce.sha256sum] = "6250aa8ff8f92c719e975569cd672132afb80eaa1346ab1832dd560393e25acc"

URI_aarch64_singularity-ce = "${EPEL_MIRROR}/aarch64/Packages/s/singularity-ce-4.4.1-1.el10_1.aarch64.rpm;name=aarch64_singularity-ce;unpack=0"
SRC_URI:append = " ${URI_aarch64_singularity-ce}"
SRC_URI[aarch64_singularity-ce.sha256sum] = "8b840671828c497e3134fa973ab6ea1401f8cbcac4cada80cf99351e16a212cb"

RDEPENDS:singularity-ce = " \
 bash \
 conmon \
 crun \
 cryptsetup \
 fuse \
 fuse3 \
 glibc \
 libseccomp \
 shadow-utils \
 shadow-utils-subid \
 squashfs-tools \
 squashfuse \
 "
