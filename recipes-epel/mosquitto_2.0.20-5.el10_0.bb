# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mosquitto"
PV = "2.0.20"
PR = "5.el10_0"
PACKAGES = " \
 mosquitto \
 mosquitto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mosquitto-2.0.20-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a24bf555bde57494b0d45909c1e28aaa1d3db27dce731e9a6a64a76329ed9fb3"

URI_x86_64_v2_mosquitto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mosquitto-2.0.20-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mosquitto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mosquitto}"
SRC_URI[x86_64_v2_mosquitto.sha256sum] = "195b28e95ac9591db8395c7cc12a95197e92e490caafe4a03e770888f0da5204"

URI_x86_64_v2_mosquitto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mosquitto-devel-2.0.20-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mosquitto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mosquitto-devel}"
SRC_URI[x86_64_v2_mosquitto-devel.sha256sum] = "8661e879c3e4d3cce41686c2c4e237b3723e64b07c3ba59b066a9ea554afacaf"

URI_aarch64_mosquitto = "${EPEL_MIRROR}/aarch64/Packages/m/mosquitto-2.0.20-5.el10_0.aarch64.rpm;name=aarch64_mosquitto;unpack=0"
SRC_URI:append = " ${URI_aarch64_mosquitto}"
SRC_URI[aarch64_mosquitto.sha256sum] = "e4fd727b754eb0a480ff2811ac65f0ca6ae8f6d532ff6cb41ac5a0918ca72049"

URI_aarch64_mosquitto-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mosquitto-devel-2.0.20-5.el10_0.aarch64.rpm;name=aarch64_mosquitto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mosquitto-devel}"
SRC_URI[aarch64_mosquitto-devel.sha256sum] = "893bc25b8d35d61394562c8bca8ef899d789c2cf5dbc10337ceb3c728e9b4275"

RDEPENDS:mosquitto = " \
 c-ares \
 cjson \
 glibc \
 libstdc++ \
 libwebsockets \
 openssl-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:mosquitto-devel = " \
 mosquitto \
 pkgconf-pkg-config \
 "
