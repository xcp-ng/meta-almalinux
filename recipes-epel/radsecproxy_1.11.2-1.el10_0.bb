# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radsecproxy"
PV = "1.11.2"
PR = "1.el10_0"
PACKAGES = " \
 radsecproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/radsecproxy-1.11.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9d6f30bcf4b3bf78df08ddad1d81592a0757f9359a9b229ed6d682fb859270e"

URI_x86_64_v2_radsecproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radsecproxy-1.11.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radsecproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radsecproxy}"
SRC_URI[x86_64_v2_radsecproxy.sha256sum] = "bb756a82af80a2e758a13938ed953cf68a6d41a577efddb65338fedce23fa908"

URI_aarch64_radsecproxy = "${EPEL_MIRROR}/aarch64/Packages/r/radsecproxy-1.11.2-1.el10_0.aarch64.rpm;name=aarch64_radsecproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_radsecproxy}"
SRC_URI[aarch64_radsecproxy.sha256sum] = "ac67eced2fa89c1df3914563072ec4b657cf16047e0e62edad38d8c5752068b2"

RDEPENDS:radsecproxy = " \
 bash \
 glibc \
 logrotate \
 nettle \
 openssl-libs \
 shadow-utils \
 systemd \
 "
