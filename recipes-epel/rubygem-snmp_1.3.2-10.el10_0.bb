# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-snmp"
PV = "1.3.2"
PR = "10.el10_0"
PACKAGES = " \
 rubygem-snmp \
 rubygem-snmp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-snmp-1.3.2-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d391e1f7e595a5539697ed5aac61c837c39faedf2d552206dbe76440fea9eef"

URI_x86_64_v2_rubygem-snmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-snmp-1.3.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-snmp}"
SRC_URI[x86_64_v2_rubygem-snmp.sha256sum] = "d8575249238c787e01fdfd1824ca641af1190961e8c7ffca9a64f745f95643d7"

URI_x86_64_v2_rubygem-snmp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-snmp-doc-1.3.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-snmp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-snmp-doc}"
SRC_URI[x86_64_v2_rubygem-snmp-doc.sha256sum] = "3b829b7766a102c21884b9d4a48c2ecd2e1b091973fa15ed9104904f6b7f1a1e"

URI_aarch64_rubygem-snmp = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-snmp-1.3.2-10.el10_0.noarch.rpm;name=aarch64_rubygem-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-snmp}"
SRC_URI[aarch64_rubygem-snmp.sha256sum] = "510aa49008dc2727369ca061e5054183d57ac0f275ab47873287d3861cd8d20d"

URI_aarch64_rubygem-snmp-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-snmp-doc-1.3.2-10.el10_0.noarch.rpm;name=aarch64_rubygem-snmp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-snmp-doc}"
SRC_URI[aarch64_rubygem-snmp-doc.sha256sum] = "b10cc1494694f82b566c862af66d6e2d3e203cb1441f59c802b024f5edf20ab1"

RDEPENDS:rubygem-snmp = " \
 rubygems \
 "
RDEPENDS:rubygem-snmp-doc = " \
 rubygem-snmp \
 "
