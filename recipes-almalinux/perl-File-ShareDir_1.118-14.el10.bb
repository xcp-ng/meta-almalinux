# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-ShareDir"
PV = "1.118"
PR = "14.el10"
PACKAGES = " \
 perl-File-ShareDir \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-File-ShareDir-1.118-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23c4aab8c04b0d7b0e69ad5f44a866f22bdfb8d3cd9911c554d42f13e0e75f53"

URI_x86_64_v2_perl-File-ShareDir = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-ShareDir-1.118-14.el10.noarch.rpm;name=x86_64_v2_perl-File-ShareDir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-ShareDir}"
SRC_URI[x86_64_v2_perl-File-ShareDir.sha256sum] = "1ff1c7353917dc893b2dec1826b4f4c334ab228730e369db92b1f55a8eb8561f"

URI_aarch64_perl-File-ShareDir = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-ShareDir-1.118-14.el10.noarch.rpm;name=aarch64_perl-File-ShareDir;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-ShareDir}"
SRC_URI[aarch64_perl-File-ShareDir.sha256sum] = "1ff1c7353917dc893b2dec1826b4f4c334ab228730e369db92b1f55a8eb8561f"

RDEPENDS:perl-File-ShareDir = " \
 perl-Carp \
 perl-Class-Inspector \
 perl-Exporter \
 perl-PathTools \
 perl-base \
 perl-constant \
 perl-libs \
 "
