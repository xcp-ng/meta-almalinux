# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portable-atomic-util"
PV = "0.2.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 rust-portable-atomic-util+serde-devel \
 rust-portable-atomic-util+std-devel \
 rust-portable-atomic-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-portable-atomic-util-0.2.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ddb01165bd7177ccc75172a28f62091cd7e6b44f84c66a6575b8d9acc6625f3"

URI_x86_64_v2_rust-portable-atomic-util+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+alloc-devel-0.2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+alloc-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+alloc-devel.sha256sum] = "f504beda50bdc4954a50f2f7bd7af1fa10ea68ffea528a1abdf7314e9db45133"

URI_x86_64_v2_rust-portable-atomic-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+default-devel-0.2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+default-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+default-devel.sha256sum] = "fa962636175dc1424f1dc7f55162dc5281a3d752f2b89d703f1d9b2b787cdaf3"

URI_x86_64_v2_rust-portable-atomic-util+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+serde-devel-0.2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+serde-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+serde-devel.sha256sum] = "a2992dabcc4a1ebb4423ee2b6b9ef54bdb9f5342f5d57a7ceab33dc68fdef5ca"

URI_x86_64_v2_rust-portable-atomic-util+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+std-devel-0.2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+std-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+std-devel.sha256sum] = "8b6f9586aaae24b4ac79449a3f47daaf299c0feec969e3c767e405d9c151bb13"

URI_x86_64_v2_rust-portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util-devel-0.2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util-devel.sha256sum] = "e7b522f11b4fd0cf2ef51d5887f71ec294da6389eb7a0a3e381be0049dc9b890"

URI_aarch64_rust-portable-atomic-util+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+alloc-devel-0.2.7-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+alloc-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+alloc-devel.sha256sum] = "f572acdb98a43b6f87b9cf675e563945c993f6f801a8959e5f49a110568bc867"

URI_aarch64_rust-portable-atomic-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+default-devel-0.2.7-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+default-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+default-devel.sha256sum] = "c9f3141d71a1fdc20109a81989d8335eafe251252be1f3b5c3a0b0918cf0147b"

URI_aarch64_rust-portable-atomic-util+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+serde-devel-0.2.7-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-util+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+serde-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+serde-devel.sha256sum] = "c39e44d3c5eb9f48cc216cd429bec81b22df449f9f4e668f1b13511036316dda"

URI_aarch64_rust-portable-atomic-util+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+std-devel-0.2.7-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+std-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+std-devel.sha256sum] = "598f7e82c84684eab53756eb4e77c8c2780b2f0a8faf17860ee747211a04d0ef"

URI_aarch64_rust-portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util-devel-0.2.7-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util-devel}"
SRC_URI[aarch64_rust-portable-atomic-util-devel.sha256sum] = "7d6acf4e8efeb2260b1246bb6660d115eaa0b33a521eb66c10e34090a94c7fc5"

RDEPENDS:rust-portable-atomic-util+alloc-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+default-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+serde-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-portable-atomic-util+std-devel = " \
 cargo \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util-devel = " \
 cargo \
 rust \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
