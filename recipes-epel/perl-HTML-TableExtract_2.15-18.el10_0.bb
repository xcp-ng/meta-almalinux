# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-TableExtract"
PV = "2.15"
PR = "18.el10_0"
PACKAGES = " \
 perl-HTML-TableExtract \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-TableExtract-2.15-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a72a0c7c8bfb4f6410056323e9298e57d034f7848e14f7ade0cdede316b5272b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-TableExtract-2.15-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-TableExtract;unpack=0"
SRC_URI[x86_64_v2_perl-HTML-TableExtract.sha256sum] = "9459e751ddeb4042b5426984871e2f0650c58a3741843aa1f38d3acd6d4a60c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-TableExtract-2.15-18.el10_0.noarch.rpm;name=aarch64_perl-HTML-TableExtract;unpack=0"
SRC_URI[aarch64_perl-HTML-TableExtract.sha256sum] = "e239be7e6f8cbcc7bd208d0da86ac2fd3379ea2e46f8b81b25ad8ca6bb37f082"

RDEPENDS:perl-HTML-TableExtract = " \
 perl-Carp \
 perl-HTML-Element-Extended \
 perl-HTML-Parser \
 perl-HTML-Tree \
 perl-libs \
 perl-vars \
 "
