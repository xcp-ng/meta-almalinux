# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crunchy"
PV = "0.2.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-crunchy+default-devel \
 rust-crunchy+limit_1024-devel \
 rust-crunchy+limit_128-devel \
 rust-crunchy+limit_2048-devel \
 rust-crunchy+limit_256-devel \
 rust-crunchy+limit_512-devel \
 rust-crunchy+limit_64-devel \
 rust-crunchy+std-devel \
 rust-crunchy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crunchy-0.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9cded72bbe6eb54839810420403731dbeb0350e43ddcd92fbc0d9c89989c59a"

URI_x86_64_v2_rust-crunchy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+default-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+default-devel}"
SRC_URI[x86_64_v2_rust-crunchy+default-devel.sha256sum] = "45e7310e8daab8d334ea6056ed7f9b49dac7cb9ab8f87920caeea4aefffdb886"

URI_x86_64_v2_rust-crunchy+limit_1024-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_1024-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_1024-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_1024-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_1024-devel.sha256sum] = "82d9519a9af64434971c768b08c0d095f0e4780cef5622b6b053b3c528353eb5"

URI_x86_64_v2_rust-crunchy+limit_128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_128-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_128-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_128-devel.sha256sum] = "006b01069e4a4ccd4de70e67baf775f378ff1bed508dadeecd6ca45ed96ace58"

URI_x86_64_v2_rust-crunchy+limit_2048-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_2048-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_2048-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_2048-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_2048-devel.sha256sum] = "40e3d4de825af5eef66f0b88397fb19cf2e1bdc3c50f9fd62d980b25679a55f0"

URI_x86_64_v2_rust-crunchy+limit_256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_256-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_256-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_256-devel.sha256sum] = "28ec6baa5a16b7b9be6b90199e26792e0075bed8fc2f8d33d2334b187bdd753e"

URI_x86_64_v2_rust-crunchy+limit_512-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_512-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_512-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_512-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_512-devel.sha256sum] = "b9f9ac5315d8c41f517499b8ea100f586086b575c0cd2d1b61c4cce34be89a85"

URI_x86_64_v2_rust-crunchy+limit_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_64-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_64-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_64-devel.sha256sum] = "228f63302c90a837aa8616f4a8fc391cf76fcb9f9e139ff22019d9fd3e780187"

URI_x86_64_v2_rust-crunchy+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+std-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+std-devel}"
SRC_URI[x86_64_v2_rust-crunchy+std-devel.sha256sum] = "b37c7733e44a463e4730f09fa7baa6c92074287d610d3ee3baf5d8feb5dcd2a9"

URI_x86_64_v2_rust-crunchy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy-devel}"
SRC_URI[x86_64_v2_rust-crunchy-devel.sha256sum] = "0879264a156d03ed35e4d32ae316e07a50bbe6afe3c5b8d96bad2e940f6612ee"

URI_aarch64_rust-crunchy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+default-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-crunchy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+default-devel}"
SRC_URI[aarch64_rust-crunchy+default-devel.sha256sum] = "72fe767bd49e29bb332ea3ad90a0fad2e23109c92211583e23e97c80e47cfc83"

URI_aarch64_rust-crunchy+limit_1024-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_1024-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-crunchy+limit_1024-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_1024-devel}"
SRC_URI[aarch64_rust-crunchy+limit_1024-devel.sha256sum] = "d1a9544721b10faa077c63e37850d036510bb20612ad32b6369d1ac6d4cde617"

URI_aarch64_rust-crunchy+limit_128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_128-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-crunchy+limit_128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_128-devel}"
SRC_URI[aarch64_rust-crunchy+limit_128-devel.sha256sum] = "cb86e8f0ac576e670c16e015bafeb276e01f5701aea26270772501105a956915"

URI_aarch64_rust-crunchy+limit_2048-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_2048-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-crunchy+limit_2048-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_2048-devel}"
SRC_URI[aarch64_rust-crunchy+limit_2048-devel.sha256sum] = "69711f9079e882d317f20ca80718ef4cb9691f29721bf5dc57472428cdc1603f"

URI_aarch64_rust-crunchy+limit_256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_256-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-crunchy+limit_256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_256-devel}"
SRC_URI[aarch64_rust-crunchy+limit_256-devel.sha256sum] = "a03a24b949894c1d86914363714c6dd77d6404bd589afe46a2cd19d24fe1c9de"

URI_aarch64_rust-crunchy+limit_512-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_512-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-crunchy+limit_512-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_512-devel}"
SRC_URI[aarch64_rust-crunchy+limit_512-devel.sha256sum] = "124f95091bb42894e3c4c91020f0f7a113af44140c409523c4c0b0346b07e21c"

URI_aarch64_rust-crunchy+limit_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_64-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-crunchy+limit_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_64-devel}"
SRC_URI[aarch64_rust-crunchy+limit_64-devel.sha256sum] = "735ff3b08e00de6275ed82ea1ee717634118c14cc470d4e0ebf20631bc252e58"

URI_aarch64_rust-crunchy+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+std-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-crunchy+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+std-devel}"
SRC_URI[aarch64_rust-crunchy+std-devel.sha256sum] = "87696ceebccdc3225f6ee43dd5dfcedfa909ba308ece3d948b5e5e6cbef01dc5"

URI_aarch64_rust-crunchy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-crunchy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy-devel}"
SRC_URI[aarch64_rust-crunchy-devel.sha256sum] = "5774ebd45e932d53288eaea079a18e55a04e16887276a81c51963bd9cfd9c115"

RDEPENDS:rust-crunchy+default-devel = " \
 cargo \
 rust-crunchy+limit_128-devel \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_1024-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_128-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_2048-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_256-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_512-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_64-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+std-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy-devel = " \
 cargo \
 "
