# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytes"
PV = "1.11.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-bytes+default-devel \
 rust-bytes+extra-platforms-devel \
 rust-bytes+serde-devel \
 rust-bytes+std-devel \
 rust-bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytes-1.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cb84f42dec842881ccc115ad6afba406844c9816cf89a26839664d4ca792b3b"

URI_x86_64_v2_rust-bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+default-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+default-devel}"
SRC_URI[x86_64_v2_rust-bytes+default-devel.sha256sum] = "5b42e2779f30a1238b0c3f66366337b97f8ac9152c66d859a645c9dddd5cdd1f"

URI_x86_64_v2_rust-bytes+extra-platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+extra-platforms-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+extra-platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+extra-platforms-devel}"
SRC_URI[x86_64_v2_rust-bytes+extra-platforms-devel.sha256sum] = "525a8db822da3f0925be0d04d62e7383b490d694af3205d16e660752addfadde"

URI_x86_64_v2_rust-bytes+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+serde-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+serde-devel}"
SRC_URI[x86_64_v2_rust-bytes+serde-devel.sha256sum] = "b0a25814dad3910a345975eb4002a9a974ea8e17b6847aa34a646f181f9abed4"

URI_x86_64_v2_rust-bytes+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+std-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+std-devel}"
SRC_URI[x86_64_v2_rust-bytes+std-devel.sha256sum] = "7fe4299203d8f2922176b8ccbc3b626d3372fd460570e9e43464c397db781115"

URI_x86_64_v2_rust-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes-devel}"
SRC_URI[x86_64_v2_rust-bytes-devel.sha256sum] = "c6d01c722f9aae0dc4a66ab4e6e353e2ec7be821f1304a456e59d262b73e42b0"

URI_aarch64_rust-bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+default-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+default-devel}"
SRC_URI[aarch64_rust-bytes+default-devel.sha256sum] = "65eb15f17cdbdb102bc40777ac572f79e2191eb5085add2cadab329b5e8e46ca"

URI_aarch64_rust-bytes+extra-platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+extra-platforms-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytes+extra-platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+extra-platforms-devel}"
SRC_URI[aarch64_rust-bytes+extra-platforms-devel.sha256sum] = "be5d486c5c9ec365de72b5a1e701c005bf99cbb01d97c4f7ce8cbaf9c890e062"

URI_aarch64_rust-bytes+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+serde-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+serde-devel}"
SRC_URI[aarch64_rust-bytes+serde-devel.sha256sum] = "6502e6f537ec9f971e58cd343c071160ce05dc7fd3097153ae386c015de5d02e"

URI_aarch64_rust-bytes+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+std-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+std-devel}"
SRC_URI[aarch64_rust-bytes+std-devel.sha256sum] = "dd61c71d1dc797a34c90f50afcd53b787815dc000c4921b456ef32ca91faa3c4"

URI_aarch64_rust-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes-devel}"
SRC_URI[aarch64_rust-bytes-devel.sha256sum] = "68776add29258d7a50f55552f93075e252a7f1e2f6a3f6857fde12718ee4912d"

RDEPENDS:rust-bytes+default-devel = " \
 cargo \
 rust-bytes+std-devel \
 rust-bytes-devel \
 "
RDEPENDS:rust-bytes+extra-platforms-devel = " \
 cargo \
 rust-bytes-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-bytes+serde-devel = " \
 cargo \
 rust-bytes-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bytes+std-devel = " \
 cargo \
 rust-bytes-devel \
 "
RDEPENDS:rust-bytes-devel = " \
 bash \
 cargo \
 rust \
 "
