# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "partclone"
PV = "0.3.48"
PR = "1.el10_2"
PACKAGES = " \
 partclone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/partclone-0.3.48-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cfc97caccd9ddfbb37e698df3a68918a25e91ca6a26344be0c2a2553d72c0c2"

URI_x86_64_v2_partclone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/partclone-0.3.48-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_partclone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_partclone}"
SRC_URI[x86_64_v2_partclone.sha256sum] = "b3dabb1cb752e189de6195bdb544d05fc4001d9a92e34a32aabf2ecbf021ad15"

URI_aarch64_partclone = "${EPEL_MIRROR}/aarch64/Packages/p/partclone-0.3.48-1.el10_2.aarch64.rpm;name=aarch64_partclone;unpack=0"
SRC_URI:append = " ${URI_aarch64_partclone}"
SRC_URI[aarch64_partclone.sha256sum] = "13b632a3b6d720317d6e63120fcfc68f6c034aca4810c4daa0dd7c42f5639232"

RDEPENDS:partclone = " \
 e2fsprogs-libs \
 fuse3-libs \
 glibc \
 libblkid \
 libuuid \
 ncurses-libs \
 ntfs-3g-libs \
 openssl-libs \
 userspace-rcu \
 xxhash-libs \
 "
