# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-benchmark"
PV = "1.9.5"
PR = "1.el10_2"
PACKAGES = " \
 google-benchmark \
 google-benchmark-devel \
 google-benchmark-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/google-benchmark-1.9.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9dacd60f26c2133da0df3b9d09ddc5fe71c046342469c83213ce445c443bdec"

URI_x86_64_v2_google-benchmark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-benchmark-1.9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-benchmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-benchmark}"
SRC_URI[x86_64_v2_google-benchmark.sha256sum] = "fc1b41f611bf6d66b327d741a55c85f4c135026d2796f9f3029c9f9841fc11e8"

URI_x86_64_v2_google-benchmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-benchmark-devel-1.9.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-benchmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-benchmark-devel}"
SRC_URI[x86_64_v2_google-benchmark-devel.sha256sum] = "1bd4295917625af31d3285f86ffed032a371e4acffcfabd4d52baa3e5efd5c4c"

URI_x86_64_v2_google-benchmark-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-benchmark-doc-1.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_google-benchmark-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-benchmark-doc}"
SRC_URI[x86_64_v2_google-benchmark-doc.sha256sum] = "0d001d9b6109fd7d53ba389f9c5e4972ee82a23a21e639253271ac0b2fb8e092"

URI_aarch64_google-benchmark = "${EPEL_MIRROR}/aarch64/Packages/g/google-benchmark-1.9.5-1.el10_2.aarch64.rpm;name=aarch64_google-benchmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-benchmark}"
SRC_URI[aarch64_google-benchmark.sha256sum] = "16bb2faafb71053d4a3bf36d9524c7040bbc4b584e4e04d56a7f4029817ba2ad"

URI_aarch64_google-benchmark-devel = "${EPEL_MIRROR}/aarch64/Packages/g/google-benchmark-devel-1.9.5-1.el10_2.aarch64.rpm;name=aarch64_google-benchmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-benchmark-devel}"
SRC_URI[aarch64_google-benchmark-devel.sha256sum] = "1687d61386fef1d65619e5e6f7a1f1ae8708ba30a252a8fbe0d848fbdf619aac"

URI_aarch64_google-benchmark-doc = "${EPEL_MIRROR}/aarch64/Packages/g/google-benchmark-doc-1.9.5-1.el10_2.noarch.rpm;name=aarch64_google-benchmark-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-benchmark-doc}"
SRC_URI[aarch64_google-benchmark-doc.sha256sum] = "cde4398811342a08639eaec00c56d902e735f5e214695b39f061451407059733"

RDEPENDS:google-benchmark = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:google-benchmark-devel = " \
 cmake-filesystem \
 google-benchmark \
 google-benchmark-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:google-benchmark-doc = " \
 google-benchmark \
 "
