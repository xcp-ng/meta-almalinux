# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "massif-visualizer"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 massif-visualizer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/massif-visualizer-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10ddbfb2211ed257e94367297f6c461c186dc839a67bfc9267dceefc1e9390c2"

URI_x86_64_v2_massif-visualizer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/massif-visualizer-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_massif-visualizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_massif-visualizer}"
SRC_URI[x86_64_v2_massif-visualizer.sha256sum] = "3988c6ab78d25a8497d5a99fb82c500445c81c62f8180caf045c1b3e1d4ecb30"

URI_aarch64_massif-visualizer = "${EPEL_MIRROR}/aarch64/Packages/m/massif-visualizer-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_massif-visualizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_massif-visualizer}"
SRC_URI[aarch64_massif-visualizer.sha256sum] = "c21bdc839239fbe520b71d123f722df5019cb2bed88d929e29f27001818f9354"

RDEPENDS:massif-visualizer = " \
 glibc \
 kdiagram \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
