# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-compilersupport"
PV = "20"
PR = "12.rocm7.1.1.el10_2"
PACKAGES:x86_64_v2 = " \
 hipcc \
 rocm-clang \
 rocm-clang-analyzer \
 rocm-clang-devel \
 rocm-clang-libs \
 rocm-clang-runtime-devel \
 rocm-clang-tools-extra \
 rocm-clang-tools-extra-devel \
 rocm-comgr \
 rocm-comgr-devel \
 rocm-compilersupport-macros \
 rocm-device-libs \
 rocm-libc++ \
 rocm-libc++-devel \
 rocm-libc++-static \
 rocm-lld \
 rocm-llvm \
 rocm-llvm-devel \
 rocm-llvm-filesystem \
 rocm-llvm-libs \
 rocm-llvm-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-compilersupport-20-12.rocm7.1.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "426f683151e1225952f9ce63d89a5737c81d564c36a9cd33d3dc74f2140f9088"

URI_x86_64_v2_hipcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipcc-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipcc}"
SRC_URI[x86_64_v2_hipcc.sha256sum] = "bd8e4abfc898017cf2d42f5b6285f45dea3047435549cd3baf08613b30820c9f"

URI_x86_64_v2_rocm-clang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang}"
SRC_URI[x86_64_v2_rocm-clang.sha256sum] = "937bb3559d028bfee2754c17b77ae1d2f668ac04b9cdf7d7cb342a76c8aa1154"

URI_x86_64_v2_rocm-clang-analyzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-analyzer-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-analyzer}"
SRC_URI[x86_64_v2_rocm-clang-analyzer.sha256sum] = "ff962e2d4516b06f002f6d1a5b3c094866b0d0b3f87bf19965beb5dfb3a3fabc"

URI_x86_64_v2_rocm-clang-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-devel-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-devel}"
SRC_URI[x86_64_v2_rocm-clang-devel.sha256sum] = "c44ed11ce08f0afd08fb6a9a694dc07d2256d667ea2536944ed5f48d9cfabb0d"

URI_x86_64_v2_rocm-clang-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-libs-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-libs}"
SRC_URI[x86_64_v2_rocm-clang-libs.sha256sum] = "5285b971daa6e84c75dfb2e1fa97180eb28be0a3920fa32b9ea0d3092470e2fa"

URI_x86_64_v2_rocm-clang-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-runtime-devel-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-runtime-devel}"
SRC_URI[x86_64_v2_rocm-clang-runtime-devel.sha256sum] = "68757f1f7ae510ac79a6f4718c34a8f07dcab1cb64db9293732037d8eceb886b"

URI_x86_64_v2_rocm-clang-tools-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-tools-extra-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-tools-extra}"
SRC_URI[x86_64_v2_rocm-clang-tools-extra.sha256sum] = "54384de08368975a0e419f7664ad2af3809da3bbe9b2842373def3626787f530"

URI_x86_64_v2_rocm-clang-tools-extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-tools-extra-devel-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-tools-extra-devel}"
SRC_URI[x86_64_v2_rocm-clang-tools-extra-devel.sha256sum] = "f76ee0672a6fc4498e98470ed5b12e364aef45b7190840d5bc953b39715a04f6"

URI_x86_64_v2_rocm-comgr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-comgr-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-comgr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-comgr}"
SRC_URI[x86_64_v2_rocm-comgr.sha256sum] = "7935b0a5af3d9b76207368ea0ea869cbc62daab4240e1deb60bf3c2fd33bc1bf"

URI_x86_64_v2_rocm-comgr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-comgr-devel-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-comgr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-comgr-devel}"
SRC_URI[x86_64_v2_rocm-comgr-devel.sha256sum] = "afa9f376125f15a923843522b928a517ea64a584e171b7579ac3491e6fba59ae"

URI_x86_64_v2_rocm-compilersupport-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-compilersupport-macros-20-12.rocm7.1.1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-compilersupport-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-compilersupport-macros}"
SRC_URI[x86_64_v2_rocm-compilersupport-macros.sha256sum] = "093070036f503a1a2e2887eecc726a2a68821afa5c4fb82113e7402ef4e87651"

URI_x86_64_v2_rocm-device-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-device-libs-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-device-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-device-libs}"
SRC_URI[x86_64_v2_rocm-device-libs.sha256sum] = "a5ab466eb55700a9bcb8470591699f6fd4ac869ae9ef8bcd54a714888ec5c1b2"

URI_x86_64_v2_rocm-libc++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-libc++-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-libc++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-libc++}"
SRC_URI[x86_64_v2_rocm-libc++.sha256sum] = "7525c66f87d709b5f874624c312a3e6fc055692ba6b26cc25765d6bc4ded94aa"

URI_x86_64_v2_rocm-libc++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-libc++-devel-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-libc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-libc++-devel}"
SRC_URI[x86_64_v2_rocm-libc++-devel.sha256sum] = "1920217c454016685f2f5e391952cf52ea2d7e6ae7de5a95a081269788b24b5d"

URI_x86_64_v2_rocm-libc++-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-libc++-static-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-libc++-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-libc++-static}"
SRC_URI[x86_64_v2_rocm-libc++-static.sha256sum] = "669e9742203475429b413a0e68374654c37e81288fc3d7c8f3d7fbc8c5836aaa"

URI_x86_64_v2_rocm-lld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-lld-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-lld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-lld}"
SRC_URI[x86_64_v2_rocm-lld.sha256sum] = "4f2fd364fd0cb0e88ad4546973c5df5253204b8c6edac9eff8fea466baed6ef5"

URI_x86_64_v2_rocm-llvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm}"
SRC_URI[x86_64_v2_rocm-llvm.sha256sum] = "83d8297b90c3fdb4084365022dc9032a365587adfe8c9d4f17e2fe69c581e029"

URI_x86_64_v2_rocm-llvm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-devel-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-devel}"
SRC_URI[x86_64_v2_rocm-llvm-devel.sha256sum] = "ee2fd859ea578583dbd3751b48bce97af99c4e0f7e9c5757bc2ce7cf0d3847b2"

URI_x86_64_v2_rocm-llvm-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-filesystem-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-filesystem}"
SRC_URI[x86_64_v2_rocm-llvm-filesystem.sha256sum] = "dec150c06368dada87a2cc059ff309313531b93879fae7a3f8f433fa3f3db3fe"

URI_x86_64_v2_rocm-llvm-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-libs-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-libs}"
SRC_URI[x86_64_v2_rocm-llvm-libs.sha256sum] = "16e3c65f8f6b67de76f461d95e19175e22be825c5234ec15eaa25d3e32c23d1d"

URI_x86_64_v2_rocm-llvm-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-static-20-12.rocm7.1.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-static}"
SRC_URI[x86_64_v2_rocm-llvm-static.sha256sum] = "4ddafdef11ab2624c79a14575c5edeaf28c5b78a9e64184b4db64f10793e430f"

RDEPENDS:hipcc = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-device-libs \
 "
RDEPENDS:rocm-clang = " \
 git \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 rocm-clang-libs \
 rocm-clang-runtime-devel \
 rocm-libc++-devel \
 rocm-llvm-libs \
 "
RDEPENDS:rocm-clang-analyzer = " \
 perl-File-Copy \
 perl-File-Find \
 perl-FindBin \
 perl-Hash-Util \
 perl-Sys-Hostname \
 perl-interpreter \
 python3 \
 rocm-clang \
 "
RDEPENDS:rocm-clang-devel = " \
 rocm-clang \
 rocm-clang-libs \
 "
RDEPENDS:rocm-clang-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-llvm-libs \
 "
RDEPENDS:rocm-clang-runtime-devel = " \
 "
RDEPENDS:rocm-clang-tools-extra = " \
 python3 \
 rocm-clang-libs \
 "
RDEPENDS:rocm-clang-tools-extra-devel = " \
 rocm-clang-tools-extra \
 "
RDEPENDS:rocm-comgr = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:rocm-comgr-devel = " \
 cmake-filesystem \
 rocm-comgr \
 rocm-device-libs \
 "
RDEPENDS:rocm-compilersupport-macros = " \
 "
RDEPENDS:rocm-device-libs = " \
 cmake-filesystem \
 rocm-clang-devel \
 rocm-lld \
 rocm-llvm-static \
 "
RDEPENDS:rocm-libc++ = " \
 glibc \
 libgcc \
 rocm-llvm-filesystem \
 "
RDEPENDS:rocm-libc++-devel = " \
 rocm-libc++ \
 "
RDEPENDS:rocm-libc++-static = " \
 rocm-libc++-devel \
 "
RDEPENDS:rocm-lld = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 rocm-llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:rocm-llvm = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 python3 \
 rocm-llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:rocm-llvm-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-llvm \
 rocm-llvm-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:rocm-llvm-filesystem = " \
 "
RDEPENDS:rocm-llvm-libs = " \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 libzstd \
 rocm-libc++ \
 rocm-llvm-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:rocm-llvm-static = " \
 rocm-llvm-devel \
 "
