# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-25-openjdk"
PE = "1"
PV = "25.0.3.0.9"
PR = "1.el10.alma.1"
PACKAGES = " \
 java-25-openjdk \
 java-25-openjdk-crypto-adapter \
 java-25-openjdk-crypto-adapter-fastdebug \
 java-25-openjdk-crypto-adapter-slowdebug \
 java-25-openjdk-demo \
 java-25-openjdk-demo-fastdebug \
 java-25-openjdk-demo-slowdebug \
 java-25-openjdk-devel \
 java-25-openjdk-devel-fastdebug \
 java-25-openjdk-devel-slowdebug \
 java-25-openjdk-fastdebug \
 java-25-openjdk-headless \
 java-25-openjdk-headless-fastdebug \
 java-25-openjdk-headless-slowdebug \
 java-25-openjdk-javadoc \
 java-25-openjdk-javadoc-zip \
 java-25-openjdk-jmods \
 java-25-openjdk-jmods-fastdebug \
 java-25-openjdk-jmods-slowdebug \
 java-25-openjdk-slowdebug \
 java-25-openjdk-src \
 java-25-openjdk-src-fastdebug \
 java-25-openjdk-src-slowdebug \
 java-25-openjdk-static-libs \
 java-25-openjdk-static-libs-fastdebug \
 java-25-openjdk-static-libs-slowdebug \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/java-25-openjdk-25.0.3.0.9-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65e910f474a976411b6ec0260a1f43b02c1f3c0f0744b923ab62e53103ed294a"

URI_x86_64_v2_java-25-openjdk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk}"
SRC_URI[x86_64_v2_java-25-openjdk.sha256sum] = "0b8c08901631806613e6d74638e8e0e7250d44162c94d9168a300cf80f21bd7c"

URI_x86_64_v2_java-25-openjdk-crypto-adapter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-crypto-adapter}"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter.sha256sum] = "e19ffede3f6119c8eeecdcb072e2754f909170fbf30da92bc7ad59bc2230c907"

URI_x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-fastdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug.sha256sum] = "761175d9d1a036bc6fc0c941a6eee7ade6eecd4b57e273e08f7cc6a1245ad122"

URI_x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-slowdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug.sha256sum] = "08af5a33f3d88e2a97a809cb59b1cdcc0cd3a1d8d6f02b96927801be391c2779"

URI_x86_64_v2_java-25-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-demo-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-demo}"
SRC_URI[x86_64_v2_java-25-openjdk-demo.sha256sum] = "f4c26a83bd414b40c90365c300eedd64b22c3de3e7caaf442f42b0c1356eb1a0"

URI_x86_64_v2_java-25-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-demo-fastdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-demo-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-demo-fastdebug.sha256sum] = "cca15f94dd6a67c722c9c5508cd9f196fc75c4725e29a3a840a35cf20c3577d7"

URI_x86_64_v2_java-25-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-demo-slowdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-demo-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-demo-slowdebug.sha256sum] = "1b87a5ea038b2deb521494a7d11eedf9fc540fef3075dc27429c4d58cfd19233"

URI_x86_64_v2_java-25-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-devel-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-devel}"
SRC_URI[x86_64_v2_java-25-openjdk-devel.sha256sum] = "6c816d6515982d92a697198193532ac4aa78ec90536c264d2fcaa4b7189cc4ef"

URI_x86_64_v2_java-25-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-devel-fastdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-devel-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-devel-fastdebug.sha256sum] = "a9243c680d0569eda56d1ff2e4f4a53179a498f48eacb5634711b0b6b54d690d"

URI_x86_64_v2_java-25-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-devel-slowdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-devel-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-devel-slowdebug.sha256sum] = "27f4458eec0c133a0dbae31ba5664ea8fc66a78afb8b185ff5a42e9ee1e2830c"

URI_x86_64_v2_java-25-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-fastdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-fastdebug.sha256sum] = "6ddbd06bb2504a8ac207bd077704a3950c8f34035f3b246a5c61a622a51ae3f9"

URI_x86_64_v2_java-25-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-headless-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-headless}"
SRC_URI[x86_64_v2_java-25-openjdk-headless.sha256sum] = "9c65a4e57490080a3591fe2cbdc513c9c0173e3400d975458d336b1d57f02b12"
RPROVIDES:java-25-openjdk-headless:x86_64_v2 = "virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

URI_x86_64_v2_java-25-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-headless-fastdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-headless-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-headless-fastdebug.sha256sum] = "08eea0dc9b4516c4714810f2b2db44ccd7dfa4381ad84cd86b825ebc554af34b"

URI_x86_64_v2_java-25-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-headless-slowdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-headless-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-headless-slowdebug.sha256sum] = "49e098ee026e868e9fa14996ab125fc8875a9563aaec7981587c7edd8c6443a7"

URI_x86_64_v2_java-25-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-javadoc-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-javadoc}"
SRC_URI[x86_64_v2_java-25-openjdk-javadoc.sha256sum] = "007df074111aef40424d0341d519fd990be1964fa8568f932a793f4a85bb8250"

URI_x86_64_v2_java-25-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-javadoc-zip-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-javadoc-zip}"
SRC_URI[x86_64_v2_java-25-openjdk-javadoc-zip.sha256sum] = "adbd085da9be8086edfecea650f7866ffa4e06b61a3b8d54679a9099a03bba9a"

URI_x86_64_v2_java-25-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-jmods-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-jmods}"
SRC_URI[x86_64_v2_java-25-openjdk-jmods.sha256sum] = "9f8460b18829d7d1880412c26560321b7362cdf78b98b8b377908e29a96a145c"

URI_x86_64_v2_java-25-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-jmods-fastdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-jmods-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-jmods-fastdebug.sha256sum] = "8f35b470c6ddc622cc3f28e46512bc071a59eddbc2be6766f7c12bf8d2af9ab4"

URI_x86_64_v2_java-25-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-jmods-slowdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-jmods-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-jmods-slowdebug.sha256sum] = "ff9e4bd3856b1a457f8e6c8c6de0f9faf36816ef3235946000bda7339094ece2"

URI_x86_64_v2_java-25-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-slowdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-slowdebug.sha256sum] = "693da4306b251204c496d209bbed33dee0f5ae6b6ec0eb7fa89beda0d1d97d19"

URI_x86_64_v2_java-25-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-src-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-src}"
SRC_URI[x86_64_v2_java-25-openjdk-src.sha256sum] = "069a971222bf6b200399deff594a88758a2ea3e20215b55232710e928cd8745c"

URI_x86_64_v2_java-25-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-src-fastdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-src-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-src-fastdebug.sha256sum] = "92ea675080b94dfe4ad65e2489cd0e2422de00e8fe49fe0af3a51a14d96b7706"

URI_x86_64_v2_java-25-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-src-slowdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-src-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-src-slowdebug.sha256sum] = "f922fae8b02390a2fe5e7880a1693fdc666da6b4eaf3366c384beb48cdeaf4fb"

URI_x86_64_v2_java-25-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-static-libs-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-static-libs}"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs.sha256sum] = "ede11b6e352ed76907b893508f8ec534e622323e3a7aa57dc7b2f208863b226d"

URI_x86_64_v2_java-25-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-static-libs-fastdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs-fastdebug.sha256sum] = "d1f4b23f2ee323b66a0f788c9985f5a2344d2110263cbebea569def8086d97b3"

URI_x86_64_v2_java-25-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-static-libs-slowdebug-25.0.3.0.9-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-25-openjdk-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs-slowdebug.sha256sum] = "06271c8a1799fcdfe4387f0759216891a6eb14519c3981b8e695d247925681ed"

URI_aarch64_java-25-openjdk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk}"
SRC_URI[aarch64_java-25-openjdk.sha256sum] = "92fe6f74c2b6b45d10dc3a802d1327bbfc405b7e0d937c052e0bb14bef0e1198"

URI_aarch64_java-25-openjdk-crypto-adapter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-crypto-adapter-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-crypto-adapter}"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter.sha256sum] = "bc84b26818ba736161acdf2751e4dc64f54a97ee98dc32ff56fa53ad09b761f0"

URI_aarch64_java-25-openjdk-crypto-adapter-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-crypto-adapter-fastdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-crypto-adapter-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter-fastdebug.sha256sum] = "656440e2c1043d0f7fec1e7806ad83cd0031ba52a8926c81e25c705e1c041c6b"

URI_aarch64_java-25-openjdk-crypto-adapter-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-crypto-adapter-slowdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-crypto-adapter-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter-slowdebug.sha256sum] = "6bd5f97d566afc5202ec4644c358a8257502896ff67fee853be9f744769d710c"

URI_aarch64_java-25-openjdk-demo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-demo-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-demo}"
SRC_URI[aarch64_java-25-openjdk-demo.sha256sum] = "e5656b1971d4f4dfb247d97d1bfce52eca5301a7e54c71a0b0ccb43104417f02"

URI_aarch64_java-25-openjdk-demo-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-demo-fastdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-demo-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-demo-fastdebug.sha256sum] = "4301f89c2d8a0d62d5bf4452a7d9cc871089e914c2798f5f08213d21938c5aa3"

URI_aarch64_java-25-openjdk-demo-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-demo-slowdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-demo-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-demo-slowdebug.sha256sum] = "59830b3c2b30e13228be144c46b9313bcd3011b7cb0493a38a968cf77d00f7ef"

URI_aarch64_java-25-openjdk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-devel-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-devel}"
SRC_URI[aarch64_java-25-openjdk-devel.sha256sum] = "89f9edc17456d47dc08074a1aa08e8fa0a4fb6708053c7eca419e417b1643c32"

URI_aarch64_java-25-openjdk-devel-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-devel-fastdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-devel-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-devel-fastdebug.sha256sum] = "2f9db6b5e76958760502d96bf9dc68d227d38e6f00bfa5609a297feef8985d02"

URI_aarch64_java-25-openjdk-devel-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-devel-slowdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-devel-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-devel-slowdebug.sha256sum] = "193dcbab7bb2d8c44aa733060d43f32b281e5a177bf4b462acf16b6b757fedc0"

URI_aarch64_java-25-openjdk-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-fastdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-fastdebug.sha256sum] = "b2519bab98d338c639b5390eb76d7d3629c351e6b39c35ed787c596a38ec8dfb"

URI_aarch64_java-25-openjdk-headless = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-headless-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-headless}"
SRC_URI[aarch64_java-25-openjdk-headless.sha256sum] = "e098022490d4846ca423a265d2af788f214a5ee957c3f8c2d8ee0513fef5b170"
RPROVIDES:java-25-openjdk-headless:aarch64 = "virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

URI_aarch64_java-25-openjdk-headless-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-headless-fastdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-headless-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-headless-fastdebug.sha256sum] = "df764fb57a28d105052330424ede89ce3f55735f6bce48151275aaf6139ba2ad"

URI_aarch64_java-25-openjdk-headless-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-headless-slowdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-headless-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-headless-slowdebug.sha256sum] = "2730bb28f88f34180585c834adb1c9b80f79f11c155087fc6c0c8f132a8fde13"

URI_aarch64_java-25-openjdk-javadoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-javadoc-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-javadoc}"
SRC_URI[aarch64_java-25-openjdk-javadoc.sha256sum] = "007122621dfb89bf8cb6123da1b861f91608405863933cadc31bd25bc54d46e4"

URI_aarch64_java-25-openjdk-javadoc-zip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-javadoc-zip-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-javadoc-zip}"
SRC_URI[aarch64_java-25-openjdk-javadoc-zip.sha256sum] = "0b2144b5cb649bcd494c0c5e85038d9cecfdc779e737519eafa7f48a69d1a811"

URI_aarch64_java-25-openjdk-jmods = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-jmods-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-jmods}"
SRC_URI[aarch64_java-25-openjdk-jmods.sha256sum] = "596064a260b15a14dc35aa11fabf8d6526d56b698410fff4103e4c469f5d748e"

URI_aarch64_java-25-openjdk-jmods-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-jmods-fastdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-jmods-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-jmods-fastdebug.sha256sum] = "5cc4b1d3513844f2bbcc1b9cfcbadb55c668bee8ac0a9b8306e6576cdb7f7dcd"

URI_aarch64_java-25-openjdk-jmods-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-jmods-slowdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-jmods-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-jmods-slowdebug.sha256sum] = "74b876cc456886983d4f69e50fa56d074ad817a0ec2c37118bf5c28542564895"

URI_aarch64_java-25-openjdk-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-slowdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-slowdebug.sha256sum] = "deb86581061d4a5a9ed16c7ad9f7325e8d555f2bf6c30af6355c7654c708b43b"

URI_aarch64_java-25-openjdk-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-src-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-src}"
SRC_URI[aarch64_java-25-openjdk-src.sha256sum] = "6d68d63ade818b0613d9b27152aef3868f0ee6e9589e0d2d5c6426cb8305e1e4"

URI_aarch64_java-25-openjdk-src-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-src-fastdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-src-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-src-fastdebug.sha256sum] = "d18266b9f0610641e86cb025ce1141b91cd7f6ccc9462316fb3d2c735469f067"

URI_aarch64_java-25-openjdk-src-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-src-slowdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-src-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-src-slowdebug.sha256sum] = "bbe3d56bc6446cf832fabb497f95f4d72ea1b386f8433571689d959728f4e8cc"

URI_aarch64_java-25-openjdk-static-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-static-libs-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-static-libs}"
SRC_URI[aarch64_java-25-openjdk-static-libs.sha256sum] = "4f3eefdb12df37e86b581d4d9efc8abe721c9e6fe1ebf1a438f8d3878b1c717b"

URI_aarch64_java-25-openjdk-static-libs-fastdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-static-libs-fastdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-static-libs-fastdebug}"
SRC_URI[aarch64_java-25-openjdk-static-libs-fastdebug.sha256sum] = "b7a97c640fca922301b320ac84c695f02c2b3fb9bab1661c56eb5e995e571ba3"

URI_aarch64_java-25-openjdk-static-libs-slowdebug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-static-libs-slowdebug-25.0.3.0.9-1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-25-openjdk-static-libs-slowdebug}"
SRC_URI[aarch64_java-25-openjdk-static-libs-slowdebug.sha256sum] = "12875e4d0c75d273675caf47eca04714804272d7ca2ffb643dff2c36386f9dbc"

RDEPENDS:java-25-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-crypto-adapter = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-crypto-adapter-fastdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-crypto-adapter-slowdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-demo = " \
 java-25-openjdk \
 "
RDEPENDS:java-25-openjdk-demo-fastdebug = " \
 java-25-openjdk-fastdebug \
 "
RDEPENDS:java-25-openjdk-demo-slowdebug = " \
 java-25-openjdk-slowdebug \
 "
RDEPENDS:java-25-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk \
 "
RDEPENDS:java-25-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk-fastdebug \
 "
RDEPENDS:java-25-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk-slowdebug \
 "
RDEPENDS:java-25-openjdk-fastdebug = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless-fastdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-headless-fastdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter-fastdebug \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-headless-slowdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter-slowdebug \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-javadoc = " \
 alternatives \
 bash \
 java-25-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-25-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 java-25-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-25-openjdk-jmods = " \
 java-25-openjdk-devel \
 "
RDEPENDS:java-25-openjdk-jmods-fastdebug = " \
 java-25-openjdk-devel-fastdebug \
 "
RDEPENDS:java-25-openjdk-jmods-slowdebug = " \
 java-25-openjdk-devel-slowdebug \
 "
RDEPENDS:java-25-openjdk-slowdebug = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless-slowdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-src = " \
 java-25-openjdk-headless \
 "
RDEPENDS:java-25-openjdk-src-fastdebug = " \
 java-25-openjdk-headless-fastdebug \
 "
RDEPENDS:java-25-openjdk-src-slowdebug = " \
 java-25-openjdk-headless-slowdebug \
 "
RDEPENDS:java-25-openjdk-static-libs = " \
 java-25-openjdk-devel \
 "
RDEPENDS:java-25-openjdk-static-libs-fastdebug = " \
 java-25-openjdk-devel-fastdebug \
 "
RDEPENDS:java-25-openjdk-static-libs-slowdebug = " \
 java-25-openjdk-devel-slowdebug \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless rpm/virtual/java-headless_or_java-25-headless"

PROVIDES:append:aarch64 = " rpm/virtual/java-headless_or_java-21-headless_or_java-25-headless rpm/virtual/java-headless_or_java-25-headless"
