# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kryoptic"
PV = "1.5.0"
PR = "3.el10_2"
PACKAGES = " \
 kryoptic \
 kryoptic-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kryoptic-1.5.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fe40a851d5ada1bb3d20ee53e3b1b4c5fb0c06f1444dc3b6e480274164ac776"

URI_x86_64_v2_kryoptic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kryoptic-1.5.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kryoptic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kryoptic}"
SRC_URI[x86_64_v2_kryoptic.sha256sum] = "c5af9ea22eb3418c146ccf86871219fa031084adbe7a2f06b5dd921be4cbd374"

URI_x86_64_v2_kryoptic-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kryoptic-tools-1.5.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kryoptic-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kryoptic-tools}"
SRC_URI[x86_64_v2_kryoptic-tools.sha256sum] = "a4c22e808d831963a73df781ab63ad2952ca24457b2d4615484042d0ef5940ca"

URI_aarch64_kryoptic = "${EPEL_MIRROR}/aarch64/Packages/k/kryoptic-1.5.0-3.el10_2.aarch64.rpm;name=aarch64_kryoptic;unpack=0"
SRC_URI:append = " ${URI_aarch64_kryoptic}"
SRC_URI[aarch64_kryoptic.sha256sum] = "90c72712d17f751ee61ccbf1f4ebd4e76382b1153703d68f093a0bf6f9f4d2c1"

URI_aarch64_kryoptic-tools = "${EPEL_MIRROR}/aarch64/Packages/k/kryoptic-tools-1.5.0-3.el10_2.aarch64.rpm;name=aarch64_kryoptic-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kryoptic-tools}"
SRC_URI[aarch64_kryoptic-tools.sha256sum] = "fd0caa712d76f8df250765c1d1d967d49e6311d930cc726f7d97251bbe3cd7b4"

RDEPENDS:kryoptic = " \
 glibc \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
RDEPENDS:kryoptic-tools = " \
 glibc \
 kryoptic \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
