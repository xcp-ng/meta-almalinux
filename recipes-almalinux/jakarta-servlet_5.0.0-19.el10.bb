# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jakarta-servlet"
PV = "5.0.0"
PR = "19.el10"
PACKAGES = " \
 jakarta-servlet \
 jakarta-servlet-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/jakarta-servlet-5.0.0-19.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "204195b28303cee1ac51070f166d9fe78429b4aa714bba1764a8c5b761f4fdb8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jakarta-servlet-5.0.0-19.el10.noarch.rpm;name=x86_64_v2_jakarta-servlet;unpack=0"
SRC_URI[x86_64_v2_jakarta-servlet.sha256sum] = "ac30effe0d8047a7a59bc71f4be49a615affb432b63c2a01a6e42b02af3d4413"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jakarta-servlet-javadoc-5.0.0-19.el10.noarch.rpm;name=x86_64_v2_jakarta-servlet-javadoc;unpack=0"
SRC_URI[x86_64_v2_jakarta-servlet-javadoc.sha256sum] = "8d40740314a1c9239a2cf4bdbdd418bea56d247dee8c694a5ae8a1999ec33410"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jakarta-servlet-5.0.0-19.el10.noarch.rpm;name=aarch64_jakarta-servlet;unpack=0"
SRC_URI[aarch64_jakarta-servlet.sha256sum] = "ac30effe0d8047a7a59bc71f4be49a615affb432b63c2a01a6e42b02af3d4413"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jakarta-servlet-javadoc-5.0.0-19.el10.noarch.rpm;name=aarch64_jakarta-servlet-javadoc;unpack=0"
SRC_URI[aarch64_jakarta-servlet-javadoc.sha256sum] = "8d40740314a1c9239a2cf4bdbdd418bea56d247dee8c694a5ae8a1999ec33410"

RDEPENDS:jakarta-servlet = " \
 javapackages-filesystem \
 "
RDEPENDS:jakarta-servlet-javadoc = " \
 javapackages-filesystem \
 "
