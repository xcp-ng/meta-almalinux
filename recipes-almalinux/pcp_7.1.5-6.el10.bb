# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcp"
PV = "7.1.5"
PR = "6.el10"
PACKAGES:x86_64_v2 = " \
 pcp \
 pcp-conf \
 pcp-devel \
 pcp-doc \
 pcp-export-pcp2elasticsearch \
 pcp-export-pcp2graphite \
 pcp-export-pcp2influxdb \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2opentelemetry \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-export-zabbix-agent \
 pcp-geolocate \
 pcp-gui \
 pcp-import-benchmarks \
 pcp-import-collectl2pcp \
 pcp-import-ganglia2pcp \
 pcp-import-iostat2pcp \
 pcp-import-mrtg2pcp \
 pcp-import-pmseries \
 pcp-import-sar2pcp \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cifs \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-hdb \
 pcp-pmda-infiniband \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mssql \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-opentelemetry \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-perfevent \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-redis \
 pcp-pmda-resctrl \
 pcp-pmda-rocestat \
 pcp-pmda-roomtemp \
 pcp-pmda-rsyslog \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-systemd \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-selinux \
 pcp-system-tools \
 pcp-testsuite \
 pcp-zeroconf \
 perl-PCP-LogImport \
 perl-PCP-LogSummary \
 perl-PCP-MMV \
 perl-PCP-PMDA \
 python3-pcp \
"
PACKAGES:aarch64 = " \
 pcp \
 pcp-conf \
 pcp-devel \
 pcp-doc \
 pcp-export-pcp2elasticsearch \
 pcp-export-pcp2graphite \
 pcp-export-pcp2influxdb \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2opentelemetry \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-export-zabbix-agent \
 pcp-geolocate \
 pcp-gui \
 pcp-import-benchmarks \
 pcp-import-collectl2pcp \
 pcp-import-ganglia2pcp \
 pcp-import-iostat2pcp \
 pcp-import-mrtg2pcp \
 pcp-import-pmseries \
 pcp-import-sar2pcp \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cifs \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-hdb \
 pcp-pmda-infiniband \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-opentelemetry \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-perfevent \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-redis \
 pcp-pmda-rocestat \
 pcp-pmda-roomtemp \
 pcp-pmda-rsyslog \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-systemd \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-selinux \
 pcp-system-tools \
 pcp-testsuite \
 pcp-zeroconf \
 perl-PCP-LogImport \
 perl-PCP-LogSummary \
 perl-PCP-MMV \
 perl-PCP-PMDA \
 python3-pcp \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pcp-7.1.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8fc17e646fd95d62746bb33d46ae1cf2c295a88018c9349610560c479bac6701"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp;unpack=0"
SRC_URI[x86_64_v2_pcp.sha256sum] = "614b7152c743c4fb269c9b64a991a5f4dba4e3a881190e8b885e1e1e780624b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-conf-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-conf;unpack=0"
SRC_URI[x86_64_v2_pcp-conf.sha256sum] = "c19c833dbe44e66a6c89212741c22e36765db66b1f2f99adf6aaa8d44d99861f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-devel-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-devel;unpack=0"
SRC_URI[x86_64_v2_pcp-devel.sha256sum] = "7138d51f7db84ade2f457a6e9685f3cc4e3931b8fe3ed18bf7b5d27280b08521"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-doc-7.1.5-6.el10.noarch.rpm;name=x86_64_v2_pcp-doc;unpack=0"
SRC_URI[x86_64_v2_pcp-doc.sha256sum] = "b3e38479584547f7299c956a30eee2306e1b623ac76f005d23337f349f8f9915"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2elasticsearch-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI[x86_64_v2_pcp-export-pcp2elasticsearch.sha256sum] = "aea8fc72728291e3f36212eeb409336e7ba3506964c62c6ce4fa3ba6bb9af64a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2graphite-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2graphite;unpack=0"
SRC_URI[x86_64_v2_pcp-export-pcp2graphite.sha256sum] = "7f92ee969f220a26f21777fec3e9ff8e7202a528dc8322e6bca3833c16efc895"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2influxdb-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2influxdb;unpack=0"
SRC_URI[x86_64_v2_pcp-export-pcp2influxdb.sha256sum] = "9d1a313fcca56680783098ad0f45d91b76c4feb22018f0e6ac82d166ff451c94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2json-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2json;unpack=0"
SRC_URI[x86_64_v2_pcp-export-pcp2json.sha256sum] = "f80aec79ca186611d232b7ecab517688c26c1a648231f75f77a964e1763f1c92"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2openmetrics-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2openmetrics;unpack=0"
SRC_URI[x86_64_v2_pcp-export-pcp2openmetrics.sha256sum] = "88f7716bb404ba680407ec8fb10a7a579c94f8f18b425f25839e091e6a9db1d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2opentelemetry-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2opentelemetry;unpack=0"
SRC_URI[x86_64_v2_pcp-export-pcp2opentelemetry.sha256sum] = "081578f8581b0461e12cefc00f02816b7a9479936e2e033a6d108ab31ab19db1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2spark-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2spark;unpack=0"
SRC_URI[x86_64_v2_pcp-export-pcp2spark.sha256sum] = "eb1c118faea2852fb145ebcf3a0c292a1675f9aa3c77a2df86327287a9551865"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2xml-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2xml;unpack=0"
SRC_URI[x86_64_v2_pcp-export-pcp2xml.sha256sum] = "44a687ebe8c468aaccbcd3e3e5888cc4c20554a54c9a5d8c82d6113dfec128c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2zabbix-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2zabbix;unpack=0"
SRC_URI[x86_64_v2_pcp-export-pcp2zabbix.sha256sum] = "deb32a9ba10ba697c40916740b8fc225e0cad15b59c6c359a4f7864487c6af65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-zabbix-agent-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-export-zabbix-agent;unpack=0"
SRC_URI[x86_64_v2_pcp-export-zabbix-agent.sha256sum] = "8fafce7848d83024b614e568711e251dad490ad9e219d824f2960b90ac20dc34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-geolocate-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-geolocate;unpack=0"
SRC_URI[x86_64_v2_pcp-geolocate.sha256sum] = "f48dc0f3ddf4237662028908dec3fd015c4e728d5e000bb3bb33166829db8e6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-gui-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-gui;unpack=0"
SRC_URI[x86_64_v2_pcp-gui.sha256sum] = "7c3e040108bce795702ae306305a8fc564b4b6ace3096262b21a066b11f55953"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-benchmarks-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-benchmarks;unpack=0"
SRC_URI[x86_64_v2_pcp-import-benchmarks.sha256sum] = "a968bcbc42c5cc1f6301089f2cbcc972a181c6c80a64981efae5e25b93f46d43"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-collectl2pcp-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-collectl2pcp;unpack=0"
SRC_URI[x86_64_v2_pcp-import-collectl2pcp.sha256sum] = "055dfe9bd39a31007345a41854f473ff895ffc6cfb496545ec643533047f9b54"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-ganglia2pcp-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-ganglia2pcp;unpack=0"
SRC_URI[x86_64_v2_pcp-import-ganglia2pcp.sha256sum] = "80dda57da7aba79092765492d90e4244360677d42804bd675310ac47255c86a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-iostat2pcp-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-iostat2pcp;unpack=0"
SRC_URI[x86_64_v2_pcp-import-iostat2pcp.sha256sum] = "a18c77bdb6c38c74cd4e5007ef9c167ec843d2b101b8f64a47ed9fcb9ee8d9ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-mrtg2pcp-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-mrtg2pcp;unpack=0"
SRC_URI[x86_64_v2_pcp-import-mrtg2pcp.sha256sum] = "ba1defaf35541f9529b517a4c15fc5804be6f6862ca488327d35ecee5bd20c5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-pmseries-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-pmseries;unpack=0"
SRC_URI[x86_64_v2_pcp-import-pmseries.sha256sum] = "5581bf360bdc9f745a0e04de8c929c8ac36ab041fafe3e7b66b42eaf2be625ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-sar2pcp-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-import-sar2pcp;unpack=0"
SRC_URI[x86_64_v2_pcp-import-sar2pcp.sha256sum] = "aacf2c6b01b67f77db5c257fd157ff913ce2b2857312b0310934d2ce80d0414e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-libs-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-libs;unpack=0"
SRC_URI[x86_64_v2_pcp-libs.sha256sum] = "a15d2436fffacf56e7864ae4981a3ed0e2319b581f6b6f985be6c396911e2ba1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-libs-devel-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-libs-devel;unpack=0"
SRC_URI[x86_64_v2_pcp-libs-devel.sha256sum] = "e820543061e1c9310c2454006be7d5892c4adef76746f0afe62ffcbdadac54d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-activemq-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-activemq;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-activemq.sha256sum] = "e3a2ab1bf42d7bf83bd01f388c6075a0486d8932d64adf8f4b0c2af1b393667c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-amdgpu-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-amdgpu;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-amdgpu.sha256sum] = "b3bbdccc4ee35925ae165ee9d946f55cf01a23f7574fccb44c859110576e7842"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-apache-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-apache;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-apache.sha256sum] = "d8b947c5def2e0951cd9d8429927f6b41216aeb7a3f7f5f47051605750f909c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bash-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bash;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-bash.sha256sum] = "3e5571c7d5b7d4d23c3dfabddf47380ab8eccf04f67332502fd58cccf6efa43c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bind2-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bind2;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-bind2.sha256sum] = "2d7271bce17ff95189db6abd5fb65a7f456a34c2218e0b9402a9f42a7d7aea90"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bonding-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bonding;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-bonding.sha256sum] = "64950a9f697d44b539964c81fdbdc6e2dd815af53265651109a906015efa6fd0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpf-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bpf;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-bpf.sha256sum] = "02125007a76546bb0e189854f9e4931aec3c8082dba1ad4d316f632f28bbcd74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpftrace-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bpftrace;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-bpftrace.sha256sum] = "0549b1b233df891717737f7088ca54ae9b6c772b6cbb465e8850ccc0220f0c94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-cifs-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-cifs;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-cifs.sha256sum] = "83105feb8fc5f46eada32aad1f31066480b930e1c8bcfb3dd92efc2543edb8b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-cisco-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-cisco;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-cisco.sha256sum] = "09afef0accfd84cb97cb5dc0a55ab2a625642bd34576eac7d7674ee19ab33509"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-dbping-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-dbping;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-dbping.sha256sum] = "9e6ec93ebf583a2384a1e0042f3b354f371c9e4049f0ecf15664f81c7add1365"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-denki-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-denki;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-denki.sha256sum] = "4e071eb2289d1fbe613cec6bf84f48bda1912b70f8b02f41b96c72b7263e8004"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-dm-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-dm;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-dm.sha256sum] = "bb2d7681c00a85c8cd9219ab096a708b607b9f62bdecc679f76db70facea28d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-docker-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-docker;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-docker.sha256sum] = "a4746cc39d5eb436e689b47f49b77bc6ab5c114a09bebd037a480d6d9f47248a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-ds389;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-ds389.sha256sum] = "5b7967e06f7ebf1e6c5cba257ca6fc7b4986734c36215cb032691568fc231c55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389log-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-ds389log;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-ds389log.sha256sum] = "6aa8a953a2524cf0fb96ee4ce184ca81078398aecd9b58206788bbf775101849"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-elasticsearch-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-elasticsearch;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-elasticsearch.sha256sum] = "62be0e814bf5d843a4bd4a6f46daa35cb461c68c63c05d3b168382e45a8d7111"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-farm-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-farm;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-farm.sha256sum] = "25f639aa5661f04911eed2fdf31d81fe4eafa75c069e6a59dc23e7ec3531640d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gluster-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gluster;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-gluster.sha256sum] = "32592fe2f0903945ce04f11ca8876669385f976e0f95880c2e04cf6365ce28c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpfs-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gpfs;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-gpfs.sha256sum] = "925b3f793be42bbfe9d50d1d905cd7f4bb71169d09f8a41341d8d6893463228a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpsd-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gpsd;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-gpsd.sha256sum] = "e443aafa311ea87f66acb0dfdb5bbdeaa1f89150261f9ef179e113a9b446d86b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-hacluster-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-hacluster;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-hacluster.sha256sum] = "c12ec8815a17dd3cc02a1e96c74d060cb7157a29efc183e18442cc085da3c751"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-haproxy-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-haproxy;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-haproxy.sha256sum] = "652ba1517e0c5c3f685b77f3dd92cbd3fb9f59aca4a8e2001c6ac85103bc8a20"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-hdb-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-hdb;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-hdb.sha256sum] = "8ceb289cdfc3869e8fcce7f7494b013f9bc79f8499a19ff8a9abd6d34ffd8451"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-infiniband-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-infiniband;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-infiniband.sha256sum] = "c94cb96d896572c7a5d16781c7204d49f22c714b62338b23ff963519ed5e5942"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-libvirt-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-libvirt;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-libvirt.sha256sum] = "6c62086d9a5886d47905e322f765b417efda6bd795a800aeadc25cc34a648639"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lio-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lio;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-lio.sha256sum] = "f3f8cb821c879beac037923b29c1962c3196957193bb4c71385b9805d638d49e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lmsensors-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lmsensors;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-lmsensors.sha256sum] = "488318eb1ef2403b547995c6b551e997fea29d594fe49c83a78dbbac25e05750"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-logger-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-logger;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-logger.sha256sum] = "900d8a927671bea53420031f31d0cccee598ce85d3626b720763e915aa8c090b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustre-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lustre;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-lustre.sha256sum] = "a872b22cb69c6d66afc942cc0ac5dc1bed466cf2e664c272c5a98ccbbd8eb9d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustrecomm-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lustrecomm;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-lustrecomm.sha256sum] = "271871cde9bd3e78294333809e8cbbebc81b8882bf113c1d86f70fe203ca6628"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mailq-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mailq;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-mailq.sha256sum] = "ce9b7c921f674a478c0bdc161fcf8689a0abb9d475d17bb635f422b2adf0e26b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-memcache-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-memcache;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-memcache.sha256sum] = "60ca3d5f5842a8625b1dcb45d4aeb6de3bf186dd47e3fd0fc55d4f2f6deffe20"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mic-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mic;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-mic.sha256sum] = "f71b953911920e00cb6de4e5ac956e2fbb625e562798383c4b0b7786bcb69833"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mongodb-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mongodb;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-mongodb.sha256sum] = "d8f9ad88b709de5884f1e5553af3b3c2e68752583c401278df2de62111c7d027"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mounts-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mounts;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-mounts.sha256sum] = "d497eb0daa72189519288a2a896b47ad848e62b74bfb5c56eb76f898dbaf7b6b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mssql-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mssql;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-mssql.sha256sum] = "d68624de7d43a9145c49b5964cf933476f6c1e1089f23959bb43f0a20d678e20"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mysql-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mysql;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-mysql.sha256sum] = "c6295b18a17a0d70417069e08b3af37dbf27433267750dd87c6ff4239ac0be50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-named-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-named;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-named.sha256sum] = "dea8089b66782ccfe40c70b16f27a21ab00374e369c016720e91bb405c802f21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-netcheck-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-netcheck;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-netcheck.sha256sum] = "4cc57cb5ff5f99b5cc937966eaa10d15f7bd70c7cb8d7f317e5db861c5a94beb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-netfilter-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-netfilter;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-netfilter.sha256sum] = "363952772d63568fda8f72969277cbd6d9d0032269b3cf53241cf70759ca4b8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-news-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-news;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-news.sha256sum] = "c5e948318ee62c77cf1cce3a2e424d7dbc086182ff74bd173422db2aaf96dad5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nfsclient-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nfsclient;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-nfsclient.sha256sum] = "6b80ba8381912f509c140237f0013f8803b022b7fdee12cc61525bc35741d930"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nginx-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nginx;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-nginx.sha256sum] = "dc309a3a446ab7010cf02aef3ba44944005862dc89e219877943535e57613c89"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nvidia-gpu-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-nvidia-gpu.sha256sum] = "2d23f5fc1d2eafa4fbbea02e96f23a9a4cd964bfefe9cd02133892cdfcc51e27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-openmetrics-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-openmetrics;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-openmetrics.sha256sum] = "b6befb98c5d5e3a9489c949f6ff6dd0129035593fd818e50a44f3537af9eb123"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-opentelemetry-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-opentelemetry;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-opentelemetry.sha256sum] = "ea176077dfab0a880a5376fa9dfbf42f1ebdd2a86b00ef57689b898dd39eaa45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-openvswitch-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-openvswitch;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-openvswitch.sha256sum] = "d6a21f0a682398f9a0008ab52145c92e54a3de21c929059fb0150b94fea931f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-oracle-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-oracle;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-oracle.sha256sum] = "3eb9c7412173328d3d734c10bb5224f64bb674d212e36e67bef57af864d95c9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-pdns-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-pdns;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-pdns.sha256sum] = "62a5e22e1db28c3b7d9aa1a317d9076449df3c079d62415270cee39de1b1a14f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-perfevent-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-perfevent;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-perfevent.sha256sum] = "718e1a83da393f1a8055a671e7d52e590e45734966ddc9954bd58eb4abc88b84"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-podman-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-podman;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-podman.sha256sum] = "975bfb71a4841920a06233269a00093269bfb47539841a0efe1dcf9b51b687c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-postfix-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-postfix;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-postfix.sha256sum] = "b93032da91c8d047ae571061d4dd4c395499b5e8a3adb9ae342c96a55452b8d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-postgresql-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-postgresql;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-postgresql.sha256sum] = "5c1bee8f349551cc1545bf27f060a1ce7dfa17b66cfd01df1a091c58432ff267"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rabbitmq-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rabbitmq;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-rabbitmq.sha256sum] = "1fd5f8d848d9ace4840f06a5d0bbb638fb8df7f13d991c727c120257cfb1464f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-redis-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-redis;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-redis.sha256sum] = "794a2a32895ed6bd81f34f28d3beb7a210ef0edf499d8623857bb23674714945"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-resctrl-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-resctrl;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-resctrl.sha256sum] = "8d379e6289da842053c68cbbf2d5178e07edcd44596d1bf187cd1ab68d7c79c3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rocestat-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rocestat;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-rocestat.sha256sum] = "c5f4aeebeb20738b4bb1bacb335d87507272da76a6deffc27506ec302a48c4ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-roomtemp-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-roomtemp;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-roomtemp.sha256sum] = "106870df22753a7152363851b4d359ccb7c35300fc2fc25ac761670ec59ee853"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rsyslog-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rsyslog;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-rsyslog.sha256sum] = "c97bc027eb9163fde67dccff26324526dca29fef5a4cc2cbc3719a5de46c5039"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-samba-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-samba;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-samba.sha256sum] = "4b6cd015329fa684678e7a49b313e5f6ad2c16037720b384c0af472561d34f7c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-sendmail-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-sendmail;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-sendmail.sha256sum] = "c564e18d0bf3ff68eef53d175081919bcb52bdf29d6d489392f6268a5a57fc5f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-shping-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-shping;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-shping.sha256sum] = "f2ad03359adeb0939b6643a7bad68352201f8e0b4ae5bdfac7b37838c8ed383c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-slurm-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-slurm;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-slurm.sha256sum] = "bb325684e4a9957bc5ea82d378f65611e7f903878463c6758d2a35cdd5ec79e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-smart-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-smart;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-smart.sha256sum] = "9823907e3e373d7fda542d59ac210f26feb7e982b0813c81d18520194050a415"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-snmp-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-snmp;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-snmp.sha256sum] = "51d7b8a71b7b914d31676d081737fc10b059dfed9282010bff42b52d90db2a9d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-sockets-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-sockets;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-sockets.sha256sum] = "c2a767410cf908fe774b75810a8c2e78cdd689d2e3a6e45b1e24fc89479f2d11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-statsd-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-statsd;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-statsd.sha256sum] = "c4f8dc0af1bbfafc3b3d14dc59aabd3187b10d4f7810fc8e7d099d2404f82202"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-summary-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-summary;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-summary.sha256sum] = "eff23a4bb8a114f276e6b1ec131b010064943b399af2f876f49d40b5da403459"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-systemd-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-systemd;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-systemd.sha256sum] = "1a81f99c8e56a77cd1306271bb54e0466d044c985450ca1d5a8228efceae9038"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-trace-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-trace;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-trace.sha256sum] = "de6f88699ba8620f08b1d21724a393b327ae0c7e5562f358951ba2d21098ed2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-unbound-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-unbound;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-unbound.sha256sum] = "5c0e72b63a33b3b51770ea91e2dc908643746615a39cd69a900b7e31a78dcf44"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-uwsgi-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-uwsgi;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-uwsgi.sha256sum] = "4ae262e5795941020551dadf51a9f521adb6e5c96d405b3c65085339bbc6ec18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-weblog-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-weblog;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-weblog.sha256sum] = "028319981e1cd34c96c704971c56ef55ee012773662dee20f878f649923a44ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-zimbra-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-zimbra;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-zimbra.sha256sum] = "8f64aa3eb0441c83594becb6bbb921be4319ea722c68f67dd855b574fb7bb20e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-zswap-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-zswap;unpack=0"
SRC_URI[x86_64_v2_pcp-pmda-zswap.sha256sum] = "48086bb8b00f49eefecb74a7ceecdeb9b873e8aa11ebc2c125a86d4a9fa023c3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-selinux-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-selinux;unpack=0"
SRC_URI[x86_64_v2_pcp-selinux.sha256sum] = "16b4a998d4f5ab3757b4ac0468c6256c9e48d90b0985c52c915130264697ea58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-system-tools-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-system-tools;unpack=0"
SRC_URI[x86_64_v2_pcp-system-tools.sha256sum] = "36234d82e1ed198b49962b2117e2775fe4ea6ebb1bf1211a393a660095a3e350"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pcp-testsuite-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-testsuite;unpack=0"
SRC_URI[x86_64_v2_pcp-testsuite.sha256sum] = "cfbccf1522feabd20c4b82a8eda23005c5f672ab6e9d8a2bb45ba054e8cad70a"
RPROVIDES:pcp-testsuite:append:x86_64_v2 = " virtual/perl_Slurm_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-zeroconf-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_pcp-zeroconf;unpack=0"
SRC_URI[x86_64_v2_pcp-zeroconf.sha256sum] = "fb87fd0fe1f4b6b097c4124958018221abf6d74eef38778c62d085475fa02458"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-LogImport-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-LogImport;unpack=0"
SRC_URI[x86_64_v2_perl-PCP-LogImport.sha256sum] = "c68959e2fd0e7b816e2b88b24fb8dbca3cbb3ee2dcc7086adea845c2aca6dd08"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-LogSummary-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-LogSummary;unpack=0"
SRC_URI[x86_64_v2_perl-PCP-LogSummary.sha256sum] = "46d7d18d22feb24dfb44808ad5721630f4cff2c1cc1aa2aea9c90bd0ea9d2cc1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-MMV-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-MMV;unpack=0"
SRC_URI[x86_64_v2_perl-PCP-MMV.sha256sum] = "63c234c518e5f36f4a893ec90ed79dbad1d85e9d66e66f4f88186afd8f98f0e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-PMDA-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-PMDA;unpack=0"
SRC_URI[x86_64_v2_perl-PCP-PMDA.sha256sum] = "10239b3f85700bf1831a4f17e313c1386154213b73a39d1aa464eace59cc3c0c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pcp-7.1.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pcp;unpack=0"
SRC_URI[x86_64_v2_python3-pcp.sha256sum] = "b27934748d8853ebbfd44e6c305837c14ebe8b5a3845fe7f5329b1fdd60ae2db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp;unpack=0"
SRC_URI[aarch64_pcp.sha256sum] = "f9ba41a06622b2eedfa1e04352950852e6eb9d3c08effba29331f1f67e3729da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-conf-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-conf;unpack=0"
SRC_URI[aarch64_pcp-conf.sha256sum] = "83bbbf5cbe04cf722b3cd62a6d43352eb310294fc67716f4f9615f81aa2bd314"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-devel-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-devel;unpack=0"
SRC_URI[aarch64_pcp-devel.sha256sum] = "161f411f17a83d8c6094d63303d7a6300532b58303bb503f43045cdae3e32e33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-doc-7.1.5-6.el10.noarch.rpm;name=aarch64_pcp-doc;unpack=0"
SRC_URI[aarch64_pcp-doc.sha256sum] = "b3e38479584547f7299c956a30eee2306e1b623ac76f005d23337f349f8f9915"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2elasticsearch-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI[aarch64_pcp-export-pcp2elasticsearch.sha256sum] = "cfb5264f1b9ca087582a05a9eca15a1fe9c08adc02ec2529bd7f0a84ed986ccb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2graphite-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2graphite;unpack=0"
SRC_URI[aarch64_pcp-export-pcp2graphite.sha256sum] = "d4e75500f3feee8df0b3404c31128187323d50fd695d677c39ac0fcfc22945e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2influxdb-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2influxdb;unpack=0"
SRC_URI[aarch64_pcp-export-pcp2influxdb.sha256sum] = "5761183c5af59ea348e051de713a3c4b30a241bd3f97c5322bcb7ed4e2a9cf41"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2json-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2json;unpack=0"
SRC_URI[aarch64_pcp-export-pcp2json.sha256sum] = "e8f06064cedf6edb8a56cdc644d9c9e9ac55841b100df1db0805548812e7ddff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2openmetrics-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2openmetrics;unpack=0"
SRC_URI[aarch64_pcp-export-pcp2openmetrics.sha256sum] = "b0e8758eb759e5bbb84b788b497bbeefb1fa3a299e7321889be51d3cef9e7d61"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2opentelemetry-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2opentelemetry;unpack=0"
SRC_URI[aarch64_pcp-export-pcp2opentelemetry.sha256sum] = "7b3614d5c34326f401a5920782ad1defa5943dedb2fe2888a1e0737402d2f55b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2spark-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2spark;unpack=0"
SRC_URI[aarch64_pcp-export-pcp2spark.sha256sum] = "989482fe94736667c4fa9d1ac70bcf771b6250b4ef5a52a70ef309c1d49de888"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2xml-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2xml;unpack=0"
SRC_URI[aarch64_pcp-export-pcp2xml.sha256sum] = "a39d54a4f5e2e7b3d7a60168994e58583c7c233195d8c3da4dac22ff322b3c9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2zabbix-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-export-pcp2zabbix;unpack=0"
SRC_URI[aarch64_pcp-export-pcp2zabbix.sha256sum] = "fddc896a25de748c13f396e8f33c38e97e5fa60c0fbe615c838aacc05e2200ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-zabbix-agent-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-export-zabbix-agent;unpack=0"
SRC_URI[aarch64_pcp-export-zabbix-agent.sha256sum] = "14625f513436dd9ac22a71283c1c2226b22e64a9e21e971cf95dffdcf39834b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-geolocate-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-geolocate;unpack=0"
SRC_URI[aarch64_pcp-geolocate.sha256sum] = "4102219a13a82d5f21cf155351e18146eb7341460df5ff3677c06cc1b593d51d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-gui-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-gui;unpack=0"
SRC_URI[aarch64_pcp-gui.sha256sum] = "de1f9e1b3b59fccbe1c2f182d7905ca7d89b0467c67ced65b14be0642645d587"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-benchmarks-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-import-benchmarks;unpack=0"
SRC_URI[aarch64_pcp-import-benchmarks.sha256sum] = "52a2e90b07d8b3b2faa209c405ffe9ccc380f1af3c7f815e0cd4ac7bf7937c2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-collectl2pcp-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-import-collectl2pcp;unpack=0"
SRC_URI[aarch64_pcp-import-collectl2pcp.sha256sum] = "1a0d6b3a47e1cfcbdc1519d67f7f8792ca98d01a7cbc312b75e1d0e19cb2129e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-ganglia2pcp-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-import-ganglia2pcp;unpack=0"
SRC_URI[aarch64_pcp-import-ganglia2pcp.sha256sum] = "7df24b8927dbcd15243ffb1f68e8b1af12a29c4f73a611b4435498cddc432643"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-iostat2pcp-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-import-iostat2pcp;unpack=0"
SRC_URI[aarch64_pcp-import-iostat2pcp.sha256sum] = "43ca1ba08c5b62402b2cae2580ae0a4f62a453fbcac99f4e27aa791b8aefd0be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-mrtg2pcp-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-import-mrtg2pcp;unpack=0"
SRC_URI[aarch64_pcp-import-mrtg2pcp.sha256sum] = "325487d265bfe102f903de16d55e54eb5d4c37a20a1dc2c325913bee6b8245d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-pmseries-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-import-pmseries;unpack=0"
SRC_URI[aarch64_pcp-import-pmseries.sha256sum] = "cc8c1f1e25ffc7cc1dae21da58755d183ff52089e2327c41949c57d341974d9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-sar2pcp-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-import-sar2pcp;unpack=0"
SRC_URI[aarch64_pcp-import-sar2pcp.sha256sum] = "17d54b42c6f213d10225abac665d6900ab7828ccb4cc22715457e2f84757a434"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-libs-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-libs;unpack=0"
SRC_URI[aarch64_pcp-libs.sha256sum] = "2123a167959180f66db91e017b881ca4fbbbde13160ecb39cd5899d600a34b76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-libs-devel-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-libs-devel;unpack=0"
SRC_URI[aarch64_pcp-libs-devel.sha256sum] = "ca21347faba8592df6d37c246bd859a7107566a758dd56a281b7053bc6b3e3e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-activemq-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-activemq;unpack=0"
SRC_URI[aarch64_pcp-pmda-activemq.sha256sum] = "0ba921a5ce58facac3dd9d9efa7c1d101d366593f8908dfa429429344b9b4623"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-amdgpu-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-amdgpu;unpack=0"
SRC_URI[aarch64_pcp-pmda-amdgpu.sha256sum] = "78424393da5534dccd71ec52463197d6f77c106cc72dcbea415db5891d4cf75b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-apache-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-apache;unpack=0"
SRC_URI[aarch64_pcp-pmda-apache.sha256sum] = "94393a44f9bd2696a1d8e9c4a2570d203041f5029d8272e04c0323266f87aa6c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bash-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-bash;unpack=0"
SRC_URI[aarch64_pcp-pmda-bash.sha256sum] = "361372ea17985e37b83036228d7a04616c8d0cd268732c00e5ac4a63ab9c000f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bind2-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-bind2;unpack=0"
SRC_URI[aarch64_pcp-pmda-bind2.sha256sum] = "85efb776e06a822619392a4a6223d75532d3df787c71143cfad96b58de105e67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bonding-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-bonding;unpack=0"
SRC_URI[aarch64_pcp-pmda-bonding.sha256sum] = "8b3bd20d2aca7b5e78bb450d9bf19d4c310c5e43c05dfa4eb8c9115fdddee6af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bpf-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-bpf;unpack=0"
SRC_URI[aarch64_pcp-pmda-bpf.sha256sum] = "10d76c2e19e77282e0e2095b34ddfeff92a404d9cee33908ae4a47c034ef0899"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bpftrace-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-bpftrace;unpack=0"
SRC_URI[aarch64_pcp-pmda-bpftrace.sha256sum] = "615aa8500723863736cfdb3930e302c589da74af487fa7a922a68b2904ebac2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-cifs-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-cifs;unpack=0"
SRC_URI[aarch64_pcp-pmda-cifs.sha256sum] = "a92bd52764676f3045631a250d7fbab4db1570fc3870275fc8a8c707dc260878"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-cisco-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-cisco;unpack=0"
SRC_URI[aarch64_pcp-pmda-cisco.sha256sum] = "498c9e85a00731ff1239a827d26299a43ddcf9a2d99cbb8aeb6a4e7bbb2c1274"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-dbping-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-dbping;unpack=0"
SRC_URI[aarch64_pcp-pmda-dbping.sha256sum] = "457b354489fea2f4c6bc62aa3526a202aec46485009bdbcba82341e75d17af5f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-denki-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-denki;unpack=0"
SRC_URI[aarch64_pcp-pmda-denki.sha256sum] = "8f231989a78c0d5e2a78c4782445e76413e6dd1707461681e3e7f2086e1468c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-dm-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-dm;unpack=0"
SRC_URI[aarch64_pcp-pmda-dm.sha256sum] = "32bcefee585909220871b040175df23ba5a6138e1761c3c5087cc34f2cfbe1db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-docker-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-docker;unpack=0"
SRC_URI[aarch64_pcp-pmda-docker.sha256sum] = "e4252a9636dd9e4bf528925c3ae7cb5e772bb9f566fd59857d1e8635704685cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-ds389-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-ds389;unpack=0"
SRC_URI[aarch64_pcp-pmda-ds389.sha256sum] = "affd03df3aba5cccbcf7275c07cd0ffb5d2e6c8e7f4075d11f4e911d82ae860d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-ds389log-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-ds389log;unpack=0"
SRC_URI[aarch64_pcp-pmda-ds389log.sha256sum] = "809d5f8171e1bcd3859a339177146af404798c716104b034d0257416f073f932"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-elasticsearch-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-elasticsearch;unpack=0"
SRC_URI[aarch64_pcp-pmda-elasticsearch.sha256sum] = "1c4b08352ac0426d2048ca856a1f8e1031fdce07e5a5e33a577bb02d1f380cf6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-farm-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-farm;unpack=0"
SRC_URI[aarch64_pcp-pmda-farm.sha256sum] = "f657866ce7894e3c5ca49544c31c3d1ac532062db511be8a1c4a90f5105aa67d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gluster-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-gluster;unpack=0"
SRC_URI[aarch64_pcp-pmda-gluster.sha256sum] = "b1d19583a741846dd365dabfd14350cc37c31096fae1255d3c792976110963e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gpfs-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-gpfs;unpack=0"
SRC_URI[aarch64_pcp-pmda-gpfs.sha256sum] = "06327b2c05d01dce426a8461b880ed0eb9e3ec13d1cf8338f64bdd92ba7b825d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gpsd-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-gpsd;unpack=0"
SRC_URI[aarch64_pcp-pmda-gpsd.sha256sum] = "01aa674c74b0e2c986a1473f0bd69035bf33ccb5ad3d308b0c45a225120c9e62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-hacluster-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-hacluster;unpack=0"
SRC_URI[aarch64_pcp-pmda-hacluster.sha256sum] = "b69a42c1bc32b4cf379b8273938a46dc303003c9b7ce267acefcdfc75b0311b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-haproxy-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-haproxy;unpack=0"
SRC_URI[aarch64_pcp-pmda-haproxy.sha256sum] = "3d5b00e589079cb4d25dca32057c8dacfaa67bc4b261fb097e33e1d2cf74b89a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-hdb-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-hdb;unpack=0"
SRC_URI[aarch64_pcp-pmda-hdb.sha256sum] = "5834d845365ba7e7d41e81cd11c15cb6952291c46eb622bae325465d86ecdb12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-infiniband-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-infiniband;unpack=0"
SRC_URI[aarch64_pcp-pmda-infiniband.sha256sum] = "a2d5b58a88b1fd1228384a9b4914c4ef5de407e38fc282421aba219983217386"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-libvirt-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-libvirt;unpack=0"
SRC_URI[aarch64_pcp-pmda-libvirt.sha256sum] = "4e6e5dbd8a9b5a4c6caa816e7215e695f8d3ad9654d853e9c8a7e5b278baee62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lio-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-lio;unpack=0"
SRC_URI[aarch64_pcp-pmda-lio.sha256sum] = "8382a9fa69899eb1f22ce8a5803b64143fb7a158714709f7be9de28979bd5f3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lmsensors-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-lmsensors;unpack=0"
SRC_URI[aarch64_pcp-pmda-lmsensors.sha256sum] = "15457b2f6e16017b8646304e88ea05af49a2e9d3dfea9e0bf938de737ce6adc9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-logger-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-logger;unpack=0"
SRC_URI[aarch64_pcp-pmda-logger.sha256sum] = "dbbb7ca4cafca7862812a892a4df285a52df0ff5d24469c17922f3581c477064"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lustre-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-lustre;unpack=0"
SRC_URI[aarch64_pcp-pmda-lustre.sha256sum] = "ef2245293156d5246d07d1237795803a29f4887df07915b36aa87f93c5183ddd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lustrecomm-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-lustrecomm;unpack=0"
SRC_URI[aarch64_pcp-pmda-lustrecomm.sha256sum] = "68edf0a440e7beefce64b4629113ea5bb39cc5256c7d237705fd62316cc897af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mailq-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-mailq;unpack=0"
SRC_URI[aarch64_pcp-pmda-mailq.sha256sum] = "df7ea81240cc1486def9a22ed12498153977710018a1b8a6bb07812508910213"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-memcache-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-memcache;unpack=0"
SRC_URI[aarch64_pcp-pmda-memcache.sha256sum] = "a3dc45b7c949791d42363e8ec8faeb8b1e97acae4d2c9a1880c5f99e2babd8fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mic-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-mic;unpack=0"
SRC_URI[aarch64_pcp-pmda-mic.sha256sum] = "5d5468a86385952b7aecd42a44043a55d7b9842389afa4447abd9633ba2c4fee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mongodb-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-mongodb;unpack=0"
SRC_URI[aarch64_pcp-pmda-mongodb.sha256sum] = "f69416d6d66e0b0fce045aff34912577144c10eda66d1688591447834ed6ecc2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mounts-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-mounts;unpack=0"
SRC_URI[aarch64_pcp-pmda-mounts.sha256sum] = "69ca071467bdf47c705669e8e7b03a9908115e1bf58d75b70a88aabc2d4b71f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mysql-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-mysql;unpack=0"
SRC_URI[aarch64_pcp-pmda-mysql.sha256sum] = "79bf1a8597ac86661aa3675948650aefc9fd8a44aede67eca2931e6829344f5a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-named-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-named;unpack=0"
SRC_URI[aarch64_pcp-pmda-named.sha256sum] = "5d91a8e59ce6fc6dad8d47c2c92c1899221306207a6857e6b1046950be3dffe9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-netcheck-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-netcheck;unpack=0"
SRC_URI[aarch64_pcp-pmda-netcheck.sha256sum] = "0bcfbb55848e9a4bf02f4f1c43c7dc06f9d32afd07e1816bcee3bf52c6183583"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-netfilter-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-netfilter;unpack=0"
SRC_URI[aarch64_pcp-pmda-netfilter.sha256sum] = "24087257b0861157b5817aa2854b4fa45c82580300928bf3ce6aa1a394ff492a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-news-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-news;unpack=0"
SRC_URI[aarch64_pcp-pmda-news.sha256sum] = "f08de67032ca3b5a39b0fa6ddbb30085df2ffbc76dd2e853640cd824ea0ee33f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nfsclient-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-nfsclient;unpack=0"
SRC_URI[aarch64_pcp-pmda-nfsclient.sha256sum] = "0d5414066b45e6c369c4390b3e4457d4e603706a6ee200beb389a2da386ec152"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nginx-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-nginx;unpack=0"
SRC_URI[aarch64_pcp-pmda-nginx.sha256sum] = "e40c7b979f30018dc83a91fb26d42573d2ab1ae4f5edea598f6c5391d1400e39"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nvidia-gpu-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI[aarch64_pcp-pmda-nvidia-gpu.sha256sum] = "f1cbd6e8b126550e4828c188835a9c61a7cdb0ac41e9fd1a5310a809ee45a008"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-openmetrics-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-openmetrics;unpack=0"
SRC_URI[aarch64_pcp-pmda-openmetrics.sha256sum] = "c67f90982c6f051e5bd0a28ef06de44c6e8657b62c5465fa28051f74ddd55516"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-opentelemetry-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-opentelemetry;unpack=0"
SRC_URI[aarch64_pcp-pmda-opentelemetry.sha256sum] = "795a9b6c685e524f709cf1313da4827fe548408004e5747b8766e47ac55fded5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-openvswitch-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-openvswitch;unpack=0"
SRC_URI[aarch64_pcp-pmda-openvswitch.sha256sum] = "b08f6725d850a60756d5ab787da3dc10d381a66d8ad9aac6f79c1f1116d876d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-oracle-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-oracle;unpack=0"
SRC_URI[aarch64_pcp-pmda-oracle.sha256sum] = "24152705c5dca4c20de270977369403bdf9917d0dad4c6b043ec0ecda79fd57d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-pdns-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-pdns;unpack=0"
SRC_URI[aarch64_pcp-pmda-pdns.sha256sum] = "28621cb9a33416e22fbd64c70af78a01a02398cc6f932b977d03c4d31d9a702d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-perfevent-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-perfevent;unpack=0"
SRC_URI[aarch64_pcp-pmda-perfevent.sha256sum] = "ba05f062475ed5295fe5ce3bff3e1ba93a8ba8cedf42f49a63c9a28ec28df339"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-podman-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-podman;unpack=0"
SRC_URI[aarch64_pcp-pmda-podman.sha256sum] = "c91659813754973cdd444196d4636e13be15928a62aad4940747b833bc56f37c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-postfix-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-postfix;unpack=0"
SRC_URI[aarch64_pcp-pmda-postfix.sha256sum] = "d72686cc2988069722605531264ae4e4ceb43f5e9fae25302c22d5c1cac50933"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-postgresql-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-postgresql;unpack=0"
SRC_URI[aarch64_pcp-pmda-postgresql.sha256sum] = "5177e52ff283e268c607bde5f3b295b0c8b9a254fe08d0f058e194dd0d51eeb9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rabbitmq-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-rabbitmq;unpack=0"
SRC_URI[aarch64_pcp-pmda-rabbitmq.sha256sum] = "1d817e19e35feef6c0d3e7c943733ac009ab1c1d2f1a639d3a7a8134303b3891"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-redis-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-redis;unpack=0"
SRC_URI[aarch64_pcp-pmda-redis.sha256sum] = "16396a94af20f2ce2f1db950dec2b5b957ddcbc75a81a78d3594b15dc429a5c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rocestat-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-rocestat;unpack=0"
SRC_URI[aarch64_pcp-pmda-rocestat.sha256sum] = "a928c10765633be594ed9903c2c66cdee5fa662d4485a9e18c3cb74fadd94ba8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-roomtemp-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-roomtemp;unpack=0"
SRC_URI[aarch64_pcp-pmda-roomtemp.sha256sum] = "c6dfb2a4481fbf9233ca0939483aecbd09036e749db6d3c4c0b13d6872e320cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rsyslog-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-rsyslog;unpack=0"
SRC_URI[aarch64_pcp-pmda-rsyslog.sha256sum] = "03ceaf5589c51d20f914073a4568b8cb084cda1897735b48c9c0cad86df21171"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-samba-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-samba;unpack=0"
SRC_URI[aarch64_pcp-pmda-samba.sha256sum] = "4b06e27cd4fcc634382f5834606d8fda73f59d07f71eb40e2d3fa4819d34a3d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-sendmail-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-sendmail;unpack=0"
SRC_URI[aarch64_pcp-pmda-sendmail.sha256sum] = "1bf8c616e82b48e49aa9e5f79b6dcc9a75832257a994b1ef27aade6edbdcfe50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-shping-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-shping;unpack=0"
SRC_URI[aarch64_pcp-pmda-shping.sha256sum] = "205c2cc2c231b9466ba81f875264fc0f35d2ad870f3719fec190d059a2e81dae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-slurm-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-slurm;unpack=0"
SRC_URI[aarch64_pcp-pmda-slurm.sha256sum] = "bc73d774cdf6d7ed70f39a950d6d72ddd79df20b71ed51ed4bac4b735e2ed382"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-smart-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-smart;unpack=0"
SRC_URI[aarch64_pcp-pmda-smart.sha256sum] = "fd08fc7a4b6867466cdc6d419c6e3716dc163eb00f3af649b7bc73f6a316df73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-snmp-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-snmp;unpack=0"
SRC_URI[aarch64_pcp-pmda-snmp.sha256sum] = "236be22e03719e82c2b7bf160a89a32f1662afb97fd323896662ab30370035a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-sockets-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-sockets;unpack=0"
SRC_URI[aarch64_pcp-pmda-sockets.sha256sum] = "54bea80cd69f526a862a541e6c780af8aa8ba092e62131142add6adab82e58cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-statsd-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-statsd;unpack=0"
SRC_URI[aarch64_pcp-pmda-statsd.sha256sum] = "8efde26b7c8d838bfb6676f9f01ec57093b954498ef4fcab7f4592e481900593"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-summary-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-summary;unpack=0"
SRC_URI[aarch64_pcp-pmda-summary.sha256sum] = "be300aea1674186c4659167a5863704477c49461e20cccfb1dfb81378c669e93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-systemd-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-systemd;unpack=0"
SRC_URI[aarch64_pcp-pmda-systemd.sha256sum] = "a61e314dc8ce34b3ed2a5ba0b3e05fd35ff0d28887a9632273785d4f20c104f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-trace-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-trace;unpack=0"
SRC_URI[aarch64_pcp-pmda-trace.sha256sum] = "6975bd8969d2f3dd86ede913efd08bb7c0810878b52cb11b4065b9abb069f3dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-unbound-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-unbound;unpack=0"
SRC_URI[aarch64_pcp-pmda-unbound.sha256sum] = "18e525055a0f421acd357e1764d69a9d253797a711d222b6d66ebb3eb4190d3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-uwsgi-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-uwsgi;unpack=0"
SRC_URI[aarch64_pcp-pmda-uwsgi.sha256sum] = "31bfd7add5c5d78e3c3dfd3862374aaba9e748033c98cb7c678267cc96426a05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-weblog-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-weblog;unpack=0"
SRC_URI[aarch64_pcp-pmda-weblog.sha256sum] = "840979c56e3b63ac604bcb37882ef1443dccbd4c7ca14bf99e6ac95675cee0c3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-zimbra-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-zimbra;unpack=0"
SRC_URI[aarch64_pcp-pmda-zimbra.sha256sum] = "3ae6e655364365db9f47c077d8daf575b0271acfda945538a3b62b2e32237584"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-zswap-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-pmda-zswap;unpack=0"
SRC_URI[aarch64_pcp-pmda-zswap.sha256sum] = "58b5bd93e3dcbc016a4e64aeb9504aa4a0f7d2b8153f21773881f9a59e35aad4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-selinux-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-selinux;unpack=0"
SRC_URI[aarch64_pcp-selinux.sha256sum] = "da084d4f5299ce84257d4c8b5c4884fe8672d1aaa28d6288275dfb158a6f40a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-system-tools-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-system-tools;unpack=0"
SRC_URI[aarch64_pcp-system-tools.sha256sum] = "2c8e37b7c627484f8be0fc21b3e2142977bec723423c6688df3976d56018129c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pcp-testsuite-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-testsuite;unpack=0"
SRC_URI[aarch64_pcp-testsuite.sha256sum] = "33b5494e51c3a6fbb9f66c8ad6edac048557c28a13dc63c1d3a2a9b5b6aa8c5b"
RPROVIDES:pcp-testsuite:append:aarch64 = " virtual/perl_Slurm_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-zeroconf-7.1.5-6.el10.aarch64.rpm;name=aarch64_pcp-zeroconf;unpack=0"
SRC_URI[aarch64_pcp-zeroconf.sha256sum] = "d512906c24086475e4035ae7a523c1594bf96c978b43c85438bd6a4e31264f68"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-LogImport-7.1.5-6.el10.aarch64.rpm;name=aarch64_perl-PCP-LogImport;unpack=0"
SRC_URI[aarch64_perl-PCP-LogImport.sha256sum] = "2e83d22a884d0a7a86e1ba7cdb27a7e66a3a0a2481a732aa01541d2932ac578d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-LogSummary-7.1.5-6.el10.aarch64.rpm;name=aarch64_perl-PCP-LogSummary;unpack=0"
SRC_URI[aarch64_perl-PCP-LogSummary.sha256sum] = "d6225a321c993eacacb0fa8a24a94d6c6916ac80dc0334964f53fed72f105b96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-MMV-7.1.5-6.el10.aarch64.rpm;name=aarch64_perl-PCP-MMV;unpack=0"
SRC_URI[aarch64_perl-PCP-MMV.sha256sum] = "6f886188f3539d14049e3523acad3c1e524bf2ffd178fcb55088205ae3cd073d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-PMDA-7.1.5-6.el10.aarch64.rpm;name=aarch64_perl-PCP-PMDA;unpack=0"
SRC_URI[aarch64_perl-PCP-PMDA.sha256sum] = "bafd2d8ef6d95e6bf3b43ff1f0d4546af27bb353f916c85b99b4d0b679261a2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pcp-7.1.5-6.el10.aarch64.rpm;name=aarch64_python3-pcp;unpack=0"
SRC_URI[aarch64_python3-pcp.sha256sum] = "71a3464d403132615b2a2fb6366a0f2ac66097eb2a820ba7150974d22ff968f0"

RDEPENDS:pcp = " \
 bash \
 diffutils \
 findutils \
 gawk \
 glibc \
 grep \
 hostname \
 libuv \
 openssl-libs \
 pcp-libs \
 pcp-selinux \
 procps-ng \
 readline \
 sed \
 virtual/coreutils \
 which \
 xz \
 zlib-ng-compat \
 zstd \
 "
RDEPENDS:pcp-conf = " \
 "
RDEPENDS:pcp-devel = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 pcp-libs-devel \
 perl-PCP-PMDA \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:pcp-doc = " \
 "
RDEPENDS:pcp-export-pcp2elasticsearch = " \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-export-pcp2graphite = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2influxdb = " \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-export-pcp2json = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2openmetrics = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2opentelemetry = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2spark = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2xml = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2zabbix = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-zabbix-agent = " \
 glibc \
 pcp-libs \
 "
RDEPENDS:pcp-geolocate = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-gui = " \
 bash \
 glibc \
 liberation-sans-fonts \
 libgcc \
 libstdc++ \
 pcp \
 pcp-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:pcp-import-benchmarks = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-import-collectl2pcp = " \
 glibc \
 pcp-libs \
 "
RDEPENDS:pcp-import-ganglia2pcp = " \
 pcp-libs \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-PCP-LogImport \
 perl-POSIX \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 perl-vars \
 rrdtool-perl \
 "
RDEPENDS:pcp-import-iostat2pcp = " \
 pcp-libs \
 perl-Getopt-Std \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-import-mrtg2pcp = " \
 pcp-libs \
 perl-PCP-LogImport \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-import-pmseries = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-import-sar2pcp = " \
 pcp-libs \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-XML-TokeParser \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-libs = " \
 cyrus-sasl-lib \
 glibc \
 libuv \
 openssl-libs \
 pcp-conf \
 systemd-libs \
 xz-libs \
 "
RDEPENDS:pcp-libs-devel = " \
 pcp \
 pcp-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pcp-pmda-activemq = " \
 bash \
 pcp \
 pcp-libs \
 perl-Digest-MD5 \
 perl-JSON \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-amdgpu = " \
 bash \
 glibc \
 libdrm \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-apache = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-bash = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-bind2 = " \
 bash \
 pcp \
 pcp-libs \
 perl-File-Slurp \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-XML-LibXML \
 perl-autodie \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-bonding = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-bpf = " \
 bash \
 elfutils-libelf \
 glibc \
 libbpf \
 pcp \
 pcp-libs \
 zlib-ng-compat \
 "
RDEPENDS:pcp-pmda-bpftrace = " \
 bash \
 bpftrace \
 pcp \
 pcp-libs \
 python3 \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-cifs = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-cisco = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-dbping = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBI \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-denki = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-dm = " \
 bash \
 device-mapper-libs \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-docker = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-ds389 = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-ds389log = " \
 bash \
 pcp \
 pcp-libs \
 perl-Date-Manip \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-elasticsearch = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-farm = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 smartmontools \
 "
RDEPENDS:pcp-pmda-gluster = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-gpfs = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-gpsd = " \
 bash \
 pcp \
 pcp-libs \
 perl-JSON \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 "
RDEPENDS:pcp-pmda-hacluster = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-haproxy = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-hdb = " \
 bash \
 pcp \
 pcp-libs \
 python3-packaging \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-infiniband = " \
 bash \
 glibc \
 infiniband-diags \
 libibumad \
 libibverbs \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-libvirt = " \
 bash \
 pcp \
 pcp-libs \
 python3-libvirt \
 python3-lxml \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-lio = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-rtslib \
 "
RDEPENDS:pcp-pmda-lmsensors = " \
 bash \
 lm_sensors \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-logger = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-lustre = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-lustrecomm = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-mailq = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-memcache = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-mic = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-mongodb = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-mounts = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-mssql = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-pyodbc \
 "
RDEPENDS:pcp-pmda-mysql = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBD-MySQL \
 perl-DBI \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-named = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-netcheck = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-netfilter = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-news = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-nfsclient = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-nginx = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-nvidia-gpu = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-openmetrics = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-pmda-opentelemetry = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-pmda-openvswitch = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-oracle = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBI \
 perl-PCP-PMDA \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-pmda-pdns = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 "
RDEPENDS:pcp-pmda-perfevent = " \
 bash \
 glibc \
 libpfm \
 pcp \
 pcp-libs \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-pmda-podman = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-postfix = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 postfix-perl-scripts \
 "
RDEPENDS:pcp-pmda-postgresql = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-psycopg2 \
 "
RDEPENDS:pcp-pmda-rabbitmq = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-redis = " \
 bash \
 pcp \
 pcp-libs \
 perl-Data-Dumper \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-autodie \
 "
RDEPENDS:pcp-pmda-resctrl = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-rocestat = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-roomtemp = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-rsyslog = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-samba = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-sendmail = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-shping = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-slurm = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-smart = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 smartmontools \
 "
RDEPENDS:pcp-pmda-snmp = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-sockets = " \
 bash \
 glibc \
 iproute \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-statsd = " \
 HdrHistogram_c \
 bash \
 chan \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-summary = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-systemd = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 systemd-libs \
 "
RDEPENDS:pcp-pmda-trace = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-unbound = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-uwsgi = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-weblog = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-zimbra = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-zswap = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-selinux = " \
 bash \
 policycoreutils \
 selinux-policy-targeted \
 "
RDEPENDS:pcp-system-tools = " \
 bash \
 glibc \
 ncurses-libs \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-testsuite = " \
 bash \
 bc \
 bzip2 \
 cyrus-sasl-lib \
 gcc \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcp \
 pcp-devel \
 pcp-libs \
 pcp-libs-devel \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 redhat-rpm-config \
 selinux-policy-devel \
 selinux-policy-targeted \
 setools \
 systemd-libs \
 xz-libs \
 "
RDEPENDS:pcp-zeroconf = " \
 bash \
 pcp \
 pcp-doc \
 pcp-libs \
 pcp-pmda-bpf \
 pcp-pmda-dm \
 pcp-pmda-nfsclient \
 pcp-pmda-openmetrics \
 pcp-pmda-opentelemetry \
 pcp-system-tools \
 "
RDEPENDS:perl-PCP-LogImport = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-PCP-LogSummary = " \
 pcp-libs \
 perl-Exporter \
 perl-PCP-LogSummary \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PCP-MMV = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-PCP-MMV \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PCP-PMDA = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:python3-pcp = " \
 glibc \
 pcp \
 pcp-libs \
 python3 \
 "
