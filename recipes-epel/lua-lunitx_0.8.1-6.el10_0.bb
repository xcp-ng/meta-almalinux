# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-lunitx"
PV = "0.8.1"
PR = "6.el10_0"
PACKAGES = " \
 lua-lunitx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-lunitx-0.8.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "628159535f44ec06801fedeef9179a86aca6d1670fe4b85198d0e430531ecabd"

URI_x86_64_v2_lua-lunitx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-lunitx-0.8.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lua-lunitx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-lunitx}"
SRC_URI[x86_64_v2_lua-lunitx.sha256sum] = "57f7a895b8529a9eeb9247484696833b8c0445d3ffe730c8e4927b30e30d2534"

URI_aarch64_lua-lunitx = "${EPEL_MIRROR}/aarch64/Packages/l/lua-lunitx-0.8.1-6.el10_0.noarch.rpm;name=aarch64_lua-lunitx;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-lunitx}"
SRC_URI[aarch64_lua-lunitx.sha256sum] = "53272247dfadea5fd1cf0836d2e5e8dc5b8cd547418276be1eccf72d1af28706"

RDEPENDS:lua-lunitx = " \
 bash \
 lua-libs \
 "
