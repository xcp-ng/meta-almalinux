# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit-qt-1"
PV = "0.201.1"
PR = "1.el10_2"
PACKAGES = " \
 polkit-qt5-1 \
 polkit-qt5-1-devel \
 polkit-qt6-1 \
 polkit-qt6-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/polkit-qt-1-0.201.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "433210fe0b0481ab2528a4b0a86c34b011e76fc4c2118650fdfcbae5762ff92a"

URI_x86_64_v2_polkit-qt5-1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt5-1-0.201.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt5-1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt5-1}"
SRC_URI[x86_64_v2_polkit-qt5-1.sha256sum] = "76d73bc17d01d76b5ca1d3ef547b3312a17c2596c49f407bf10cef7b65bc1c47"

URI_x86_64_v2_polkit-qt5-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt5-1-devel-0.201.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt5-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt5-1-devel}"
SRC_URI[x86_64_v2_polkit-qt5-1-devel.sha256sum] = "27fc5e881789b9d839f4e76d4dce02b8ad054025f0a4cdcddccd5d4a51144319"

URI_x86_64_v2_polkit-qt6-1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt6-1-0.201.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt6-1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt6-1}"
SRC_URI[x86_64_v2_polkit-qt6-1.sha256sum] = "de36751bbe7ab708db4e08f1b4e559875bca8758d607d968c8541a6aca8fd53e"

URI_x86_64_v2_polkit-qt6-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt6-1-devel-0.201.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt6-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt6-1-devel}"
SRC_URI[x86_64_v2_polkit-qt6-1-devel.sha256sum] = "08b8aaca288eb73a96da9336e8e33fb8a37142d52c40e045f81c3b2a22ee6f5b"

URI_aarch64_polkit-qt5-1 = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt5-1-0.201.1-1.el10_2.aarch64.rpm;name=aarch64_polkit-qt5-1;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt5-1}"
SRC_URI[aarch64_polkit-qt5-1.sha256sum] = "d65877587e61c3b31bbd17e92b5da9540af6cff2c8d21d6610ddfa93bfb96cff"

URI_aarch64_polkit-qt5-1-devel = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt5-1-devel-0.201.1-1.el10_2.aarch64.rpm;name=aarch64_polkit-qt5-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt5-1-devel}"
SRC_URI[aarch64_polkit-qt5-1-devel.sha256sum] = "d7ba9dc0132db424b6a6af625b98c7f58ad62f338338edb398e0bdfea9e3dfae"

URI_aarch64_polkit-qt6-1 = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt6-1-0.201.1-1.el10_2.aarch64.rpm;name=aarch64_polkit-qt6-1;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt6-1}"
SRC_URI[aarch64_polkit-qt6-1.sha256sum] = "60f926de76e1f06fd8f8a6740ec99deecd79263f28379b38b16fb2a7a69f99cc"

URI_aarch64_polkit-qt6-1-devel = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt6-1-devel-0.201.1-1.el10_2.aarch64.rpm;name=aarch64_polkit-qt6-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt6-1-devel}"
SRC_URI[aarch64_polkit-qt6-1-devel.sha256sum] = "58cdfbcb060512670b03292ea85bf5122fecb2052d4a0b2238b0883053059438"

RDEPENDS:polkit-qt5-1 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 polkit-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:polkit-qt5-1-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 polkit-qt5-1 \
 polkit-qt5-1-devel \
 qt5-qtbase-devel \
 "
RDEPENDS:polkit-qt6-1 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 polkit-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:polkit-qt6-1-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 polkit-qt6-1 \
 polkit-qt6-1-devel \
 qt6-qtbase-devel \
 "
