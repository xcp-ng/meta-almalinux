# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-qemu-ga-win"
PV = "110.2.1"
PR = "1.el10"
PACKAGES = " \
 mingw-qemu-ga-win \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mingw-qemu-ga-win-110.2.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "030ced5346c5cf8db2097b1825863a75cd4a8bfd81c53e225899db24602d91f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mingw-qemu-ga-win-110.2.1-1.el10.noarch.rpm;name=x86_64_v2_mingw-qemu-ga-win;unpack=0"
SRC_URI[x86_64_v2_mingw-qemu-ga-win.sha256sum] = "8525d63f25fdb3f700a650284dc4b2457aaba65e97d0c0bcb6b29ec763516c98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mingw-qemu-ga-win-110.2.1-1.el10.noarch.rpm;name=aarch64_mingw-qemu-ga-win;unpack=0"
SRC_URI[aarch64_mingw-qemu-ga-win.sha256sum] = "8525d63f25fdb3f700a650284dc4b2457aaba65e97d0c0bcb6b29ec763516c98"

RDEPENDS:mingw-qemu-ga-win = " \
 systemd \
 "
