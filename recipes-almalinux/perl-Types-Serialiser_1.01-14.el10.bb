# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Types-Serialiser"
PV = "1.01"
PR = "14.el10"
PACKAGES = " \
 perl-Types-Serialiser \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Types-Serialiser-1.01-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23d88825c6a512c56022c89624b9192c676347486867ea59fba7f141d5d41e2b"

URI_x86_64_v2_perl-Types-Serialiser = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Types-Serialiser-1.01-14.el10.noarch.rpm;name=x86_64_v2_perl-Types-Serialiser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Types-Serialiser}"
SRC_URI[x86_64_v2_perl-Types-Serialiser.sha256sum] = "53df8a6210e8d02641bf1a2baf7e4e270ce112c2b1fe91c60e26212a66365583"

URI_aarch64_perl-Types-Serialiser = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Types-Serialiser-1.01-14.el10.noarch.rpm;name=aarch64_perl-Types-Serialiser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Types-Serialiser}"
SRC_URI[aarch64_perl-Types-Serialiser.sha256sum] = "53df8a6210e8d02641bf1a2baf7e4e270ce112c2b1fe91c60e26212a66365583"

RDEPENDS:perl-Types-Serialiser = " \
 perl-Carp \
 perl-Types-Serialiser \
 perl-common-sense \
 perl-libs \
 perl-overload \
 "
