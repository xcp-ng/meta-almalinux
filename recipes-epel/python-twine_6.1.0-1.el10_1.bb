# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-twine"
PV = "6.1.0"
PR = "1.el10_1"
PACKAGES = " \
 twine \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-twine-6.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7a1b007e0015ce6781df5e54573f99cafe14359238fea1f65b6ecaac267f9f7"

URI_x86_64_v2_twine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/twine-6.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_twine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_twine}"
SRC_URI[x86_64_v2_twine.sha256sum] = "1e50108d6531869cfbd4c65c512d5f97d29c9358934e8462b074547b8bfce9d6"

URI_aarch64_twine = "${EPEL_MIRROR}/aarch64/Packages/t/twine-6.1.0-1.el10_1.noarch.rpm;name=aarch64_twine;unpack=0"
SRC_URI:append = " ${URI_aarch64_twine}"
SRC_URI[aarch64_twine.sha256sum] = "632ef63eb5009a4c4e32236ef4e001a9420b9bf7e39ff21f059a49a2af1b7f35"

RDEPENDS:twine = " \
 python3 \
 python3-id \
 python3-keyring \
 python3-packaging \
 python3-readme-renderer \
 python3-requests \
 python3-requests-toolbelt \
 python3-rfc3986 \
 python3-rich \
 python3-urllib3 \
 "
