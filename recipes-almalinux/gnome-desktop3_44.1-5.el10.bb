# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-desktop3"
PV = "44.1"
PR = "5.el10"
PACKAGES = " \
 gnome-desktop3 \
 gnome-desktop3-devel \
 gnome-desktop4 \
 gnome-desktop4-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-desktop3-44.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4424eb923d0104a716e84aa9223b9ddd3ded9e17c20992b77669947b985643bf"

URI_x86_64_v2_gnome-desktop3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-desktop3-44.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop3}"
SRC_URI[x86_64_v2_gnome-desktop3.sha256sum] = "c045803e46b8d02a953650e01e190cf8ec981cbf4efc34afec4c27ad472b3761"

URI_x86_64_v2_gnome-desktop3-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-desktop3-devel-44.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop3-devel}"
SRC_URI[x86_64_v2_gnome-desktop3-devel.sha256sum] = "d2c6c836faaf7577d64633e5132427654f5cad73599c0ea48b7008cb869d6549"

URI_x86_64_v2_gnome-desktop4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-desktop4-44.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop4}"
SRC_URI[x86_64_v2_gnome-desktop4.sha256sum] = "84c1776a7734ac9d8729817ed339ef5f2717d6a443753d396f48e34609b30573"

URI_x86_64_v2_gnome-desktop4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-desktop4-devel-44.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop4-devel}"
SRC_URI[x86_64_v2_gnome-desktop4-devel.sha256sum] = "3e7ccff2ba949e7338851051a518e9b9ab0902d7eea35f4ac0c9b693f5339ccd"

URI_aarch64_gnome-desktop3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-desktop3-44.1-5.el10.aarch64.rpm;name=aarch64_gnome-desktop3;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop3}"
SRC_URI[aarch64_gnome-desktop3.sha256sum] = "2a330a4784c4ef6961502c667890b4ae6e11b35ac083cce579d1eec418259c02"

URI_aarch64_gnome-desktop3-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-desktop3-devel-44.1-5.el10.aarch64.rpm;name=aarch64_gnome-desktop3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop3-devel}"
SRC_URI[aarch64_gnome-desktop3-devel.sha256sum] = "a43a82573a32dd2023b7881bc60ef64a09f9ace7aaaf2d4d3de11a922c86c8a7"

URI_aarch64_gnome-desktop4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-desktop4-44.1-5.el10.aarch64.rpm;name=aarch64_gnome-desktop4;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop4}"
SRC_URI[aarch64_gnome-desktop4.sha256sum] = "1f8586ee0a6284e48a76a521c439eb65d43d7f328e8478b40ea7cc9e4baa5766"

URI_aarch64_gnome-desktop4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-desktop4-devel-44.1-5.el10.aarch64.rpm;name=aarch64_gnome-desktop4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop4-devel}"
SRC_URI[aarch64_gnome-desktop4-devel.sha256sum] = "63cd426f570d07c77b7b471bb09e6bba6340341bbe8474ba9562647f10afb896"

RDEPENDS:gnome-desktop3 = " \
 bubblewrap \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gsettings-desktop-schemas \
 gtk3 \
 libgcc \
 libseccomp \
 libxkbcommon \
 shared-mime-info \
 systemd-libs \
 "
RDEPENDS:gnome-desktop3-devel = " \
 gdk-pixbuf2-devel \
 glib2-devel \
 gnome-desktop3 \
 gsettings-desktop-schemas-devel \
 gtk3-devel \
 iso-codes-devel \
 libseccomp-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 systemd-devel \
 xkeyboard-config-devel \
 "
RDEPENDS:gnome-desktop4 = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-desktop3 \
 gtk4 \
 libgcc \
 libseccomp \
 libxkbcommon \
 systemd-libs \
 "
RDEPENDS:gnome-desktop4-devel = " \
 gdk-pixbuf2-devel \
 glib2-devel \
 gnome-desktop4 \
 gnome-desktop4-devel \
 gsettings-desktop-schemas-devel \
 gtk4-devel \
 iso-codes-devel \
 libseccomp-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 systemd-devel \
 xkeyboard-config-devel \
 "
