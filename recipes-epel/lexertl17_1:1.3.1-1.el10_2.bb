# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lexertl17"
PE = "1"
PV = "1.3.1"
PR = "1.el10_2"
PACKAGES = " \
 lexertl17-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lexertl17-1.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba03614f3a69001a017909b59cb0ec8778b1af7681abba15bc0040aa1c073e25"

URI_x86_64_v2_lexertl17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lexertl17-devel-1.3.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lexertl17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lexertl17-devel}"
SRC_URI[x86_64_v2_lexertl17-devel.sha256sum] = "0fdb8943828a83d7c30c1c437e8e41387accbe15f7d77c63ae6d3c3333ef2f96"

URI_aarch64_lexertl17-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lexertl17-devel-1.3.1-1.el10_2.aarch64.rpm;name=aarch64_lexertl17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lexertl17-devel}"
SRC_URI[aarch64_lexertl17-devel.sha256sum] = "7d89032d1f34759271834450ba7d69abd0f14ff627fd46cbd5ad05ce967cc864"

RDEPENDS:lexertl17-devel = " \
 cmake-filesystem \
 "
