# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pip"
PV = "23.3.2"
PR = "11.el10_2"
PACKAGES = " \
 python3-pip \
 python3-pip-wheel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-pip-23.3.2-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9eeca4f420a516f599650f0122d4d8824da2c8154b9c2453fbae693d119ba7bb"

URI_x86_64_v2_python3-pip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pip-23.3.2-11.el10_2.noarch.rpm;name=x86_64_v2_python3-pip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pip}"
SRC_URI[x86_64_v2_python3-pip.sha256sum] = "da926fa0fa1a2ca6a4c4f00a5ff3eebc88d4f785589a68d280036ebf0a994263"

URI_x86_64_v2_python3-pip-wheel = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-pip-wheel-23.3.2-11.el10_2.noarch.rpm;name=x86_64_v2_python3-pip-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pip-wheel}"
SRC_URI[x86_64_v2_python3-pip-wheel.sha256sum] = "38af4bb101b0f4c095687c2234ab5fc35f0656c5fda22767489e960bed454472"

URI_aarch64_python3-pip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pip-23.3.2-11.el10_2.noarch.rpm;name=aarch64_python3-pip;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pip}"
SRC_URI[aarch64_python3-pip.sha256sum] = "da926fa0fa1a2ca6a4c4f00a5ff3eebc88d4f785589a68d280036ebf0a994263"

URI_aarch64_python3-pip-wheel = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-pip-wheel-23.3.2-11.el10_2.noarch.rpm;name=aarch64_python3-pip-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pip-wheel}"
SRC_URI[aarch64_python3-pip-wheel.sha256sum] = "38af4bb101b0f4c095687c2234ab5fc35f0656c5fda22767489e960bed454472"

RDEPENDS:python3-pip = " \
 ca-certificates \
 python3 \
 "
RDEPENDS:python3-pip-wheel = " \
 ca-certificates \
 "
