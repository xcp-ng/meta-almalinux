# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-SOAP-WSDL"
PV = "3.004"
PR = "18.el10_0"
PACKAGES = " \
 perl-SOAP-WSDL \
 perl-SOAP-WSDL-Apache \
 perl-SOAP-WSDL-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-SOAP-WSDL-3.004-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "987893308ebb434b895106b7ee943e9e7b78f71631adac65c7c93665ec3f4aa8"

URI_x86_64_v2_perl-SOAP-WSDL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SOAP-WSDL-3.004-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SOAP-WSDL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SOAP-WSDL}"
SRC_URI[x86_64_v2_perl-SOAP-WSDL.sha256sum] = "ebcff824790e8da4403198503f1da8ac0762b80511095e8baa02da66145a98e0"

URI_x86_64_v2_perl-SOAP-WSDL-Apache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SOAP-WSDL-Apache-3.004-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SOAP-WSDL-Apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SOAP-WSDL-Apache}"
SRC_URI[x86_64_v2_perl-SOAP-WSDL-Apache.sha256sum] = "21c981cacd0727d5be8c6a79789c5e8651fd8c30816ac11184d9dfc923a66098"

URI_x86_64_v2_perl-SOAP-WSDL-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SOAP-WSDL-examples-3.004-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SOAP-WSDL-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SOAP-WSDL-examples}"
SRC_URI[x86_64_v2_perl-SOAP-WSDL-examples.sha256sum] = "15f43a4d73f66017609fcf53396d43b2e7bc2aa686acbb9ed16bce1cca3a2b6a"

URI_aarch64_perl-SOAP-WSDL = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SOAP-WSDL-3.004-18.el10_0.noarch.rpm;name=aarch64_perl-SOAP-WSDL;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SOAP-WSDL}"
SRC_URI[aarch64_perl-SOAP-WSDL.sha256sum] = "81a315609c5e26d0e835d88761c864a1206b56d29b56f9b16f13956a12a541c9"

URI_aarch64_perl-SOAP-WSDL-Apache = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SOAP-WSDL-Apache-3.004-18.el10_0.noarch.rpm;name=aarch64_perl-SOAP-WSDL-Apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SOAP-WSDL-Apache}"
SRC_URI[aarch64_perl-SOAP-WSDL-Apache.sha256sum] = "0fa7b70241428a6ade1274e17a0aa23e898e36003b3507fd9c3eace2dbdf4447"

URI_aarch64_perl-SOAP-WSDL-examples = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SOAP-WSDL-examples-3.004-18.el10_0.noarch.rpm;name=aarch64_perl-SOAP-WSDL-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SOAP-WSDL-examples}"
SRC_URI[aarch64_perl-SOAP-WSDL-examples.sha256sum] = "345d5a7698b221f2315904e5dbdb9807ebe973cfcaacb7da89588b06c7fc1f8e"

RDEPENDS:perl-SOAP-WSDL = " \
 perl-Carp \
 perl-Class-Load \
 perl-Class-Std-Fast \
 perl-Data-Dumper \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Usage \
 perl-SOAP-Lite \
 perl-SOAP-WSDL \
 perl-Scalar-List-Utils \
 perl-Template-Toolkit \
 perl-TermReadKey \
 perl-TimeDate \
 perl-URI \
 perl-XML-Parser \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 "
RDEPENDS:perl-SOAP-WSDL-Apache = " \
 mod_perl \
 perl-Class-Std-Fast \
 perl-Encode \
 perl-HTTP-Message \
 perl-SOAP-WSDL \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-SOAP-WSDL-examples = " \
 perl-SOAP-WSDL \
 "
