# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Std-Fast"
PV = "0.0.8"
PR = "27.el10_0"
PACKAGES = " \
 perl-Class-Std-Fast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Std-Fast-0.0.8-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e580f94bc6c16e419d138fe69bfaa41a1bb266fa3afce665cfbab2e638e0a32"

URI_x86_64_v2_perl-Class-Std-Fast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Std-Fast-0.0.8-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Std-Fast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Std-Fast}"
SRC_URI[x86_64_v2_perl-Class-Std-Fast.sha256sum] = "792b1842496daaec209e366221bcab080ada4c48dc94abd49da3e6b55518d30f"

URI_aarch64_perl-Class-Std-Fast = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Std-Fast-0.0.8-27.el10_0.noarch.rpm;name=aarch64_perl-Class-Std-Fast;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Std-Fast}"
SRC_URI[aarch64_perl-Class-Std-Fast.sha256sum] = "478ca1453e950701d277c2dc3172104af227388cf9a3d6ea2f6a9aa8430123ab"

RDEPENDS:perl-Class-Std-Fast = " \
 perl-Carp \
 perl-Class-Std \
 perl-Data-Dumper \
 perl-Storable \
 perl-libs \
 perl-version \
 "
