# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_generator"
PV = "0.11.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-phf_generator+default-devel \
 rust-phf_generator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_generator-0.11.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b814c25aa1f0070109d941124198edd90fdc3cf64a01c91848cd63077ba1cf1f"

URI_x86_64_v2_rust-phf_generator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_generator+default-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_generator+default-devel}"
SRC_URI[x86_64_v2_rust-phf_generator+default-devel.sha256sum] = "de7a40b9436f12841c882dcd0f842e15f4227227c72948092e3bb7a1e9441e0f"

URI_x86_64_v2_rust-phf_generator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_generator-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_generator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_generator-devel}"
SRC_URI[x86_64_v2_rust-phf_generator-devel.sha256sum] = "7bd556cdd2f9d68195b867e8c55d14f5d5e53a622fb942027af5d2f0d7202359"

URI_aarch64_rust-phf_generator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_generator+default-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_generator+default-devel}"
SRC_URI[aarch64_rust-phf_generator+default-devel.sha256sum] = "f84ccd4068c047b963ed50ad8ea19c6f21ca6df48f68d4d4f0d56a15c7480008"

URI_aarch64_rust-phf_generator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_generator-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-phf_generator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_generator-devel}"
SRC_URI[aarch64_rust-phf_generator-devel.sha256sum] = "544d807a14a91c29668b1a76fbeb91dbf950ae8b2c35a78e85570f8212a2fdf0"

RDEPENDS:rust-phf_generator+default-devel = " \
 cargo \
 rust-phf_generator-devel \
 "
RDEPENDS:rust-phf_generator-devel = " \
 cargo \
 rust \
 rust-phf_shared-devel \
 rust-rand0.8+small_rng-devel \
 rust-rand0.8-devel \
 "
