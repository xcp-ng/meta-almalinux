# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "utf8cpp"
PV = "4.0.5"
PR = "1.el10_0"
PACKAGES = " \
 utf8cpp-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/utf8cpp-4.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3f8f00bd796cb2377f7630d909ea66bee820c9ea24342239501786fe4f1aeb48"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/utf8cpp-devel-4.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_utf8cpp-devel;unpack=0"
SRC_URI[x86_64_v2_utf8cpp-devel.sha256sum] = "97e38caa2701132682cd0ef4fdd20ea22587327ff229977a2c4bf766006cf7a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/utf8cpp-devel-4.0.5-1.el10_0.noarch.rpm;name=aarch64_utf8cpp-devel;unpack=0"
SRC_URI[aarch64_utf8cpp-devel.sha256sum] = "513950ac537de52e412ca2c31c234da0034d01d6bf66e183b31c67eb9f698d4b"

RDEPENDS:utf8cpp-devel = " \
 cmake-filesystem \
 "
