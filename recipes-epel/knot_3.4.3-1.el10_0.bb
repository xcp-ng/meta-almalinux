# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knot"
PV = "3.4.3"
PR = "1.el10_0"
PACKAGES = " \
 knot \
 knot-devel \
 knot-dnssecutils \
 knot-doc \
 knot-libs \
 knot-module-dnstap \
 knot-module-geoip \
 knot-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knot-3.4.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5983e132d094e8ee6efe1568302c874fcb038d0c7e4d8f8113ae0661db7bfd83"

URI_x86_64_v2_knot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-3.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot}"
SRC_URI[x86_64_v2_knot.sha256sum] = "058f4020255c5604a1edef9020f7c6856c69e9231c6825370b2a8fbe31903e22"

URI_x86_64_v2_knot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-devel-3.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-devel}"
SRC_URI[x86_64_v2_knot-devel.sha256sum] = "45b7e2bf4f65bc88a66c743db897cb262b87c8ec1df033f509e1052d0c1e8b5d"

URI_x86_64_v2_knot-dnssecutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-dnssecutils-3.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-dnssecutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-dnssecutils}"
SRC_URI[x86_64_v2_knot-dnssecutils.sha256sum] = "a0446e451a596e61da10e7916828b12c374543eb0a73c0c121a8e0bc3f8c0acf"

URI_x86_64_v2_knot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-doc-3.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_knot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-doc}"
SRC_URI[x86_64_v2_knot-doc.sha256sum] = "fd1f415460c4a1baa0643096a206d6fc0942c40b5cf467f7ce86bdba1baa72c1"

URI_x86_64_v2_knot-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-libs-3.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-libs}"
SRC_URI[x86_64_v2_knot-libs.sha256sum] = "038d7cf7e77504a2da8113e0e1447c939a4c319213c6d567cd31ab49d23cbd68"

URI_x86_64_v2_knot-module-dnstap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-module-dnstap-3.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-module-dnstap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-module-dnstap}"
SRC_URI[x86_64_v2_knot-module-dnstap.sha256sum] = "1da2f0373696545171382760c586cc854708d333c284b57e153666a1cc7e9ab9"

URI_x86_64_v2_knot-module-geoip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-module-geoip-3.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-module-geoip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-module-geoip}"
SRC_URI[x86_64_v2_knot-module-geoip.sha256sum] = "57c1258fef0426c1cea87f32915f9a185a7485e3c49c87f4b81627473d953b7a"

URI_x86_64_v2_knot-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knot-utils-3.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knot-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knot-utils}"
SRC_URI[x86_64_v2_knot-utils.sha256sum] = "a19a17f7c94d8dc2530931776bddec856417de0f570d429fa2403d7c6f212286"

URI_aarch64_knot = "${EPEL_MIRROR}/aarch64/Packages/k/knot-3.4.3-1.el10_0.aarch64.rpm;name=aarch64_knot;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot}"
SRC_URI[aarch64_knot.sha256sum] = "ed375ad1f5ac8e1b844f71957824e2743ce3ea35d368c383f39e9beea9b14b89"

URI_aarch64_knot-devel = "${EPEL_MIRROR}/aarch64/Packages/k/knot-devel-3.4.3-1.el10_0.aarch64.rpm;name=aarch64_knot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-devel}"
SRC_URI[aarch64_knot-devel.sha256sum] = "066a3cf5504d09620ee0ee3dee40fe72b0ee93e6eb40f39882b17e7b1a412e96"

URI_aarch64_knot-dnssecutils = "${EPEL_MIRROR}/aarch64/Packages/k/knot-dnssecutils-3.4.3-1.el10_0.aarch64.rpm;name=aarch64_knot-dnssecutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-dnssecutils}"
SRC_URI[aarch64_knot-dnssecutils.sha256sum] = "bbc47c9fa26479d1e0db64c5438bb817c421b873ebd30d41d6b1debcabf93da2"

URI_aarch64_knot-doc = "${EPEL_MIRROR}/aarch64/Packages/k/knot-doc-3.4.3-1.el10_0.noarch.rpm;name=aarch64_knot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-doc}"
SRC_URI[aarch64_knot-doc.sha256sum] = "4b4c34d06be6b0a685174dce6b2835de82c29a159bae1de7158196ef569dbc95"

URI_aarch64_knot-libs = "${EPEL_MIRROR}/aarch64/Packages/k/knot-libs-3.4.3-1.el10_0.aarch64.rpm;name=aarch64_knot-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-libs}"
SRC_URI[aarch64_knot-libs.sha256sum] = "be587330982072fb43fc9c1ce1b9874d029d54eb76c32daf33f242d6b2d5c609"

URI_aarch64_knot-module-dnstap = "${EPEL_MIRROR}/aarch64/Packages/k/knot-module-dnstap-3.4.3-1.el10_0.aarch64.rpm;name=aarch64_knot-module-dnstap;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-module-dnstap}"
SRC_URI[aarch64_knot-module-dnstap.sha256sum] = "cc764c91935d3111b75fec823d448e0d50a99de1c27b87a53a8497bf5a99f2e4"

URI_aarch64_knot-module-geoip = "${EPEL_MIRROR}/aarch64/Packages/k/knot-module-geoip-3.4.3-1.el10_0.aarch64.rpm;name=aarch64_knot-module-geoip;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-module-geoip}"
SRC_URI[aarch64_knot-module-geoip.sha256sum] = "882b92e69be08ee09c4fa8bd26fc3c4c2afb07d561c027d022092e255a3d1cfc"

URI_aarch64_knot-utils = "${EPEL_MIRROR}/aarch64/Packages/k/knot-utils-3.4.3-1.el10_0.aarch64.rpm;name=aarch64_knot-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_knot-utils}"
SRC_URI[aarch64_knot-utils.sha256sum] = "dfe8d11d006101c48eaeeb7aaca33a380e4f6905a35d11cdb56e868a01f85a4f"

RDEPENDS:knot = " \
 bash \
 glibc \
 gnutls \
 knot-libs \
 libcap-ng \
 libedit \
 libgcc \
 lmdb-libs \
 systemd \
 systemd-libs \
 userspace-rcu \
 util-linux \
 "
RDEPENDS:knot-devel = " \
 gnutls-devel \
 knot-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:knot-dnssecutils = " \
 glibc \
 knot-libs \
 libgcc \
 lmdb-libs \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:knot-doc = " \
 "
RDEPENDS:knot-libs = " \
 glibc \
 gnutls \
 libbpf \
 libgcc \
 libxdp \
 lmdb-libs \
 "
RDEPENDS:knot-module-dnstap = " \
 fstrm \
 glibc \
 knot \
 protobuf-c \
 "
RDEPENDS:knot-module-geoip = " \
 glibc \
 knot \
 libgcc \
 libmaxminddb \
 "
RDEPENDS:knot-utils = " \
 fstrm \
 glibc \
 gnutls \
 knot-libs \
 libedit \
 libgcc \
 libidn2 \
 libmnl \
 libnghttp2 \
 protobuf-c \
 "
