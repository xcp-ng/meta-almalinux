# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-headers-more"
PV = "0.39"
PR = "1.el10_1"
PACKAGES = " \
 nginx-mod-headers-more \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-headers-more-0.39-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72f768ab8007c68d7137806900a1e9951e46abb3ce9fd5e035234c64d223b5bf"

URI_x86_64_v2_nginx-mod-headers-more = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-headers-more-0.39-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-headers-more;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-headers-more}"
SRC_URI[x86_64_v2_nginx-mod-headers-more.sha256sum] = "f7310eccadf6cbdf157ec4c43b09cae4c6321648ba7c08058f8540b78bb19782"

URI_aarch64_nginx-mod-headers-more = "${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-headers-more-0.39-1.el10_1.aarch64.rpm;name=aarch64_nginx-mod-headers-more;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-headers-more}"
SRC_URI[aarch64_nginx-mod-headers-more.sha256sum] = "e2b258d97c891a257e6a87b96e6642956438e705cdc1134c43abd1e6353d2eec"

RDEPENDS:nginx-mod-headers-more = " \
 glibc \
 nginx \
 "
