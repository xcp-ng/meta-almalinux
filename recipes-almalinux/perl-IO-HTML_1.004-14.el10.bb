# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-HTML"
PV = "1.004"
PR = "14.el10"
PACKAGES = " \
 perl-IO-HTML \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-IO-HTML-1.004-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fa807f47896223cb7d357f6488dfa61eeee4bb86a554b4ffe5aa6293a4ce24a"

URI_x86_64_v2_perl-IO-HTML = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IO-HTML-1.004-14.el10.noarch.rpm;name=x86_64_v2_perl-IO-HTML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-HTML}"
SRC_URI[x86_64_v2_perl-IO-HTML.sha256sum] = "6e23241b69a11f5cbd6ce534def5dfe5492982991c61e77d105ca01a31d66448"

URI_aarch64_perl-IO-HTML = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IO-HTML-1.004-14.el10.noarch.rpm;name=aarch64_perl-IO-HTML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-HTML}"
SRC_URI[aarch64_perl-IO-HTML.sha256sum] = "6e23241b69a11f5cbd6ce534def5dfe5492982991c61e77d105ca01a31d66448"

RDEPENDS:perl-IO-HTML = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-libs \
 "
