# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Signature"
PV = "0.88"
PR = "12.el10"
PACKAGES = " \
 perl-Module-Signature \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Module-Signature-0.88-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2917d9569533cba46692a0dcc4022b09177f8791ef793b83045c585e3dcc13fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-Signature-0.88-12.el10.noarch.rpm;name=x86_64_v2_perl-Module-Signature;unpack=0"
SRC_URI[x86_64_v2_perl-Module-Signature.sha256sum] = "4735784aedbbf84b047d4a7e41773d9333dbeeae535386b7daf4cbd4f754b2d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-Signature-0.88-12.el10.noarch.rpm;name=aarch64_perl-Module-Signature;unpack=0"
SRC_URI[aarch64_perl-Module-Signature.sha256sum] = "4735784aedbbf84b047d4a7e41773d9333dbeeae535386b7daf4cbd4f754b2d7"

RDEPENDS:perl-Module-Signature = " \
 gnupg2 \
 perl-Digest-SHA \
 perl-Exporter \
 perl-ExtUtils-Manifest \
 perl-File-Temp \
 perl-IO \
 perl-Module-Signature \
 perl-PathTools \
 perl-Text-Diff \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 perl-version \
 "
