# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-file-read-tokio"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-reqsign-file-read-tokio+default-devel \
 rust-reqsign-file-read-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-file-read-tokio-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce8ac20afb2cfac11a79cbe89b5ee9b701468c16cbbca1d547663eada72a719c"

URI_x86_64_v2_rust-reqsign-file-read-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-file-read-tokio+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-file-read-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-file-read-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-file-read-tokio+default-devel.sha256sum] = "2435a46849114beb4e3101eff85f3012ee8689616237453100c04b5315e7b063"

URI_x86_64_v2_rust-reqsign-file-read-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-file-read-tokio-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-file-read-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-file-read-tokio-devel}"
SRC_URI[x86_64_v2_rust-reqsign-file-read-tokio-devel.sha256sum] = "4591a800ecd3c646ed4e28ccf13fee7983b2dddb74aa35c56579e740964c2ad1"

URI_aarch64_rust-reqsign-file-read-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-file-read-tokio+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-file-read-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-file-read-tokio+default-devel}"
SRC_URI[aarch64_rust-reqsign-file-read-tokio+default-devel.sha256sum] = "d2f877570b45a80cdc9457f4ec8d681902c1f7efbea9b2fcbc45a435d754002b"

URI_aarch64_rust-reqsign-file-read-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-file-read-tokio-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-file-read-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-file-read-tokio-devel}"
SRC_URI[aarch64_rust-reqsign-file-read-tokio-devel.sha256sum] = "fae356da59882a60bcf77ac119f5587f84e3dc179ecca75db8a840fcfaa7f4dd"

RDEPENDS:rust-reqsign-file-read-tokio+default-devel = " \
 cargo \
 rust-reqsign-file-read-tokio-devel \
 "
RDEPENDS:rust-reqsign-file-read-tokio-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-reqsign-core+default-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 "
