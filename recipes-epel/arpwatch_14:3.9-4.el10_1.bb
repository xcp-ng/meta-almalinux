# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arpwatch"
PE = "14"
PV = "3.9"
PR = "4.el10_1"
PACKAGES = " \
 arpwatch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/arpwatch-3.9-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7c8533a5e780ff0a4b91ad90bfc2e44bbd04070f1b4fba65ad4b4e70909b3df"

URI_x86_64_v2_arpwatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arpwatch-3.9-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arpwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arpwatch}"
SRC_URI[x86_64_v2_arpwatch.sha256sum] = "835d7fd729ac01e178b64003da1fb23bd0e5107f3fb6663a01c207ba5a6ff2e0"

URI_aarch64_arpwatch = "${EPEL_MIRROR}/aarch64/Packages/a/arpwatch-3.9-4.el10_1.aarch64.rpm;name=aarch64_arpwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_arpwatch}"
SRC_URI[aarch64_arpwatch.sha256sum] = "be432ebc07e42ee50e4f057d9d4289cac4bb49d7658d5ee74eaef58906400cf4"

RDEPENDS:arpwatch = " \
 bash \
 glibc \
 libpcap \
 python3 \
 shadow-utils \
 virtual//usr/sbin/sendmail \
 "
