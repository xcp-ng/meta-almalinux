# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aide"
PV = "0.19.2"
PR = "4.el10_2.1"
PACKAGES = " \
 aide \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/aide-0.19.2-4.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d937557ae198c677105d23d57bd2be9b6645447e62f23aed2e5bc4c78ff97d1"

URI_x86_64_v2_aide = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aide-0.19.2-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_aide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aide}"
SRC_URI[x86_64_v2_aide.sha256sum] = "50768bb27c068766330d201ae178250cf31396e705d711d0795f15f3c9b0facd"

URI_aarch64_aide = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aide-0.19.2-4.el10_2.1.aarch64.rpm;name=aarch64_aide;unpack=0"
SRC_URI:append = " ${URI_aarch64_aide}"
SRC_URI[aarch64_aide.sha256sum] = "14375868fcf2f43adb006417d584927896b3c4ca67a4cfa22a306c328b5e6f64"

RDEPENDS:aide = " \
 audit-libs \
 bash \
 e2fsprogs-libs \
 glibc \
 libacl \
 libselinux \
 nettle \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
