# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcsv"
PV = "3.0.3^20210820gitb1d5212"
PR = "15.el10_0"
PACKAGES = " \
 libcsv \
 libcsv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcsv-3.0.3^20210820gitb1d5212-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d933778811dc44b2548a7ccafe83515017895baee3a404f6ff26cab1cc097c62"

URI_x86_64_v2_libcsv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcsv-3.0.3^20210820gitb1d5212-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcsv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcsv}"
SRC_URI[x86_64_v2_libcsv.sha256sum] = "78d321c9ae948276b1c79ac1f65c04ed7f5e8cbc53e3fae6e82e022d01cbf1ec"

URI_x86_64_v2_libcsv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcsv-devel-3.0.3^20210820gitb1d5212-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcsv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcsv-devel}"
SRC_URI[x86_64_v2_libcsv-devel.sha256sum] = "3718d1f59a7f163a446d02429ca6e80f32e4066b7568c4624a177a0c6aa9a731"

URI_aarch64_libcsv = "${EPEL_MIRROR}/aarch64/Packages/l/libcsv-3.0.3^20210820gitb1d5212-15.el10_0.aarch64.rpm;name=aarch64_libcsv;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcsv}"
SRC_URI[aarch64_libcsv.sha256sum] = "6fe46f237c4518fea78b2f074439b459876eef48dc40fdae1c14a07a3fbb94b9"

URI_aarch64_libcsv-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcsv-devel-3.0.3^20210820gitb1d5212-15.el10_0.aarch64.rpm;name=aarch64_libcsv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcsv-devel}"
SRC_URI[aarch64_libcsv-devel.sha256sum] = "bee114815eb05d0a063e974113d68b4faceee0e55da1de859f742cd77f75ce4e"

RDEPENDS:libcsv = " \
 glibc \
 "
RDEPENDS:libcsv-devel = " \
 libcsv \
 "
