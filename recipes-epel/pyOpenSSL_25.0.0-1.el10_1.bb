# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyOpenSSL"
PV = "25.0.0"
PR = "1.el10_1"
PACKAGES = " \
 pyOpenSSL-doc \
 python3-pyOpenSSL \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pyOpenSSL-25.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1074a5db874cece76aea6d82115e5a2d65ddaa77315ce7cbd685807d8e80312"

URI_x86_64_v2_pyOpenSSL-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyOpenSSL-doc-25.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pyOpenSSL-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyOpenSSL-doc}"
SRC_URI[x86_64_v2_pyOpenSSL-doc.sha256sum] = "576b37b173787861df56c412c483b54c89baeb96e983fe523f2bd1c23a3a3209"

URI_x86_64_v2_python3-pyOpenSSL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyOpenSSL-25.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyOpenSSL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyOpenSSL}"
SRC_URI[x86_64_v2_python3-pyOpenSSL.sha256sum] = "a651fe7fd0f2b45a3785eee7331bd94ca221b45b01ec6af26020eebe03a06f6b"

URI_aarch64_pyOpenSSL-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pyOpenSSL-doc-25.0.0-1.el10_1.noarch.rpm;name=aarch64_pyOpenSSL-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyOpenSSL-doc}"
SRC_URI[aarch64_pyOpenSSL-doc.sha256sum] = "6622588f1b827f9edbffd5c22fd36329a6675b1b2cd329ac86ac9260802b7d28"

URI_aarch64_python3-pyOpenSSL = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyOpenSSL-25.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-pyOpenSSL;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyOpenSSL}"
SRC_URI[aarch64_python3-pyOpenSSL.sha256sum] = "eb5d2a6be0e47099c63fa042f83afac12021820bfc0d79fa0f9dcd57b71941dc"

RDEPENDS:pyOpenSSL-doc = " \
 "
RDEPENDS:python3-pyOpenSSL = " \
 python3 \
 python3-cryptography \
 python3-typing-extensions \
 "
