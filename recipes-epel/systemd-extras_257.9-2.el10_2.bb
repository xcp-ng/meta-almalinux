# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemd-extras"
PV = "257.9"
PR = "2.el10_2"
PACKAGES = " \
 systemd-networkd \
 systemd-networkd-defaults \
 systemd-timesyncd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/systemd-extras-257.9-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2a1bd15379c844e6eeb086e8712ea3acc8cefdf4e32130f8021803d2548d3ac"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - systemd-networkd: libcap.so.2()(64bit)
# - systemd-timesyncd: libcap.so.2()(64bit)

URI_x86_64_v2_systemd-networkd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/systemd-networkd-257.9-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_systemd-networkd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-networkd}"
SRC_URI[x86_64_v2_systemd-networkd.sha256sum] = "1101831c3764b2f433435a5eee3925a33676bf884d97ec844e9a41151d99e15f"

URI_x86_64_v2_systemd-networkd-defaults = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/systemd-networkd-defaults-257.9-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_systemd-networkd-defaults;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-networkd-defaults}"
SRC_URI[x86_64_v2_systemd-networkd-defaults.sha256sum] = "6a5439647a6050c840d70422c8f125a0769565cf75ec9af1262da8d6c0436fac"

URI_x86_64_v2_systemd-timesyncd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/systemd-timesyncd-257.9-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_systemd-timesyncd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-timesyncd}"
SRC_URI[x86_64_v2_systemd-timesyncd.sha256sum] = "89c509fcbc89488c357d69f4572acbf235cd3575b477655c0824d785dac8b523"

URI_aarch64_systemd-networkd = "${EPEL_MIRROR}/aarch64/Packages/s/systemd-networkd-257.9-2.el10_2.aarch64.rpm;name=aarch64_systemd-networkd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-networkd}"
SRC_URI[aarch64_systemd-networkd.sha256sum] = "930dbc484b9116e6e66fc6eaba9a17670a6c2537dc4be9b744c2334ae7b23398"

URI_aarch64_systemd-networkd-defaults = "${EPEL_MIRROR}/aarch64/Packages/s/systemd-networkd-defaults-257.9-2.el10_2.noarch.rpm;name=aarch64_systemd-networkd-defaults;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-networkd-defaults}"
SRC_URI[aarch64_systemd-networkd-defaults.sha256sum] = "32183895fa2b6fa28467defb1a8b8dc75b3a364fc380541598d208b006ae8ffb"

URI_aarch64_systemd-timesyncd = "${EPEL_MIRROR}/aarch64/Packages/s/systemd-timesyncd-257.9-2.el10_2.aarch64.rpm;name=aarch64_systemd-timesyncd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-timesyncd}"
SRC_URI[aarch64_systemd-timesyncd.sha256sum] = "98739cdb18d713b069ce8ce3807f2b76e2eb752517cef09c4ae929ebaa8a24ab"

RDEPENDS:systemd-networkd:x86_64_v2 = " \
 bash \
 dbus \
 glibc \
 libcap \
 libgcc \
 libmount \
 libselinux \
 shadow-utils \
 systemd \
 virtual/util-linux-core_or_util-linux \
"
RDEPENDS:systemd-networkd:aarch64 = " \
 bash \
 dbus \
 glibc \
 libgcc \
 libmount \
 libselinux \
 shadow-utils \
 systemd \
 virtual/util-linux-core_or_util-linux \
"
RDEPENDS:systemd-networkd-defaults = " \
 systemd-networkd \
 "
RDEPENDS:systemd-timesyncd:x86_64_v2 = " \
 bash \
 dbus \
 glibc \
 libcap \
 libgcc \
 libselinux \
 shadow-utils \
 systemd \
 virtual/util-linux-core_or_util-linux \
"
RDEPENDS:systemd-timesyncd:aarch64 = " \
 bash \
 dbus \
 glibc \
 libgcc \
 libselinux \
 shadow-utils \
 systemd \
 virtual/util-linux-core_or_util-linux \
"
