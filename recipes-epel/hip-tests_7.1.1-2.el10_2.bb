# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hip-tests"
PV = "7.1.1"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 hip-tests \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hip-tests-7.1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df077f1b1bfc64e7713d1b46b2a999c524215bfcf990472fc1e1c45d5c5107c5"

URI_x86_64_v2_hip-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hip-tests-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hip-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hip-tests}"
SRC_URI[x86_64_v2_hip-tests.sha256sum] = "9e3e6ff24bc38d9dd345ad76a3d25089fbcca6d81fc73224dc2bd31e1db94842"

RDEPENDS:hip-tests = " \
 cmake \
 freeglut \
 glibc \
 libgcc \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 numactl-libs \
 rocm-hip \
 rocminfo \
 "
