# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Pluggable"
PE = "2"
PV = "5.2"
PR = "24.el10_0"
PACKAGES = " \
 perl-Module-Pluggable \
 perl-Module-Pluggable-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Pluggable-5.2-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "477edcda76f8cdb069c192b490cceb00aa3698f0f059e148175bdfbe8e42b39a"

URI_x86_64_v2_perl-Module-Pluggable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Pluggable-5.2-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Pluggable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Pluggable}"
SRC_URI[x86_64_v2_perl-Module-Pluggable.sha256sum] = "7f628cc94c3aa7dc3f561dc12c025b4683a983a3102f7f9f59841c81d1720ea3"

URI_x86_64_v2_perl-Module-Pluggable-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Pluggable-tests-5.2-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Pluggable-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Pluggable-tests}"
SRC_URI[x86_64_v2_perl-Module-Pluggable-tests.sha256sum] = "479e4e49d999e9f507cbe9df787e36451bf826e3338f5398679406d425f66a19"

URI_aarch64_perl-Module-Pluggable = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Pluggable-5.2-24.el10_0.noarch.rpm;name=aarch64_perl-Module-Pluggable;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Pluggable}"
SRC_URI[aarch64_perl-Module-Pluggable.sha256sum] = "712da2e8fd4575f701d7c381b5ce6936d189566e75b9ed23601ca7a297e743b6"

URI_aarch64_perl-Module-Pluggable-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Pluggable-tests-5.2-24.el10_0.noarch.rpm;name=aarch64_perl-Module-Pluggable-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Pluggable-tests}"
SRC_URI[aarch64_perl-Module-Pluggable-tests.sha256sum] = "fde0057643e09e1cda42c9a7795be2ca9fb688215c6114e193c3fd5a25117b51"

RDEPENDS:perl-Module-Pluggable = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Find \
 perl-Module-Pluggable \
 perl-PathTools \
 perl-deprecate \
 perl-if \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Module-Pluggable-tests = " \
 bash \
 perl-Data-Dumper \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Module-Pluggable \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
