# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-defcon"
PV = "0.12.1"
PR = "25.el10_2"
PACKAGES = " \
 python3-defcon \
 python3-defcon+lxml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-defcon-0.12.1-25.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a79056c0f68fa3974ac1655d38bd7d6bba6ccc0261eb7808bce4a5c82e1e632e"

URI_x86_64_v2_python3-defcon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-defcon-0.12.1-25.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-defcon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-defcon}"
SRC_URI[x86_64_v2_python3-defcon.sha256sum] = "244e9da01bc19587c8b5c446cae988adf89888aadc9931d26bf5927b01ddce67"

URI_x86_64_v2_python3-defcon+lxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-defcon+lxml-0.12.1-25.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-defcon+lxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-defcon+lxml}"
SRC_URI[x86_64_v2_python3-defcon+lxml.sha256sum] = "8ec9fcc976561294b87c7652e7854eccf8e0698a1f55896793207405851c1902"

URI_aarch64_python3-defcon = "${EPEL_MIRROR}/aarch64/Packages/p/python3-defcon-0.12.1-25.el10_2.noarch.rpm;name=aarch64_python3-defcon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-defcon}"
SRC_URI[aarch64_python3-defcon.sha256sum] = "0a169dc66a75ce5580c2d27d106b47527f8919cb0ac513be1cc2f026ef5bd4a6"

URI_aarch64_python3-defcon+lxml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-defcon+lxml-0.12.1-25.el10_2.noarch.rpm;name=aarch64_python3-defcon+lxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-defcon+lxml}"
SRC_URI[aarch64_python3-defcon+lxml.sha256sum] = "34b0b431d6b60c2424b944ef5fb5d41d9028ff4f9d81798e47cf1bc2cabfc6e3"

RDEPENDS:python3-defcon = " \
 python3 \
 python3-fonttools \
 python3-fonttools+ufo \
 python3-fonttools+unicode \
 "
RDEPENDS:python3-defcon+lxml = " \
 python3 \
 python3-defcon \
 python3-fonttools \
 python3-fonttools+lxml \
 "
