# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-itertools"
PV = "0.15.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-itertools+default-devel \
 rust-itertools+use_alloc-devel \
 rust-itertools+use_std-devel \
 rust-itertools-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-itertools-0.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7db5844b732fc0b1546395ed5a3f1ac92242a60e19e3668d8870b3278226d64a"

URI_x86_64_v2_rust-itertools+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools+default-devel-0.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools+default-devel}"
SRC_URI[x86_64_v2_rust-itertools+default-devel.sha256sum] = "208441c3006cb21e5d8ea18c51b9196036ba56e008f9e99272e89dcdcbb5b9f5"

URI_x86_64_v2_rust-itertools+use_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools+use_alloc-devel-0.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools+use_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools+use_alloc-devel}"
SRC_URI[x86_64_v2_rust-itertools+use_alloc-devel.sha256sum] = "c6ceb5d6e6577eff9ae2177c148d63557638c5af940e35fd9cb05ef580ef2712"

URI_x86_64_v2_rust-itertools+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools+use_std-devel-0.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools+use_std-devel}"
SRC_URI[x86_64_v2_rust-itertools+use_std-devel.sha256sum] = "35162cde6a7a353a38e660f750cfe058f932e727db8087f0bb22ec07b59f4c1d"

URI_x86_64_v2_rust-itertools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools-devel-0.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools-devel}"
SRC_URI[x86_64_v2_rust-itertools-devel.sha256sum] = "3a95e0460f1210fe36e0842f721cef90fbcc223d845c8a27f89b6a2f14a5bb56"

URI_aarch64_rust-itertools+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools+default-devel-0.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-itertools+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools+default-devel}"
SRC_URI[aarch64_rust-itertools+default-devel.sha256sum] = "bb9742c5ce820a012950fd3172bc6c8c4450ee90e1f0ae32e2ac48dc67da8650"

URI_aarch64_rust-itertools+use_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools+use_alloc-devel-0.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-itertools+use_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools+use_alloc-devel}"
SRC_URI[aarch64_rust-itertools+use_alloc-devel.sha256sum] = "4e3b44d4cf02c326b8dbce4a22aeb001bd07d9e5e00694c4b7e390c59899f81c"

URI_aarch64_rust-itertools+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools+use_std-devel-0.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-itertools+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools+use_std-devel}"
SRC_URI[aarch64_rust-itertools+use_std-devel.sha256sum] = "78a9f7a68a7a30d57f8992667647c68eddb472b0c854ded840b27d84232c10af"

URI_aarch64_rust-itertools-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools-devel-0.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-itertools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools-devel}"
SRC_URI[aarch64_rust-itertools-devel.sha256sum] = "86fd1e21ff1986ab0838f8784bc5da53c4935f978d31b13105aabfd2dc26a893"

RDEPENDS:rust-itertools+default-devel = " \
 cargo \
 rust-itertools+use_std-devel \
 rust-itertools-devel \
 "
RDEPENDS:rust-itertools+use_alloc-devel = " \
 cargo \
 rust-itertools-devel \
 "
RDEPENDS:rust-itertools+use_std-devel = " \
 cargo \
 rust-either+use_std-devel \
 rust-itertools+use_alloc-devel \
 rust-itertools-devel \
 "
RDEPENDS:rust-itertools-devel = " \
 cargo \
 rust \
 rust-either-devel \
 "
