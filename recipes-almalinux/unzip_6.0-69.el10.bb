# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unzip"
PV = "6.0"
PR = "69.el10"
PACKAGES = " \
 unzip \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/unzip-6.0-69.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71676dc65cc465ad76347527073e3e77b46c1718f3ef3a3b0c1a10ced7a2d170"

URI_x86_64_v2_unzip = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/unzip-6.0-69.el10.x86_64_v2.rpm;name=x86_64_v2_unzip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unzip}"
SRC_URI[x86_64_v2_unzip.sha256sum] = "59a832e1193baf91054f8c53134e683be18417ce4058ff225aea969e14e5e5e4"

URI_aarch64_unzip = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/unzip-6.0-69.el10.aarch64.rpm;name=aarch64_unzip;unpack=0"
SRC_URI:append = " ${URI_aarch64_unzip}"
SRC_URI[aarch64_unzip.sha256sum] = "e08abb02f10992783b4e1f5bd8b3ead1974dc3d7cde7803eea8c88b2dfc32218"

RDEPENDS:unzip = " \
 bash \
 bzip2-libs \
 glibc \
 "
