# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zip"
PV = "3.0"
PR = "45.el10"
PACKAGES = " \
 zip \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/zip-3.0-45.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28a7903bf870bdcb89def52338cd5e15055ebfaf12dccd74f1308cc493e93857"

URI_x86_64_v2_zip = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/zip-3.0-45.el10.x86_64_v2.rpm;name=x86_64_v2_zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zip}"
SRC_URI[x86_64_v2_zip.sha256sum] = "af7c1d46dc346595a56d36832b90b292cd65348cdaf8f60026b0740847b425e3"

URI_aarch64_zip = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/zip-3.0-45.el10.aarch64.rpm;name=aarch64_zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_zip}"
SRC_URI[aarch64_zip.sha256sum] = "112dec06ef61fb7c052028e28082a5ef184953a0407326f322980ba2d38604d9"

RDEPENDS:zip = " \
 bzip2-libs \
 glibc \
 unzip \
 "
