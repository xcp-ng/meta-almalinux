# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby"
PV = "3.3.12"
PR = "15.el10_2"
PACKAGES = " \
 ruby \
 ruby-bundled-gems \
 ruby-default-gems \
 ruby-devel \
 ruby-doc \
 ruby-libs \
 rubygem-bigdecimal \
 rubygem-bundler \
 rubygem-io-console \
 rubygem-irb \
 rubygem-json \
 rubygem-minitest \
 rubygem-power_assert \
 rubygem-psych \
 rubygem-racc \
 rubygem-rake \
 rubygem-rbs \
 rubygem-rdoc \
 rubygem-rexml \
 rubygem-rss \
 rubygem-test-unit \
 rubygem-typeprof \
 rubygems \
 rubygems-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ruby-3.3.12-15.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ea9e1e35e522fa2219a09f32b4a07e6c0c162bf118fb67445e2924e566d1abc1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-3.3.12-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby;unpack=0"
SRC_URI[x86_64_v2_ruby.sha256sum] = "a3624acc54bebca4c4c5e8edc6c9a037c8e782f11fe076ef23765595babc6656"
RPROVIDES:ruby:append:x86_64_v2 = " virtual/ruby_runtime_executable_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-bundled-gems-3.3.12-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby-bundled-gems;unpack=0"
SRC_URI[x86_64_v2_ruby-bundled-gems.sha256sum] = "3bc7c06570bf9109f73d527e3773cabbd38dfbe0daa14f2a24e2cbf08e30770f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-default-gems-3.3.12-15.el10_2.noarch.rpm;name=x86_64_v2_ruby-default-gems;unpack=0"
SRC_URI[x86_64_v2_ruby-default-gems.sha256sum] = "9155f150b9f91e2dafb16414991ca13c36df3f4aee6ca777ca785c0180a1f86e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-devel-3.3.12-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby-devel;unpack=0"
SRC_URI[x86_64_v2_ruby-devel.sha256sum] = "fe85fbeeb157868b130a3061e2dd593aae106fd2a46bb3fe024242113cfe76d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ruby-doc-3.3.12-15.el10_2.noarch.rpm;name=x86_64_v2_ruby-doc;unpack=0"
SRC_URI[x86_64_v2_ruby-doc.sha256sum] = "09682b03de1764d4aa428a677326ab926d2bf8f1aa301f04748e026b8ab4198d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-libs-3.3.12-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby-libs;unpack=0"
SRC_URI[x86_64_v2_ruby-libs.sha256sum] = "e97cb88e2198708a302f7ae4c34ecea91513b4329af7fe889582a14ed0c74749"
RPROVIDES:ruby-libs:append:x86_64_v2 = " virtual/ruby_release_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bigdecimal-3.1.5-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-bigdecimal;unpack=0"
SRC_URI[x86_64_v2_rubygem-bigdecimal.sha256sum] = "c52d2bc6c38b58ab1f5685cba308260afe8c686cb57daab1f19f93a019fb7746"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bundler-2.5.22-15.el10_2.noarch.rpm;name=x86_64_v2_rubygem-bundler;unpack=0"
SRC_URI[x86_64_v2_rubygem-bundler.sha256sum] = "ff78ada1e367ca1dff09e79265bf4cff6a89438532915087f337c77c7cd2923f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-io-console-0.7.1-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-io-console;unpack=0"
SRC_URI[x86_64_v2_rubygem-io-console.sha256sum] = "9f6ed4705c3d086fe515d24598c1cea65a3faa270101539f33aa3e3a2e1e0d99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-irb-1.13.1-15.el10_2.noarch.rpm;name=x86_64_v2_rubygem-irb;unpack=0"
SRC_URI[x86_64_v2_rubygem-irb.sha256sum] = "109ed4ad1eaa45bf5dd31e4d43f1ae7d8d990a2c4d7eb7d161005b447b9cfc31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-json-2.7.2-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-json;unpack=0"
SRC_URI[x86_64_v2_rubygem-json.sha256sum] = "dad6de9a8b42dc87288cc879a10aeafb4265181459fc382a33178b91d295335b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-minitest-5.20.0-15.el10_2.noarch.rpm;name=x86_64_v2_rubygem-minitest;unpack=0"
SRC_URI[x86_64_v2_rubygem-minitest.sha256sum] = "981707b75742760cc5c109ab99fa4285d4062bb296b498d5b21eb4ff7869c5fd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-power_assert-2.0.3-15.el10_2.noarch.rpm;name=x86_64_v2_rubygem-power_assert;unpack=0"
SRC_URI[x86_64_v2_rubygem-power_assert.sha256sum] = "854289d012a71949ba1daef7ada1a60911e03ba7ba8676153267c548b6ad62e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-psych-5.1.2-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-psych;unpack=0"
SRC_URI[x86_64_v2_rubygem-psych.sha256sum] = "f37e0932ee671431d56bb7b58a8faef6c6374982420f039b376eb40f345a4a14"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-racc-1.7.3-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-racc;unpack=0"
SRC_URI[x86_64_v2_rubygem-racc.sha256sum] = "db6a5c4834d76646f3f8e9030f190cb6d6bfeb650e5d14afbf9be0b484b9e5db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rake-13.1.0-15.el10_2.noarch.rpm;name=x86_64_v2_rubygem-rake;unpack=0"
SRC_URI[x86_64_v2_rubygem-rake.sha256sum] = "6c4b9241ff9efa450aa5d3329a216aa37da225de270e1a5fe3f5f832b872e5ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rbs-3.4.0-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-rbs;unpack=0"
SRC_URI[x86_64_v2_rubygem-rbs.sha256sum] = "2065ea40d1c0655031909cc2e683b9b77b948024325d9c082aa1f099955fd21e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rdoc-6.6.3.1-15.el10_2.noarch.rpm;name=x86_64_v2_rubygem-rdoc;unpack=0"
SRC_URI[x86_64_v2_rubygem-rdoc.sha256sum] = "da102fb3c095a3ec1f34f5f5a2ac9fd136e78f9fb8ae0ed3b5f70b5e93856125"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rexml-3.4.4-15.el10_2.noarch.rpm;name=x86_64_v2_rubygem-rexml;unpack=0"
SRC_URI[x86_64_v2_rubygem-rexml.sha256sum] = "e05b865f8e326502a6561acbfe24e18752a7487792d727bb1f7154f70d471abb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rss-0.3.1-15.el10_2.noarch.rpm;name=x86_64_v2_rubygem-rss;unpack=0"
SRC_URI[x86_64_v2_rubygem-rss.sha256sum] = "f72093880d7151f2ac3049b0131eef30043c09b0a89c1ef075bae97585e288eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-test-unit-3.6.1-15.el10_2.noarch.rpm;name=x86_64_v2_rubygem-test-unit;unpack=0"
SRC_URI[x86_64_v2_rubygem-test-unit.sha256sum] = "982aad6d4f946198793b11b68f74cc897cad5306f4398bac99c666a1c85bdf92"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-typeprof-0.21.9-15.el10_2.noarch.rpm;name=x86_64_v2_rubygem-typeprof;unpack=0"
SRC_URI[x86_64_v2_rubygem-typeprof.sha256sum] = "a685c24c2adbb428ee0cbfe323eb4e6a3c6c342892b6be21a0290944b16acf89"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-3.5.22-15.el10_2.noarch.rpm;name=x86_64_v2_rubygems;unpack=0"
SRC_URI[x86_64_v2_rubygems.sha256sum] = "11349eba9345d9f2cc94bf421e58373e1d5458cbb9114f92d6b98d8207922418"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-devel-3.5.22-15.el10_2.noarch.rpm;name=x86_64_v2_rubygems-devel;unpack=0"
SRC_URI[x86_64_v2_rubygems-devel.sha256sum] = "492612048da0e57f477983879982cb57b3eada4308202c6d3fee92d24838f1e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-3.3.12-15.el10_2.aarch64.rpm;name=aarch64_ruby;unpack=0"
SRC_URI[aarch64_ruby.sha256sum] = "9845bb0e3bd79980e6579cf41a5872f1bc063125597e1579591bdde37d1ec3ae"
RPROVIDES:ruby:append:aarch64 = " virtual/ruby_runtime_executable_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-bundled-gems-3.3.12-15.el10_2.aarch64.rpm;name=aarch64_ruby-bundled-gems;unpack=0"
SRC_URI[aarch64_ruby-bundled-gems.sha256sum] = "b856d8bafb82ac84adcbeffb0e43de6893a26abc2206729b972d71d1d3a5ffd4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-default-gems-3.3.12-15.el10_2.noarch.rpm;name=aarch64_ruby-default-gems;unpack=0"
SRC_URI[aarch64_ruby-default-gems.sha256sum] = "9155f150b9f91e2dafb16414991ca13c36df3f4aee6ca777ca785c0180a1f86e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-devel-3.3.12-15.el10_2.aarch64.rpm;name=aarch64_ruby-devel;unpack=0"
SRC_URI[aarch64_ruby-devel.sha256sum] = "32d7d85361587908538580d463bffed6b8d2894fa09548a8f6721fe7ece47a74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ruby-doc-3.3.12-15.el10_2.noarch.rpm;name=aarch64_ruby-doc;unpack=0"
SRC_URI[aarch64_ruby-doc.sha256sum] = "09682b03de1764d4aa428a677326ab926d2bf8f1aa301f04748e026b8ab4198d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-libs-3.3.12-15.el10_2.aarch64.rpm;name=aarch64_ruby-libs;unpack=0"
SRC_URI[aarch64_ruby-libs.sha256sum] = "5c7738b1a0889128dabd153305483a5c74ef8432eaf22db82f5a7a7c9e408c67"
RPROVIDES:ruby-libs:append:aarch64 = " virtual/ruby_release_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bigdecimal-3.1.5-15.el10_2.aarch64.rpm;name=aarch64_rubygem-bigdecimal;unpack=0"
SRC_URI[aarch64_rubygem-bigdecimal.sha256sum] = "51f703aa299f0703ff2af7654181de3f9c80a06aec844c7e6c50efb659196636"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bundler-2.5.22-15.el10_2.noarch.rpm;name=aarch64_rubygem-bundler;unpack=0"
SRC_URI[aarch64_rubygem-bundler.sha256sum] = "ff78ada1e367ca1dff09e79265bf4cff6a89438532915087f337c77c7cd2923f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-io-console-0.7.1-15.el10_2.aarch64.rpm;name=aarch64_rubygem-io-console;unpack=0"
SRC_URI[aarch64_rubygem-io-console.sha256sum] = "0882220ae9bbc8704daebdffd90c418409632b2fee303acade0338829ec0fe23"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-irb-1.13.1-15.el10_2.noarch.rpm;name=aarch64_rubygem-irb;unpack=0"
SRC_URI[aarch64_rubygem-irb.sha256sum] = "109ed4ad1eaa45bf5dd31e4d43f1ae7d8d990a2c4d7eb7d161005b447b9cfc31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-json-2.7.2-15.el10_2.aarch64.rpm;name=aarch64_rubygem-json;unpack=0"
SRC_URI[aarch64_rubygem-json.sha256sum] = "53d3de10db4f547fbb8145488ed4a1199fb7884aaa330bc81d6ebdc56ee8f652"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-minitest-5.20.0-15.el10_2.noarch.rpm;name=aarch64_rubygem-minitest;unpack=0"
SRC_URI[aarch64_rubygem-minitest.sha256sum] = "981707b75742760cc5c109ab99fa4285d4062bb296b498d5b21eb4ff7869c5fd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-power_assert-2.0.3-15.el10_2.noarch.rpm;name=aarch64_rubygem-power_assert;unpack=0"
SRC_URI[aarch64_rubygem-power_assert.sha256sum] = "854289d012a71949ba1daef7ada1a60911e03ba7ba8676153267c548b6ad62e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-psych-5.1.2-15.el10_2.aarch64.rpm;name=aarch64_rubygem-psych;unpack=0"
SRC_URI[aarch64_rubygem-psych.sha256sum] = "79d30ef9d5418d287f4cbd2dc4ef40a4d5f6fe50e2afd17af75bb8ef9394969f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-racc-1.7.3-15.el10_2.aarch64.rpm;name=aarch64_rubygem-racc;unpack=0"
SRC_URI[aarch64_rubygem-racc.sha256sum] = "dbbfb5b468e251312fe0864112731c173619bb314219947336c1fb9c7ed7e5ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rake-13.1.0-15.el10_2.noarch.rpm;name=aarch64_rubygem-rake;unpack=0"
SRC_URI[aarch64_rubygem-rake.sha256sum] = "6c4b9241ff9efa450aa5d3329a216aa37da225de270e1a5fe3f5f832b872e5ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rbs-3.4.0-15.el10_2.aarch64.rpm;name=aarch64_rubygem-rbs;unpack=0"
SRC_URI[aarch64_rubygem-rbs.sha256sum] = "36efc5db787e75fd408b01480e4f23d3974fa831db5b3c7997c27f114bc37c4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rdoc-6.6.3.1-15.el10_2.noarch.rpm;name=aarch64_rubygem-rdoc;unpack=0"
SRC_URI[aarch64_rubygem-rdoc.sha256sum] = "da102fb3c095a3ec1f34f5f5a2ac9fd136e78f9fb8ae0ed3b5f70b5e93856125"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rexml-3.4.4-15.el10_2.noarch.rpm;name=aarch64_rubygem-rexml;unpack=0"
SRC_URI[aarch64_rubygem-rexml.sha256sum] = "e05b865f8e326502a6561acbfe24e18752a7487792d727bb1f7154f70d471abb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rss-0.3.1-15.el10_2.noarch.rpm;name=aarch64_rubygem-rss;unpack=0"
SRC_URI[aarch64_rubygem-rss.sha256sum] = "f72093880d7151f2ac3049b0131eef30043c09b0a89c1ef075bae97585e288eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-test-unit-3.6.1-15.el10_2.noarch.rpm;name=aarch64_rubygem-test-unit;unpack=0"
SRC_URI[aarch64_rubygem-test-unit.sha256sum] = "982aad6d4f946198793b11b68f74cc897cad5306f4398bac99c666a1c85bdf92"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-typeprof-0.21.9-15.el10_2.noarch.rpm;name=aarch64_rubygem-typeprof;unpack=0"
SRC_URI[aarch64_rubygem-typeprof.sha256sum] = "a685c24c2adbb428ee0cbfe323eb4e6a3c6c342892b6be21a0290944b16acf89"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-3.5.22-15.el10_2.noarch.rpm;name=aarch64_rubygems;unpack=0"
SRC_URI[aarch64_rubygems.sha256sum] = "11349eba9345d9f2cc94bf421e58373e1d5458cbb9114f92d6b98d8207922418"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-devel-3.5.22-15.el10_2.noarch.rpm;name=aarch64_rubygems-devel;unpack=0"
SRC_URI[aarch64_rubygems-devel.sha256sum] = "492612048da0e57f477983879982cb57b3eada4308202c6d3fee92d24838f1e5"

RDEPENDS:ruby = " \
 glibc \
 gmp \
 libxcrypt \
 ruby-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby-bundled-gems = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygem-irb \
 rubygems \
 "
RDEPENDS:ruby-default-gems = " \
 ruby \
 ruby-default-gems \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:ruby-devel = " \
 pkgconf-pkg-config \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:ruby-doc = " \
 rubygem-rdoc \
 "
RDEPENDS:ruby-libs = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:rubygem-bigdecimal = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-bundler = " \
 ruby \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:rubygem-io-console = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-irb = " \
 ruby \
 ruby-default-gems \
 rubygem-rdoc \
 rubygems \
 "
RDEPENDS:rubygem-json = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-minitest = " \
 rubygems \
 "
RDEPENDS:rubygem-power_assert = " \
 rubygems \
 "
RDEPENDS:rubygem-psych = " \
 glibc \
 libyaml \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-racc = " \
 glibc \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rake = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-rbs = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rdoc = " \
 ruby \
 rubygem-io-console \
 rubygem-json \
 rubygem-psych \
 rubygems \
 "
RDEPENDS:rubygem-rexml = " \
 rubygems \
 "
RDEPENDS:rubygem-rss = " \
 rubygem-rexml \
 rubygems \
 "
RDEPENDS:rubygem-test-unit = " \
 rubygem-power_assert \
 rubygems \
 "
RDEPENDS:rubygem-typeprof = " \
 ruby \
 rubygem-rbs \
 rubygems \
 "
RDEPENDS:rubygems = " \
 ruby \
 rubygem-psych \
 virtual/ruby_release_ \
 "
RDEPENDS:rubygems-devel = " \
 ruby \
 rubygem-json \
 rubygem-rdoc \
 rubygems \
 "
