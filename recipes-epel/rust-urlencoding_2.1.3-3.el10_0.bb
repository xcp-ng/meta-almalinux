# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-urlencoding"
PV = "2.1.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-urlencoding+default-devel \
 rust-urlencoding-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-urlencoding-2.1.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd04911cb782528d124bbe58a346f82889a3a525957bae4e6cb4a5ecaa74445e"

URI_x86_64_v2_rust-urlencoding+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-urlencoding+default-devel-2.1.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-urlencoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-urlencoding+default-devel}"
SRC_URI[x86_64_v2_rust-urlencoding+default-devel.sha256sum] = "ad6814b9eecdab6a117c56a017fcddfb52c78e65ed400f8e8917a6292eb127a3"

URI_x86_64_v2_rust-urlencoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-urlencoding-devel-2.1.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-urlencoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-urlencoding-devel}"
SRC_URI[x86_64_v2_rust-urlencoding-devel.sha256sum] = "2d4176ea8f8e91987f370383d007f817996289f0604851ad4b0b8d8012841f7d"

URI_aarch64_rust-urlencoding+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-urlencoding+default-devel-2.1.3-3.el10_0.noarch.rpm;name=aarch64_rust-urlencoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-urlencoding+default-devel}"
SRC_URI[aarch64_rust-urlencoding+default-devel.sha256sum] = "78a2bd673191dd5962fdd9b9d6e261ca9fa6bbb34454475e4d11109f78982391"

URI_aarch64_rust-urlencoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-urlencoding-devel-2.1.3-3.el10_0.noarch.rpm;name=aarch64_rust-urlencoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-urlencoding-devel}"
SRC_URI[aarch64_rust-urlencoding-devel.sha256sum] = "1c917fad2337ab1e7c3cd1b3159979664846c4b485d2eb734eb8c390530b7618"

RDEPENDS:rust-urlencoding+default-devel = " \
 cargo \
 rust-urlencoding-devel \
 "
RDEPENDS:rust-urlencoding-devel = " \
 cargo \
 "
