# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-cmake"
PV = "7.1.0"
PR = "2.el10_2"
PACKAGES = " \
 rocm-cmake \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-cmake-7.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf65026c5ceba9f9df6f6e8c0eda0b84dd849ad4b2aa193ad8b9beb95c00b88a"

URI_x86_64_v2_rocm-cmake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-cmake-7.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-cmake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-cmake}"
SRC_URI[x86_64_v2_rocm-cmake.sha256sum] = "fcf400fca89234b45eb9dff08e416c7dd3f58dfab335576906a8569ec7641a8e"

URI_aarch64_rocm-cmake = "${EPEL_MIRROR}/aarch64/Packages/r/rocm-cmake-7.1.0-2.el10_2.noarch.rpm;name=aarch64_rocm-cmake;unpack=0"
SRC_URI:append = " ${URI_aarch64_rocm-cmake}"
SRC_URI[aarch64_rocm-cmake.sha256sum] = "96d683952422c6306b5908b2ea6982f3f5199a28398724f8e65bf97b9fb592c2"

RDEPENDS:rocm-cmake = " \
 cmake \
 "
