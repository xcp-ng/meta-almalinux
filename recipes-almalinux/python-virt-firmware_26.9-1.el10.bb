# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-virt-firmware"
PV = "26.9"
PR = "1.el10"
PACKAGES = " \
 python3-virt-firmware \
 uki-direct \
 virt-sb-certs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-virt-firmware-26.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f2c0153e6985c928d5cd3e36cbbda3c9cef2a99cd3bc93ab2082329e1d3f6553"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-virt-firmware-26.9-1.el10.noarch.rpm;name=x86_64_v2_python3-virt-firmware;unpack=0"
SRC_URI[x86_64_v2_python3-virt-firmware.sha256sum] = "c3958dd8d7326d0874f524ad2b13e0958e5f7754d79c411b098a31d307243a5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uki-direct-26.9-1.el10.noarch.rpm;name=x86_64_v2_uki-direct;unpack=0"
SRC_URI[x86_64_v2_uki-direct.sha256sum] = "9d285af91aa490ee296e48028672f38040860d932fd9713b66ff1c39cb972c36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-sb-certs-26.9-1.el10.noarch.rpm;name=x86_64_v2_virt-sb-certs;unpack=0"
SRC_URI[x86_64_v2_virt-sb-certs.sha256sum] = "5598f28a0344b003356b64d01560ee867908353441fe1cd6961d14a831f7362f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-virt-firmware-26.9-1.el10.noarch.rpm;name=aarch64_python3-virt-firmware;unpack=0"
SRC_URI[aarch64_python3-virt-firmware.sha256sum] = "c3958dd8d7326d0874f524ad2b13e0958e5f7754d79c411b098a31d307243a5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uki-direct-26.9-1.el10.noarch.rpm;name=aarch64_uki-direct;unpack=0"
SRC_URI[aarch64_uki-direct.sha256sum] = "9d285af91aa490ee296e48028672f38040860d932fd9713b66ff1c39cb972c36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-sb-certs-26.9-1.el10.noarch.rpm;name=aarch64_virt-sb-certs;unpack=0"
SRC_URI[aarch64_virt-sb-certs.sha256sum] = "5598f28a0344b003356b64d01560ee867908353441fe1cd6961d14a831f7362f"

RDEPENDS:python3-virt-firmware = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-pyyaml \
 python3-requests \
 python3-setuptools \
 virt-sb-certs \
 "
RDEPENDS:uki-direct = " \
 bash \
 python3-virt-firmware \
 "
RDEPENDS:virt-sb-certs = " \
 "
