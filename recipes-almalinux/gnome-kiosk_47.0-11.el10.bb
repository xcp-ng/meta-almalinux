# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-kiosk"
PV = "47.0"
PR = "11.el10"
PACKAGES = " \
 gnome-kiosk \
 gnome-kiosk-script-session \
 gnome-kiosk-search-appliance \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-kiosk-47.0-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82253a7f704c141ea2927b8526f8d78bf024878420982834c03f20eaac636ecd"

URI_x86_64_v2_gnome-kiosk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-47.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-kiosk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-kiosk}"
SRC_URI[x86_64_v2_gnome-kiosk.sha256sum] = "cda6648538a1fce835a21ed68e8475bc665a8257c1665f1a1dab80f2e8d18d3b"
RPROVIDES:gnome-kiosk:append:x86_64_v2 = " virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_x86_64_v2_gnome-kiosk-script-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-script-session-47.0-11.el10.noarch.rpm;name=x86_64_v2_gnome-kiosk-script-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-kiosk-script-session}"
SRC_URI[x86_64_v2_gnome-kiosk-script-session.sha256sum] = "fe12ef3aac211c1e190e9650a65b949cbb42141fa173aeab83e6047f86f04c89"

URI_x86_64_v2_gnome-kiosk-search-appliance = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-search-appliance-47.0-11.el10.noarch.rpm;name=x86_64_v2_gnome-kiosk-search-appliance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-kiosk-search-appliance}"
SRC_URI[x86_64_v2_gnome-kiosk-search-appliance.sha256sum] = "229c1a0cd898044a1b481cf4be8761b5f8c17ea2b1673fb563ba1b107261a3a1"

URI_aarch64_gnome-kiosk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-47.0-11.el10.aarch64.rpm;name=aarch64_gnome-kiosk;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-kiosk}"
SRC_URI[aarch64_gnome-kiosk.sha256sum] = "0a2daa7da075624c5f73012430a12082a0f6515e4255e55ecdf3a24b41760921"
RPROVIDES:gnome-kiosk:append:aarch64 = " virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

URI_aarch64_gnome-kiosk-script-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-script-session-47.0-11.el10.noarch.rpm;name=aarch64_gnome-kiosk-script-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-kiosk-script-session}"
SRC_URI[aarch64_gnome-kiosk-script-session.sha256sum] = "fe12ef3aac211c1e190e9650a65b949cbb42141fa173aeab83e6047f86f04c89"

URI_aarch64_gnome-kiosk-search-appliance = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-search-appliance-47.0-11.el10.noarch.rpm;name=aarch64_gnome-kiosk-search-appliance;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-kiosk-search-appliance}"
SRC_URI[aarch64_gnome-kiosk-search-appliance.sha256sum] = "229c1a0cd898044a1b481cf4be8761b5f8c17ea2b1673fb563ba1b107261a3a1"

RDEPENDS:gnome-kiosk = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-desktop4 \
 gnome-settings-daemon \
 gsettings-desktop-schemas \
 ibus-libs \
 libX11 \
 libgcc \
 libglvnd-gles \
 mutter \
 systemd-libs \
 "
RDEPENDS:gnome-kiosk-script-session = " \
 bash \
 gnome-kiosk \
 gnome-session \
 "
RDEPENDS:gnome-kiosk-search-appliance = " \
 flatpak \
 gnome-kiosk \
 gnome-session \
 "
