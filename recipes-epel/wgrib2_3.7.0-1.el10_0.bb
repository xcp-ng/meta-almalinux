# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wgrib2"
PV = "3.7.0"
PR = "1.el10_0"
PACKAGES = " \
 wgrib2 \
 wgrib2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wgrib2-3.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "831e49452030f20569c9d5b83fb0aa8040e9f3fc707e7c77d363af6b7961d789"

URI_x86_64_v2_wgrib2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wgrib2-3.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wgrib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wgrib2}"
SRC_URI[x86_64_v2_wgrib2.sha256sum] = "703e5b75b672218918e7ab91c6a0067a79b13a9c031b021f1361155a6cb129fe"

URI_x86_64_v2_wgrib2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wgrib2-devel-3.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wgrib2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wgrib2-devel}"
SRC_URI[x86_64_v2_wgrib2-devel.sha256sum] = "8765e56f1e25a8cb998e125d77a72a872c3108d7f2c8aa209f26f4b6f4c2685b"

URI_aarch64_wgrib2 = "${EPEL_MIRROR}/aarch64/Packages/w/wgrib2-3.7.0-1.el10_0.aarch64.rpm;name=aarch64_wgrib2;unpack=0"
SRC_URI:append = " ${URI_aarch64_wgrib2}"
SRC_URI[aarch64_wgrib2.sha256sum] = "a56fff41e6b353b4b2a1f54fb6725a501e1d2f73fd970ab1c7b8f774b6842af5"

URI_aarch64_wgrib2-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wgrib2-devel-3.7.0-1.el10_0.aarch64.rpm;name=aarch64_wgrib2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wgrib2-devel}"
SRC_URI[aarch64_wgrib2-devel.sha256sum] = "47d0b3e659be823a3e2f86ffa639786ad0d0f78cafefd9de68b9696852906463"

RDEPENDS:wgrib2 = " \
 glibc \
 libaec \
 libgcc \
 libgomp \
 mariadb-connector-c \
 netcdf \
 "
RDEPENDS:wgrib2-devel = " \
 cmake-filesystem \
 glibc \
 libaec \
 libgcc \
 libgfortran \
 libgomp \
 mariadb-connector-c \
 netcdf \
 "
