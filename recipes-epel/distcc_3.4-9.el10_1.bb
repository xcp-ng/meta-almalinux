# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distcc"
PV = "3.4"
PR = "9.el10_1"
PACKAGES = " \
 distcc \
 distcc-gnome \
 distcc-server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/distcc-3.4-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9c706c06e0c7053dd83b88d63ee87a20600600bbaae0fed11dbba8c232610ce"

URI_x86_64_v2_distcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distcc-3.4-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_distcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distcc}"
SRC_URI[x86_64_v2_distcc.sha256sum] = "d139598a949a8301de59e3650e1272f5a14e057b7806ce244c9c57f79abebf63"

URI_x86_64_v2_distcc-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distcc-gnome-3.4-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_distcc-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distcc-gnome}"
SRC_URI[x86_64_v2_distcc-gnome.sha256sum] = "601a3b480ab326eca3d1038997bf4bc8f6450aa5242befa6895367f3de360908"

URI_x86_64_v2_distcc-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distcc-server-3.4-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_distcc-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distcc-server}"
SRC_URI[x86_64_v2_distcc-server.sha256sum] = "bd8a56c6b62e40d86479b618ba13b64cab06316e5e62203331cb7dedc9308bf7"

URI_aarch64_distcc = "${EPEL_MIRROR}/aarch64/Packages/d/distcc-3.4-9.el10_1.aarch64.rpm;name=aarch64_distcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_distcc}"
SRC_URI[aarch64_distcc.sha256sum] = "0a26f01673dae71818b20d87073cbd94aed405f0b3b1c6cfa759f6b3c5cfbd42"

URI_aarch64_distcc-gnome = "${EPEL_MIRROR}/aarch64/Packages/d/distcc-gnome-3.4-9.el10_1.aarch64.rpm;name=aarch64_distcc-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_distcc-gnome}"
SRC_URI[aarch64_distcc-gnome.sha256sum] = "8732f90971218b6659f926d7921f375b9943b6c78fe93b1dc7d51aa9567b5e86"

URI_aarch64_distcc-server = "${EPEL_MIRROR}/aarch64/Packages/d/distcc-server-3.4-9.el10_1.aarch64.rpm;name=aarch64_distcc-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_distcc-server}"
SRC_URI[aarch64_distcc-server.sha256sum] = "3954e010ef6faff08d5f8fa9e1c171f363744f27539a26ba8308c1572c0c7edd"

RDEPENDS:distcc = " \
 avahi-libs \
 bash \
 glibc \
 krb5-libs \
 python3 \
 "
RDEPENDS:distcc-gnome = " \
 cairo \
 distcc \
 glib2 \
 glibc \
 gtk3 \
 "
RDEPENDS:distcc-server = " \
 avahi-libs \
 bash \
 distcc \
 glibc \
 krb5-libs \
 popt \
 python3 \
 systemd \
 "
