# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernel-srpm-macros"
PV = "1.0"
PR = "25.el10"
PACKAGES = " \
 kernel-rpm-macros \
 kernel-srpm-macros \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/kernel-srpm-macros-1.0-25.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d16d05a53da5bded6c52aa3743253f497463803ab38168621812f728a794bb9d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-rpm-macros-205-25.el10.noarch.rpm;name=x86_64_v2_kernel-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_kernel-rpm-macros.sha256sum] = "c1b332b9b8f881b0e05736638fb013f0131b821ce643c75d2090fc46f0b42ddf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-srpm-macros-1.0-25.el10.noarch.rpm;name=x86_64_v2_kernel-srpm-macros;unpack=0"
SRC_URI[x86_64_v2_kernel-srpm-macros.sha256sum] = "9eda056264ee33ae8d68c6c3467232637afbfc9901eb96df88ca4f7286877171"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-rpm-macros-205-25.el10.noarch.rpm;name=aarch64_kernel-rpm-macros;unpack=0"
SRC_URI[aarch64_kernel-rpm-macros.sha256sum] = "c1b332b9b8f881b0e05736638fb013f0131b821ce643c75d2090fc46f0b42ddf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-srpm-macros-1.0-25.el10.noarch.rpm;name=aarch64_kernel-srpm-macros;unpack=0"
SRC_URI[aarch64_kernel-srpm-macros.sha256sum] = "9eda056264ee33ae8d68c6c3467232637afbfc9901eb96df88ca4f7286877171"

RDEPENDS:kernel-rpm-macros = " \
 bash \
 binutils \
 findutils \
 gawk \
 grep \
 kmod \
 perl-interpreter \
 redhat-rpm-config \
 sed \
 xz \
 "
RDEPENDS:kernel-srpm-macros = " \
 "
