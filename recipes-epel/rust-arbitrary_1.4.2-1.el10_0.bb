# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arbitrary"
PV = "1.4.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-arbitrary+derive_arbitrary-devel \
 rust-arbitrary-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arbitrary-1.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44effbe3a3a8a65f4eeccc721b417478989a4f40648fed3d9c95a58dde2ac416"

URI_x86_64_v2_rust-arbitrary+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arbitrary+default-devel-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arbitrary+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arbitrary+default-devel}"
SRC_URI[x86_64_v2_rust-arbitrary+default-devel.sha256sum] = "e9577fcbb59b4fdc5e2c31d49922935bcc503bca1bf7c25de611003b9301accc"

URI_x86_64_v2_rust-arbitrary+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arbitrary+derive-devel-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arbitrary+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arbitrary+derive-devel}"
SRC_URI[x86_64_v2_rust-arbitrary+derive-devel.sha256sum] = "078e6b0c72076332d6c29b0ce15496f61a2f5f81f7d5464a01744253635a84cf"

URI_x86_64_v2_rust-arbitrary+derive_arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arbitrary+derive_arbitrary-devel-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arbitrary+derive_arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arbitrary+derive_arbitrary-devel}"
SRC_URI[x86_64_v2_rust-arbitrary+derive_arbitrary-devel.sha256sum] = "663da2cd71fa48b08917d4189a2f8f7f7c3979d56748be6850fd6cfc6aa4ad67"

URI_x86_64_v2_rust-arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arbitrary-devel-1.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arbitrary-devel}"
SRC_URI[x86_64_v2_rust-arbitrary-devel.sha256sum] = "e05094ad6ef25e52d7f58429bdcb6763c9d3b903fe3efed0c1bc9edcbb39149c"

URI_aarch64_rust-arbitrary+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arbitrary+default-devel-1.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-arbitrary+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arbitrary+default-devel}"
SRC_URI[aarch64_rust-arbitrary+default-devel.sha256sum] = "b579ccb86711ecb2f6f43bfc2f94e32b9b746c6f9012ffb8ae6f7ad8d083ed88"

URI_aarch64_rust-arbitrary+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arbitrary+derive-devel-1.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-arbitrary+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arbitrary+derive-devel}"
SRC_URI[aarch64_rust-arbitrary+derive-devel.sha256sum] = "8b9f481c501e5f8b2904fdc0a703abae3e0d49a749f4a4568c55ae6fa7b93426"

URI_aarch64_rust-arbitrary+derive_arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arbitrary+derive_arbitrary-devel-1.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-arbitrary+derive_arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arbitrary+derive_arbitrary-devel}"
SRC_URI[aarch64_rust-arbitrary+derive_arbitrary-devel.sha256sum] = "9794a67e91d662ca8c5f63bf7f903022b4c9083cd028b3d2626c8a1cb1a07929"

URI_aarch64_rust-arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arbitrary-devel-1.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arbitrary-devel}"
SRC_URI[aarch64_rust-arbitrary-devel.sha256sum] = "595b514c9ffd37468864b321f4ba135f7555b2771ad79c6aaae6631666e33ef2"

RDEPENDS:rust-arbitrary+default-devel = " \
 cargo \
 rust-arbitrary-devel \
 "
RDEPENDS:rust-arbitrary+derive-devel = " \
 cargo \
 rust-arbitrary+derive_arbitrary-devel \
 rust-arbitrary-devel \
 "
RDEPENDS:rust-arbitrary+derive_arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-derive_arbitrary+default-devel \
 "
RDEPENDS:rust-arbitrary-devel = " \
 bash \
 cargo \
 rust \
 "
