# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kseexpr"
PV = "6.0.0.0"
PR = "1.el10_3"
PACKAGES = " \
 kseexpr \
 kseexpr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kseexpr-6.0.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c68531587a4ab7e7d5f64f93b089d6e3eaa029f18d76a43d7f1947f8e2ea6f5"

URI_x86_64_v2_kseexpr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kseexpr-6.0.0.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kseexpr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kseexpr}"
SRC_URI[x86_64_v2_kseexpr.sha256sum] = "b913f226226275ebb2586a8748f25a418daa1f5e72bd15072562a74955315d32"

URI_x86_64_v2_kseexpr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kseexpr-devel-6.0.0.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kseexpr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kseexpr-devel}"
SRC_URI[x86_64_v2_kseexpr-devel.sha256sum] = "9680c0ffea1ce1b6ea1ab78a318530bf5d0311af9ab58f567cd513497c5778e0"

URI_aarch64_kseexpr = "${EPEL_MIRROR}/aarch64/Packages/k/kseexpr-6.0.0.0-1.el10_3.aarch64.rpm;name=aarch64_kseexpr;unpack=0"
SRC_URI:append = " ${URI_aarch64_kseexpr}"
SRC_URI[aarch64_kseexpr.sha256sum] = "208db5afed304573a49c28888adc21705e74231898c92551d04c6f8b12a15951"

URI_aarch64_kseexpr-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kseexpr-devel-6.0.0.0-1.el10_3.aarch64.rpm;name=aarch64_kseexpr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kseexpr-devel}"
SRC_URI[aarch64_kseexpr-devel.sha256sum] = "8bdb2f11dc04a1492ffb20ac9b700947910a0614e824d74a80cd8604a602076e"

RDEPENDS:kseexpr = " \
 glibc \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kseexpr-devel = " \
 cmake-filesystem \
 kseexpr \
 pkgconf-pkg-config \
 "
