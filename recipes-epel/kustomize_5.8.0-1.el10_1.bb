# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kustomize"
PV = "5.8.0"
PR = "1.el10_1"
PACKAGES = " \
 kustomize \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kustomize-5.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f749332adb78d7826e5c202a1f5cde93016dbd711bfe75b04be292872c701f2f"

URI_x86_64_v2_kustomize = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kustomize-5.8.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kustomize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kustomize}"
SRC_URI[x86_64_v2_kustomize.sha256sum] = "9dc21937da337a87cea434923663424ac21eff54fcd358c8b37cbbf329e2cf63"

URI_aarch64_kustomize = "${EPEL_MIRROR}/aarch64/Packages/k/kustomize-5.8.0-1.el10_1.aarch64.rpm;name=aarch64_kustomize;unpack=0"
SRC_URI:append = " ${URI_aarch64_kustomize}"
SRC_URI[aarch64_kustomize.sha256sum] = "cba02fbfe5f8788092677ee90a21e6c7bb27abc2baacbdf9774c010db8a6a852"

RDEPENDS:kustomize = " \
 git-core \
 glibc \
 "
