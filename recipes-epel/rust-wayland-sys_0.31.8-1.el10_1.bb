# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-sys"
PV = "0.31.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-wayland-sys+client-devel \
 rust-wayland-sys+cursor-devel \
 rust-wayland-sys+default-devel \
 rust-wayland-sys+dlopen-devel \
 rust-wayland-sys+egl-devel \
 rust-wayland-sys+libc-devel \
 rust-wayland-sys+memoffset-devel \
 rust-wayland-sys+once_cell-devel \
 rust-wayland-sys+server-devel \
 rust-wayland-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-sys-0.31.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59a67ffb6f144d752fde4599181b8e020610616aeff987e7cb8c5cb27a5a623b"

URI_x86_64_v2_rust-wayland-sys+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+client-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+client-devel.sha256sum] = "e555fa97f01503ae0efab723f49424d1a7551a8519ecfaa6efc07129fe987ccf"

URI_x86_64_v2_rust-wayland-sys+cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+cursor-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+cursor-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+cursor-devel.sha256sum] = "8daae0482b4f93a4824445cc1051371db25f051d64c95d224aff3c307294e26c"

URI_x86_64_v2_rust-wayland-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+default-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+default-devel.sha256sum] = "8be393683b44568ead205a7bcf7ea3aa784374d1602c153d1ac29b1e7c90a3ed"

URI_x86_64_v2_rust-wayland-sys+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+dlopen-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+dlopen-devel.sha256sum] = "1018505519e024e58d914e8179325840e2cabcb3f63026025788a63b6943231b"

URI_x86_64_v2_rust-wayland-sys+egl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+egl-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+egl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+egl-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+egl-devel.sha256sum] = "6ae36f95e410a3bdb3a671a4169ddfd07978f18e310d868053aeae84250ff6a0"

URI_x86_64_v2_rust-wayland-sys+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+libc-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+libc-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+libc-devel.sha256sum] = "bcf74aafc5097eac25792b66d81160d10d754450a41c27a52682c648aaabfc03"

URI_x86_64_v2_rust-wayland-sys+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+memoffset-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+memoffset-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+memoffset-devel.sha256sum] = "b2d3a9d4a050f04ba93f1efc3e46faa5e26e22a67c3a042507dce6b15d84b7c7"

URI_x86_64_v2_rust-wayland-sys+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+once_cell-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+once_cell-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+once_cell-devel.sha256sum] = "03834f0f41f13a3e01ac7f462a6b076424d6a418efcb986d15b468a59ab0bb63"

URI_x86_64_v2_rust-wayland-sys+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys+server-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys+server-devel.sha256sum] = "08ba6eeb628417cc1affe11e472682b9fb265d15665e8b84baa9f4c706ab056c"

URI_x86_64_v2_rust-wayland-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-sys-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-sys-devel}"
SRC_URI[x86_64_v2_rust-wayland-sys-devel.sha256sum] = "93aea21f439f983f4351b90de918f55f183d0ef198b8dabd725e61d32b3f78f0"

URI_aarch64_rust-wayland-sys+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+client-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-sys+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+client-devel}"
SRC_URI[aarch64_rust-wayland-sys+client-devel.sha256sum] = "786b0afecbbd3146d48f119f51495291fd952dd231de1b2389ecd08443b748a2"

URI_aarch64_rust-wayland-sys+cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+cursor-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-sys+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+cursor-devel}"
SRC_URI[aarch64_rust-wayland-sys+cursor-devel.sha256sum] = "befac397f78c0e3689ce5babf9f750b92bf2b1bf641993ed19646563492e46e9"

URI_aarch64_rust-wayland-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+default-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+default-devel}"
SRC_URI[aarch64_rust-wayland-sys+default-devel.sha256sum] = "0e04513cb7d4704c82fdd544ebc9b7ac7ac1d03884c0a13f9734823c945c5460"

URI_aarch64_rust-wayland-sys+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+dlopen-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-sys+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+dlopen-devel}"
SRC_URI[aarch64_rust-wayland-sys+dlopen-devel.sha256sum] = "d4871ff79f3fe06a242b96656318ec1bcf6725884ad0bb8cb5c190865b2867f0"

URI_aarch64_rust-wayland-sys+egl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+egl-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-sys+egl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+egl-devel}"
SRC_URI[aarch64_rust-wayland-sys+egl-devel.sha256sum] = "3f7374314133221b6b66f301e8e4e1be29f16d94c79c8b773ee0c4b6f056f89d"

URI_aarch64_rust-wayland-sys+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+libc-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+libc-devel}"
SRC_URI[aarch64_rust-wayland-sys+libc-devel.sha256sum] = "b899fa731412e3a9a1d4992d5a3f755e75b608bd4f449ec297dc769f5be3c3a6"

URI_aarch64_rust-wayland-sys+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+memoffset-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-sys+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+memoffset-devel}"
SRC_URI[aarch64_rust-wayland-sys+memoffset-devel.sha256sum] = "aca8001e6ff5af70966a3373f5967cb1eb059e8a915566f3ce38fec51cd63f4c"

URI_aarch64_rust-wayland-sys+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+once_cell-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-sys+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+once_cell-devel}"
SRC_URI[aarch64_rust-wayland-sys+once_cell-devel.sha256sum] = "a26619f5470c55f0183a986262f7924f5c4ac4f53410e04dc2fbde5728d01eb5"

URI_aarch64_rust-wayland-sys+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys+server-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-sys+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys+server-devel}"
SRC_URI[aarch64_rust-wayland-sys+server-devel.sha256sum] = "ddef430227fd478b06e16064cbb86e927d569f57964f83c2a3cdc18255192f18"

URI_aarch64_rust-wayland-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-sys-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-sys-devel}"
SRC_URI[aarch64_rust-wayland-sys-devel.sha256sum] = "1e1ae4e20d28f021e89b24a86755399df1bd6fdf76041ba80973f235e05519a5"

RDEPENDS:rust-wayland-sys+client-devel = " \
 cargo \
 rust-dlib+default-devel \
 rust-log+default-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+cursor-devel = " \
 cargo \
 rust-wayland-sys+client-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+default-devel = " \
 cargo \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+dlopen-devel = " \
 cargo \
 rust-wayland-sys+once_cell-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+egl-devel = " \
 cargo \
 rust-wayland-sys+client-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-wayland-sys-devel \
 "
RDEPENDS:rust-wayland-sys+server-devel = " \
 cargo \
 rust-dlib+default-devel \
 rust-log+default-devel \
 rust-wayland-sys+libc-devel \
 rust-wayland-sys+memoffset-devel \
 rust-wayland-sys-devel \
 wayland-devel \
 "
RDEPENDS:rust-wayland-sys-devel = " \
 cargo \
 rust \
 rust-pkg-config+default-devel \
 wayland-devel \
 "
