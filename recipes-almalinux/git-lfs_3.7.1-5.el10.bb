# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-lfs"
PV = "3.7.1"
PR = "5.el10"
PACKAGES = " \
 git-lfs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/git-lfs-3.7.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5620841f922f65d991fb938b23be8a39dbc684279f2afb7cd551b94751dee713"

URI_x86_64_v2_git-lfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-lfs-3.7.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_git-lfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-lfs}"
SRC_URI[x86_64_v2_git-lfs.sha256sum] = "7db73de069ea7db9f12d81a0dec1f1662bbcac4678a8c733936796573b27a036"

URI_aarch64_git-lfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-lfs-3.7.1-5.el10.aarch64.rpm;name=aarch64_git-lfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-lfs}"
SRC_URI[aarch64_git-lfs.sha256sum] = "dd319f2333c8d032d4bf0e42c2c67624135d10f8d3e34a535a312c7dcbfa7a9c"

RDEPENDS:git-lfs = " \
 bash \
 git-core \
 glibc \
 "
