# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "disciplining-minipod"
PV = "3.10.3"
PR = "1.el10_3"
PACKAGES = " \
 liboscillator-disciplining \
 liboscillator-disciplining-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/disciplining-minipod-3.10.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a18c1d87b2fa0d0b7a1dd673962426e842c4a5a99577e5877e0cde628811594"

URI_x86_64_v2_liboscillator-disciplining = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboscillator-disciplining-3.10.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboscillator-disciplining;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboscillator-disciplining}"
SRC_URI[x86_64_v2_liboscillator-disciplining.sha256sum] = "259178e008d9a1cb19737f691b0eb7a05e4757a89693e8ed327b676af5dee646"

URI_x86_64_v2_liboscillator-disciplining-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboscillator-disciplining-devel-3.10.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboscillator-disciplining-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboscillator-disciplining-devel}"
SRC_URI[x86_64_v2_liboscillator-disciplining-devel.sha256sum] = "1caa124380467674cb9ee4d868f3407225edb2a6023d135328834a490f4b0620"

URI_aarch64_liboscillator-disciplining = "${EPEL_MIRROR}/aarch64/Packages/l/liboscillator-disciplining-3.10.3-1.el10_3.aarch64.rpm;name=aarch64_liboscillator-disciplining;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboscillator-disciplining}"
SRC_URI[aarch64_liboscillator-disciplining.sha256sum] = "7548e0b9e9227af39ffe40d9a14c1100160f3d1102c33597cb36b0b9d9aa0325"

URI_aarch64_liboscillator-disciplining-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liboscillator-disciplining-devel-3.10.3-1.el10_3.aarch64.rpm;name=aarch64_liboscillator-disciplining-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboscillator-disciplining-devel}"
SRC_URI[aarch64_liboscillator-disciplining-devel.sha256sum] = "0cc42a67378c5f617bd534af2344ec5263d4be7c410b61e20b103b2cc4241946"

RDEPENDS:liboscillator-disciplining = " \
 glibc \
 "
RDEPENDS:liboscillator-disciplining-devel = " \
 liboscillator-disciplining \
 pkgconf-pkg-config \
 "
