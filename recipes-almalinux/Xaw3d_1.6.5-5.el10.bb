# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Xaw3d"
PV = "1.6.5"
PR = "5.el10"
PACKAGES = " \
 Xaw3d \
 Xaw3d-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/Xaw3d-1.6.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6acd0e75cab37fe3812c488eb5258a0af219bf2f233790e4e6ca5b4c2b7df70a"

URI_x86_64_v2_Xaw3d = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/Xaw3d-1.6.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_Xaw3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Xaw3d}"
SRC_URI[x86_64_v2_Xaw3d.sha256sum] = "51ba47b56366466e7b1fa912bd7f461a4243b323b79dc9ee2f7f408837f14c7d"

URI_x86_64_v2_Xaw3d-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/Xaw3d-devel-1.6.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_Xaw3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Xaw3d-devel}"
SRC_URI[x86_64_v2_Xaw3d-devel.sha256sum] = "fbbc6cd377eba8d2a16cf5826fb4e9d626ad4a6b943aeafdbd2275572c6943ae"

URI_aarch64_Xaw3d = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/Xaw3d-1.6.5-5.el10.aarch64.rpm;name=aarch64_Xaw3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_Xaw3d}"
SRC_URI[aarch64_Xaw3d.sha256sum] = "63834016c42a0edf1d228dbae1708159a126470af35e58cd894eadf683d89c45"

URI_aarch64_Xaw3d-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/Xaw3d-devel-1.6.5-5.el10.aarch64.rpm;name=aarch64_Xaw3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_Xaw3d-devel}"
SRC_URI[aarch64_Xaw3d-devel.sha256sum] = "0d23a5334c4d829b0deaf20d6b09253333ac05a27d96a3a8204fa20d12bc7f65"

RDEPENDS:Xaw3d = " \
 glibc \
 libX11 \
 libXext \
 libXmu \
 libXpm \
 libXt \
 "
RDEPENDS:Xaw3d-devel = " \
 Xaw3d \
 libSM-devel \
 libX11-devel \
 libXext-devel \
 libXmu-devel \
 libXpm-devel \
 libXt-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
