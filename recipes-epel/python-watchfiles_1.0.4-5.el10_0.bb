# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-watchfiles"
PV = "1.0.4"
PR = "5.el10_0"
PACKAGES = " \
 python3-watchfiles \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-watchfiles-1.0.4-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "764142ddf2c6583064dd4d17028e4855232662ad6174a3f85cb25b6f9c2509e6"

URI_x86_64_v2_python3-watchfiles = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-watchfiles-1.0.4-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-watchfiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-watchfiles}"
SRC_URI[x86_64_v2_python3-watchfiles.sha256sum] = "578230442396eb3afb78f4a67db5230adfa43e7420582ac99bd450b441ea294c"

URI_aarch64_python3-watchfiles = "${EPEL_MIRROR}/aarch64/Packages/p/python3-watchfiles-1.0.4-5.el10_0.aarch64.rpm;name=aarch64_python3-watchfiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-watchfiles}"
SRC_URI[aarch64_python3-watchfiles.sha256sum] = "68f64bb3b7dbc6793978d672ca91b9d519e6573560703bf0194f6f1ec64c13dd"

RDEPENDS:python3-watchfiles = " \
 glibc \
 libgcc \
 python3 \
 python3-anyio \
 "
