# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cloud-utils"
PV = "0.33"
PR = "11.el10"
PACKAGES = " \
 cloud-utils-growpart \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cloud-utils-0.33-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "470967a86958c3348264646a117ee29982432d795426c6f48ab5ea3ecab808c3"

URI_x86_64_v2_cloud-utils-growpart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cloud-utils-growpart-0.33-11.el10.noarch.rpm;name=x86_64_v2_cloud-utils-growpart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cloud-utils-growpart}"
SRC_URI[x86_64_v2_cloud-utils-growpart.sha256sum] = "15e588602306bef1e6f1fc41faec76d2c1f6c801f4228c90d5e5095cb394dfe9"

URI_aarch64_cloud-utils-growpart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cloud-utils-growpart-0.33-11.el10.noarch.rpm;name=aarch64_cloud-utils-growpart;unpack=0"
SRC_URI:append = " ${URI_aarch64_cloud-utils-growpart}"
SRC_URI[aarch64_cloud-utils-growpart.sha256sum] = "15e588602306bef1e6f1fc41faec76d2c1f6c801f4228c90d5e5095cb394dfe9"

RDEPENDS:cloud-utils-growpart = " \
 bash \
 gawk \
 util-linux \
 "
