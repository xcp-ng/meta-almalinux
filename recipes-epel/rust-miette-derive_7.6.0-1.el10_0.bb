# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-miette-derive"
PV = "7.6.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-miette-derive+default-devel \
 rust-miette-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-miette-derive-7.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a31ee6ed3b27bd97692d60f68c743da288f1fc11a68e7ed97b90dfbda593b094"

URI_x86_64_v2_rust-miette-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette-derive+default-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette-derive+default-devel}"
SRC_URI[x86_64_v2_rust-miette-derive+default-devel.sha256sum] = "489cbd9ffff23a9d854dadbfbcdd41aefdd2274e177c4b492fb339cd32712543"

URI_x86_64_v2_rust-miette-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette-derive-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette-derive-devel}"
SRC_URI[x86_64_v2_rust-miette-derive-devel.sha256sum] = "e4cc49367b70b7d1beafbbce25c0ab1ea2168342ef7f42e96a464f6d111b8169"

URI_aarch64_rust-miette-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette-derive+default-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette-derive+default-devel}"
SRC_URI[aarch64_rust-miette-derive+default-devel.sha256sum] = "fb2b19dd756e35b657558f708269db5ddb31136498ad893ce9e8ccf3199900b1"

URI_aarch64_rust-miette-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette-derive-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette-derive-devel}"
SRC_URI[aarch64_rust-miette-derive-devel.sha256sum] = "6aa30507ebd4ff8405d92a7e348dbafbbf09cb1f4044d8f9672b0b2084223180"

RDEPENDS:rust-miette-derive+default-devel = " \
 cargo \
 rust-miette-derive-devel \
 "
RDEPENDS:rust-miette-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
