# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-dec"
PV = "0.0.6"
PR = "1.el10_0"
PACKAGES = " \
 ghc-boring \
 ghc-boring-devel \
 ghc-boring-doc \
 ghc-boring-prof \
 ghc-dec \
 ghc-dec-devel \
 ghc-dec-doc \
 ghc-dec-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-dec-0.0.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bb175dccea07510ea37998246f38c3b956afeaf399bdcb40da529df0ed59f19"

URI_x86_64_v2_ghc-boring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-boring-0.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-boring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-boring}"
SRC_URI[x86_64_v2_ghc-boring.sha256sum] = "e178f8d134f1775909ebce20b5252bd413a5e3e2c6b87797d31ab93665134919"

URI_x86_64_v2_ghc-boring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-boring-devel-0.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-boring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-boring-devel}"
SRC_URI[x86_64_v2_ghc-boring-devel.sha256sum] = "1150037cee2b69fca2f8913b41fc4b6fbb8d1a74253112cfbb4c5ef233bbb686"

URI_x86_64_v2_ghc-boring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-boring-doc-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-boring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-boring-doc}"
SRC_URI[x86_64_v2_ghc-boring-doc.sha256sum] = "3f0d1be766418bc2744a6b521583a1cf8458b9f81471950c2c23ccfebf8a044a"

URI_x86_64_v2_ghc-boring-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-boring-prof-0.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-boring-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-boring-prof}"
SRC_URI[x86_64_v2_ghc-boring-prof.sha256sum] = "4190817779ad7edf25a462c49bf65aa7681136dd9f57172d2bfc169a19303aab"

URI_x86_64_v2_ghc-dec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dec-0.0.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dec}"
SRC_URI[x86_64_v2_ghc-dec.sha256sum] = "d59e0ba67df5d78d365ce03ea4d5a78e2e10a969c7f863f4d1a078de6648cb59"

URI_x86_64_v2_ghc-dec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dec-devel-0.0.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dec-devel}"
SRC_URI[x86_64_v2_ghc-dec-devel.sha256sum] = "76d7ccfe2bf64429201432ef89c89d8ebd3f7bf9e60e077fcad94d24bde496c9"

URI_x86_64_v2_ghc-dec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dec-doc-0.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-dec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dec-doc}"
SRC_URI[x86_64_v2_ghc-dec-doc.sha256sum] = "1f13232d594a4664e2d480a4b1068ed99a08bc0cbc2fe93eefe035fa4e70e3b9"

URI_x86_64_v2_ghc-dec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dec-prof-0.0.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dec-prof}"
SRC_URI[x86_64_v2_ghc-dec-prof.sha256sum] = "034a4fd27d0d8c882bef158a071de9b2d56d29d9a47a426d14e79ffbd368d68c"

URI_aarch64_ghc-boring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-boring-0.2.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-boring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-boring}"
SRC_URI[aarch64_ghc-boring.sha256sum] = "b56ef82fc74dbfa263d5d2465ff258fea44345066acd879e4e1fa72691badc6d"

URI_aarch64_ghc-boring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-boring-devel-0.2.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-boring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-boring-devel}"
SRC_URI[aarch64_ghc-boring-devel.sha256sum] = "6f96bb9f0e2263990b14993926933938dac81131a89fdf65f2b97fcb3758a295"

URI_aarch64_ghc-boring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-boring-doc-0.2.2-1.el10_0.noarch.rpm;name=aarch64_ghc-boring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-boring-doc}"
SRC_URI[aarch64_ghc-boring-doc.sha256sum] = "7d955e535208f0fea7cf685cc8240bfc865f0c8ed6a3c00ef0684abfe12f2dfd"

URI_aarch64_ghc-boring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-boring-prof-0.2.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-boring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-boring-prof}"
SRC_URI[aarch64_ghc-boring-prof.sha256sum] = "8f9fa2d1600b02e26a8b6bf85f7113c1671077bd795bbd1339647e1eeb60572f"

URI_aarch64_ghc-dec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dec-0.0.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-dec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dec}"
SRC_URI[aarch64_ghc-dec.sha256sum] = "7ead7468f0166c7c36d341945c87dca1e5a1cbf8a68b151908bf26bb94b623b0"

URI_aarch64_ghc-dec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dec-devel-0.0.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-dec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dec-devel}"
SRC_URI[aarch64_ghc-dec-devel.sha256sum] = "1f7f83cd5438c27c029f118ea8279a3a511c6fa3bdc8c2f2836028a619bd0c4a"

URI_aarch64_ghc-dec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dec-doc-0.0.6-1.el10_0.noarch.rpm;name=aarch64_ghc-dec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dec-doc}"
SRC_URI[aarch64_ghc-dec-doc.sha256sum] = "afb0f366cb561734dfbe041c95994fcb3a9306a2893ad834a676072184177d65"

URI_aarch64_ghc-dec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dec-prof-0.0.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-dec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dec-prof}"
SRC_URI[aarch64_ghc-dec-prof.sha256sum] = "9d21ebda7290bf4bb7cb5e99af53bc11ed42ac4421ad8083bd20cf53f7f445e2"

RDEPENDS:ghc-boring = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-tagged \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-boring-devel = " \
 ghc-base-devel \
 ghc-boring \
 ghc-compiler \
 ghc-tagged-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-boring-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-boring-prof = " \
 ghc-base-prof \
 ghc-boring-devel \
 ghc-tagged-prof \
 ghc-transformers-prof \
 "
RDEPENDS:ghc-dec = " \
 ghc-array \
 ghc-base \
 ghc-boring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-tagged \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-dec-devel = " \
 ghc-base-devel \
 ghc-boring-devel \
 ghc-compiler \
 ghc-dec \
 "
RDEPENDS:ghc-dec-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-dec-prof = " \
 ghc-base-prof \
 ghc-boring-prof \
 ghc-dec-devel \
 "
