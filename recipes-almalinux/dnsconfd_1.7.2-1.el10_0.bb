# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsconfd"
PV = "1.7.2"
PR = "1.el10_0"
PACKAGES = " \
 dnsconfd \
 dnsconfd-dracut \
 dnsconfd-micro \
 dnsconfd-selinux \
 dnsconfd-unbound \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dnsconfd-1.7.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "070e96e92da3df8266fa3b8fb41281db02649480d77a68e990579b047f3f0d94"

URI_x86_64_v2_dnsconfd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-1.7.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dnsconfd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsconfd}"
SRC_URI[x86_64_v2_dnsconfd.sha256sum] = "64809991bc083461dd72ddaa1be887c733673cc42868813ed84e20912e1e5d1f"

URI_x86_64_v2_dnsconfd-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-dracut-1.7.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dnsconfd-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsconfd-dracut}"
SRC_URI[x86_64_v2_dnsconfd-dracut.sha256sum] = "1db601042b5440ff4706c674a1fa7a9f2d6a61596ee1eacefd9e5449209bcaec"

URI_x86_64_v2_dnsconfd-micro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-micro-1.7.2-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dnsconfd-micro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsconfd-micro}"
SRC_URI[x86_64_v2_dnsconfd-micro.sha256sum] = "cc4d2698c5f7e76dc050a990212d572dc1547f65bb000faf91f2e627cad5cb66"

URI_x86_64_v2_dnsconfd-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-selinux-1.7.2-1.el10_0.noarch.rpm;name=x86_64_v2_dnsconfd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsconfd-selinux}"
SRC_URI[x86_64_v2_dnsconfd-selinux.sha256sum] = "863d3f5304b66e20740ec9bee0c0297f1268efae295c90c484d4d841b48c151c"

URI_x86_64_v2_dnsconfd-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-unbound-1.7.2-1.el10_0.noarch.rpm;name=x86_64_v2_dnsconfd-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsconfd-unbound}"
SRC_URI[x86_64_v2_dnsconfd-unbound.sha256sum] = "a10f267af8dad38dd79c6980bb2ceeac94983e6e11be3b6baa04a84e037c05bc"

URI_aarch64_dnsconfd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-1.7.2-1.el10_0.aarch64.rpm;name=aarch64_dnsconfd;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsconfd}"
SRC_URI[aarch64_dnsconfd.sha256sum] = "10dd8286fd3279b80fa2f53d3fed063e5820ed8ba707fb07bc51972131bf599e"

URI_aarch64_dnsconfd-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-dracut-1.7.2-1.el10_0.aarch64.rpm;name=aarch64_dnsconfd-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsconfd-dracut}"
SRC_URI[aarch64_dnsconfd-dracut.sha256sum] = "c8d88652349c25ddc85190851fe551a44a202577b446b39e2fe3d36c45e62565"

URI_aarch64_dnsconfd-micro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-micro-1.7.2-1.el10_0.aarch64.rpm;name=aarch64_dnsconfd-micro;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsconfd-micro}"
SRC_URI[aarch64_dnsconfd-micro.sha256sum] = "822cf347ad16a97d46fb04e95b4a950cb87e4057581ec99beaa3b6abce238ce7"

URI_aarch64_dnsconfd-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-selinux-1.7.2-1.el10_0.noarch.rpm;name=aarch64_dnsconfd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsconfd-selinux}"
SRC_URI[aarch64_dnsconfd-selinux.sha256sum] = "863d3f5304b66e20740ec9bee0c0297f1268efae295c90c484d4d841b48c151c"

URI_aarch64_dnsconfd-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-unbound-1.7.2-1.el10_0.noarch.rpm;name=aarch64_dnsconfd-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsconfd-unbound}"
SRC_URI[aarch64_dnsconfd-unbound.sha256sum] = "a10f267af8dad38dd79c6980bb2ceeac94983e6e11be3b6baa04a84e037c05bc"

RDEPENDS:dnsconfd = " \
 bash \
 dbus-common \
 dnsconfd-selinux \
 dnsconfd-unbound \
 polkit \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-pyyaml \
 python3-systemd \
 shadow-utils \
 "
RDEPENDS:dnsconfd-dracut = " \
 bash \
 dnsconfd-micro \
 dracut \
 dracut-network \
 unbound \
 "
RDEPENDS:dnsconfd-micro = " \
 dnsconfd \
 dnsconfd-selinux \
 glib2 \
 glibc \
 systemd-libs \
 unbound-dracut \
 virtual/libcurl \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:dnsconfd-selinux = " \
 bash \
 dnsconfd \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:dnsconfd-unbound = " \
 bash \
 dnsconfd \
 unbound \
 "
