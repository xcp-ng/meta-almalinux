# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-litemap"
PV = "0.8.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-litemap+alloc-devel \
 rust-litemap+databake-devel \
 rust-litemap+default-devel \
 rust-litemap+serde-devel \
 rust-litemap+testing-devel \
 rust-litemap+yoke-devel \
 rust-litemap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-litemap-0.8.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "153223de95583aa9490e683c55f96db3eab64376159cd8711ea40fdbf68599ad"

URI_x86_64_v2_rust-litemap+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+alloc-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+alloc-devel}"
SRC_URI[x86_64_v2_rust-litemap+alloc-devel.sha256sum] = "a32ff75c374fc6e2cb857f0c0031dc6c474d2572783cb0c03968c0d969e8c476"

URI_x86_64_v2_rust-litemap+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+databake-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+databake-devel}"
SRC_URI[x86_64_v2_rust-litemap+databake-devel.sha256sum] = "5702cfe6e381899078754e923bba9a8e6172fb881284b8ed8bc230988af65e03"

URI_x86_64_v2_rust-litemap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+default-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+default-devel}"
SRC_URI[x86_64_v2_rust-litemap+default-devel.sha256sum] = "c5a3e51467cbb608b15a5d8736b06dbd3ddcb5c2271d659de859fd88786f994c"

URI_x86_64_v2_rust-litemap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+serde-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+serde-devel}"
SRC_URI[x86_64_v2_rust-litemap+serde-devel.sha256sum] = "6d77f89b1347cd2a3cd6d81c704890b21d2d5778aa50d07902518a46e36e06fe"

URI_x86_64_v2_rust-litemap+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+testing-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+testing-devel}"
SRC_URI[x86_64_v2_rust-litemap+testing-devel.sha256sum] = "d6d0a219d4c39470e152ed4e352391559f84ae3365a90d58327e98164bfdf420"

URI_x86_64_v2_rust-litemap+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap+yoke-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap+yoke-devel}"
SRC_URI[x86_64_v2_rust-litemap+yoke-devel.sha256sum] = "e609e3d1632eeb9b295d18ac9082b3a1286f8f54d87b1f6d49ce2deaf992ec1b"

URI_x86_64_v2_rust-litemap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-litemap-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-litemap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-litemap-devel}"
SRC_URI[x86_64_v2_rust-litemap-devel.sha256sum] = "695c905987be0b0da72aa8b8842fc2dcff7abcb68d65850d44fb4f045ef2559f"

URI_aarch64_rust-litemap+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+alloc-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+alloc-devel}"
SRC_URI[aarch64_rust-litemap+alloc-devel.sha256sum] = "086e87227eaf08edcf1ea9d7c9e7c9e044a7772886da88fef47fe71b8cb06cf0"

URI_aarch64_rust-litemap+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+databake-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+databake-devel}"
SRC_URI[aarch64_rust-litemap+databake-devel.sha256sum] = "3e33e0fdf14358e6cdf003aea650edf2831a07da909758bdacba468fcf309206"

URI_aarch64_rust-litemap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+default-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+default-devel}"
SRC_URI[aarch64_rust-litemap+default-devel.sha256sum] = "efe74ee5a11318ccdd83022f153592b3ea9e71d6d273aab5920c693f463f306a"

URI_aarch64_rust-litemap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+serde-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+serde-devel}"
SRC_URI[aarch64_rust-litemap+serde-devel.sha256sum] = "354e8c72b1f15e39eaa4c4cdb29dbd009f9666aab828fd5292be8ed4f57b7119"

URI_aarch64_rust-litemap+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+testing-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+testing-devel}"
SRC_URI[aarch64_rust-litemap+testing-devel.sha256sum] = "bb2db32880e09c801c180e8bf72bde52f03fd90ea75d4e52ca2b3b41d6207db1"

URI_aarch64_rust-litemap+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap+yoke-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-litemap+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap+yoke-devel}"
SRC_URI[aarch64_rust-litemap+yoke-devel.sha256sum] = "19e7aa7778a754b2343210043cf85640304335238052f4e5cb3999f99f5d1652"

URI_aarch64_rust-litemap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-litemap-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-litemap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-litemap-devel}"
SRC_URI[aarch64_rust-litemap-devel.sha256sum] = "f147af6a99749a7aa161e71ee8eba28476f02fcc8274bd7a2391c20a5970f4e0"

RDEPENDS:rust-litemap+alloc-devel = " \
 cargo \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+default-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+serde-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-litemap+testing-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 "
RDEPENDS:rust-litemap+yoke-devel = " \
 cargo \
 rust-litemap-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-litemap-devel = " \
 cargo \
 rust \
 "
