# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_mkfifo"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_mkfifo+default-devel \
 rust-uu_mkfifo+selinux-devel \
 rust-uu_mkfifo+smack-devel \
 rust-uu_mkfifo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_mkfifo-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6696c5c14de911d2b51a4841d449e0b638ead5f0bf2c50afd070b3fb10f9cae"

URI_x86_64_v2_rust-uu_mkfifo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mkfifo+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mkfifo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mkfifo+default-devel}"
SRC_URI[x86_64_v2_rust-uu_mkfifo+default-devel.sha256sum] = "880dde2d5a1c14e7cbc8260ad9429bd92ff24e601afa9f643c8458cad28e26be"

URI_x86_64_v2_rust-uu_mkfifo+selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mkfifo+selinux-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mkfifo+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mkfifo+selinux-devel}"
SRC_URI[x86_64_v2_rust-uu_mkfifo+selinux-devel.sha256sum] = "18f1ced1b7e8f0ca158e73a709df1bbe03d177795d12abd4bf3f158199da5599"

URI_x86_64_v2_rust-uu_mkfifo+smack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mkfifo+smack-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mkfifo+smack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mkfifo+smack-devel}"
SRC_URI[x86_64_v2_rust-uu_mkfifo+smack-devel.sha256sum] = "8040929b30b0fbdd9a6d545c8f712f1df354c3cde12708e87cc7293f131b94a2"

URI_x86_64_v2_rust-uu_mkfifo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mkfifo-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mkfifo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mkfifo-devel}"
SRC_URI[x86_64_v2_rust-uu_mkfifo-devel.sha256sum] = "a911979ae84b080d2a9faa8e2e22f3276c85fcf980231eddc550c47edbdf9135"

URI_aarch64_rust-uu_mkfifo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mkfifo+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mkfifo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mkfifo+default-devel}"
SRC_URI[aarch64_rust-uu_mkfifo+default-devel.sha256sum] = "5e3ee0f676937b59231ddd4d7815ea52a2410a38249552902cc9a45964c0cc15"

URI_aarch64_rust-uu_mkfifo+selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mkfifo+selinux-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mkfifo+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mkfifo+selinux-devel}"
SRC_URI[aarch64_rust-uu_mkfifo+selinux-devel.sha256sum] = "23464600269232d095678c0a5d7cd858f165d0225afcd3308581cd09a4f97eea"

URI_aarch64_rust-uu_mkfifo+smack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mkfifo+smack-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mkfifo+smack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mkfifo+smack-devel}"
SRC_URI[aarch64_rust-uu_mkfifo+smack-devel.sha256sum] = "d21af8d888a38f9d29eab7a9cff3890d7d94c17ecf2533f0120ac86c2ad13ec3"

URI_aarch64_rust-uu_mkfifo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mkfifo-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mkfifo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mkfifo-devel}"
SRC_URI[aarch64_rust-uu_mkfifo-devel.sha256sum] = "516a2d9bb13c01b00169026047417b4a011dd121c9ec875c32ea5e9d731b312f"

RDEPENDS:rust-uu_mkfifo+default-devel = " \
 cargo \
 rust-uu_mkfifo-devel \
 "
RDEPENDS:rust-uu_mkfifo+selinux-devel = " \
 cargo \
 rust-uu_mkfifo-devel \
 rust-uucore+selinux-devel \
 "
RDEPENDS:rust-uu_mkfifo+smack-devel = " \
 cargo \
 rust-uu_mkfifo-devel \
 rust-uucore+smack-devel \
 "
RDEPENDS:rust-uu_mkfifo-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 rust-uucore+mode-devel \
 "
