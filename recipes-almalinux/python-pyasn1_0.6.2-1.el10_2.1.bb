# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyasn1"
PV = "0.6.2"
PR = "1.el10_2.1"
PACKAGES = " \
 python3-pyasn1 \
 python3-pyasn1-modules \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pyasn1-0.6.2-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4179a183a6766c1ed79a0d77dda2533421416abe0b1598ed1b631267d77665ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyasn1-0.6.2-1.el10_2.1.noarch.rpm;name=x86_64_v2_python3-pyasn1;unpack=0"
SRC_URI[x86_64_v2_python3-pyasn1.sha256sum] = "5a44c6804ccdde9b93b518b3d47f1187e4ee407ae6a058b986bc2fa52399e8bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyasn1-modules-0.6.2-1.el10_2.1.noarch.rpm;name=x86_64_v2_python3-pyasn1-modules;unpack=0"
SRC_URI[x86_64_v2_python3-pyasn1-modules.sha256sum] = "05edb19dae2edc37e82548abae6af2808fd01ad0c9fb7d6e914cb343e2182e02"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyasn1-0.6.2-1.el10_2.1.noarch.rpm;name=aarch64_python3-pyasn1;unpack=0"
SRC_URI[aarch64_python3-pyasn1.sha256sum] = "5a44c6804ccdde9b93b518b3d47f1187e4ee407ae6a058b986bc2fa52399e8bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyasn1-modules-0.6.2-1.el10_2.1.noarch.rpm;name=aarch64_python3-pyasn1-modules;unpack=0"
SRC_URI[aarch64_python3-pyasn1-modules.sha256sum] = "05edb19dae2edc37e82548abae6af2808fd01ad0c9fb7d6e914cb343e2182e02"

RDEPENDS:python3-pyasn1 = " \
 python3 \
 "
RDEPENDS:python3-pyasn1-modules = " \
 python3 \
 python3-pyasn1 \
 "
