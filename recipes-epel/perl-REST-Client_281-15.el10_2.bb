# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-REST-Client"
PV = "281"
PR = "15.el10_2"
PACKAGES = " \
 perl-REST-Client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-REST-Client-281-15.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7cd2c60cbd1d7619fe8dc98e62a6a450be70d1b568af303e1b51e4f44f6bca5"

URI_x86_64_v2_perl-REST-Client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-REST-Client-281-15.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-REST-Client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-REST-Client}"
SRC_URI[x86_64_v2_perl-REST-Client.sha256sum] = "54449453f2a9221d4263f2c1c1c3b3e2cecbd7b3f382325a3df44b042c1f0f76"

URI_aarch64_perl-REST-Client = "${EPEL_MIRROR}/aarch64/Packages/p/perl-REST-Client-281-15.el10_2.noarch.rpm;name=aarch64_perl-REST-Client;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-REST-Client}"
SRC_URI[aarch64_perl-REST-Client.sha256sum] = "7786507e0cd5555a3438cba55feb26cfbc4aa330099369095d207aef9d680192"

RDEPENDS:perl-REST-Client = " \
 perl-Carp \
 perl-URI \
 perl-XML-LibXML \
 perl-constant \
 perl-libs \
 perl-libwww-perl \
 "
