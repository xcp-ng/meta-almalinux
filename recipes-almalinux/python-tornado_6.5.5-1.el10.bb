# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tornado"
PV = "6.5.5"
PR = "1.el10"
PACKAGES = " \
 python3-tornado \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-tornado-6.5.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92e752c995d0a9f244357411f25cbbf48ec53b78b5fedd9f4be4f1108e091f12"

URI_x86_64_v2_python3-tornado = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tornado-6.5.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tornado;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tornado}"
SRC_URI[x86_64_v2_python3-tornado.sha256sum] = "0328d8a4831a77d6327891de91e3a58ec1cf357b6eebf79ab731b96bf6afa554"

URI_aarch64_python3-tornado = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tornado-6.5.5-1.el10.aarch64.rpm;name=aarch64_python3-tornado;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tornado}"
SRC_URI[aarch64_python3-tornado.sha256sum] = "4415e55bce6dc1042516449efbed561f66336ccd95b6523844b38a45f9f73180"

RDEPENDS:python3-tornado = " \
 glibc \
 python3 \
 "
