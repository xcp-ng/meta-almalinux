# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-anthy"
PV = "1.5.16"
PR = "22.el10"
PACKAGES = " \
 ibus-anthy \
 ibus-anthy-python \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-anthy-1.5.16-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cfb008dc6fb246a51b284ae73e4a82460b88370698d97379005f5da6b5191d7"

URI_x86_64_v2_ibus-anthy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-anthy-1.5.16-22.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-anthy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-anthy}"
SRC_URI[x86_64_v2_ibus-anthy.sha256sum] = "12e130284f1ec42cd108136bb15fbdf933edc5e129d48ebb2910e5b1068666c0"

URI_x86_64_v2_ibus-anthy-python = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-anthy-python-1.5.16-22.el10.noarch.rpm;name=x86_64_v2_ibus-anthy-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-anthy-python}"
SRC_URI[x86_64_v2_ibus-anthy-python.sha256sum] = "0d807ff35fd7ebe92a9a724e0fe197992ea5cc3567d8a9b41496a9514a0c4ef3"

URI_aarch64_ibus-anthy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-anthy-1.5.16-22.el10.aarch64.rpm;name=aarch64_ibus-anthy;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-anthy}"
SRC_URI[aarch64_ibus-anthy.sha256sum] = "25ad938587381391bfae29746fc26d44161d55885219928a3f64ddcabe612af5"

URI_aarch64_ibus-anthy-python = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-anthy-python-1.5.16-22.el10.noarch.rpm;name=aarch64_ibus-anthy-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-anthy-python}"
SRC_URI[aarch64_ibus-anthy-python.sha256sum] = "0d807ff35fd7ebe92a9a724e0fe197992ea5cc3567d8a9b41496a9514a0c4ef3"

RDEPENDS:ibus-anthy = " \
 anthy-unicode \
 glib2 \
 glibc \
 ibus \
 ibus-anthy-python \
 kasumi-unicode \
 "
RDEPENDS:ibus-anthy-python = " \
 bash \
 gtk3 \
 ibus-anthy \
 python3-cairo \
 python3-gobject \
 "
