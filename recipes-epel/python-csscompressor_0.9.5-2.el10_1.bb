# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-csscompressor"
PV = "0.9.5"
PR = "2.el10_1"
PACKAGES = " \
 python3-csscompressor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-csscompressor-0.9.5-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0e6ef8866cc8a3f39e77903217ffaa935d130a42c3684c16bf65853668ee75f"

URI_x86_64_v2_python3-csscompressor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-csscompressor-0.9.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-csscompressor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-csscompressor}"
SRC_URI[x86_64_v2_python3-csscompressor.sha256sum] = "9c156da7a630e243da05145375ccbc323745dc40583d658873c52959e9aded3a"

URI_aarch64_python3-csscompressor = "${EPEL_MIRROR}/aarch64/Packages/p/python3-csscompressor-0.9.5-2.el10_1.noarch.rpm;name=aarch64_python3-csscompressor;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-csscompressor}"
SRC_URI[aarch64_python3-csscompressor.sha256sum] = "22232a7c5e311b2a4d9233c68ac6f977d5db1b1cf24e192c2923cea5ec6735fb"

RDEPENDS:python3-csscompressor = " \
 python3 \
 "
