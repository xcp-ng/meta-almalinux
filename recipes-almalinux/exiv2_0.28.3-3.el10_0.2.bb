# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "exiv2"
PV = "0.28.3"
PR = "3.el10_0.2"
PACKAGES = " \
 exiv2 \
 exiv2-devel \
 exiv2-doc \
 exiv2-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/exiv2-0.28.3-3.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b1db4b906387070539f64e06babf8a10a7ed8427f9e67a9e39c463aae6d1c69"

URI_x86_64_v2_exiv2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/exiv2-0.28.3-3.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_exiv2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exiv2}"
SRC_URI[x86_64_v2_exiv2.sha256sum] = "5cc2092bf98b6c303ee78a2e4a98a26d5c81daaf03d497f659a2a37b2dc70692"

URI_x86_64_v2_exiv2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/exiv2-devel-0.28.3-3.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_exiv2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exiv2-devel}"
SRC_URI[x86_64_v2_exiv2-devel.sha256sum] = "093626748bf9f3764f7850a47c8d6f9b2da015291aa79b191af1f7f616a1b9d5"

URI_x86_64_v2_exiv2-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/exiv2-doc-0.28.3-3.el10_0.2.noarch.rpm;name=x86_64_v2_exiv2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exiv2-doc}"
SRC_URI[x86_64_v2_exiv2-doc.sha256sum] = "df5197478815f16ca0878ace43f689b865b95841cef933edf587a6d389415457"

URI_x86_64_v2_exiv2-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/exiv2-libs-0.28.3-3.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_exiv2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exiv2-libs}"
SRC_URI[x86_64_v2_exiv2-libs.sha256sum] = "839389ff032f9e275465411edd4db6247f7dc5ceea5600d100ff08f5fbbfbc34"

URI_aarch64_exiv2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/exiv2-0.28.3-3.el10_0.2.aarch64.rpm;name=aarch64_exiv2;unpack=0"
SRC_URI:append = " ${URI_aarch64_exiv2}"
SRC_URI[aarch64_exiv2.sha256sum] = "14c415d783b62b19d821707768d1f87c1157e6ccdc4f71fb322559f2694eb34e"

URI_aarch64_exiv2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/exiv2-devel-0.28.3-3.el10_0.2.aarch64.rpm;name=aarch64_exiv2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_exiv2-devel}"
SRC_URI[aarch64_exiv2-devel.sha256sum] = "1eba7a2f39778538b4633f778d19afc806e9ff2811e75f57ef3819f69f0ae578"

URI_aarch64_exiv2-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/exiv2-doc-0.28.3-3.el10_0.2.noarch.rpm;name=aarch64_exiv2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_exiv2-doc}"
SRC_URI[aarch64_exiv2-doc.sha256sum] = "df5197478815f16ca0878ace43f689b865b95841cef933edf587a6d389415457"

URI_aarch64_exiv2-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/exiv2-libs-0.28.3-3.el10_0.2.aarch64.rpm;name=aarch64_exiv2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_exiv2-libs}"
SRC_URI[aarch64_exiv2-libs.sha256sum] = "d01769fcd94434be7f1fc68376e451add20612fd1ee4035b0bf181591046674f"

RDEPENDS:exiv2 = " \
 exiv2-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:exiv2-devel = " \
 brotli-devel \
 cmake-filesystem \
 exiv2-libs \
 expat-devel \
 inih-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:exiv2-doc = " \
 "
RDEPENDS:exiv2-libs = " \
 expat \
 glibc \
 inih-cpp \
 libbrotli \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
