# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-time-core"
PV = "0.1.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-time-core+default-devel \
 rust-time-core+large-dates-devel \
 rust-time-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-time-core-0.1.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95e8bd0e517b44fadd0f303622ed0cf83bf65b9081b8d041b38dad2f98167bca"

URI_x86_64_v2_rust-time-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-core+default-devel-0.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-core+default-devel}"
SRC_URI[x86_64_v2_rust-time-core+default-devel.sha256sum] = "0cfe141de1c91cf0178e40d5e73ae8cf83b2041a8cff71cb96c82cd84f0f5f39"

URI_x86_64_v2_rust-time-core+large-dates-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-core+large-dates-devel-0.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-core+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-core+large-dates-devel}"
SRC_URI[x86_64_v2_rust-time-core+large-dates-devel.sha256sum] = "e0c649c15cd7232379502f7a9b4f1da646c4ba9fb9919041dea0370688a210ad"

URI_x86_64_v2_rust-time-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-core-devel-0.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-core-devel}"
SRC_URI[x86_64_v2_rust-time-core-devel.sha256sum] = "38230cf547796087c33d24200c48df0d655449aab5acca9e4022040aa7b8e67d"

URI_aarch64_rust-time-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-core+default-devel-0.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-time-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-core+default-devel}"
SRC_URI[aarch64_rust-time-core+default-devel.sha256sum] = "e0d6c7959c1ce63b7828200479ec5df199a8e629e53ea56ce35f1996db60f178"

URI_aarch64_rust-time-core+large-dates-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-core+large-dates-devel-0.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-time-core+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-core+large-dates-devel}"
SRC_URI[aarch64_rust-time-core+large-dates-devel.sha256sum] = "dead1c1ff85a9fed3d92e6535d21fa00d02c0e5dabc80d0bd21d652647301f0c"

URI_aarch64_rust-time-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-core-devel-0.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-time-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-core-devel}"
SRC_URI[aarch64_rust-time-core-devel.sha256sum] = "56389625fbf47d1b256159bf52dbd63c9f04f82101306e0a888002e3ccc4adaf"

RDEPENDS:rust-time-core+default-devel = " \
 cargo \
 rust-time-core-devel \
 "
RDEPENDS:rust-time-core+large-dates-devel = " \
 cargo \
 rust-time-core-devel \
 "
RDEPENDS:rust-time-core-devel = " \
 cargo \
 rust \
 "
