# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-ExtraTests"
PV = "0.008"
PR = "34.el10_0"
PACKAGES = " \
 perl-Module-Install-ExtraTests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Install-ExtraTests-0.008-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88a83aa3fb077a0288454923da2b36917110cdb531c82a4fe7beedcf75083f2c"

URI_x86_64_v2_perl-Module-Install-ExtraTests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Install-ExtraTests-0.008-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Install-ExtraTests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Install-ExtraTests}"
SRC_URI[x86_64_v2_perl-Module-Install-ExtraTests.sha256sum] = "f4b492c0afaf13517eac0127ab27b7ee6ed47e96c28e46523487e1a42b7b0372"

URI_aarch64_perl-Module-Install-ExtraTests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Install-ExtraTests-0.008-34.el10_0.noarch.rpm;name=aarch64_perl-Module-Install-ExtraTests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Install-ExtraTests}"
SRC_URI[aarch64_perl-Module-Install-ExtraTests.sha256sum] = "880686d6d9e1d78e73b4d9701ce2b9c616cd60b0247ad6c73d2fc735a094cf6c"

RDEPENDS:perl-Module-Install-ExtraTests = " \
 perl-ExtUtils-Command \
 perl-File-Find \
 perl-Module-Install \
 perl-PathTools \
 perl-libs \
 "
