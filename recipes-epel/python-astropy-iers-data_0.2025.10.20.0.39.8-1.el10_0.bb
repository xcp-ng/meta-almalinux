# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-astropy-iers-data"
PV = "0.2025.10.20.0.39.8"
PR = "1.el10_0"
PACKAGES = " \
 python3-astropy-iers-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-astropy-iers-data-0.2025.10.20.0.39.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c1739e0793d8645ec08483c45025afb80930759e58f9c18714a5b8b9ac93e2f"

URI_x86_64_v2_python3-astropy-iers-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-astropy-iers-data-0.2025.10.20.0.39.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-astropy-iers-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-astropy-iers-data}"
SRC_URI[x86_64_v2_python3-astropy-iers-data.sha256sum] = "a6a94527aa0c3d43b90a4acd09a5c84d4aba408cff6c70584f891ccb538218e1"

URI_aarch64_python3-astropy-iers-data = "${EPEL_MIRROR}/aarch64/Packages/p/python3-astropy-iers-data-0.2025.10.20.0.39.8-1.el10_0.noarch.rpm;name=aarch64_python3-astropy-iers-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-astropy-iers-data}"
SRC_URI[aarch64_python3-astropy-iers-data.sha256sum] = "443a5a6c88db22461e1900a6dbd272febd0861b16df7066fdfa5a86a85901aed"

RDEPENDS:python3-astropy-iers-data = " \
 python3 \
 "
