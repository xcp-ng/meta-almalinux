# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-object"
PV = "0.39.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-object+all-devel \
 rust-object+archive-devel \
 rust-object+build-devel \
 rust-object+build_core-devel \
 rust-object+cargo-all-devel \
 rust-object+coff-devel \
 rust-object+compression-devel \
 rust-object+default-devel \
 rust-object+doc-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read-devel \
 rust-object+read_core-devel \
 rust-object+std-devel \
 rust-object+unaligned-devel \
 rust-object+unstable-all-devel \
 rust-object+unstable-devel \
 rust-object+write-devel \
 rust-object+write_core-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-object-0.39.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9a7236c9579a93a45db69adce9d8a793b469cf7e160aff093027962b8388e80"

URI_x86_64_v2_rust-object+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+all-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+all-devel}"
SRC_URI[x86_64_v2_rust-object+all-devel.sha256sum] = "63a0734e8e3733f734fb6b68a7426daaa57c2fda141be70a13473f287e68fde5"

URI_x86_64_v2_rust-object+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+archive-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+archive-devel}"
SRC_URI[x86_64_v2_rust-object+archive-devel.sha256sum] = "42e413d264b2124889fec182fbc37a399f623de1b5b302c61b6271af529d9a11"

URI_x86_64_v2_rust-object+build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+build-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+build-devel}"
SRC_URI[x86_64_v2_rust-object+build-devel.sha256sum] = "6727c78f0e264fafc05a973a1cb1828b127b76b0b07dd1944a7451adaa140712"

URI_x86_64_v2_rust-object+build_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+build_core-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+build_core-devel}"
SRC_URI[x86_64_v2_rust-object+build_core-devel.sha256sum] = "cac4355ba9b89e980fb002969efce3a649751c4e2d9ad82ca09a34e6757bde11"

URI_x86_64_v2_rust-object+cargo-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+cargo-all-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+cargo-all-devel}"
SRC_URI[x86_64_v2_rust-object+cargo-all-devel.sha256sum] = "15401c971f0660eab4baba921d41a5da85932f65aad557f55fa034fe6667432a"

URI_x86_64_v2_rust-object+coff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+coff-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+coff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+coff-devel}"
SRC_URI[x86_64_v2_rust-object+coff-devel.sha256sum] = "1b85cb6af1873eeb4ccb8aa579d8edfe74d34dac36a1201eb4a4d090517a3d0f"

URI_x86_64_v2_rust-object+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+compression-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+compression-devel}"
SRC_URI[x86_64_v2_rust-object+compression-devel.sha256sum] = "1eade6efcbbae2f29c7e53db7ebe47b64fd919e48f0b338e21c3d1e6d30aa571"

URI_x86_64_v2_rust-object+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+default-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+default-devel}"
SRC_URI[x86_64_v2_rust-object+default-devel.sha256sum] = "b099e3f11924f57b635bd50d9b3828c44a01a898564714366807a57ee033d88b"

URI_x86_64_v2_rust-object+doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+doc-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+doc-devel}"
SRC_URI[x86_64_v2_rust-object+doc-devel.sha256sum] = "d9c2d472a32583d4ff9e360bf01bcb34c73fccee21778d76d40949506a2fa5cc"

URI_x86_64_v2_rust-object+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+elf-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+elf-devel}"
SRC_URI[x86_64_v2_rust-object+elf-devel.sha256sum] = "f5bf9e2ec28d8d50be320ebe5e5d11851028fb67e20df80ad0abd94cc8a02dff"

URI_x86_64_v2_rust-object+macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+macho-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+macho-devel}"
SRC_URI[x86_64_v2_rust-object+macho-devel.sha256sum] = "d03ab4b6a767a3292239c4fc2a85a89736eba6f7b22ca5629ba64eb62e9581b6"

URI_x86_64_v2_rust-object+pe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+pe-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+pe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+pe-devel}"
SRC_URI[x86_64_v2_rust-object+pe-devel.sha256sum] = "d16a1757bd0989f3b2b832309e1fa39185ff508e8017d069670c798c0382bd33"

URI_x86_64_v2_rust-object+read-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+read-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+read-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+read-devel}"
SRC_URI[x86_64_v2_rust-object+read-devel.sha256sum] = "095054de1c991d9467ff735b203e128dc77c975ff0c810f4a8c7164a318ec2ae"

URI_x86_64_v2_rust-object+read_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+read_core-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+read_core-devel}"
SRC_URI[x86_64_v2_rust-object+read_core-devel.sha256sum] = "b3b4fafea36ff38db7e471e93d77c146d4b617ee4e83e0d2673d0ca6051d6f2e"

URI_x86_64_v2_rust-object+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+std-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+std-devel}"
SRC_URI[x86_64_v2_rust-object+std-devel.sha256sum] = "3019cf6cf545443349be6bb6a5506d6a9e451b9d6a3d78a25b7f337ac270bb04"

URI_x86_64_v2_rust-object+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unaligned-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unaligned-devel}"
SRC_URI[x86_64_v2_rust-object+unaligned-devel.sha256sum] = "4d4c2801e307ebb093957c5ef0aae60745467d7dbf7bdd6f1ef8bc2aa2172660"

URI_x86_64_v2_rust-object+unstable-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unstable-all-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unstable-all-devel}"
SRC_URI[x86_64_v2_rust-object+unstable-all-devel.sha256sum] = "15df64a799dbb7e8861dbcb211665371ae25fc02783198e9e81c2b8dd6f50e3e"

URI_x86_64_v2_rust-object+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+unstable-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+unstable-devel}"
SRC_URI[x86_64_v2_rust-object+unstable-devel.sha256sum] = "541b54636c26e4dc408ceb18d7df9ef5e3f0681637d15e0f8d7aa6137bbfa5fb"

URI_x86_64_v2_rust-object+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write-devel}"
SRC_URI[x86_64_v2_rust-object+write-devel.sha256sum] = "258aeef31fbf5e6119783a81b9faa44f7a50b897de20b9c3850974303bd5418b"

URI_x86_64_v2_rust-object+write_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write_core-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write_core-devel}"
SRC_URI[x86_64_v2_rust-object+write_core-devel.sha256sum] = "3158db9ebaa640a4eec01793bd4f2d9fac9332e7e44fbc9ab99894fc0e97d0f1"

URI_x86_64_v2_rust-object+write_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+write_std-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+write_std-devel}"
SRC_URI[x86_64_v2_rust-object+write_std-devel.sha256sum] = "88b60fea89f0b317bf89914980e8d227b957cf7fd38f7026e35458c7d9678214"

URI_x86_64_v2_rust-object+xcoff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object+xcoff-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object+xcoff-devel}"
SRC_URI[x86_64_v2_rust-object+xcoff-devel.sha256sum] = "1320150f41980319292a50b18335c49ec4a71b148b6488e02f416b5ea0bfcee6"

URI_x86_64_v2_rust-object-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object-devel-0.39.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object-devel}"
SRC_URI[x86_64_v2_rust-object-devel.sha256sum] = "270edc47084a3bd5da74ec59a245c473a5030cc8d546c4c04570eeb05e498d11"

URI_aarch64_rust-object+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+all-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+all-devel}"
SRC_URI[aarch64_rust-object+all-devel.sha256sum] = "4d9124095399b57c63079f214a284d65c5a989f53aa34524c80cc3b7c70df8a3"

URI_aarch64_rust-object+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+archive-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+archive-devel}"
SRC_URI[aarch64_rust-object+archive-devel.sha256sum] = "71bc880ea047f57d5ceecf3b03971bacdb4eb20a5eb23f768e8530ed2a6aae06"

URI_aarch64_rust-object+build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+build-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+build-devel}"
SRC_URI[aarch64_rust-object+build-devel.sha256sum] = "25ccb830a6a2e06513c1b65bd26b5a73dc2c780be3c87a55b4a2f5fd7a19e2cd"

URI_aarch64_rust-object+build_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+build_core-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+build_core-devel}"
SRC_URI[aarch64_rust-object+build_core-devel.sha256sum] = "8d68fd7a8b1b88fa7ea82e2b7618713cdc6a4a46628ff20a4630ba3280d26a98"

URI_aarch64_rust-object+cargo-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+cargo-all-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+cargo-all-devel}"
SRC_URI[aarch64_rust-object+cargo-all-devel.sha256sum] = "fba07c813258b0cd7d655371889fbcbd105133e481f4d7b84e9b2d713e317ee2"

URI_aarch64_rust-object+coff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+coff-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+coff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+coff-devel}"
SRC_URI[aarch64_rust-object+coff-devel.sha256sum] = "24178b4cf753dc28c17c4117fd7feac738d505b22ab595b7b9344564a1923c40"

URI_aarch64_rust-object+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+compression-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+compression-devel}"
SRC_URI[aarch64_rust-object+compression-devel.sha256sum] = "047ede5695b6ee2f5a80ae8733de138e41c9189ac96f4e22e9b1dda2cdcf6262"

URI_aarch64_rust-object+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+default-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+default-devel}"
SRC_URI[aarch64_rust-object+default-devel.sha256sum] = "3ada3caf25e832d4d7b7694ca3df992b8460102d060a39fe201cd7b515a69486"

URI_aarch64_rust-object+doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+doc-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+doc-devel}"
SRC_URI[aarch64_rust-object+doc-devel.sha256sum] = "da67405dc496855d1a37b0bb63b45042b9098fb5829f0d0fed7973460edbc600"

URI_aarch64_rust-object+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+elf-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+elf-devel}"
SRC_URI[aarch64_rust-object+elf-devel.sha256sum] = "84d70cf9f9e00ae6cfa91b936bc272c686c5478bc65915d51cd90b6f43617fbf"

URI_aarch64_rust-object+macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+macho-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+macho-devel}"
SRC_URI[aarch64_rust-object+macho-devel.sha256sum] = "e3933d5cd921f83abceda3661c1f280a3839987fe818de6703c360e3b92c7551"

URI_aarch64_rust-object+pe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+pe-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+pe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+pe-devel}"
SRC_URI[aarch64_rust-object+pe-devel.sha256sum] = "d0602db17d5f7e151d40bc3f9c59d05b3914f89bd36f4097f4321b79a8ec2984"

URI_aarch64_rust-object+read-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+read-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+read-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+read-devel}"
SRC_URI[aarch64_rust-object+read-devel.sha256sum] = "4424eab5da029d68a1e1164f18da108b94c42df8b8cdf24350eb70f6b14f2c62"

URI_aarch64_rust-object+read_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+read_core-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+read_core-devel}"
SRC_URI[aarch64_rust-object+read_core-devel.sha256sum] = "ca274bd04be982be16dd6c1cb19d9e37f4db8edbc6459270f49e57714026313b"

URI_aarch64_rust-object+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+std-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+std-devel}"
SRC_URI[aarch64_rust-object+std-devel.sha256sum] = "20277de7519480ed27ae00b78b2b490fa1dd3e326fc2c37760c02230476440a3"

URI_aarch64_rust-object+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unaligned-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unaligned-devel}"
SRC_URI[aarch64_rust-object+unaligned-devel.sha256sum] = "03464be6f4dc2eb4d0b1250307f490d9089554053dd70fdca930d6ae51ff5d6b"

URI_aarch64_rust-object+unstable-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unstable-all-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unstable-all-devel}"
SRC_URI[aarch64_rust-object+unstable-all-devel.sha256sum] = "6f55fc4ce449cb2fb2afb56ae4c250b2c05d8ed88bdb82c4f98fc1a4096b90b0"

URI_aarch64_rust-object+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+unstable-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+unstable-devel}"
SRC_URI[aarch64_rust-object+unstable-devel.sha256sum] = "cd8fb66945012cc150f3a68ac654a84f3b1e2620addd77c47ab1c15681db9517"

URI_aarch64_rust-object+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write-devel}"
SRC_URI[aarch64_rust-object+write-devel.sha256sum] = "d5489d36f5a93366d939464ea66847b6d28c276859a543d58c5aa138a8c61260"

URI_aarch64_rust-object+write_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write_core-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write_core-devel}"
SRC_URI[aarch64_rust-object+write_core-devel.sha256sum] = "143a2cfec117ef73d56bb46a1135a168a040c071f7c8083d75d68f7ef964259d"

URI_aarch64_rust-object+write_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+write_std-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+write_std-devel}"
SRC_URI[aarch64_rust-object+write_std-devel.sha256sum] = "a7df91b104d9673e85ecbc786c861cc5c02a886436cf9df276559cb68818faf7"

URI_aarch64_rust-object+xcoff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object+xcoff-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object+xcoff-devel}"
SRC_URI[aarch64_rust-object+xcoff-devel.sha256sum] = "976ba3d23753c0fd467097a454f7d55b61c4be077a3ce7275c38d6484704161c"

URI_aarch64_rust-object-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object-devel-0.39.1-1.el10_3.noarch.rpm;name=aarch64_rust-object-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object-devel}"
SRC_URI[aarch64_rust-object-devel.sha256sum] = "b52225456985ff37abbc4f69c97de2cdc20ea1c79b33c880c7e2bc4ef058d02c"

RDEPENDS:rust-object+all-devel = " \
 cargo \
 rust-object+build-devel \
 rust-object+compression-devel \
 rust-object+read-devel \
 rust-object+std-devel \
 rust-object+write-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+archive-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+build-devel = " \
 cargo \
 rust-object+build_core-devel \
 rust-object+elf-devel \
 rust-object+write_std-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+build_core-devel = " \
 cargo \
 rust-object+read_core-devel \
 rust-object+write_core-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+cargo-all-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+coff-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+compression-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-object+std-devel \
 rust-object-devel \
 rust-ruzstd+default-devel \
 "
RDEPENDS:rust-object+default-devel = " \
 cargo \
 rust-object+compression-devel \
 rust-object+read-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+doc-devel = " \
 cargo \
 rust-object+all-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+elf-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+macho-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+pe-devel = " \
 cargo \
 rust-object+coff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+read-devel = " \
 cargo \
 rust-object+archive-devel \
 rust-object+coff-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+read_core-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+unaligned-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+unstable-all-devel = " \
 cargo \
 rust-object+all-devel \
 rust-object+unstable-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+unstable-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object+write-devel = " \
 cargo \
 rust-object+coff-devel \
 rust-object+elf-devel \
 rust-object+macho-devel \
 rust-object+pe-devel \
 rust-object+write_std-devel \
 rust-object+xcoff-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+write_core-devel = " \
 cargo \
 rust-crc32fast-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown-devel \
 rust-indexmap-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+write_std-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-object+std-devel \
 rust-object+write_core-devel \
 rust-object-devel \
 "
RDEPENDS:rust-object+xcoff-devel = " \
 cargo \
 rust-object-devel \
 "
RDEPENDS:rust-object-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
