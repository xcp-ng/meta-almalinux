# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerotrie"
PV = "0.2.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-zerotrie+alloc-devel \
 rust-zerotrie+databake-devel \
 rust-zerotrie+default-devel \
 rust-zerotrie+litemap-devel \
 rust-zerotrie+serde-devel \
 rust-zerotrie+yoke-devel \
 rust-zerotrie+zerofrom-devel \
 rust-zerotrie+zerovec-devel \
 rust-zerotrie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerotrie-0.2.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a5bb11e319c86787a24106b5874e4be22a762ee7100530af3fc0ff6c781668b"

URI_x86_64_v2_rust-zerotrie+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+alloc-devel-0.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+alloc-devel.sha256sum] = "bc91649fe50c893255441b170cdb0cf15c49a038e0872de6cff2332425c858b2"

URI_x86_64_v2_rust-zerotrie+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+databake-devel-0.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+databake-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+databake-devel.sha256sum] = "f87ea432746e8c04f493b54b603204f67f65770c2dc777972b543e73ddc1b74f"

URI_x86_64_v2_rust-zerotrie+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+default-devel-0.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+default-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+default-devel.sha256sum] = "e90cc087f120ffc7a750905ccf5e2ac556e4b0dc59b752ed27426ee72fd238ec"

URI_x86_64_v2_rust-zerotrie+litemap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+litemap-devel-0.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+litemap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+litemap-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+litemap-devel.sha256sum] = "8cc70d5208c48221e7782c5df54e44cb15d4ba7cbb3e222d8d35cbb8627d217f"

URI_x86_64_v2_rust-zerotrie+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+serde-devel-0.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+serde-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+serde-devel.sha256sum] = "2728b3448571a681284dc49b55aae7b4b94f6346b6d4ffe77fab8e3bc910a683"

URI_x86_64_v2_rust-zerotrie+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+yoke-devel-0.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+yoke-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+yoke-devel.sha256sum] = "4d1573866effd852bd114f53b85a80a718e98bb60d057a6eb3bcb94a17dd74b6"

URI_x86_64_v2_rust-zerotrie+zerofrom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+zerofrom-devel-0.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+zerofrom-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+zerofrom-devel.sha256sum] = "39c81b00a8d49971db11f1b3cce5b32f8920489006d966505a8dd2dc7391e361"

URI_x86_64_v2_rust-zerotrie+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+zerovec-devel-0.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+zerovec-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+zerovec-devel.sha256sum] = "96b46e16b44ad86703ae5c1fb832daf0b68f0c482e6e6665397793a8987edd00"

URI_x86_64_v2_rust-zerotrie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie-devel-0.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie-devel}"
SRC_URI[x86_64_v2_rust-zerotrie-devel.sha256sum] = "7b6bcb06f172ec6f06ade1d0d8a1a7f44ad050b0c93f7a67c166eb53d151ae5e"

URI_aarch64_rust-zerotrie+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+alloc-devel-0.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-zerotrie+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+alloc-devel}"
SRC_URI[aarch64_rust-zerotrie+alloc-devel.sha256sum] = "3e1c71b4815e559a8db9b13dc896e10144d2f473c33d345e5af0b428998664b8"

URI_aarch64_rust-zerotrie+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+databake-devel-0.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-zerotrie+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+databake-devel}"
SRC_URI[aarch64_rust-zerotrie+databake-devel.sha256sum] = "3821f5b0c55c2b744c37d891f03d19ded17c402dae883ae64a6ed0f3fff33f54"

URI_aarch64_rust-zerotrie+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+default-devel-0.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-zerotrie+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+default-devel}"
SRC_URI[aarch64_rust-zerotrie+default-devel.sha256sum] = "fe0d5e0381edad699ae00c0316747d6be8192c5d8f9b41075dae3c45a097e859"

URI_aarch64_rust-zerotrie+litemap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+litemap-devel-0.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-zerotrie+litemap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+litemap-devel}"
SRC_URI[aarch64_rust-zerotrie+litemap-devel.sha256sum] = "bdbefbcb0b6c62220a4178ea929b8c2b58da36d7f461dec93e990c2cba58769e"

URI_aarch64_rust-zerotrie+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+serde-devel-0.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-zerotrie+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+serde-devel}"
SRC_URI[aarch64_rust-zerotrie+serde-devel.sha256sum] = "253feab50c0b31d5590807a95cbac8f57016a1a02fd34d1eedb511c241716cb4"

URI_aarch64_rust-zerotrie+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+yoke-devel-0.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-zerotrie+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+yoke-devel}"
SRC_URI[aarch64_rust-zerotrie+yoke-devel.sha256sum] = "3b5387507e8e228ce8031230b90d9d06a2856a6804d4e1c10c0b5178461743a9"

URI_aarch64_rust-zerotrie+zerofrom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+zerofrom-devel-0.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-zerotrie+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+zerofrom-devel}"
SRC_URI[aarch64_rust-zerotrie+zerofrom-devel.sha256sum] = "4f9d77acb43096a39ea222dd850d6058b1f5bb03e9cbfe19ab2e8bc6f5330b57"

URI_aarch64_rust-zerotrie+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+zerovec-devel-0.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-zerotrie+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+zerovec-devel}"
SRC_URI[aarch64_rust-zerotrie+zerovec-devel.sha256sum] = "f57ba4a5fdbe21d4df011c64d98b0b6421d0b10d1f0c367c44e09bc2ba6acb41"

URI_aarch64_rust-zerotrie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie-devel-0.2.3-1.el10_1.noarch.rpm;name=aarch64_rust-zerotrie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie-devel}"
SRC_URI[aarch64_rust-zerotrie-devel.sha256sum] = "882303bc3e3ef6d396f1d75d94b0f0c36d7ffe7587478aeb1c8a7371cb2884ae"

RDEPENDS:rust-zerotrie+alloc-devel = " \
 cargo \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-zerotrie-devel \
 rust-zerovec+databake-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+default-devel = " \
 cargo \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+litemap-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+serde-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap+serde-devel \
 rust-litemap-devel \
 rust-serde_core-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 rust-zerovec+serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+yoke-devel = " \
 cargo \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+zerofrom-devel = " \
 cargo \
 rust-zerofrom-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+zerovec-devel = " \
 cargo \
 rust-zerotrie-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 "
