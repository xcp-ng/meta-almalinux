# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firejail"
PV = "0.9.78"
PR = "1.el10_2"
PACKAGES = " \
 firejail \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/firejail-0.9.78-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcb494472383a08fa7df4d384bb4d72140a67cde1361896f415b913e6c34453f"

URI_x86_64_v2_firejail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firejail-0.9.78-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_firejail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firejail}"
SRC_URI[x86_64_v2_firejail.sha256sum] = "814aece27c423915aaaeeeec4aabd0892bc59e96f6e950ecb0794ddfa8ae95b3"

URI_aarch64_firejail = "${EPEL_MIRROR}/aarch64/Packages/f/firejail-0.9.78-1.el10_2.aarch64.rpm;name=aarch64_firejail;unpack=0"
SRC_URI:append = " ${URI_aarch64_firejail}"
SRC_URI[aarch64_firejail.sha256sum] = "814e6cf34442bdf12895b5e6b3f0f643e8f000f88a9d8158151691091d0c2232"

RDEPENDS:firejail = " \
 bash \
 glibc \
 libselinux \
 python3 \
 xdg-dbus-proxy \
 "
