# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-nikic-php-parser5"
PV = "5.8.0"
PR = "1.el10_2"
PACKAGES = " \
 php-nikic-php-parser5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-nikic-php-parser5-5.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "beeb232790f4b5186b07bf319f09d06eb98c64d28f995f1a3b13046a33740875"

URI_x86_64_v2_php-nikic-php-parser5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-nikic-php-parser5-5.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_php-nikic-php-parser5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-nikic-php-parser5}"
SRC_URI[x86_64_v2_php-nikic-php-parser5.sha256sum] = "06eb6af5e262bc3fcec141caaa5597c6a02c8774a5603db44dd45caba59667a7"

URI_aarch64_php-nikic-php-parser5 = "${EPEL_MIRROR}/aarch64/Packages/p/php-nikic-php-parser5-5.8.0-1.el10_2.noarch.rpm;name=aarch64_php-nikic-php-parser5;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-nikic-php-parser5}"
SRC_URI[aarch64_php-nikic-php-parser5.sha256sum] = "28270314e33dc0834eda1d53a1bd614924b42efa1b8ab4b7f41e2ac84c5bb4df"

RDEPENDS:php-nikic-php-parser5 = " \
 php-fedora-autoloader \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-json \
 virtual/php-tokenizer \
 virtual/php_language__ge_7.4 \
 "
