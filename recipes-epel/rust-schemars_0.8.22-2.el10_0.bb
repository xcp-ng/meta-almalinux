# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-schemars"
PV = "0.8.22"
PR = "2.el10_0"
PACKAGES = " \
 rust-schemars+arrayvec07-devel \
 rust-schemars+bigdecimal04-devel \
 rust-schemars+bytes-devel \
 rust-schemars+chrono-devel \
 rust-schemars+default-devel \
 rust-schemars+derive-devel \
 rust-schemars+derive_json_schema-devel \
 rust-schemars+either-devel \
 rust-schemars+enumset-devel \
 rust-schemars+impl_json_schema-devel \
 rust-schemars+indexmap-devel \
 rust-schemars+indexmap1-devel \
 rust-schemars+indexmap2-devel \
 rust-schemars+preserve_order-devel \
 rust-schemars+raw_value-devel \
 rust-schemars+rust_decimal-devel \
 rust-schemars+schemars_derive-devel \
 rust-schemars+semver-devel \
 rust-schemars+smallvec-devel \
 rust-schemars+smol_str-devel \
 rust-schemars+ui_test-devel \
 rust-schemars+url-devel \
 rust-schemars+uuid1-devel \
 rust-schemars-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-schemars-0.8.22-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3353b0414e6a46361baa9be755dc873b25fc344e66cb3d69e7ae2ebfd62f037"

URI_x86_64_v2_rust-schemars+arrayvec07-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+arrayvec07-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+arrayvec07-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+arrayvec07-devel}"
SRC_URI[x86_64_v2_rust-schemars+arrayvec07-devel.sha256sum] = "f1eaaacf887afd1f5c9aa8d2f333eedef5d7b26f6c4b59675139ddab89a54dbf"

URI_x86_64_v2_rust-schemars+bigdecimal04-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+bigdecimal04-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+bigdecimal04-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+bigdecimal04-devel}"
SRC_URI[x86_64_v2_rust-schemars+bigdecimal04-devel.sha256sum] = "266049fa75bee1f52f656ae880ecae9a97858eb3936a1b6513ba7037a7ce3b73"

URI_x86_64_v2_rust-schemars+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+bytes-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+bytes-devel}"
SRC_URI[x86_64_v2_rust-schemars+bytes-devel.sha256sum] = "676040d1e99b76fb69a687eacdd1d6e8d98adbd88c5a34d853bda5519bb8b69c"

URI_x86_64_v2_rust-schemars+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+chrono-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+chrono-devel}"
SRC_URI[x86_64_v2_rust-schemars+chrono-devel.sha256sum] = "740a1c687dec2de2b5eab8858406db9af3686884737f1bc9f5a37ed9dfffeae1"

URI_x86_64_v2_rust-schemars+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+default-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+default-devel}"
SRC_URI[x86_64_v2_rust-schemars+default-devel.sha256sum] = "65aba76ca9a3de718958b4bf1d372f5ccd61ee91263a3aa545864bc37025bc1c"

URI_x86_64_v2_rust-schemars+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+derive-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+derive-devel}"
SRC_URI[x86_64_v2_rust-schemars+derive-devel.sha256sum] = "6e8ab670306723bc9a5ab7ededf2d81e6ff3d49ce935c43d2e0451855e4b00c0"

URI_x86_64_v2_rust-schemars+derive_json_schema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+derive_json_schema-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+derive_json_schema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+derive_json_schema-devel}"
SRC_URI[x86_64_v2_rust-schemars+derive_json_schema-devel.sha256sum] = "c6ad70366107a7d0b6fe88b79dac3c6bc19551ab7cab9be917341e52178dd6cb"

URI_x86_64_v2_rust-schemars+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+either-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+either-devel}"
SRC_URI[x86_64_v2_rust-schemars+either-devel.sha256sum] = "4d70c8a57b7105bb630afb160c8ca9cadd0803ba1fc84cc95eda1fb2d30a2f17"

URI_x86_64_v2_rust-schemars+enumset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+enumset-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+enumset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+enumset-devel}"
SRC_URI[x86_64_v2_rust-schemars+enumset-devel.sha256sum] = "b74d8b4271f4ebbb795186160daf60815a1bbeac21cdbbc69e1ea8cacbd5311d"

URI_x86_64_v2_rust-schemars+impl_json_schema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+impl_json_schema-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+impl_json_schema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+impl_json_schema-devel}"
SRC_URI[x86_64_v2_rust-schemars+impl_json_schema-devel.sha256sum] = "109c5ce32ca28d380529851149290d5e47ea0f162d36d67c8e680e7fc11b93a6"

URI_x86_64_v2_rust-schemars+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+indexmap-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+indexmap-devel}"
SRC_URI[x86_64_v2_rust-schemars+indexmap-devel.sha256sum] = "c028abc16115020664c5147ff726995be0b716158b5adb50d7f83814fcbc1648"

URI_x86_64_v2_rust-schemars+indexmap1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+indexmap1-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+indexmap1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+indexmap1-devel}"
SRC_URI[x86_64_v2_rust-schemars+indexmap1-devel.sha256sum] = "bd1cd85a9e7361fe80edc8fe1956de3a1fed7b7640cb2cf5efbb8f0bb4789fdd"

URI_x86_64_v2_rust-schemars+indexmap2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+indexmap2-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+indexmap2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+indexmap2-devel}"
SRC_URI[x86_64_v2_rust-schemars+indexmap2-devel.sha256sum] = "c3e331676d0932bdd796f0e264bba5439f25ac5f2293c0178307eab9e75ac5ef"

URI_x86_64_v2_rust-schemars+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+preserve_order-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-schemars+preserve_order-devel.sha256sum] = "83492cf3e58a5a37fdcdebfa090e54dc0a873e003724889c20a19844c07df736"

URI_x86_64_v2_rust-schemars+raw_value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+raw_value-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+raw_value-devel}"
SRC_URI[x86_64_v2_rust-schemars+raw_value-devel.sha256sum] = "38e113a4c6bd4188c8122c42033000d25a68578d04eca525bb1e20471b3ed762"

URI_x86_64_v2_rust-schemars+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+rust_decimal-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-schemars+rust_decimal-devel.sha256sum] = "889c0033dea9a818f770af6d3e1a1a6580cee83946d7e16435cc9132b679477e"

URI_x86_64_v2_rust-schemars+schemars_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+schemars_derive-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+schemars_derive-devel}"
SRC_URI[x86_64_v2_rust-schemars+schemars_derive-devel.sha256sum] = "02bd9447c21b989e6eb342607e443737b71a6b5397194759af223ed39f91e4a4"

URI_x86_64_v2_rust-schemars+semver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+semver-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+semver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+semver-devel}"
SRC_URI[x86_64_v2_rust-schemars+semver-devel.sha256sum] = "3c00ee645ae8818e2f0c38bc47a2f8090f80c62d53541c28c98acf72b085b5d2"

URI_x86_64_v2_rust-schemars+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smallvec-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smallvec-devel}"
SRC_URI[x86_64_v2_rust-schemars+smallvec-devel.sha256sum] = "3c4c47baeed062d38e491ed5f219b710e7f6cfe88fd57e77660c7344a51ffe2d"

URI_x86_64_v2_rust-schemars+smol_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+smol_str-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+smol_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+smol_str-devel}"
SRC_URI[x86_64_v2_rust-schemars+smol_str-devel.sha256sum] = "e1a528cff77d462da2eb45efc88303d5e4e77243ec59297ac9593ad70e8c3363"

URI_x86_64_v2_rust-schemars+ui_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+ui_test-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+ui_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+ui_test-devel}"
SRC_URI[x86_64_v2_rust-schemars+ui_test-devel.sha256sum] = "a4638417d20b5801c696eb737d9e055dc5688a18acb2e2119752ef5295980664"

URI_x86_64_v2_rust-schemars+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+url-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+url-devel}"
SRC_URI[x86_64_v2_rust-schemars+url-devel.sha256sum] = "72a4326128ba26c47067c34562bb5d880f78a532dd00815af52e7c6f47af31ce"

URI_x86_64_v2_rust-schemars+uuid1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars+uuid1-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars+uuid1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars+uuid1-devel}"
SRC_URI[x86_64_v2_rust-schemars+uuid1-devel.sha256sum] = "01ef8f3dc29a38d4b5e14646e78ec133e589dc34e9cc39894266c5d89a1b5a57"

URI_x86_64_v2_rust-schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars-devel-0.8.22-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars-devel}"
SRC_URI[x86_64_v2_rust-schemars-devel.sha256sum] = "af057918c77ba2fe78f4dbb5545d95396fe7bf2180d52e87c293e9a44c21bea4"

URI_aarch64_rust-schemars+arrayvec07-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+arrayvec07-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+arrayvec07-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+arrayvec07-devel}"
SRC_URI[aarch64_rust-schemars+arrayvec07-devel.sha256sum] = "84c8f004ab499fdca8967de9c7fb76adab4255b1a0213415135c1362bc90b0a1"

URI_aarch64_rust-schemars+bigdecimal04-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+bigdecimal04-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+bigdecimal04-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+bigdecimal04-devel}"
SRC_URI[aarch64_rust-schemars+bigdecimal04-devel.sha256sum] = "f4e5baf53acacdb4dbab98db517f027c72d592c6007d31c22d67291f37e02446"

URI_aarch64_rust-schemars+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+bytes-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+bytes-devel}"
SRC_URI[aarch64_rust-schemars+bytes-devel.sha256sum] = "44a18b507d1730a4b277bf111cb7585966eb8f32eb37de91feb5e97964b53e86"

URI_aarch64_rust-schemars+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+chrono-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+chrono-devel}"
SRC_URI[aarch64_rust-schemars+chrono-devel.sha256sum] = "b6856439ecc9535b13add1dd74699b8da449fe5c475ad81a291b986216e155b4"

URI_aarch64_rust-schemars+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+default-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+default-devel}"
SRC_URI[aarch64_rust-schemars+default-devel.sha256sum] = "def6d2fa3877449e4dd8082c552fb16b2ff18ce5660fd29653a2a20b19d96528"

URI_aarch64_rust-schemars+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+derive-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+derive-devel}"
SRC_URI[aarch64_rust-schemars+derive-devel.sha256sum] = "dcb0cf4da057f59506f3cf9d0a10e16ade3b6777ba4f1adca0bee24be683d766"

URI_aarch64_rust-schemars+derive_json_schema-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+derive_json_schema-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+derive_json_schema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+derive_json_schema-devel}"
SRC_URI[aarch64_rust-schemars+derive_json_schema-devel.sha256sum] = "9735b80626fe984e5f299d4a257b3830caba2645ff9d0720a4817f3c1072cf3c"

URI_aarch64_rust-schemars+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+either-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+either-devel}"
SRC_URI[aarch64_rust-schemars+either-devel.sha256sum] = "a1f0ba8526baf0de715a6e1e79b4885c31aeb1738cd174482097f54a2421016a"

URI_aarch64_rust-schemars+enumset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+enumset-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+enumset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+enumset-devel}"
SRC_URI[aarch64_rust-schemars+enumset-devel.sha256sum] = "27351489df6ff1cc484b796ab050358b9e9a1ea7fb509ac0fb928de40441fb26"

URI_aarch64_rust-schemars+impl_json_schema-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+impl_json_schema-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+impl_json_schema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+impl_json_schema-devel}"
SRC_URI[aarch64_rust-schemars+impl_json_schema-devel.sha256sum] = "56ae7cc5e7ad8978a037a5aed8f8c34daa52653d671ae299ed32e4d83771743f"

URI_aarch64_rust-schemars+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+indexmap-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+indexmap-devel}"
SRC_URI[aarch64_rust-schemars+indexmap-devel.sha256sum] = "ccc798643cda22bc767369ad0bff917a2a37d96fbfa88aa5691707f9b9549ce7"

URI_aarch64_rust-schemars+indexmap1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+indexmap1-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+indexmap1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+indexmap1-devel}"
SRC_URI[aarch64_rust-schemars+indexmap1-devel.sha256sum] = "88ded50b0db970978b6bdef45f1cab0c3d90a81cc2175147c6ac02b88384acac"

URI_aarch64_rust-schemars+indexmap2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+indexmap2-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+indexmap2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+indexmap2-devel}"
SRC_URI[aarch64_rust-schemars+indexmap2-devel.sha256sum] = "1fbad773dc9900c1d2895c06827ca2a9bf1f0cbada070733fb6cbbde1c9b2882"

URI_aarch64_rust-schemars+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+preserve_order-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+preserve_order-devel}"
SRC_URI[aarch64_rust-schemars+preserve_order-devel.sha256sum] = "d7077713f5619685400176669d0f5c0a30a6d8e52195bb6d77bc3265ac6a6591"

URI_aarch64_rust-schemars+raw_value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+raw_value-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+raw_value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+raw_value-devel}"
SRC_URI[aarch64_rust-schemars+raw_value-devel.sha256sum] = "ac144493477f928dd99ca527297324ae4a90c2f33496ca1e6f0611e4f9ea80e7"

URI_aarch64_rust-schemars+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+rust_decimal-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+rust_decimal-devel}"
SRC_URI[aarch64_rust-schemars+rust_decimal-devel.sha256sum] = "819668ebd5bb9bb366d4cfd29a4da21e17ccbb3b074bb54065df1c0c9de622d5"

URI_aarch64_rust-schemars+schemars_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+schemars_derive-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+schemars_derive-devel}"
SRC_URI[aarch64_rust-schemars+schemars_derive-devel.sha256sum] = "c9e779a3639bea3f0feee1c7907a78b878bf59d6d13318bfc35303b4228b60cb"

URI_aarch64_rust-schemars+semver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+semver-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+semver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+semver-devel}"
SRC_URI[aarch64_rust-schemars+semver-devel.sha256sum] = "1aa912748f66783200255c34fb345cf2f62bb1613e1ac23b1f686c1f498ff8ba"

URI_aarch64_rust-schemars+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smallvec-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smallvec-devel}"
SRC_URI[aarch64_rust-schemars+smallvec-devel.sha256sum] = "701f2b9cfa3aa91417976c5ac9323767e55d75162a39bae277d1f88f82524a07"

URI_aarch64_rust-schemars+smol_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+smol_str-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+smol_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+smol_str-devel}"
SRC_URI[aarch64_rust-schemars+smol_str-devel.sha256sum] = "a3a3344d14511da43559a134549307b6299b4b05fbd8cf89fdf44c3b5bd35aca"

URI_aarch64_rust-schemars+ui_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+ui_test-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+ui_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+ui_test-devel}"
SRC_URI[aarch64_rust-schemars+ui_test-devel.sha256sum] = "421234c44b26bdcd5baa31118a39eabc1fce25493190c89bfc1698e244963125"

URI_aarch64_rust-schemars+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+url-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+url-devel}"
SRC_URI[aarch64_rust-schemars+url-devel.sha256sum] = "fcb2ea054ef2e740c831d694e2ca1ab9bb1d93c6d54c13488ba1394c3b33097d"

URI_aarch64_rust-schemars+uuid1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars+uuid1-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars+uuid1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars+uuid1-devel}"
SRC_URI[aarch64_rust-schemars+uuid1-devel.sha256sum] = "8aab02fcb4684141c8183e775efb5d67f97214d710b529e5e7270acb61076bbf"

URI_aarch64_rust-schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars-devel-0.8.22-2.el10_0.noarch.rpm;name=aarch64_rust-schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars-devel}"
SRC_URI[aarch64_rust-schemars-devel.sha256sum] = "f34706a0c54e580e677d05246b466e171381614162585bbbfdb9a227e5bd2efe"

RDEPENDS:rust-schemars+arrayvec07-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+bigdecimal04-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+default-devel = " \
 cargo \
 rust-schemars+derive-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+derive-devel = " \
 cargo \
 rust-schemars+schemars_derive-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+derive_json_schema-devel = " \
 cargo \
 rust-schemars+impl_json_schema-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+either-devel = " \
 cargo \
 rust-either-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+enumset-devel = " \
 cargo \
 rust-enumset+default-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+impl_json_schema-devel = " \
 cargo \
 rust-schemars+derive-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+indexmap-devel = " \
 cargo \
 rust-indexmap1+default-devel \
 rust-indexmap1+serde-1-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+indexmap1-devel = " \
 cargo \
 rust-schemars+indexmap-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+indexmap2-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+preserve_order-devel = " \
 cargo \
 rust-schemars+indexmap-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+raw_value-devel = " \
 cargo \
 rust-schemars-devel \
 rust-serde_json+raw_value-devel \
 "
RDEPENDS:rust-schemars+rust_decimal-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+schemars_derive-devel = " \
 cargo \
 rust-schemars-devel \
 rust-schemars_derive+default-devel \
 "
RDEPENDS:rust-schemars+semver-devel = " \
 cargo \
 rust-schemars-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 "
RDEPENDS:rust-schemars+smallvec-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-schemars+smol_str-devel = " \
 cargo \
 rust-schemars-devel \
 rust-smol_str0.1+default-devel \
 "
RDEPENDS:rust-schemars+ui_test-devel = " \
 cargo \
 rust-schemars-devel \
 "
RDEPENDS:rust-schemars+url-devel = " \
 cargo \
 rust-schemars-devel \
 rust-url-devel \
 "
RDEPENDS:rust-schemars+uuid1-devel = " \
 cargo \
 rust-schemars-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-schemars-devel = " \
 cargo \
 rust \
 rust-dyn-clone+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
