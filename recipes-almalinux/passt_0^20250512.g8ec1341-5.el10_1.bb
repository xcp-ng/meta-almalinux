# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "passt"
PV = "0^20250512.g8ec1341"
PR = "5.el10_1"
PACKAGES = " \
 passt \
 passt-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/passt-0^20250512.g8ec1341-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a2d837eb57377db58743a7670ed57a2a618b333a439d4ca78877dde014fe099d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-0^20250512.g8ec1341-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_passt;unpack=0"
SRC_URI[x86_64_v2_passt.sha256sum] = "6868d05d1b30cb7a8310ce67b68caaa30c40ae8cfbbcaf3222f4aa205ee3f52c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-selinux-0^20250512.g8ec1341-5.el10_1.noarch.rpm;name=x86_64_v2_passt-selinux;unpack=0"
SRC_URI[x86_64_v2_passt-selinux.sha256sum] = "d1f8b78bead4cfd2e81202ddd1049122ba44658c7564815317cf4fd821832a57"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-0^20250512.g8ec1341-5.el10_1.aarch64.rpm;name=aarch64_passt;unpack=0"
SRC_URI[aarch64_passt.sha256sum] = "23e163f959b839a1057717b9d131152dd25d28f9a4c27a3aa003fdd4a4675ff3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-selinux-0^20250512.g8ec1341-5.el10_1.noarch.rpm;name=aarch64_passt-selinux;unpack=0"
SRC_URI[aarch64_passt-selinux.sha256sum] = "d1f8b78bead4cfd2e81202ddd1049122ba44658c7564815317cf4fd821832a57"

RDEPENDS:passt = " \
 glibc \
 passt-selinux \
 "
RDEPENDS:passt-selinux = " \
 bash \
 passt \
 policycoreutils \
 selinux-policy \
 "
