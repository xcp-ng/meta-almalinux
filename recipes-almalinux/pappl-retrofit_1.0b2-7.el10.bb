# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pappl-retrofit"
PV = "1.0b2"
PR = "7.el10"
PACKAGES = " \
 legacy-printer-app \
 pappl-retrofit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pappl-retrofit-1.0b2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c9ec0aca8c090544c8a57810708021c3af8851513e3bed126639ac1aa4f0848"

URI_x86_64_v2_legacy-printer-app = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/legacy-printer-app-1.0b2-7.el10.x86_64_v2.rpm;name=x86_64_v2_legacy-printer-app;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_legacy-printer-app}"
SRC_URI[x86_64_v2_legacy-printer-app.sha256sum] = "8074c0535a937e8ead6f3d4a3b0f905461f8d6764930632e8537a605fde44029"

URI_x86_64_v2_pappl-retrofit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pappl-retrofit-1.0b2-7.el10.x86_64_v2.rpm;name=x86_64_v2_pappl-retrofit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pappl-retrofit}"
SRC_URI[x86_64_v2_pappl-retrofit.sha256sum] = "a6f2095575149cceeb808a71a5e1efc81fdc7ecf965e42fa08dba1a7773f6abc"

URI_aarch64_legacy-printer-app = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/legacy-printer-app-1.0b2-7.el10.aarch64.rpm;name=aarch64_legacy-printer-app;unpack=0"
SRC_URI:append = " ${URI_aarch64_legacy-printer-app}"
SRC_URI[aarch64_legacy-printer-app.sha256sum] = "afe6173db2db445e9fdeeeb9196eeadd26c3b47c7e8ad539e6cb8363481580f9"

URI_aarch64_pappl-retrofit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pappl-retrofit-1.0b2-7.el10.aarch64.rpm;name=aarch64_pappl-retrofit;unpack=0"
SRC_URI:append = " ${URI_aarch64_pappl-retrofit}"
SRC_URI[aarch64_pappl-retrofit.sha256sum] = "0964515946eb0f393f30996dca061291549d76f0b40822f1ec9dcf35da7638f8"

RDEPENDS:legacy-printer-app = " \
 authselect-libs \
 bash \
 cups-filesystem \
 cups-libs \
 glibc \
 libcupsfilters \
 libppd \
 pappl-retrofit \
 systemd \
 "
RDEPENDS:pappl-retrofit = " \
 cups-libs \
 glibc \
 libcupsfilters \
 libppd \
 pappl \
 "
