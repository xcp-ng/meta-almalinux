# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-bluez-qt"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-bluez-qt \
 kf6-bluez-qt-devel \
 kf6-bluez-qt-doc \
 kf6-bluez-qt-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-bluez-qt-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "684ad0e0699b1547b09d769d13455ccd1a2360a93685a4c10de3cf29a7646417"

URI_x86_64_v2_kf6-bluez-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-bluez-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt}"
SRC_URI[x86_64_v2_kf6-bluez-qt.sha256sum] = "9d880084d2e7d40d687da72fece6ac1c087f16730da070fb44bc0a6d221f6657"

URI_x86_64_v2_kf6-bluez-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-bluez-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-devel}"
SRC_URI[x86_64_v2_kf6-bluez-qt-devel.sha256sum] = "2b8a6a5fe55c39c69e6a14bbbe966096cf6def21a079d0a034ddcb38aa7ae527"

URI_x86_64_v2_kf6-bluez-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-bluez-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-doc}"
SRC_URI[x86_64_v2_kf6-bluez-qt-doc.sha256sum] = "dda980aef7da75825bd7865689d8c3ad5e672518d82dd7b07e3b292f021ef334"

URI_x86_64_v2_kf6-bluez-qt-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-bluez-qt-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-bluez-qt-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-bluez-qt-html}"
SRC_URI[x86_64_v2_kf6-bluez-qt-html.sha256sum] = "e01523fd7e28b117a4b82b20cd87f88a2132787a18a6387c69cf922768f1cb9f"

URI_aarch64_kf6-bluez-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-bluez-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt}"
SRC_URI[aarch64_kf6-bluez-qt.sha256sum] = "78793598187a9c37b8047e13f5556d4227aa7e4077d8e48713ffdba9cc271c73"

URI_aarch64_kf6-bluez-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-bluez-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-devel}"
SRC_URI[aarch64_kf6-bluez-qt-devel.sha256sum] = "2b4b0d43dfbab6665de7b0ae384bbaf1a0116c0cc38b491f1ad97c0623320104"

URI_aarch64_kf6-bluez-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-bluez-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-doc}"
SRC_URI[aarch64_kf6-bluez-qt-doc.sha256sum] = "fb1df603001c7406fd40752839c1b111169da4f299e8948a9f334d5ea77cbf33"

URI_aarch64_kf6-bluez-qt-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-bluez-qt-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-bluez-qt-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-bluez-qt-html}"
SRC_URI[aarch64_kf6-bluez-qt-html.sha256sum] = "a9c0f602cf8b5569510cf34ad911e6c23b47dc09d9435a9bf2e05eef4e4f5296"

RDEPENDS:kf6-bluez-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-bluez-qt-devel = " \
 cmake-filesystem \
 kf6-bluez-qt \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-bluez-qt-doc = " \
 "
RDEPENDS:kf6-bluez-qt-html = " \
 "
