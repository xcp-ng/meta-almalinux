# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lxc"
PV = "6.0.5"
PR = "1.el10_0"
PACKAGES = " \
 lxc \
 lxc-devel \
 lxc-doc \
 lxc-libs \
 lxc-templates \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lxc-6.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41b22ee0ccf54709734c5dcd3a06b24bf6b7aca0ec2b8d7e49110ef9efe525aa"

URI_x86_64_v2_lxc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-6.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc}"
SRC_URI[x86_64_v2_lxc.sha256sum] = "c06be56c627d41b563f508de0c44ef17bd37c969eeb318c02a848d98a3b3fd12"

URI_x86_64_v2_lxc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-devel-6.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-devel}"
SRC_URI[x86_64_v2_lxc-devel.sha256sum] = "b5fa1bdccb204ce346169605c9cb261c09d6760a8e25f83d65138962e473cfdb"

URI_x86_64_v2_lxc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-doc-6.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lxc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-doc}"
SRC_URI[x86_64_v2_lxc-doc.sha256sum] = "3f5f3d3b9196dfc692a1ccf87ca5dc338c522079ca902294c16c6b36e889807e"

URI_x86_64_v2_lxc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-libs-6.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-libs}"
SRC_URI[x86_64_v2_lxc-libs.sha256sum] = "3b066da8e29aaac4a6907846587364ed767beaff4bfa7a8ad1b504b30a958e01"

URI_x86_64_v2_lxc-templates = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxc-templates-6.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxc-templates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lxc-templates}"
SRC_URI[x86_64_v2_lxc-templates.sha256sum] = "788b025ce0c967d4be0a90c77f6bfb39f990175541431ae78d62967a88773929"

URI_aarch64_lxc = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-6.0.5-1.el10_0.aarch64.rpm;name=aarch64_lxc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc}"
SRC_URI[aarch64_lxc.sha256sum] = "0b1d64578ea6e33e45f3e9ee430e8d5f8c26371e2c1a0ef8db39d87d5163310c"

URI_aarch64_lxc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-devel-6.0.5-1.el10_0.aarch64.rpm;name=aarch64_lxc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-devel}"
SRC_URI[aarch64_lxc-devel.sha256sum] = "d07de2c4a9f54f024f58a2f01be878c889d0ab1f6d04a1aabb1aac4658f181a8"

URI_aarch64_lxc-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-doc-6.0.5-1.el10_0.noarch.rpm;name=aarch64_lxc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-doc}"
SRC_URI[aarch64_lxc-doc.sha256sum] = "f9f7e81ec95245ee9e087e94287fb40a2e86b3950736858b092cf333b00050b3"

URI_aarch64_lxc-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-libs-6.0.5-1.el10_0.aarch64.rpm;name=aarch64_lxc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-libs}"
SRC_URI[aarch64_lxc-libs.sha256sum] = "f146a6b409ae6a0ab0654a39c0b9cfa643764d8f606967a8643253d4ddc8f024"

URI_aarch64_lxc-templates = "${EPEL_MIRROR}/aarch64/Packages/l/lxc-templates-6.0.5-1.el10_0.aarch64.rpm;name=aarch64_lxc-templates;unpack=0"
SRC_URI:append = " ${URI_aarch64_lxc-templates}"
SRC_URI[aarch64_lxc-templates.sha256sum] = "255ce03fa7e8aa2d6b9474f6d7babbae7049610e606a2d5a98d5b5c3eae328bf"

RDEPENDS:lxc = " \
 bash \
 dbus-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 lxc-libs \
 lxcfs \
 openssl \
 openssl-libs \
 rsync \
 "
RDEPENDS:lxc-devel = " \
 dbus-devel \
 libcap-devel \
 libseccomp-devel \
 libselinux-devel \
 lxc-libs \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:lxc-doc = " \
 "
RDEPENDS:lxc-libs = " \
 bash \
 dbus-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 pam-libs \
 rsync \
 systemd \
 "
RDEPENDS:lxc-templates = " \
 bash \
 lxc-libs \
 wget \
 "
