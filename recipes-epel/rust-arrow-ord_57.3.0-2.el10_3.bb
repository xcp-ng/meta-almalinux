# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-ord"
PV = "57.3.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-arrow-ord+default-devel \
 rust-arrow-ord-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-ord-57.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62839fcfbbdb965dfa353dc30bf7c76e43b621068e94d7e0a60512683c844bf9"

URI_x86_64_v2_rust-arrow-ord+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-ord+default-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-ord+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-ord+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-ord+default-devel.sha256sum] = "956100a3a3ebbc0580367b14cc20acbb7c76d98929e59427e8f5c5b75340398c"

URI_x86_64_v2_rust-arrow-ord-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-ord-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-ord-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-ord-devel}"
SRC_URI[x86_64_v2_rust-arrow-ord-devel.sha256sum] = "acd2c38900d8eca25d2a9813ecc1902841befff0907cb62fe7f9669aa5c813c5"

URI_aarch64_rust-arrow-ord+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-ord+default-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-ord+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-ord+default-devel}"
SRC_URI[aarch64_rust-arrow-ord+default-devel.sha256sum] = "01221548a95c8c083464823d2f6a6c82c83ce88b9f9fc2c9907d97fe91774e65"

URI_aarch64_rust-arrow-ord-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-ord-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-ord-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-ord-devel}"
SRC_URI[aarch64_rust-arrow-ord-devel.sha256sum] = "370fe6f0fb6c84bc4415e26895e39e95d77a716cf3aedb068bdf6ae340dff159"

RDEPENDS:rust-arrow-ord+default-devel = " \
 cargo \
 rust-arrow-ord-devel \
 "
RDEPENDS:rust-arrow-ord-devel = " \
 cargo \
 rust \
 rust-arrow-array+default-devel \
 rust-arrow-buffer+default-devel \
 rust-arrow-data+default-devel \
 rust-arrow-schema+default-devel \
 rust-arrow-select+default-devel \
 "
