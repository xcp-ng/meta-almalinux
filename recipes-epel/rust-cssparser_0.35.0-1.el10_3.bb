# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cssparser"
PV = "0.35.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-cssparser+bench-devel \
 rust-cssparser+default-devel \
 rust-cssparser+dummy_match_byte-devel \
 rust-cssparser+serde-devel \
 rust-cssparser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cssparser-0.35.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecbe5baedb55ca8e8964e0aff8fccd0c75808d0059b17d0a50c3871b8b812509"

URI_x86_64_v2_rust-cssparser+bench-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cssparser+bench-devel-0.35.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cssparser+bench-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cssparser+bench-devel}"
SRC_URI[x86_64_v2_rust-cssparser+bench-devel.sha256sum] = "1818b1c5fedddf6de8aade6fe6f1717685afd038ee3c77a6d06e729a71621c44"

URI_x86_64_v2_rust-cssparser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cssparser+default-devel-0.35.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cssparser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cssparser+default-devel}"
SRC_URI[x86_64_v2_rust-cssparser+default-devel.sha256sum] = "90713b2fa3e8ff7f2868280a5b8cbf609c77345232236a5db334af72bad49741"

URI_x86_64_v2_rust-cssparser+dummy_match_byte-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cssparser+dummy_match_byte-devel-0.35.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cssparser+dummy_match_byte-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cssparser+dummy_match_byte-devel}"
SRC_URI[x86_64_v2_rust-cssparser+dummy_match_byte-devel.sha256sum] = "eef1528ea7bf6f4647132d082ff1b93defe6eb56cbdc03e991c9becbac0237be"

URI_x86_64_v2_rust-cssparser+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cssparser+serde-devel-0.35.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cssparser+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cssparser+serde-devel}"
SRC_URI[x86_64_v2_rust-cssparser+serde-devel.sha256sum] = "ca25d681b609bea1284380f840f60b01adf7e384b7538859b04e64064e23c303"

URI_x86_64_v2_rust-cssparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cssparser-devel-0.35.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cssparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cssparser-devel}"
SRC_URI[x86_64_v2_rust-cssparser-devel.sha256sum] = "8afdfe0f8a4773fb1fd01037e62b05a1b60f584731d854486a4b4e3162d8fac0"

URI_aarch64_rust-cssparser+bench-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cssparser+bench-devel-0.35.0-1.el10_3.noarch.rpm;name=aarch64_rust-cssparser+bench-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cssparser+bench-devel}"
SRC_URI[aarch64_rust-cssparser+bench-devel.sha256sum] = "609fa32ad0e74e1538faf0334662f5c8cf4d75d5c40d7dad5d27c550b30d1f2d"

URI_aarch64_rust-cssparser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cssparser+default-devel-0.35.0-1.el10_3.noarch.rpm;name=aarch64_rust-cssparser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cssparser+default-devel}"
SRC_URI[aarch64_rust-cssparser+default-devel.sha256sum] = "e99d3c8a893b06e66fba67e35fe57afaa979112cc811cc725fe24cde56577ea1"

URI_aarch64_rust-cssparser+dummy_match_byte-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cssparser+dummy_match_byte-devel-0.35.0-1.el10_3.noarch.rpm;name=aarch64_rust-cssparser+dummy_match_byte-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cssparser+dummy_match_byte-devel}"
SRC_URI[aarch64_rust-cssparser+dummy_match_byte-devel.sha256sum] = "2f8be370378382071fe0e351bd33acdab1bb5b74f742fa333354fa22442cd887"

URI_aarch64_rust-cssparser+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cssparser+serde-devel-0.35.0-1.el10_3.noarch.rpm;name=aarch64_rust-cssparser+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cssparser+serde-devel}"
SRC_URI[aarch64_rust-cssparser+serde-devel.sha256sum] = "e386339eb4bb94b345fe0009ecaa7c673b02fa14d29687c3e2eca260ece1ec70"

URI_aarch64_rust-cssparser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cssparser-devel-0.35.0-1.el10_3.noarch.rpm;name=aarch64_rust-cssparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cssparser-devel}"
SRC_URI[aarch64_rust-cssparser-devel.sha256sum] = "d93cca26411f6c6548b34ec399cc3895381ed998913c438ce749488fa7b75d2a"

RDEPENDS:rust-cssparser+bench-devel = " \
 cargo \
 rust-cssparser-devel \
 "
RDEPENDS:rust-cssparser+default-devel = " \
 cargo \
 rust-cssparser-devel \
 "
RDEPENDS:rust-cssparser+dummy_match_byte-devel = " \
 cargo \
 rust-cssparser-devel \
 "
RDEPENDS:rust-cssparser+serde-devel = " \
 cargo \
 rust-cssparser-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-cssparser-devel = " \
 cargo \
 rust \
 rust-cssparser-macros+default-devel \
 rust-dtoa-short+default-devel \
 rust-itoa+default-devel \
 rust-phf0.11+default-devel \
 rust-phf0.11+macros-devel \
 rust-smallvec+default-devel \
 "
