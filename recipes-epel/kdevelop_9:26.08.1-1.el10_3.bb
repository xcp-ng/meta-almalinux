# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdevelop"
PE = "9"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdevelop \
 kdevelop-devel \
 kdevelop-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdevelop-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "99b2536c4c3a7822b71f15e31f013dc5b4d7712ef34aa5380c021713ea4538bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop;unpack=0"
SRC_URI[x86_64_v2_kdevelop.sha256sum] = "113de4597497a211f4ad04f1809f1cd7949229d3b5218f2acfa0c12c164b72e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop-devel;unpack=0"
SRC_URI[x86_64_v2_kdevelop-devel.sha256sum] = "8e47b50df87e8ab9618cd80eff4b830d4930221643ab6e7db4a5a08fdf8209c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop-libs;unpack=0"
SRC_URI[x86_64_v2_kdevelop-libs.sha256sum] = "93ae674246c74e577fa7642502989c557bf3626ed1ac45f2212b27c9da736454"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdevelop;unpack=0"
SRC_URI[aarch64_kdevelop.sha256sum] = "66c2aa24b5fddb47813f8e08e25601382572a8064c034565114edd40195eb654"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdevelop-devel;unpack=0"
SRC_URI[aarch64_kdevelop-devel.sha256sum] = "0b227f919a1945610e190a010a41b13f15a6bac90795bf54df1e9f8ea4f99c1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdevelop-libs;unpack=0"
SRC_URI[aarch64_kdevelop-libs.sha256sum] = "bc8a3df28b47766f50a2b06623f9561ee4aa8f05706bcfd76be299531007437b"

RDEPENDS:kdevelop = " \
 astyle \
 bash \
 cmake \
 cppcheck \
 git \
 glibc \
 kdevelop-libs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 konsole-part \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kdevelop-devel = " \
 cmake-filesystem \
 kdevelop-libs \
 kf6-ktexteditor-devel \
 kf6-threadweaver-devel \
 qt6-qt5compat-devel \
 qt6-qtbase-devel \
 qt6-qtwebengine-devel \
 "
RDEPENDS:kdevelop-libs = " \
 apr \
 apr-util \
 astyle \
 clang-libs \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-krunner \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-purpose \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kf6-threadweaver \
 libgcc \
 libkomparediff2 \
 libksysguard \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-help \
 qt6-qtwebengine \
 subversion-libs \
 "
