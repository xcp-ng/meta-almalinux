# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ct-codecs"
PV = "1.1.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-ct-codecs+default-devel \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ct-codecs-1.1.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "03d8fe891fe37228ee2f58e97ca75bb2e6366ab1c04e73e37b5f4187ddb30290"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+default-devel-1.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ct-codecs+default-devel.sha256sum] = "fa1e3e7ae62eb9a939f6a8f0b8981035a989eff42a532817043572863112d1ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+std-devel-1.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ct-codecs+std-devel.sha256sum] = "929d0976a842d3d1c71742a95bfe14057bfcf1e8779a368f1a1e0c0d3d15dc5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs-devel-1.1.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ct-codecs-devel.sha256sum] = "12eff27dcf609e822a94b36314bcfc6c3d4cf94a729c05dc451e334ac9d0acca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+default-devel-1.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-ct-codecs+default-devel;unpack=0"
SRC_URI[aarch64_rust-ct-codecs+default-devel.sha256sum] = "59830eacad3c522c4811fcff12dce68883f53b6a7b4dcbcf04bda5c6f746b8ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+std-devel-1.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-ct-codecs+std-devel;unpack=0"
SRC_URI[aarch64_rust-ct-codecs+std-devel.sha256sum] = "4e5f2dc8f40d690b4b5a4934a389032e7b14990c79d2e9ac487b80b700b20ff2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs-devel-1.1.8-1.el10_2.noarch.rpm;name=aarch64_rust-ct-codecs-devel;unpack=0"
SRC_URI[aarch64_rust-ct-codecs-devel.sha256sum] = "6a190cd2932b5c601802a2f664e03a62a7b8d976c671197ce62aca57bbcccbd1"

RDEPENDS:rust-ct-codecs+default-devel = " \
 cargo \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs+std-devel = " \
 cargo \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs-devel = " \
 cargo \
 "
