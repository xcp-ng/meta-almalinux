# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ioping"
PV = "1.3"
PR = "9.el10_2"
PACKAGES = " \
 ioping \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ioping-1.3-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4039ee52e68f42be53a6b98c938c4b0c34e1c66cf33b4adb943e175fb5ed9a69"

URI_x86_64_v2_ioping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ioping-1.3-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ioping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ioping}"
SRC_URI[x86_64_v2_ioping.sha256sum] = "01507cb35c43f0ed28538c476af2c196bb4eba5af840c351212cac6d512cab30"

URI_aarch64_ioping = "${EPEL_MIRROR}/aarch64/Packages/i/ioping-1.3-9.el10_2.aarch64.rpm;name=aarch64_ioping;unpack=0"
SRC_URI:append = " ${URI_aarch64_ioping}"
SRC_URI[aarch64_ioping.sha256sum] = "7e6fcad9f82773858a54c66a206fb05c1560fadf9d66bbe0f5ffe72bda6d12d0"

RDEPENDS:ioping = " \
 glibc \
 "
