# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_macros"
PV = "0.11.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-phf_macros+default-devel \
 rust-phf_macros+unicase-devel \
 rust-phf_macros+unicase_-devel \
 rust-phf_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_macros-0.11.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "260960f2c00bdb125148784103b0617d76d7f2dba9eee023c1e36b355ed11636"

URI_x86_64_v2_rust-phf_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+default-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+default-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+default-devel.sha256sum] = "6927d3783a2b21b88361abc6b7eac8c2bfb3fab3306981358de2679574fa7a5d"

URI_x86_64_v2_rust-phf_macros+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+unicase-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+unicase-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+unicase-devel.sha256sum] = "cd48e7d60e839d1b1029f162aaaa69d47cdee267cea928d55550fb423e02d18f"

URI_x86_64_v2_rust-phf_macros+unicase_-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros+unicase_-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros+unicase_-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros+unicase_-devel}"
SRC_URI[x86_64_v2_rust-phf_macros+unicase_-devel.sha256sum] = "29918b9e14795de3cac6a77ee4e0144262b3ef42d6086d5ff69dbe9c6b08c56d"

URI_x86_64_v2_rust-phf_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_macros-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_macros-devel}"
SRC_URI[x86_64_v2_rust-phf_macros-devel.sha256sum] = "1ff8ceff6b133177c82a670e24ca4ad73e50f8cb2ba34dc7e7df56a72c1c1914"

URI_aarch64_rust-phf_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+default-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+default-devel}"
SRC_URI[aarch64_rust-phf_macros+default-devel.sha256sum] = "573f6c6f2af3496f4061a9b82a362aa57af728feafd0fd4bbb375c75a5d7c185"

URI_aarch64_rust-phf_macros+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+unicase-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_macros+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+unicase-devel}"
SRC_URI[aarch64_rust-phf_macros+unicase-devel.sha256sum] = "db99a04fc5919cd6454ed5f622af63c58c07137459fec314e6fa9589e0ce1786"

URI_aarch64_rust-phf_macros+unicase_-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros+unicase_-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_macros+unicase_-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros+unicase_-devel}"
SRC_URI[aarch64_rust-phf_macros+unicase_-devel.sha256sum] = "0e58d5552a637f50e29b2dc7febe1d32635531e1bb347946670d38d3a68a56e9"

URI_aarch64_rust-phf_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_macros-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_macros-devel}"
SRC_URI[aarch64_rust-phf_macros-devel.sha256sum] = "9b821252089774727912969589c199043b7b24b1389a11e3248e5b73a1cadd27"

RDEPENDS:rust-phf_macros+default-devel = " \
 cargo \
 rust-phf_macros-devel \
 "
RDEPENDS:rust-phf_macros+unicase-devel = " \
 cargo \
 rust-phf_macros+unicase_-devel \
 rust-phf_macros-devel \
 rust-phf_shared+unicase-devel \
 "
RDEPENDS:rust-phf_macros+unicase_-devel = " \
 cargo \
 rust-phf_macros-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-phf_macros-devel = " \
 cargo \
 rust \
 rust-phf_generator+default-devel \
 rust-phf_shared-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
