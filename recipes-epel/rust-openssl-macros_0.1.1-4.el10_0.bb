# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl-macros"
PV = "0.1.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-openssl-macros+default-devel \
 rust-openssl-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-macros-0.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8ca0ca787ed1046735bb84e3276da89342fced6195ec4a58763781bfa50978a"

URI_x86_64_v2_rust-openssl-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-macros+default-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-macros+default-devel}"
SRC_URI[x86_64_v2_rust-openssl-macros+default-devel.sha256sum] = "ec02991d80938560010f9ac01a1356aff2ea192355f1e6601e4ea2dd6d3dcbdc"

URI_x86_64_v2_rust-openssl-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-macros-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-macros-devel}"
SRC_URI[x86_64_v2_rust-openssl-macros-devel.sha256sum] = "bc6d45271eed8d3b93bdfe8ae780012fa45e6eb55b5ba8948d30b82d9852fd06"

URI_aarch64_rust-openssl-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-macros+default-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-openssl-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-macros+default-devel}"
SRC_URI[aarch64_rust-openssl-macros+default-devel.sha256sum] = "92dd3a25cd15b63dc087c6ede32a8973fae238f9e2c24571c2668a99d3847a52"

URI_aarch64_rust-openssl-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-macros-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-openssl-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-macros-devel}"
SRC_URI[aarch64_rust-openssl-macros-devel.sha256sum] = "fdc5bc580d7065f73263455d096c4c2a5cafddfd9baf0da29ef844f2f68d1d6e"

RDEPENDS:rust-openssl-macros+default-devel = " \
 cargo \
 rust-openssl-macros-devel \
 "
RDEPENDS:rust-openssl-macros-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
