# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkgapi"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libkgapi \
 libkgapi-devel \
 libkgapi-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkgapi-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "875d0e2fc47a14ba0a3ccc297fbf781481147187e5d056863140b99b41c699ad"

URI_x86_64_v2_libkgapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkgapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi}"
SRC_URI[x86_64_v2_libkgapi.sha256sum] = "142d4416d9883ad466fea7430fdec292cf52fae095d9b7b8dc236e80305ed167"

URI_x86_64_v2_libkgapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkgapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi-devel}"
SRC_URI[x86_64_v2_libkgapi-devel.sha256sum] = "4637d860dd6206bdfaed17e15a1d0319104e8df28f5d1d19dbc5d38ffe759ae4"

URI_x86_64_v2_libkgapi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libkgapi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi-doc}"
SRC_URI[x86_64_v2_libkgapi-doc.sha256sum] = "81a8680804bd9a626253a79971da71442cc757b5c1089565737e3b8759891793"

URI_aarch64_libkgapi = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkgapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi}"
SRC_URI[aarch64_libkgapi.sha256sum] = "378bd01a8259039180c9532f189c02cb2d730da6606117eb27e92de087034706"

URI_aarch64_libkgapi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkgapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi-devel}"
SRC_URI[aarch64_libkgapi-devel.sha256sum] = "e320d652f1aec0f7eb1355edf65b009e9850d61e46baccc31b2d6cbcea496344"

URI_aarch64_libkgapi-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_libkgapi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi-doc}"
SRC_URI[aarch64_libkgapi-doc.sha256sum] = "d63d5895783519ecab152365f01249a2541c062bec2832a93f0f58f01edf8171"

RDEPENDS:libkgapi = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-kwallet-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkgapi-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kcoreaddons-devel \
 libkgapi \
 "
RDEPENDS:libkgapi-doc = " \
 "
