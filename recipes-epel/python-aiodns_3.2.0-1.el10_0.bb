# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiodns"
PV = "3.2.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-aiodns \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiodns-3.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb6c662cf5570eb89596d4710d476166668b70a510b6acbd73b7481e2787b4d5"

URI_x86_64_v2_python3-aiodns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiodns-3.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiodns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiodns}"
SRC_URI[x86_64_v2_python3-aiodns.sha256sum] = "8d8a2deb871d617b63bef056c3cb19f9ed730b339924a8e27e9d5f2a85c88d62"

URI_aarch64_python3-aiodns = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiodns-3.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-aiodns;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiodns}"
SRC_URI[aarch64_python3-aiodns.sha256sum] = "a7f84f38fa68b838784e3f43618ccf2603a33d40cf6a59ebbb3112279b78bce6"

RDEPENDS:python3-aiodns = " \
 python3 \
 python3-pycares \
 "
