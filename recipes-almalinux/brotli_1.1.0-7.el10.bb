# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "brotli"
PV = "1.1.0"
PR = "7.el10"
PACKAGES = " \
 brotli \
 brotli-devel \
 libbrotli \
 python3-brotli \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/brotli-1.1.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f741739088848759c8ae7dbbecf3551c11633ead53bcba5f938a6a2070a61c4a"

URI_x86_64_v2_brotli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brotli-1.1.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brotli}"
SRC_URI[x86_64_v2_brotli.sha256sum] = "a5625a3e71417a646d17d4f7f2f1538c7c1f7b585c432fef29a51bfee8a9e8ff"

URI_x86_64_v2_brotli-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brotli-devel-1.1.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brotli-devel}"
SRC_URI[x86_64_v2_brotli-devel.sha256sum] = "617760835201738b9fc0c8fd4450047b0a364405f466a7a3d3ea8e5d5a0a65e8"

URI_x86_64_v2_libbrotli = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libbrotli-1.1.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_libbrotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbrotli}"
SRC_URI[x86_64_v2_libbrotli.sha256sum] = "16383bb859651858e4e51982636695d9bf04296bd404347804040295ea659ed6"

URI_x86_64_v2_python3-brotli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-brotli-1.1.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_python3-brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-brotli}"
SRC_URI[x86_64_v2_python3-brotli.sha256sum] = "7ad61a3c02f14783e3215e828062f27de8402e5ace7dfad9a5c42c99b7dab2ee"

URI_aarch64_brotli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brotli-1.1.0-7.el10.aarch64.rpm;name=aarch64_brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_brotli}"
SRC_URI[aarch64_brotli.sha256sum] = "7a215cb195a179f11d66de746e986eebe5fb0943ca43cad1c28c19e53c278843"

URI_aarch64_brotli-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brotli-devel-1.1.0-7.el10.aarch64.rpm;name=aarch64_brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_brotli-devel}"
SRC_URI[aarch64_brotli-devel.sha256sum] = "82a895a0f315629d9a510d135b62a9d2295c7ec64112c97e1c1252bb43a116e4"

URI_aarch64_libbrotli = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libbrotli-1.1.0-7.el10.aarch64.rpm;name=aarch64_libbrotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbrotli}"
SRC_URI[aarch64_libbrotli.sha256sum] = "fdf86612ce82148f1ec0e8fb2d4f4c3c0942b7bd4d075325b92564bb7f3641aa"

URI_aarch64_python3-brotli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-brotli-1.1.0-7.el10.aarch64.rpm;name=aarch64_python3-brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-brotli}"
SRC_URI[aarch64_python3-brotli.sha256sum] = "7128401efdb4ebc3fb8ec41af3737af25cd45963e927a3c96cb28bf6749d72ed"

RDEPENDS:brotli = " \
 glibc \
 libbrotli \
 "
RDEPENDS:brotli-devel = " \
 brotli \
 brotli-devel \
 libbrotli \
 pkgconf-pkg-config \
 "
RDEPENDS:libbrotli = " \
 glibc \
 "
RDEPENDS:python3-brotli = " \
 glibc \
 python3 \
 "
