# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "haproxy"
PV = "3.0.5"
PR = "7.el10"
PACKAGES = " \
 haproxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/haproxy-3.0.5-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0c65a38cb161bb30e4ec366fa9d166db97aae6d953a6e2ded4b24fb519d5229"

URI_x86_64_v2_haproxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/haproxy-3.0.5-7.el10.x86_64_v2.rpm;name=x86_64_v2_haproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_haproxy}"
SRC_URI[x86_64_v2_haproxy.sha256sum] = "cfa887a0b7d6ef72dc3287f21f4d23eef20514b6307e5f9eea9c3fdbfebcc5e6"

URI_aarch64_haproxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/haproxy-3.0.5-7.el10.aarch64.rpm;name=aarch64_haproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_haproxy}"
SRC_URI[aarch64_haproxy.sha256sum] = "f6840a3f131b357fbc6eef1ac814ea72cd9f8507d53163382f37d9d4f3ab5676"

RDEPENDS:haproxy = " \
 bash \
 glibc \
 libxcrypt \
 lua-libs \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 "
