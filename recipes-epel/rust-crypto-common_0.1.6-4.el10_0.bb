# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-common"
PV = "0.1.6"
PR = "4.el10_0"
PACKAGES = " \
 rust-crypto-common+default-devel \
 rust-crypto-common+getrandom-devel \
 rust-crypto-common+rand_core-devel \
 rust-crypto-common+std-devel \
 rust-crypto-common-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crypto-common-0.1.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6934a92fd6d36e932dc6ad7e25ad3bb12656762aacdce5a9cbd5125e92b4a85b"

URI_x86_64_v2_rust-crypto-common+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+default-devel-0.1.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+default-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+default-devel.sha256sum] = "3237f9b10b1017adde8190c5fdf6dff763851c0c9fc4bf63c93a6220f6b6789e"

URI_x86_64_v2_rust-crypto-common+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+getrandom-devel-0.1.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+getrandom-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+getrandom-devel.sha256sum] = "fee011a876bba1d7acf4b141cb4b67903b0459594b3768dc05c2fe0d12c8a042"

URI_x86_64_v2_rust-crypto-common+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+rand_core-devel-0.1.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+rand_core-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+rand_core-devel.sha256sum] = "28247ef9acc766c24fed47cfdaaf98a7e73d59d21a81696bac720b86768bd4c3"

URI_x86_64_v2_rust-crypto-common+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common+std-devel-0.1.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common+std-devel}"
SRC_URI[x86_64_v2_rust-crypto-common+std-devel.sha256sum] = "cc99a7eb56d210a5b54bd79be0b44cad4e581ad3204e72a404f7a9c7abeb1835"

URI_x86_64_v2_rust-crypto-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-common-devel-0.1.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-common-devel}"
SRC_URI[x86_64_v2_rust-crypto-common-devel.sha256sum] = "7c0a618bc5076caff41567c7d59dc2934641790c0f0db7446e5bd948ae2d5eae"

URI_aarch64_rust-crypto-common+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+default-devel-0.1.6-4.el10_0.noarch.rpm;name=aarch64_rust-crypto-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+default-devel}"
SRC_URI[aarch64_rust-crypto-common+default-devel.sha256sum] = "6d8e1c91050b09ee2641d32b78d665924f752969db64934817ece946b518053a"

URI_aarch64_rust-crypto-common+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+getrandom-devel-0.1.6-4.el10_0.noarch.rpm;name=aarch64_rust-crypto-common+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+getrandom-devel}"
SRC_URI[aarch64_rust-crypto-common+getrandom-devel.sha256sum] = "4a0e061dbcbde01d694a55c1d601fabc70b74f99536509ae7816c3748a286a36"

URI_aarch64_rust-crypto-common+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+rand_core-devel-0.1.6-4.el10_0.noarch.rpm;name=aarch64_rust-crypto-common+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+rand_core-devel}"
SRC_URI[aarch64_rust-crypto-common+rand_core-devel.sha256sum] = "d85108e6c1d61c7c73c651628bbefb257a3928d7373b739c4c6379402d36ce12"

URI_aarch64_rust-crypto-common+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common+std-devel-0.1.6-4.el10_0.noarch.rpm;name=aarch64_rust-crypto-common+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common+std-devel}"
SRC_URI[aarch64_rust-crypto-common+std-devel.sha256sum] = "d9c4abdd5199b6ece3a6d5c04520021408b03dcdacebe2ef855afae306b5df4b"

URI_aarch64_rust-crypto-common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-common-devel-0.1.6-4.el10_0.noarch.rpm;name=aarch64_rust-crypto-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-common-devel}"
SRC_URI[aarch64_rust-crypto-common-devel.sha256sum] = "ed7afaddf3ee52a69bf5b21f0b241241eb0c636df912569f09977d159e736b31"

RDEPENDS:rust-crypto-common+default-devel = " \
 cargo \
 rust-crypto-common-devel \
 "
RDEPENDS:rust-crypto-common+getrandom-devel = " \
 cargo \
 rust-crypto-common-devel \
 rust-rand_core0.6+default-devel \
 rust-rand_core0.6+getrandom-devel \
 "
RDEPENDS:rust-crypto-common+rand_core-devel = " \
 cargo \
 rust-crypto-common-devel \
 rust-rand_core0.6+default-devel \
 "
RDEPENDS:rust-crypto-common+std-devel = " \
 cargo \
 rust-crypto-common-devel \
 "
RDEPENDS:rust-crypto-common-devel = " \
 cargo \
 rust-generic-array+default-devel \
 rust-generic-array+more_lengths-devel \
 rust-typenum+default-devel \
 "
