# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-aeson-yaml"
PV = "1.1.0.1"
PR = "13.el10_0"
PACKAGES = " \
 ghc-aeson-yaml \
 ghc-aeson-yaml-devel \
 ghc-aeson-yaml-doc \
 ghc-aeson-yaml-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-aeson-yaml-1.1.0.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ea6df029c0d606c49cf49df2c1f179322ad9bec287d7823e2160b8830be8258"

URI_x86_64_v2_ghc-aeson-yaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-aeson-yaml-1.1.0.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-aeson-yaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-aeson-yaml}"
SRC_URI[x86_64_v2_ghc-aeson-yaml.sha256sum] = "431edfbdd547dcae0e9479d53bb023f9bc3be7e8ba2b5b446bee5a9c498a7f60"

URI_x86_64_v2_ghc-aeson-yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-aeson-yaml-devel-1.1.0.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-aeson-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-aeson-yaml-devel}"
SRC_URI[x86_64_v2_ghc-aeson-yaml-devel.sha256sum] = "2822a27a0b8f32e88035c14180e0266d1aa336c17d897e388d728d35110e2444"

URI_x86_64_v2_ghc-aeson-yaml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-aeson-yaml-doc-1.1.0.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-aeson-yaml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-aeson-yaml-doc}"
SRC_URI[x86_64_v2_ghc-aeson-yaml-doc.sha256sum] = "c0d7e4a18fa1a289df0f8fa601d033fc21bd6b654af13476f8dde625c0896182"

URI_x86_64_v2_ghc-aeson-yaml-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-aeson-yaml-prof-1.1.0.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-aeson-yaml-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-aeson-yaml-prof}"
SRC_URI[x86_64_v2_ghc-aeson-yaml-prof.sha256sum] = "105dd35cfaeac4a3a38c9b795e2b553809debcbaf6b52a9457df0f0e7d279815"

URI_aarch64_ghc-aeson-yaml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-aeson-yaml-1.1.0.1-13.el10_0.aarch64.rpm;name=aarch64_ghc-aeson-yaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-aeson-yaml}"
SRC_URI[aarch64_ghc-aeson-yaml.sha256sum] = "931f0cee57d0fa6c0396dea9cf05a677c7bb90f17ad8de2ca8b8fc7bf1fd4e6b"

URI_aarch64_ghc-aeson-yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-aeson-yaml-devel-1.1.0.1-13.el10_0.aarch64.rpm;name=aarch64_ghc-aeson-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-aeson-yaml-devel}"
SRC_URI[aarch64_ghc-aeson-yaml-devel.sha256sum] = "5443ded1ace6311327ab8904b7e2f6236bab789b038fcd1875a9fdb2e1c114d2"

URI_aarch64_ghc-aeson-yaml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-aeson-yaml-doc-1.1.0.1-13.el10_0.noarch.rpm;name=aarch64_ghc-aeson-yaml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-aeson-yaml-doc}"
SRC_URI[aarch64_ghc-aeson-yaml-doc.sha256sum] = "3ad7ba38322d8611fabc7e043a46ef0a9bf6806cc2722564fb1fb99f485133fd"

URI_aarch64_ghc-aeson-yaml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-aeson-yaml-prof-1.1.0.1-13.el10_0.aarch64.rpm;name=aarch64_ghc-aeson-yaml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-aeson-yaml-prof}"
SRC_URI[aarch64_ghc-aeson-yaml-prof.sha256sum] = "bbf7b78fe806947d8c5c0f7490e04cd88e4590492dd265cbe2e3c43b87c53497"

RDEPENDS:ghc-aeson-yaml = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-aeson-yaml-devel = " \
 ghc-aeson-devel \
 ghc-aeson-yaml \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-text-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-aeson-yaml-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-aeson-yaml-prof = " \
 ghc-aeson-prof \
 ghc-aeson-yaml-devel \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-text-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
