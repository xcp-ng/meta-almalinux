# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pem"
PV = "3.0.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-pem+default-devel \
 rust-pem+serde-devel \
 rust-pem+std-devel \
 rust-pem-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pem-3.0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfd3399054d0b60d9854d82f3960f8dd184f0fde69ae3e25dc837f4c0e0df204"

URI_x86_64_v2_rust-pem+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+default-devel-3.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem+default-devel}"
SRC_URI[x86_64_v2_rust-pem+default-devel.sha256sum] = "cd4fe34365ea61b955556402d0856a8ad7d2127c80cd02047c44c6d199ee4b8c"

URI_x86_64_v2_rust-pem+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+serde-devel-3.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem+serde-devel}"
SRC_URI[x86_64_v2_rust-pem+serde-devel.sha256sum] = "b3a5ee49c7446883b9bcd4f890bc64433dfe70d90f75244014fe3d5970b6f1f0"

URI_x86_64_v2_rust-pem+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+std-devel-3.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem+std-devel}"
SRC_URI[x86_64_v2_rust-pem+std-devel.sha256sum] = "a8db6f15c42eb8e9d0bf6052ced3f62f2e9ebe3749a167509f881e631f176cfa"

URI_x86_64_v2_rust-pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-devel-3.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-devel}"
SRC_URI[x86_64_v2_rust-pem-devel.sha256sum] = "0669adea4e4792f4ea66a4c86ac635215b27b74bf72f1be5d41652ed2b7013b1"

URI_aarch64_rust-pem+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+default-devel-3.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-pem+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem+default-devel}"
SRC_URI[aarch64_rust-pem+default-devel.sha256sum] = "7f2461046ae7660e03896e38ac1545a07ed7cbe43615912b5dfc43b48fa31a0e"

URI_aarch64_rust-pem+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+serde-devel-3.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-pem+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem+serde-devel}"
SRC_URI[aarch64_rust-pem+serde-devel.sha256sum] = "f9ecaf977bbbe6ae87c9359c3b919f510be78c37b1f8c3ef094c043eb87ca90a"

URI_aarch64_rust-pem+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+std-devel-3.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-pem+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem+std-devel}"
SRC_URI[aarch64_rust-pem+std-devel.sha256sum] = "76cdf6eb45110b9fd8c2ea47d9ecc909e4a9cf848b3d1987f65663ff09340477"

URI_aarch64_rust-pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-devel-3.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-devel}"
SRC_URI[aarch64_rust-pem-devel.sha256sum] = "d8f93e9b60a1766ecf65f8b54c8f72871c32f0fd5a03b09c86134f740e7d76af"

RDEPENDS:rust-pem+default-devel = " \
 cargo \
 rust-pem+std-devel \
 rust-pem-devel \
 "
RDEPENDS:rust-pem+serde-devel = " \
 cargo \
 rust-pem-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-pem+std-devel = " \
 cargo \
 rust-base64+std-devel \
 rust-pem-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-pem-devel = " \
 cargo \
 rust \
 rust-base64+alloc-devel \
 rust-base64-devel \
 "
