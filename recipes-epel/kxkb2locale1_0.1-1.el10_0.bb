# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kxkb2locale1"
PV = "0.1"
PR = "1.el10_0"
PACKAGES = " \
 kxkb2locale1 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kxkb2locale1-0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a5c4a0a84c313d0f64175a2bfc38879cf8e7f247918ba43666eb5dcd98a09ea"

URI_x86_64_v2_kxkb2locale1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kxkb2locale1-0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kxkb2locale1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kxkb2locale1}"
SRC_URI[x86_64_v2_kxkb2locale1.sha256sum] = "413d817a2c1fdaedccd89994511a629c041c7431760310c6ccd0de43070cbd22"

URI_aarch64_kxkb2locale1 = "${EPEL_MIRROR}/aarch64/Packages/k/kxkb2locale1-0.1-1.el10_0.aarch64.rpm;name=aarch64_kxkb2locale1;unpack=0"
SRC_URI:append = " ${URI_aarch64_kxkb2locale1}"
SRC_URI[aarch64_kxkb2locale1.sha256sum] = "e8551acedc89943d88bf0611bd7140046ec908bebd252b5c2dd8b2cd240213df"

RDEPENDS:kxkb2locale1 = " \
 glibc \
 kf6-kconfig \
 libstdc++ \
 qt6-qtbase \
 "
