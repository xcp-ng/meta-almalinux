# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nload"
PV = "0.7.4"
PR = "30.el10_0"
PACKAGES = " \
 nload \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nload-0.7.4-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff438ea4cf4734c5c59f3ef0813ee19815196435aded8a2b607d2d2a9913cc42"

URI_x86_64_v2_nload = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nload-0.7.4-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nload;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nload}"
SRC_URI[x86_64_v2_nload.sha256sum] = "72ff4ca63cb549db6ad6af609e05fc36359b5518ac3ce04ac22365544f93cec0"

URI_aarch64_nload = "${EPEL_MIRROR}/aarch64/Packages/n/nload-0.7.4-30.el10_0.aarch64.rpm;name=aarch64_nload;unpack=0"
SRC_URI:append = " ${URI_aarch64_nload}"
SRC_URI[aarch64_nload.sha256sum] = "da75e0603195726f84c92a7338768e07f924aa0d8be2c83ff0a490700849c22c"

RDEPENDS:nload = " \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 "
