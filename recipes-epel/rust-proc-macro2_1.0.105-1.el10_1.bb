# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro2"
PV = "1.0.105"
PR = "1.el10_1"
PACKAGES = " \
 rust-proc-macro2+default-devel \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro2-1.0.105-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfe0f44bdb9f8168ecf8bbb5dc25bee483bc995fe25e0cfd3b22859615fe9473"

URI_x86_64_v2_rust-proc-macro2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+default-devel-1.0.105-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+default-devel.sha256sum] = "d8da19a956c1277a599f9911456379669ce78dec02a37d1ed9a1f2fbb016f8ff"

URI_x86_64_v2_rust-proc-macro2+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+proc-macro-devel-1.0.105-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+proc-macro-devel.sha256sum] = "d759b9e61e0eb82d30971b82936a19fb52c93212ed35959052b947e9a5564f78"

URI_x86_64_v2_rust-proc-macro2+span-locations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+span-locations-devel-1.0.105-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+span-locations-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+span-locations-devel.sha256sum] = "da5c1c66b345db5ebf417cca176c55676be57f3bc735929e7f108d646238652b"

URI_x86_64_v2_rust-proc-macro2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2-devel-1.0.105-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2-devel.sha256sum] = "2f3e2ba6b697e8ff68325e0257835113986eb1e4e5425a8cf25e2120f6a72031"

URI_aarch64_rust-proc-macro2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+default-devel-1.0.105-1.el10_1.noarch.rpm;name=aarch64_rust-proc-macro2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+default-devel}"
SRC_URI[aarch64_rust-proc-macro2+default-devel.sha256sum] = "de0f79b9b6b19fcf0454460b6220ef4e41ea25001c6dfd6d8f5826e4f7eb0761"

URI_aarch64_rust-proc-macro2+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+proc-macro-devel-1.0.105-1.el10_1.noarch.rpm;name=aarch64_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+proc-macro-devel}"
SRC_URI[aarch64_rust-proc-macro2+proc-macro-devel.sha256sum] = "04a127fdd9d04b86e71830c40e8197c911a459b739018bc56d77aea503b05b02"

URI_aarch64_rust-proc-macro2+span-locations-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+span-locations-devel-1.0.105-1.el10_1.noarch.rpm;name=aarch64_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+span-locations-devel}"
SRC_URI[aarch64_rust-proc-macro2+span-locations-devel.sha256sum] = "83711da366ff18d832c4438b420ff3d909c69d593995cdf6207f680d2085b7f4"

URI_aarch64_rust-proc-macro2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2-devel-1.0.105-1.el10_1.noarch.rpm;name=aarch64_rust-proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2-devel}"
SRC_URI[aarch64_rust-proc-macro2-devel.sha256sum] = "733c12eba8667afe54a13da9ef3cbc614e06c7ae1e4f86c33cb42a87cf478645"

RDEPENDS:rust-proc-macro2+default-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+proc-macro-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+span-locations-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2-devel = " \
 cargo \
 rust \
 rust-unicode-ident+default-devel \
 "
