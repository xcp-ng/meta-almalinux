# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sysstat"
PV = "12.7.6"
PR = "4.el10"
PACKAGES = " \
 sysstat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sysstat-12.7.6-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4ff00eb28466c27e8cedc18ffdc7a90a15f591e153ee7554b41ef00b6291d8a"

URI_x86_64_v2_sysstat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sysstat-12.7.6-4.el10.x86_64_v2.rpm;name=x86_64_v2_sysstat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sysstat}"
SRC_URI[x86_64_v2_sysstat.sha256sum] = "eff404903252447435d497c57ab7f7cef6554841f1400f134be1309ccdb64168"

URI_aarch64_sysstat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sysstat-12.7.6-4.el10.aarch64.rpm;name=aarch64_sysstat;unpack=0"
SRC_URI:append = " ${URI_aarch64_sysstat}"
SRC_URI[aarch64_sysstat.sha256sum] = "a3148c2350bed875056b6f2e54ceae58a87feba48f2c86760580419e0f08457f"

RDEPENDS:sysstat = " \
 bash \
 findutils \
 glibc \
 lm_sensors-libs \
 pcp-libs \
 xz \
 "
