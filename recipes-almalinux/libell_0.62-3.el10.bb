# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libell"
PV = "0.62"
PR = "3.el10"
PACKAGES = " \
 libell \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libell-0.62-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "681ac4bb306f39e8feeac21ce4bae88c1b0eb7d4c89a42043bdd675a36dad61d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libell-0.62-3.el10.x86_64_v2.rpm;name=x86_64_v2_libell;unpack=0"
SRC_URI[x86_64_v2_libell.sha256sum] = "6c37004ecd99b31d599f730f7c94a65d5fa88405bc05dd6ac12bcd01593a5d9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libell-0.62-3.el10.aarch64.rpm;name=aarch64_libell;unpack=0"
SRC_URI[aarch64_libell.sha256sum] = "0d70baf30036faffa95eef03da97a08c15f401940b11f4e89a22175ea6a10170"

RDEPENDS:libell = " \
 glibc \
 libgcc \
 "
