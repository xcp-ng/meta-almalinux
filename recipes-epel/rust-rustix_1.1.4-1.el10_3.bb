# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustix"
PV = "1.1.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustix+all-apis-devel \
 rust-rustix+alloc-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+libc-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix+linux_4_11-devel \
 rust-rustix+linux_5_1-devel \
 rust-rustix+linux_5_11-devel \
 rust-rustix+linux_latest-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+std-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix+try_close-devel \
 rust-rustix+use-explicitly-provided-auxv-devel \
 rust-rustix+use-libc-auxv-devel \
 rust-rustix+use-libc-devel \
 rust-rustix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustix-1.1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "657dc7f0adfaa2d15e05fe93eb3fa438bd587f59ff820144e115e8c5b173fe77"

URI_x86_64_v2_rust-rustix+all-apis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+all-apis-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+all-apis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+all-apis-devel}"
SRC_URI[x86_64_v2_rust-rustix+all-apis-devel.sha256sum] = "7f76d340fb57539c3a93dc3996c7088e56e8176449e34a3b5ae80f389f12d675"

URI_x86_64_v2_rust-rustix+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+alloc-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustix+alloc-devel.sha256sum] = "08ee8c7868601ceffa5069e57cd0c2ddf3b01cf1d3e8bd5cc54061ffc9887526"

URI_x86_64_v2_rust-rustix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+default-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+default-devel}"
SRC_URI[x86_64_v2_rust-rustix+default-devel.sha256sum] = "adc38d77f03ac967a38d4b238844db56efb76aa8db5dc683ec98eaa126fcf0ff"

URI_x86_64_v2_rust-rustix+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+event-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+event-devel}"
SRC_URI[x86_64_v2_rust-rustix+event-devel.sha256sum] = "811c52fa38350430040de14457cb3918e8288d7b28a3ca983d84c0ba8860a299"

URI_x86_64_v2_rust-rustix+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+fs-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+fs-devel}"
SRC_URI[x86_64_v2_rust-rustix+fs-devel.sha256sum] = "6489641e2fcefcb24454ce357b37e58f3985efd0dbc5e64ee77e0aab0552a988"

URI_x86_64_v2_rust-rustix+io_uring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+io_uring-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+io_uring-devel}"
SRC_URI[x86_64_v2_rust-rustix+io_uring-devel.sha256sum] = "242d0fa7453a6dea7ddce782decc47ef724ec8c723193da5b8b4fcf97bb8fd5b"

URI_x86_64_v2_rust-rustix+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+libc-devel}"
SRC_URI[x86_64_v2_rust-rustix+libc-devel.sha256sum] = "1ae625938ac7c9e402c3a2c3d05e802332cb3f73d62ff7f333089890bd9cd83c"

URI_x86_64_v2_rust-rustix+libc_errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc_errno-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+libc_errno-devel}"
SRC_URI[x86_64_v2_rust-rustix+libc_errno-devel.sha256sum] = "4a2a75ee0acada7cf0202cb72826dbbb572b7d43761270cabdb9bb1f629fad5d"

URI_x86_64_v2_rust-rustix+linux_4_11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_4_11-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_4_11-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_4_11-devel.sha256sum] = "8dae19e8fdda85bcf39cf14a008500dde721227c621e32d05f932ae37ce532af"

URI_x86_64_v2_rust-rustix+linux_5_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_5_1-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_5_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_5_1-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_5_1-devel.sha256sum] = "2d4c9f27838989a22a3496e10f5c402b72e4b7fb59652c6151a7964323cef108"

URI_x86_64_v2_rust-rustix+linux_5_11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_5_11-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_5_11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_5_11-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_5_11-devel.sha256sum] = "51fe58df3eb9325d9508de4908fd9ce5db3af229f3aa9095a716c083b741d0f6"

URI_x86_64_v2_rust-rustix+linux_latest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_latest-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_latest-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_latest-devel.sha256sum] = "9570d5ec3519e2b196981126e575d1f278f600f8219eb5988c6ed98dd4523bdc"

URI_x86_64_v2_rust-rustix+mm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mm-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+mm-devel}"
SRC_URI[x86_64_v2_rust-rustix+mm-devel.sha256sum] = "e38922bb2f835f31633819f49a5960a4ce70f0b5fbb8ca9983f6a960ae4b4e81"

URI_x86_64_v2_rust-rustix+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mount-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+mount-devel}"
SRC_URI[x86_64_v2_rust-rustix+mount-devel.sha256sum] = "2bf5ea53f427f68427559ee6d6564926ec91f2fc3eca97aef8a9348d20e3bb93"

URI_x86_64_v2_rust-rustix+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+net-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+net-devel}"
SRC_URI[x86_64_v2_rust-rustix+net-devel.sha256sum] = "438f807d4d56bce2073da1e1dfcc88e6b164d2a6e473cab996f62ea15b88c9e4"

URI_x86_64_v2_rust-rustix+param-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+param-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+param-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+param-devel}"
SRC_URI[x86_64_v2_rust-rustix+param-devel.sha256sum] = "f28cb7591e254515773fd6cd30d7d098b5a5fc6742de271c082f6b9ea9f22a6d"

URI_x86_64_v2_rust-rustix+pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pipe-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+pipe-devel}"
SRC_URI[x86_64_v2_rust-rustix+pipe-devel.sha256sum] = "0e9071c7275d1ccb85901a18baeab24d3298b3a1027f3d62e0e5f0f5a24fde26"

URI_x86_64_v2_rust-rustix+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+process-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+process-devel}"
SRC_URI[x86_64_v2_rust-rustix+process-devel.sha256sum] = "05aaf9ba1ea90160896c5a62505d50e9dc9cc50bf1c3b178ad80eaeb85edd9d4"

URI_x86_64_v2_rust-rustix+pty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pty-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+pty-devel}"
SRC_URI[x86_64_v2_rust-rustix+pty-devel.sha256sum] = "ab16f499bb4b77529dcc45cb8000787fd8d9d9bb3939d0edf3228717dbea60ed"

URI_x86_64_v2_rust-rustix+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+rand-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+rand-devel}"
SRC_URI[x86_64_v2_rust-rustix+rand-devel.sha256sum] = "2320680630bdfbcfaccbf57f33b31b2109c5c5f40c952a3bfa402da81e0aa116"

URI_x86_64_v2_rust-rustix+runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+runtime-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+runtime-devel}"
SRC_URI[x86_64_v2_rust-rustix+runtime-devel.sha256sum] = "c4423b20f74bd89ed2f7fcb773f694798fc08080f36f4d476fcc4f3a2f58de55"

URI_x86_64_v2_rust-rustix+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+shm-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+shm-devel}"
SRC_URI[x86_64_v2_rust-rustix+shm-devel.sha256sum] = "f6c668410dbbe749417786dc027ebe712201f86f113a063521dc1f58a41f6bd2"

URI_x86_64_v2_rust-rustix+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+std-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+std-devel}"
SRC_URI[x86_64_v2_rust-rustix+std-devel.sha256sum] = "505354596fc36af25878454308031fec7ac8c8245ad414a2103efbff06c44ecc"

URI_x86_64_v2_rust-rustix+stdio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+stdio-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+stdio-devel}"
SRC_URI[x86_64_v2_rust-rustix+stdio-devel.sha256sum] = "2b0ffeec333997ee0164f84562ff82b710b52d1fd781b877c49af8a79a61d179"

URI_x86_64_v2_rust-rustix+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+system-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+system-devel}"
SRC_URI[x86_64_v2_rust-rustix+system-devel.sha256sum] = "64e4730339f02e2fc14908d13deadc7410bdfa268ccc14dd7784b93afe38638c"

URI_x86_64_v2_rust-rustix+termios-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+termios-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+termios-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+termios-devel}"
SRC_URI[x86_64_v2_rust-rustix+termios-devel.sha256sum] = "db780a43676e31630d27c3d3717b9edcd7aff31c1bebdc01429ab0cb42fa7e60"

URI_x86_64_v2_rust-rustix+thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+thread-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+thread-devel}"
SRC_URI[x86_64_v2_rust-rustix+thread-devel.sha256sum] = "cca1edd0b1571c47fd682cb45876b4ea4170b57351331b22a833270a7cf8fc42"

URI_x86_64_v2_rust-rustix+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+time-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+time-devel}"
SRC_URI[x86_64_v2_rust-rustix+time-devel.sha256sum] = "745b5b7806afe8db055d79a49c5ec1f6dd618a443a3bd858d0c8c6f4773609a0"

URI_x86_64_v2_rust-rustix+try_close-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+try_close-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+try_close-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+try_close-devel}"
SRC_URI[x86_64_v2_rust-rustix+try_close-devel.sha256sum] = "498cf2ef5866d830fe903cb2f8e74f185bf56ea3ad907fffd13bca39d8d294b6"

URI_x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-explicitly-provided-auxv-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "7cb985d80a8bb6ac84f06a861189da2f655cc7abe835fe196ce06756875cd5f2"

URI_x86_64_v2_rust-rustix+use-libc-auxv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-auxv-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-libc-auxv-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-libc-auxv-devel.sha256sum] = "fb6c20dd357f799562361cb3d1d147f87caee217659c42d8f3d34acff7a011b7"

URI_x86_64_v2_rust-rustix+use-libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-libc-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-libc-devel.sha256sum] = "8abefa9b84d6cc0cff291cf88e9bf2ad8dca170a0c0bec1cb1d2f61a97d9a20e"

URI_x86_64_v2_rust-rustix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix-devel-1.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix-devel}"
SRC_URI[x86_64_v2_rust-rustix-devel.sha256sum] = "32cf386535084fac2ab8df941c498d74518cbefe86cf0bbbdf223f741f339b44"

URI_aarch64_rust-rustix+all-apis-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+all-apis-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+all-apis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+all-apis-devel}"
SRC_URI[aarch64_rust-rustix+all-apis-devel.sha256sum] = "cf41c6358d2883dc2e0936f76da458e41657097571b19ee028e753f87239a43a"

URI_aarch64_rust-rustix+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+alloc-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+alloc-devel}"
SRC_URI[aarch64_rust-rustix+alloc-devel.sha256sum] = "e24def5caa0892eb3bf736a3e2bc69c3a761c24f329e662e89ed2fe695d81de1"

URI_aarch64_rust-rustix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+default-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+default-devel}"
SRC_URI[aarch64_rust-rustix+default-devel.sha256sum] = "98701c5d557e1666ae5fb1a9cfa765e6db21a0bbee1488d57bffecde53f69ffc"

URI_aarch64_rust-rustix+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+event-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+event-devel}"
SRC_URI[aarch64_rust-rustix+event-devel.sha256sum] = "3072ee35dcbd809c19bc5fac6aba7c98f88f942c1f7c1a321e833ec669a5a8f3"

URI_aarch64_rust-rustix+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+fs-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+fs-devel}"
SRC_URI[aarch64_rust-rustix+fs-devel.sha256sum] = "6af5860baeaf2d3d86664e8093d5ceed2b40569862edb35c38c75c8534716998"

URI_aarch64_rust-rustix+io_uring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+io_uring-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+io_uring-devel}"
SRC_URI[aarch64_rust-rustix+io_uring-devel.sha256sum] = "8f2ceafdb8220551e4b9222ff2d3f7c5c36ee219313a63c2857a9911919ace17"

URI_aarch64_rust-rustix+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+libc-devel}"
SRC_URI[aarch64_rust-rustix+libc-devel.sha256sum] = "ddfb3a22203ea0b5e2eef71bdf5fca6206f88704b4e42c0e97241e59ea30c980"

URI_aarch64_rust-rustix+libc_errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc_errno-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+libc_errno-devel}"
SRC_URI[aarch64_rust-rustix+libc_errno-devel.sha256sum] = "dbc9966b249356ea33771d931a74f6030540d9c9c6d44c99530b528a0f8b43a1"

URI_aarch64_rust-rustix+linux_4_11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_4_11-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_4_11-devel}"
SRC_URI[aarch64_rust-rustix+linux_4_11-devel.sha256sum] = "6a5bd663b91cb7c76751f00f2d26ffeae4f0669ad9b2d7166d9a78b20f897224"

URI_aarch64_rust-rustix+linux_5_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_5_1-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+linux_5_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_5_1-devel}"
SRC_URI[aarch64_rust-rustix+linux_5_1-devel.sha256sum] = "f89d1b3fb960ece3f3ff28cbce10c623505614fffd7abccad3775df64f88ab73"

URI_aarch64_rust-rustix+linux_5_11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_5_11-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+linux_5_11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_5_11-devel}"
SRC_URI[aarch64_rust-rustix+linux_5_11-devel.sha256sum] = "5d7f5f5a6386f2698b8f4231b94a8efe6d34d4d1d1f863eb9115176ec0c848b4"

URI_aarch64_rust-rustix+linux_latest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_latest-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_latest-devel}"
SRC_URI[aarch64_rust-rustix+linux_latest-devel.sha256sum] = "9b0f3cea825e6ae32bc6f23187d67e599806edc6e41c7ce22c2151e967b4444e"

URI_aarch64_rust-rustix+mm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mm-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+mm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+mm-devel}"
SRC_URI[aarch64_rust-rustix+mm-devel.sha256sum] = "49b5cd3044e457f23533e6ece0261a19f207e1ac734c58cfa6b0e34fc8573c86"

URI_aarch64_rust-rustix+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mount-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+mount-devel}"
SRC_URI[aarch64_rust-rustix+mount-devel.sha256sum] = "9ca4c3178d22bdf56dea41500d3cd93277ee689ceab4c516e9446566405f8c64"

URI_aarch64_rust-rustix+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+net-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+net-devel}"
SRC_URI[aarch64_rust-rustix+net-devel.sha256sum] = "94ed734fbca3d3f8be6037beb58659606faae52f6792f658784aa3e5f5c59a90"

URI_aarch64_rust-rustix+param-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+param-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+param-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+param-devel}"
SRC_URI[aarch64_rust-rustix+param-devel.sha256sum] = "db2e81fa9b5b8955ddd44a5d758d980ba18caf2fa2924ef70499eb94c80082d0"

URI_aarch64_rust-rustix+pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pipe-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+pipe-devel}"
SRC_URI[aarch64_rust-rustix+pipe-devel.sha256sum] = "5a2144c51e6593a80c48d4e3fa148cb1714b48b38a70ac1d39fddc60f516d099"

URI_aarch64_rust-rustix+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+process-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+process-devel}"
SRC_URI[aarch64_rust-rustix+process-devel.sha256sum] = "9ab9ba0106762cd7ee9733fd5cd1977026591174931c271306e2316684c01902"

URI_aarch64_rust-rustix+pty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pty-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+pty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+pty-devel}"
SRC_URI[aarch64_rust-rustix+pty-devel.sha256sum] = "a8d3f47f9646ff115069e78bd353fe576734c7324358a08df39f73d2dfc90967"

URI_aarch64_rust-rustix+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+rand-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+rand-devel}"
SRC_URI[aarch64_rust-rustix+rand-devel.sha256sum] = "3f4df422ed09aea61ea4c96ad1e5812077b1b3fac28e66bbc157645d1e115a75"

URI_aarch64_rust-rustix+runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+runtime-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+runtime-devel}"
SRC_URI[aarch64_rust-rustix+runtime-devel.sha256sum] = "80024b5595d2bbcfbc83645a1073c46300b8447b27fa90631cac8fa438bb0149"

URI_aarch64_rust-rustix+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+shm-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+shm-devel}"
SRC_URI[aarch64_rust-rustix+shm-devel.sha256sum] = "7645e1fbb44870b5991388ca5184777611ea4afaf6aff2c07e48af921edb7e6b"

URI_aarch64_rust-rustix+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+std-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+std-devel}"
SRC_URI[aarch64_rust-rustix+std-devel.sha256sum] = "bf3bfcaa23321899246d5eaef96a73391ca19fc037800b8aaa595cecfcecc068"

URI_aarch64_rust-rustix+stdio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+stdio-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+stdio-devel}"
SRC_URI[aarch64_rust-rustix+stdio-devel.sha256sum] = "874fd835bcce23598cdfadecd9f9f0e530b1ea7b19833b3483bf0d6e148d87fb"

URI_aarch64_rust-rustix+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+system-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+system-devel}"
SRC_URI[aarch64_rust-rustix+system-devel.sha256sum] = "46c248d5224b36e85056ccbaefc946878eaf390eb7821008b753d6b373b77614"

URI_aarch64_rust-rustix+termios-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+termios-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+termios-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+termios-devel}"
SRC_URI[aarch64_rust-rustix+termios-devel.sha256sum] = "56888649f9597efeeeec32dda10ad68150fd3f89e239231cf4e6acd17d99f8a4"

URI_aarch64_rust-rustix+thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+thread-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+thread-devel}"
SRC_URI[aarch64_rust-rustix+thread-devel.sha256sum] = "ed9529b02a8e2f34d8aaa5d5a791f693997331a2ed3449615ed86d7c6fa05812"

URI_aarch64_rust-rustix+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+time-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+time-devel}"
SRC_URI[aarch64_rust-rustix+time-devel.sha256sum] = "d402deb25db6fd6d0073477b23db8b8d2e9bca853dd42a31dbf00edecf002fef"

URI_aarch64_rust-rustix+try_close-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+try_close-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+try_close-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+try_close-devel}"
SRC_URI[aarch64_rust-rustix+try_close-devel.sha256sum] = "86e74b36296d02de6b29124b2b40e717e38016aa1ae459678f98186060ec69f4"

URI_aarch64_rust-rustix+use-explicitly-provided-auxv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-explicitly-provided-auxv-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-explicitly-provided-auxv-devel}"
SRC_URI[aarch64_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "255468c4a79fa30beef9ff5895eb52514534c626bf2c18a3854ae03e3d90dd98"

URI_aarch64_rust-rustix+use-libc-auxv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-auxv-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-libc-auxv-devel}"
SRC_URI[aarch64_rust-rustix+use-libc-auxv-devel.sha256sum] = "f5ef60c7c0e584f7969d77c1eaa8b361a2240692a9af8e6ca55cbbeea848b2f1"

URI_aarch64_rust-rustix+use-libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix+use-libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-libc-devel}"
SRC_URI[aarch64_rust-rustix+use-libc-devel.sha256sum] = "684d4437ff9de277cf3d285a833ab64a5aeb99d35391d9049a396330f75c6cde"

URI_aarch64_rust-rustix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix-devel-1.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix-devel}"
SRC_URI[aarch64_rust-rustix-devel.sha256sum] = "1cf56948ff17ba250608e07e1cf756a83e9f28843e5da5047d18c54769a14c2d"

RDEPENDS:rust-rustix+all-apis-devel = " \
 cargo \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+alloc-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+default-devel = " \
 cargo \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+event-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+fs-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys+io_uring-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+thread-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc_errno-devel = " \
 cargo \
 rust-errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_4_11-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_5_1-devel = " \
 cargo \
 rust-rustix+linux_4_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_5_11-devel = " \
 cargo \
 rust-rustix+linux_5_1-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_latest-devel = " \
 cargo \
 rust-rustix+linux_5_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mm-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mount-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+net-devel = " \
 cargo \
 rust-linux-raw-sys+if_ether-devel \
 rust-linux-raw-sys+net-devel \
 rust-linux-raw-sys+netlink-devel \
 rust-linux-raw-sys+xdp-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+param-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pipe-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+process-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pty-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+rand-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+runtime-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+shm-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+std-devel = " \
 cargo \
 rust-bitflags+std-devel \
 rust-errno+std-devel \
 rust-errno-devel \
 rust-libc+std-devel \
 rust-libc-devel \
 rust-rustix+alloc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+stdio-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+system-devel = " \
 cargo \
 rust-linux-raw-sys+system-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+termios-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+thread-devel = " \
 cargo \
 rust-linux-raw-sys+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+time-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+try_close-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-explicitly-provided-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-devel = " \
 cargo \
 rust-rustix+libc-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix-devel = " \
 cargo \
 rust \
 rust-bitflags-devel \
 rust-errno-devel \
 rust-libc-devel \
 rust-linux-raw-sys+auxvec-devel \
 rust-linux-raw-sys+elf-devel \
 rust-linux-raw-sys+errno-devel \
 rust-linux-raw-sys+general-devel \
 rust-linux-raw-sys+ioctl-devel \
 rust-linux-raw-sys+no_std-devel \
 rust-linux-raw-sys-devel \
 "
