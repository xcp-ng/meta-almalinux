# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snapbox"
PV = "0.6.22"
PR = "1.el10_1"
PACKAGES = " \
 rust-snapbox+cmd-devel \
 rust-snapbox+color-auto-devel \
 rust-snapbox+color-devel \
 rust-snapbox+debug-devel \
 rust-snapbox+default-devel \
 rust-snapbox+detect-encoding-devel \
 rust-snapbox+diff-devel \
 rust-snapbox+dir-devel \
 rust-snapbox+document-features-devel \
 rust-snapbox+examples-devel \
 rust-snapbox+json-devel \
 rust-snapbox+path-devel \
 rust-snapbox+regex-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox+term-svg-devel \
 rust-snapbox-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-snapbox-0.6.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "38c8fbbce1bd6ac239358ba8bb1f3d4bef6d9a13dbb3997ef3eb6bdc6e1ec170"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+cmd-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+cmd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+cmd-devel.sha256sum] = "48975401a452915c7cfee801b9665e52676ad7f5e9044f95327cc1cbf0781124"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+color-auto-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+color-auto-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+color-auto-devel.sha256sum] = "137577ca5f9e4b0d4c42bee515ed8ceb0451620a239dff35b5f90f2015e45ed0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+color-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+color-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+color-devel.sha256sum] = "81a1a8baa8e3a48caa64b6b2e1fc9977e6d0c92562669bdd574824c2a9d74d93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+debug-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+debug-devel.sha256sum] = "dec38cec1b1f14f1eb2b798549228b9ae75cd06e93eb42d65f29f1a1ead77a66"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+default-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+default-devel.sha256sum] = "225fefaf08e931c0d6c5cdb5817aba8b669d471fb45cfdf4777acb179e74056b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+detect-encoding-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+detect-encoding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+detect-encoding-devel.sha256sum] = "f6786bd63316c8f0289362a4fb0bedb83cb09093c21a943adb21a2a84a891a21"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+diff-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+diff-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+diff-devel.sha256sum] = "da56546b5ee9b0f4c7f6195da77bc077a73e5bfc6600d63cfeabfbe4201c8b7a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+dir-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+dir-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+dir-devel.sha256sum] = "cb2b0c58d9f24fe269305448d79537133799e46bde3be605fbf83d776c451c8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+document-features-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+document-features-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+document-features-devel.sha256sum] = "03eac61afb3b68c78d685d1574650cd4371f284f35a897bfb6ab13c4ba1bbb48"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+examples-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+examples-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+examples-devel.sha256sum] = "5fc2cc19cc2fe0a905a8339d3a806fe04b7f7b2fce2f3555cea567d156c5f5ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+json-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+json-devel.sha256sum] = "1bfe5cd946b7fbddc0933fdf7c65d27c72dfcede8e9e4ee03924de3d3b3c2531"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+path-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+path-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+path-devel.sha256sum] = "20b9a987fb5bbc975e68ee5d6bf27d2946173c1a391ca6d2de18f079b98d31c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+regex-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+regex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+regex-devel.sha256sum] = "b16bd93210b3118155f80db764840aeedcd78bb926acfd4ec36c371f80313323"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+structured-data-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+structured-data-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+structured-data-devel.sha256sum] = "f7530b826799e2618e3d3139cf2e4b350ef02b6e77174b607d51365647b9af35"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox+term-svg-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox+term-svg-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox+term-svg-devel.sha256sum] = "3ee9facedefae339b2821d7f128a7117321c435c654b10c604cd64965756f5ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-devel-0.6.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-devel;unpack=0"
SRC_URI[x86_64_v2_rust-snapbox-devel.sha256sum] = "e72099b349989f818f2762562e72dc4550c9c6e4a56c947c30a4b714e8dcee1f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+cmd-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+cmd-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+cmd-devel.sha256sum] = "b0d47d679e54c96b87eb75c39dc3ae6b044496635fa4c24f678da57c3ade5d6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+color-auto-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+color-auto-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+color-auto-devel.sha256sum] = "a0bfb37688e1feb20e8d2502580e9b14c17975ef13fc9480e43aa7624a4cc1b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+color-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+color-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+color-devel.sha256sum] = "4bb89e15be4caf23f620551060c13b5313e4cebc1c5e72d1fd5b0ff11ff2389e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+debug-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+debug-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+debug-devel.sha256sum] = "193b70d982023393ddeb1141bf3626ec5fbdbab07bd0d3f19384c59a038852e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+default-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+default-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+default-devel.sha256sum] = "0c312dc8c4008c4be33760164e8542a40f89f815c2d9ceb33e6db5d49ad0365b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+detect-encoding-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+detect-encoding-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+detect-encoding-devel.sha256sum] = "348d84f309f917b03ca389b1c3c407a6e282dbbe12171562fdb539c60b89a153"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+diff-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+diff-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+diff-devel.sha256sum] = "03bee385c6fddfc68bb7b0acb61a16214323c512befa774bfd312acffa7db749"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+dir-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+dir-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+dir-devel.sha256sum] = "c30680722c3671bcca5a8c702b36c41d8646f0f975ae9f1fb9d45ae364e94eba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+document-features-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+document-features-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+document-features-devel.sha256sum] = "0d19d1f96672976a4e1a2773a09de00464586ac8e034e129fc592a15ca657441"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+examples-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+examples-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+examples-devel.sha256sum] = "e427066d6a789208becbbdcc1e2d1bfc6b6d10f188503da7e0e7734cefbb1233"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+json-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+json-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+json-devel.sha256sum] = "b166e1c4053304af895572c85ea77690c9f4acdfe1e23f4a9b79590fda01091d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+path-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+path-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+path-devel.sha256sum] = "6e1835cfcedc1a21a3d1d61fdeb029237deddf9a1db739d087500ad7f77838a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+regex-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+regex-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+regex-devel.sha256sum] = "ca534b494dbec956d1f39e7aa72879a3d505ab44b407d94e3165969acdcbcad0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+structured-data-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+structured-data-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+structured-data-devel.sha256sum] = "831c044068b1b7a5a4589ae5d006ac6c50cb69e7a634d784322305f31989d255"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox+term-svg-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox+term-svg-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox+term-svg-devel.sha256sum] = "27796eb8be28a3ec50775061eccb8797fa7f6e83e3e37584384b3f1a536a953b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-devel-0.6.22-1.el10_1.noarch.rpm;name=aarch64_rust-snapbox-devel;unpack=0"
SRC_URI[aarch64_rust-snapbox-devel.sha256sum] = "6b7fc524018627f78eb4d323765789d397e14f8d03a20180d681bc21a0c90e72"

RDEPENDS:rust-snapbox+cmd-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-os_pipe+default-devel \
 rust-snapbox-devel \
 rust-wait-timeout+default-devel \
 "
RDEPENDS:rust-snapbox+color-auto-devel = " \
 cargo \
 rust-snapbox+color-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox-devel \
 rust-snapbox-macros+color-devel \
 "
RDEPENDS:rust-snapbox+debug-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-snapbox-devel \
 rust-snapbox-macros+debug-devel \
 "
RDEPENDS:rust-snapbox+default-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-snapbox+diff-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+detect-encoding-devel = " \
 cargo \
 rust-content_inspector+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+diff-devel = " \
 cargo \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+dir-devel = " \
 cargo \
 rust-dunce+default-devel \
 rust-filetime+default-devel \
 rust-snapbox+detect-encoding-devel \
 rust-snapbox-devel \
 rust-tempfile+default-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-snapbox+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+examples-devel = " \
 cargo \
 rust-escargot+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+json-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+path-devel = " \
 cargo \
 rust-snapbox+dir-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+regex-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+structured-data-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox+term-svg-devel = " \
 cargo \
 rust-anstyle-svg+default-devel \
 rust-snapbox+structured-data-devel \
 rust-snapbox-devel \
 "
RDEPENDS:rust-snapbox-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-normalize-line-endings+default-devel \
 rust-snapbox-macros+default-devel \
 "
