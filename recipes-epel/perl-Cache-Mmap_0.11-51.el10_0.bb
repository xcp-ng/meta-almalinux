# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cache-Mmap"
PV = "0.11"
PR = "51.el10_0"
PACKAGES = " \
 perl-Cache-Mmap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cache-Mmap-0.11-51.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ea67d5a6ae5aa8e7182b3153f885b6d467db508672c02f949ed41673712c4dc"

URI_x86_64_v2_perl-Cache-Mmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cache-Mmap-0.11-51.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cache-Mmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cache-Mmap}"
SRC_URI[x86_64_v2_perl-Cache-Mmap.sha256sum] = "4a7abba4d0c976bcb734214c352d2c960c9382e764d151b032a9198a664e341e"

URI_aarch64_perl-Cache-Mmap = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cache-Mmap-0.11-51.el10_0.aarch64.rpm;name=aarch64_perl-Cache-Mmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cache-Mmap}"
SRC_URI[aarch64_perl-Cache-Mmap.sha256sum] = "b1d3cd7198ec945ecf3c0fe30e464df64afeb0c164b14066bd7e3ea23df41062"

RDEPENDS:perl-Cache-Mmap = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-Fcntl \
 perl-IO \
 perl-Storable \
 perl-Symbol \
 perl-constant \
 perl-libs \
 perl-vars \
 "
