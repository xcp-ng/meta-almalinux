# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-BaseDir"
PV = "0.09"
PR = "11.el10"
PACKAGES = " \
 perl-File-BaseDir \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-File-BaseDir-0.09-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e46318181ccab0b75185dba492b0c29dbb2fda81e6b9b5d64b4b03932e01c57c"

URI_x86_64_v2_perl-File-BaseDir = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-File-BaseDir-0.09-11.el10.noarch.rpm;name=x86_64_v2_perl-File-BaseDir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-BaseDir}"
SRC_URI[x86_64_v2_perl-File-BaseDir.sha256sum] = "58028e83eab28cfa7524a8258f16ae8056e2f88fd97a0ea3afa17c7fe2a1fb79"

URI_aarch64_perl-File-BaseDir = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-File-BaseDir-0.09-11.el10.noarch.rpm;name=aarch64_perl-File-BaseDir;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-BaseDir}"
SRC_URI[aarch64_perl-File-BaseDir.sha256sum] = "58028e83eab28cfa7524a8258f16ae8056e2f88fd97a0ea3afa17c7fe2a1fb79"

RDEPENDS:perl-File-BaseDir = " \
 perl-Exporter \
 perl-File-BaseDir \
 perl-PathTools \
 perl-libs \
 "
