# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wget"
PV = "1.24.5"
PR = "8.el10_2"
PACKAGES = " \
 wget \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wget-1.24.5-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f3ce3a897ba91ea6c93b00b7502102043791cc824901ebade038d6e631498365"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wget-1.24.5-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_wget;unpack=0"
SRC_URI[x86_64_v2_wget.sha256sum] = "46c791ddc173d4e6bccfa9145df954c3cd70a90514698c1372c8b75987fa0919"
RPROVIDES:wget:append:x86_64_v2 = " virtual/wget_or_curl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wget-1.24.5-8.el10_2.aarch64.rpm;name=aarch64_wget;unpack=0"
SRC_URI[aarch64_wget.sha256sum] = "33d89e817d5ca24c5e4d0f8b9191aa06c6ef66a20f92561a6f2645e02ccb06ac"
RPROVIDES:wget:append:aarch64 = " virtual/wget_or_curl"

RDEPENDS:wget = " \
 glibc \
 gnutls \
 libidn2 \
 libpsl \
 libuuid \
 pcre2 \
 zlib-ng-compat \
 "
