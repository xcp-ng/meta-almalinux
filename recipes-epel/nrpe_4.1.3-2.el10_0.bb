# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nrpe"
PV = "4.1.3"
PR = "2.el10_0"
PACKAGES = " \
 nagios-plugins-nrpe \
 nrpe \
 nrpe-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nrpe-4.1.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3de21acab4168724ed99eb2e06606fc6294cc65108e3d9170ae3e3ecb391001"

URI_x86_64_v2_nagios-plugins-nrpe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-nrpe-4.1.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-nrpe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-nrpe}"
SRC_URI[x86_64_v2_nagios-plugins-nrpe.sha256sum] = "d9514d008ad82e0e9ea8367e14a9318c39d734337524d84eee176d782b82d2f6"

URI_x86_64_v2_nrpe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nrpe-4.1.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nrpe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nrpe}"
SRC_URI[x86_64_v2_nrpe.sha256sum] = "c62b00813ef42461339359cbdc47dcd43cd2576e18c94693c16606cf82a4d684"

URI_x86_64_v2_nrpe-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nrpe-selinux-4.1.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nrpe-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nrpe-selinux}"
SRC_URI[x86_64_v2_nrpe-selinux.sha256sum] = "3506905765f964af274e773607b860189b55691c4ae8a684ec2f0cb7448ec1f1"

URI_aarch64_nagios-plugins-nrpe = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-nrpe-4.1.3-2.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-nrpe;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-nrpe}"
SRC_URI[aarch64_nagios-plugins-nrpe.sha256sum] = "98d7bbc4cbe84f9653ae4dba28ade2640684144f3f920633861d8539662afb10"

URI_aarch64_nrpe = "${EPEL_MIRROR}/aarch64/Packages/n/nrpe-4.1.3-2.el10_0.aarch64.rpm;name=aarch64_nrpe;unpack=0"
SRC_URI:append = " ${URI_aarch64_nrpe}"
SRC_URI[aarch64_nrpe.sha256sum] = "970d596662cf9a96da760139f50191ac64fa85f79ecebca07dbebcb25ebc5335"

URI_aarch64_nrpe-selinux = "${EPEL_MIRROR}/aarch64/Packages/n/nrpe-selinux-4.1.3-2.el10_0.aarch64.rpm;name=aarch64_nrpe-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_nrpe-selinux}"
SRC_URI[aarch64_nrpe-selinux.sha256sum] = "5bf298319678cb8d64cdc0fab56d96cdc04d786dac5d4197a8a746e546cf67cc"

RDEPENDS:nagios-plugins-nrpe = " \
 glibc \
 nagios-plugins \
 openssl-libs \
 "
RDEPENDS:nrpe = " \
 bash \
 glibc \
 nagios-common \
 openssl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:nrpe-selinux = " \
 bash \
 nrpe \
 policycoreutils \
 "
