# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-autobahn"
PV = "24.4.2"
PR = "3.el10_2"
PACKAGES = " \
 python-autobahn-doc \
 python3-autobahn \
 python3-autobahn+twisted \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-autobahn-24.4.2-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a0994927317185f8db9b6ca482e589c2ace544865471bc764216978092ba5e1"

URI_x86_64_v2_python-autobahn-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-autobahn-doc-24.4.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-autobahn-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-autobahn-doc}"
SRC_URI[x86_64_v2_python-autobahn-doc.sha256sum] = "f69f23e461fbe298cd02450f1c82d549825ede0e1519685268d5a302eae16e86"

URI_x86_64_v2_python3-autobahn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-autobahn-24.4.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-autobahn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-autobahn}"
SRC_URI[x86_64_v2_python3-autobahn.sha256sum] = "2222f465f0b8fb4b1f305c1545b7437ba0eb4f43fce6f5bcb9db25464ba67c71"

URI_x86_64_v2_python3-autobahn+twisted = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-autobahn+twisted-24.4.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-autobahn+twisted;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-autobahn+twisted}"
SRC_URI[x86_64_v2_python3-autobahn+twisted.sha256sum] = "ab2f168637f0f7f9972c97aa9266b027cd3c99579aa64700ef1439c58b486aa8"

URI_aarch64_python-autobahn-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-autobahn-doc-24.4.2-3.el10_2.noarch.rpm;name=aarch64_python-autobahn-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-autobahn-doc}"
SRC_URI[aarch64_python-autobahn-doc.sha256sum] = "231223f59ec262303581b2792caa74c9cde4c4b3bac567158f409bc4069511cd"

URI_aarch64_python3-autobahn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-autobahn-24.4.2-3.el10_2.noarch.rpm;name=aarch64_python3-autobahn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-autobahn}"
SRC_URI[aarch64_python3-autobahn.sha256sum] = "0b9a52f31f6818f6860f28804fda424dd203a4ff15f35b41560a93928faa4f2a"

URI_aarch64_python3-autobahn+twisted = "${EPEL_MIRROR}/aarch64/Packages/p/python3-autobahn+twisted-24.4.2-3.el10_2.noarch.rpm;name=aarch64_python3-autobahn+twisted;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-autobahn+twisted}"
SRC_URI[aarch64_python3-autobahn+twisted.sha256sum] = "73291b5615fd55386ed6dca513de3288effa4c0829fd3655b2a036a9e0045a5e"

RDEPENDS:python-autobahn-doc = " \
 "
RDEPENDS:python3-autobahn = " \
 python3 \
 python3-cryptography \
 python3-hyperlink \
 python3-setuptools \
 python3-txaio \
 "
RDEPENDS:python3-autobahn+twisted = " \
 python3 \
 python3-attrs \
 python3-autobahn \
 python3-twisted \
 python3-zope-interface \
 "
