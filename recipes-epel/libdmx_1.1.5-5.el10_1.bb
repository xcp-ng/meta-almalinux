# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdmx"
PV = "1.1.5"
PR = "5.el10_1"
PACKAGES = " \
 libdmx \
 libdmx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdmx-1.1.5-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f7bb4d8d0090a5d790f101fda45f03018ad568f44a5bceb33a6d595ee29026c"

URI_x86_64_v2_libdmx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdmx-1.1.5-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdmx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdmx}"
SRC_URI[x86_64_v2_libdmx.sha256sum] = "73a4d727e24488fee5612402293adb74ebf734171d64ba10af769c2bb561d19e"

URI_x86_64_v2_libdmx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdmx-devel-1.1.5-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdmx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdmx-devel}"
SRC_URI[x86_64_v2_libdmx-devel.sha256sum] = "a5eb97d3bdae35e8ed04f8bd3a0793fd7f1588423fc5e891804d1f60f701105c"

URI_aarch64_libdmx = "${EPEL_MIRROR}/aarch64/Packages/l/libdmx-1.1.5-5.el10_1.aarch64.rpm;name=aarch64_libdmx;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdmx}"
SRC_URI[aarch64_libdmx.sha256sum] = "770b16efb7f4471b8586987515b4f6d98e546cc176dcce8be8163e5dd3fc6527"

URI_aarch64_libdmx-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdmx-devel-1.1.5-5.el10_1.aarch64.rpm;name=aarch64_libdmx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdmx-devel}"
SRC_URI[aarch64_libdmx-devel.sha256sum] = "7f27dc81e4b31cc665736a19420a6033b8d0d75a4de8b6a5244705309c95d13b"

RDEPENDS:libdmx = " \
 glibc \
 libX11 \
 libXext \
 "
RDEPENDS:libdmx-devel = " \
 libX11-devel \
 libXext-devel \
 libdmx \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
