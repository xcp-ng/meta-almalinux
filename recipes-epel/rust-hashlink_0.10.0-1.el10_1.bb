# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashlink"
PV = "0.10.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-hashlink+default-devel \
 rust-hashlink+serde-devel \
 rust-hashlink+serde_impl-devel \
 rust-hashlink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashlink-0.10.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed7029c99277115bfb3b477204d7b4fb9088f71e9f9495ccacedc090bf0c3217"

URI_x86_64_v2_rust-hashlink+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+default-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+default-devel}"
SRC_URI[x86_64_v2_rust-hashlink+default-devel.sha256sum] = "03eb501cfe0f4980727e18884343465f0e0507d16bb61d68f20d6099eed7b5cf"

URI_x86_64_v2_rust-hashlink+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+serde-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+serde-devel}"
SRC_URI[x86_64_v2_rust-hashlink+serde-devel.sha256sum] = "d31f27784c2de7676e78f9c3264f021a25576691ffde6327d2c64d60ce183f8e"

URI_x86_64_v2_rust-hashlink+serde_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink+serde_impl-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink+serde_impl-devel}"
SRC_URI[x86_64_v2_rust-hashlink+serde_impl-devel.sha256sum] = "67e557fd4fababf5ac722e732965593a7f4e73745675e75225a7e98f0561aed7"

URI_x86_64_v2_rust-hashlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashlink-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashlink-devel}"
SRC_URI[x86_64_v2_rust-hashlink-devel.sha256sum] = "f74d247cb1b6a1da6d4c1d7abe12e6050eebf036042862523c069456c37d2fac"

URI_aarch64_rust-hashlink+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+default-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-hashlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+default-devel}"
SRC_URI[aarch64_rust-hashlink+default-devel.sha256sum] = "663627d6dc325f879259002d10b42ba15d8e0591d349067c0ee1d6a503dc7e03"

URI_aarch64_rust-hashlink+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+serde-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-hashlink+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+serde-devel}"
SRC_URI[aarch64_rust-hashlink+serde-devel.sha256sum] = "d1edaf624fda267f7b648f6db60b62e4a7dffd2fc9d0599435467c5a080db9ff"

URI_aarch64_rust-hashlink+serde_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink+serde_impl-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-hashlink+serde_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink+serde_impl-devel}"
SRC_URI[aarch64_rust-hashlink+serde_impl-devel.sha256sum] = "f623312835b30699899d3a0d4e2682326152c162bb43d28f84433e7b61d59503"

URI_aarch64_rust-hashlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashlink-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-hashlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashlink-devel}"
SRC_URI[aarch64_rust-hashlink-devel.sha256sum] = "44e18bc454e291ea2a926a02f442ad5bc975f716ae5f57ae894370eeb480e949"

RDEPENDS:rust-hashlink+default-devel = " \
 cargo \
 rust-hashlink-devel \
 "
RDEPENDS:rust-hashlink+serde-devel = " \
 cargo \
 rust-hashlink-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashlink+serde_impl-devel = " \
 cargo \
 rust-hashlink+serde-devel \
 rust-hashlink-devel \
 "
RDEPENDS:rust-hashlink-devel = " \
 cargo \
 rust \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown-devel \
 "
