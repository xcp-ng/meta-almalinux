# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-RPM2"
PV = "1.4"
PR = "36.el10_1"
PACKAGES = " \
 perl-RPM2 \
 perl-RPM2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-RPM2-1.4-36.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ba8f8cfae1aab03e6535e69ba8ee058c7c9808f1d3b11a8772ac91e9f356028"

URI_x86_64_v2_perl-RPM2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-RPM2-1.4-36.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-RPM2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-RPM2}"
SRC_URI[x86_64_v2_perl-RPM2.sha256sum] = "a177d20154e85e5cb35da438f2e9a962b39f27ab3166e57a2f26d3af854ab2fe"

URI_x86_64_v2_perl-RPM2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-RPM2-tests-1.4-36.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-RPM2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-RPM2-tests}"
SRC_URI[x86_64_v2_perl-RPM2-tests.sha256sum] = "4ecc5c15d18ef95394ca7ca0bca7704a4ed2f62cd078556bf32a99e219252c6d"

URI_aarch64_perl-RPM2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-RPM2-1.4-36.el10_1.aarch64.rpm;name=aarch64_perl-RPM2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-RPM2}"
SRC_URI[aarch64_perl-RPM2.sha256sum] = "49a16430ba6be7101d566facac8e31df81a463fcecc2298ae185ff54a9ca90d5"

URI_aarch64_perl-RPM2-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-RPM2-tests-1.4-36.el10_1.noarch.rpm;name=aarch64_perl-RPM2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-RPM2-tests}"
SRC_URI[aarch64_perl-RPM2-tests.sha256sum] = "1cf11c1551d589b8235fdaef61f227ca2625a9f6357361d740f31bf235c0e663"

RDEPENDS:perl-RPM2 = " \
 glibc \
 perl-DynaLoader \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 perl-overload \
 rpm-libs \
 "
RDEPENDS:perl-RPM2-tests = " \
 bash \
 perl-File-Temp \
 perl-POSIX \
 perl-RPM2 \
 perl-Test \
 perl-Test-Harness \
 perl-interpreter \
 perl-libs \
 rpm \
 "
