# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pem3"
PV = "3.0.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-pem3+default-devel \
 rust-pem3+serde-devel \
 rust-pem3+std-devel \
 rust-pem3-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-pem3-3.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "33133b37dce18c377f1f871a699828d1f81c8c69b2d7021d1613739b14bf3a10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem3+default-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem3+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pem3+default-devel.sha256sum] = "afcf95fac7c523a13c4eb2fef8e34a7138c9eba6c674dabc9c801ce88fe382d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem3+serde-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem3+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pem3+serde-devel.sha256sum] = "80100f2c5c4a5c57c93f6dfd0d34f5dff04d170007dd3b991cb52bfe3554f99b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem3+std-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem3+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pem3+std-devel.sha256sum] = "06ea2f87ee443c74bbf41e15a5845f84366ad8da031b9398bab33115f649eccb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem3-devel-3.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem3-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pem3-devel.sha256sum] = "c1e0e84185f412a13051604a069e9962eafb82ef6d86aa25e521a0e5e41211c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pem3+default-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-pem3+default-devel;unpack=0"
SRC_URI[aarch64_rust-pem3+default-devel.sha256sum] = "376d9ed74a1ac1105e3da4a1e8eef7454a7752861851b5977a34b4ae3193531a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pem3+serde-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-pem3+serde-devel;unpack=0"
SRC_URI[aarch64_rust-pem3+serde-devel.sha256sum] = "1c963d87a8c348196043510b2a3ec9b2d3a305fa240e72c0a53642b5a6ef89cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pem3+std-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-pem3+std-devel;unpack=0"
SRC_URI[aarch64_rust-pem3+std-devel.sha256sum] = "428b478ba2c36de47773d954cb831960cc2ca7b29efa29c8a424432ab53d3822"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pem3-devel-3.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-pem3-devel;unpack=0"
SRC_URI[aarch64_rust-pem3-devel.sha256sum] = "c56a5963c40d7911e313026874c821f80338dc1b401058d23837a4c2cca87b57"

RDEPENDS:rust-pem3+default-devel = " \
 cargo \
 rust-pem3+std-devel \
 rust-pem3-devel \
 "
RDEPENDS:rust-pem3+serde-devel = " \
 cargo \
 rust-pem3-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-pem3+std-devel = " \
 cargo \
 rust-base64_0.22+std-devel \
 rust-pem3-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-pem3-devel = " \
 cargo \
 rust \
 rust-base64_0.22+alloc-devel \
 rust-base64_0.22-devel \
 "
