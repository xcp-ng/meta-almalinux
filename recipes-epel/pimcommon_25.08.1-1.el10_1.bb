# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pimcommon"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 pimcommon \
 pimcommon-devel \
 pimcommon-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pimcommon-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be5a171d87dc251c33db7c93d5cd05d731102a6a5abf921e11277ce1e2893720"

URI_x86_64_v2_pimcommon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon}"
SRC_URI[x86_64_v2_pimcommon.sha256sum] = "f0fdf8acca66212b6c08b28fbd542d3c6bc411016d4e7cdadef0375add452027"

URI_x86_64_v2_pimcommon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon-devel}"
SRC_URI[x86_64_v2_pimcommon-devel.sha256sum] = "9303aa769cde87c1b1cad9b34a18bc75d4898750c73e4a71a266ded491b6bd57"

URI_x86_64_v2_pimcommon-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-doc-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon-doc}"
SRC_URI[x86_64_v2_pimcommon-doc.sha256sum] = "035ed7f97e3eab0189b995aa24d040217c8addd7dedb927dadf427a232c69019"

URI_aarch64_pimcommon = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_pimcommon;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon}"
SRC_URI[aarch64_pimcommon.sha256sum] = "bb7cf748a309c08f9f2194f41e0a60d0eb5eae69bd14246df43c37538a475ffa"

URI_aarch64_pimcommon-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_pimcommon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon-devel}"
SRC_URI[aarch64_pimcommon-devel.sha256sum] = "5948ba04775b5add25213d9735cf62db166979a2da3eb21d27f2311e46b98cfd"

URI_aarch64_pimcommon-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-doc-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_pimcommon-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon-doc}"
SRC_URI[aarch64_pimcommon-doc.sha256sum] = "7d79db45c55dcf0fd7b7f3700aefdce21ee66c6522062cb8a88c725852856396"

RDEPENDS:pimcommon = " \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 glibc \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kimap \
 kldap \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pimcommon-devel = " \
 akonadi-contacts-devel \
 akonadi-server-devel \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kcontacts-devel \
 kimap-devel \
 ktextaddons-qt6-devel \
 libgcc \
 libstdc++ \
 pimcommon \
 plasma-activities-devel \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pimcommon-doc = " \
 "
