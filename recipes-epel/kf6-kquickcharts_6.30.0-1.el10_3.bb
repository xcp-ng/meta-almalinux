# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kquickcharts"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kquickcharts \
 kf6-kquickcharts-devel \
 kf6-kquickcharts-doc \
 kf6-kquickcharts-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kquickcharts-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "56b5528509b6eb168b7755f3b8ca0ad2489405796f0c95fba615821168c48751"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kquickcharts;unpack=0"
SRC_URI[x86_64_v2_kf6-kquickcharts.sha256sum] = "19fe924c134f0272a1e8d3653b3e46e562c11ddf691a51bc19d967d11ef0019f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kquickcharts-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kquickcharts-devel.sha256sum] = "2d48233c640d6d878682a7e1d2f01a04f4c5d178153b688c4b4f23982b69d575"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kquickcharts-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kquickcharts-doc.sha256sum] = "0dc9ea699a0f05337ab530af238c3466997264fe270b81aa425ac4f358ce83f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kquickcharts-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kquickcharts-html.sha256sum] = "7b001b30016817f2f4244b2bfcf5fe153bd9ecd34c107fd18ff9cd66b3c2c798"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kquickcharts;unpack=0"
SRC_URI[aarch64_kf6-kquickcharts.sha256sum] = "721bf59680ddc79a2000e80454fbc13d9e2ebf022e7f5e89c2ab05fe372ed982"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kquickcharts-devel;unpack=0"
SRC_URI[aarch64_kf6-kquickcharts-devel.sha256sum] = "924ee14b6377cb2221ba66e8088a502bf409c97a9c48c112be4cf32138a8d1af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kquickcharts-doc;unpack=0"
SRC_URI[aarch64_kf6-kquickcharts-doc.sha256sum] = "b5bd614eca2ecee40af6ad7e028ac691e8a48b032932045ba6bbb7aa22dbb437"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kquickcharts-html;unpack=0"
SRC_URI[aarch64_kf6-kquickcharts-html.sha256sum] = "0109f9d8ba1bcf54f0b163477b20184a0f4bafbf4302d7bfcad2d2dc0f227416"

RDEPENDS:kf6-kquickcharts = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kquickcharts-devel = " \
 cmake-filesystem \
 kf6-kquickcharts \
 "
RDEPENDS:kf6-kquickcharts-doc = " \
 "
RDEPENDS:kf6-kquickcharts-html = " \
 "
