# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plutovg"
PV = "1.3.0"
PR = "5.el10_0"
PACKAGES = " \
 plutovg \
 plutovg-devel \
 plutovg-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plutovg-1.3.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6fd51225a5b584a4e8633292aa378d9bf33c71e0fe5ae1b742d0e43427d647e"

URI_x86_64_v2_plutovg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-1.3.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg}"
SRC_URI[x86_64_v2_plutovg.sha256sum] = "9d52f0c0e772a8b42d7fba99d31fc9411898aa88413bab614318856242595149"

URI_x86_64_v2_plutovg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-devel-1.3.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg-devel}"
SRC_URI[x86_64_v2_plutovg-devel.sha256sum] = "71ce36a3524075406bd5a42abc47e0818df19078a7459ebc7592567353f483f0"

URI_x86_64_v2_plutovg-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-samples-1.3.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg-samples}"
SRC_URI[x86_64_v2_plutovg-samples.sha256sum] = "d0e3e44fb674dd1a3d66a75c2ef1870e6eff2bbcf6e8dbd0f948ea9de04b1686"

URI_aarch64_plutovg = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-1.3.0-5.el10_0.aarch64.rpm;name=aarch64_plutovg;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg}"
SRC_URI[aarch64_plutovg.sha256sum] = "7e47ebb6b944ef27f25c86dde0c83f0ec74254cd40f7f43562a9c7f645d62e74"

URI_aarch64_plutovg-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-devel-1.3.0-5.el10_0.aarch64.rpm;name=aarch64_plutovg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg-devel}"
SRC_URI[aarch64_plutovg-devel.sha256sum] = "75431a6e53f63b2adb4f7c706462113599373a5c8a4eac46fa067df26db020d7"

URI_aarch64_plutovg-samples = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-samples-1.3.0-5.el10_0.aarch64.rpm;name=aarch64_plutovg-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg-samples}"
SRC_URI[aarch64_plutovg-samples.sha256sum] = "c47db957a0981ad61cf4d842a7837b4df0a575b8fd0217d65e47ac18f011d693"

RDEPENDS:plutovg = " \
 glibc \
 "
RDEPENDS:plutovg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plutovg \
 "
RDEPENDS:plutovg-samples = " \
 glibc \
 plutovg \
 "
