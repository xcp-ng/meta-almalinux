# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-deepdiff"
PV = "8.6.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-deepdiff \
 python3-deepdiff+cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-deepdiff-8.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a93149ef99be8faab961b1179b18e82ecfc6624437c2f0163958bb6eadf3a40"

URI_x86_64_v2_python3-deepdiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-deepdiff-8.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-deepdiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-deepdiff}"
SRC_URI[x86_64_v2_python3-deepdiff.sha256sum] = "8f70febf4c4e29c552a7f275eddd6b686178e69e5b0163e59c584c4034828756"

URI_x86_64_v2_python3-deepdiff+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-deepdiff+cli-8.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-deepdiff+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-deepdiff+cli}"
SRC_URI[x86_64_v2_python3-deepdiff+cli.sha256sum] = "50ac5e2d0164b3aaae839307c82bebe9b33926586e5d871500bd8c14c0e16c51"

URI_aarch64_python3-deepdiff = "${EPEL_MIRROR}/aarch64/Packages/p/python3-deepdiff-8.6.1-1.el10_2.noarch.rpm;name=aarch64_python3-deepdiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-deepdiff}"
SRC_URI[aarch64_python3-deepdiff.sha256sum] = "e59df1676860807db439fc3e3e5c0076a5c80cc6a6a781b4a5ab36923be43c7b"

URI_aarch64_python3-deepdiff+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-deepdiff+cli-8.6.1-1.el10_2.noarch.rpm;name=aarch64_python3-deepdiff+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-deepdiff+cli}"
SRC_URI[aarch64_python3-deepdiff+cli.sha256sum] = "12a92bbff9396330a20f092795246b8a4bc66e864eb0dad44bb6e06788e8d729"

RDEPENDS:python3-deepdiff = " \
 python3 \
 python3-orderly-set \
 "
RDEPENDS:python3-deepdiff+cli = " \
 python3 \
 python3-click \
 python3-deepdiff \
 python3-pyyaml \
 "
