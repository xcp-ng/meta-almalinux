# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-calendar"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-calendar \
 akonadi-calendar-devel \
 akonadi-calendar-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-calendar-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fe6e77f24bb88139e5f35c0ce056caa9f39857cf27f82b10f93efc515741ba8"

URI_x86_64_v2_akonadi-calendar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar}"
SRC_URI[x86_64_v2_akonadi-calendar.sha256sum] = "8fd490736ae1a55c1705e2637db46740e0b8e9974df8cc1ed17155b691b75016"

URI_x86_64_v2_akonadi-calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-devel}"
SRC_URI[x86_64_v2_akonadi-calendar-devel.sha256sum] = "41a060c91d080a7068d186f0e0f2390162df9fea5689b19a648066c752b2d1d7"

URI_x86_64_v2_akonadi-calendar-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-calendar-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-doc}"
SRC_URI[x86_64_v2_akonadi-calendar-doc.sha256sum] = "2717b4dc4b2046aa141a5e60da1a2942de666caafc63ecdc3ec3bd5425d51170"

URI_aarch64_akonadi-calendar = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-calendar;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar}"
SRC_URI[aarch64_akonadi-calendar.sha256sum] = "0b18a03827fba9ee649ec0be81eed3d76e0b7da449d10cd3731705d6e327ac5f"

URI_aarch64_akonadi-calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-devel}"
SRC_URI[aarch64_akonadi-calendar-devel.sha256sum] = "2153dcf5cbf51f1a736a630543df8df84503cd766ed92cfd1b407d8888bc4d4e"

URI_aarch64_akonadi-calendar-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_akonadi-calendar-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-doc}"
SRC_URI[aarch64_akonadi-calendar-doc.sha256sum] = "5b4d3363622b2d5c581a5c8332c0a580e64520e2794d38d9872f9f117ae437e1"

RDEPENDS:akonadi-calendar = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgme2pp \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libkleo \
 libstdc++ \
 messagelib \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-calendar-devel = " \
 akonadi-calendar \
 akonadi-contacts-devel \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kidentitymanagement-devel \
 "
RDEPENDS:akonadi-calendar-doc = " \
 "
