# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khealthcertificate"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 khealthcertificate \
 khealthcertificate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khealthcertificate-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2e9ce739939ea565004a319982f5f7d44284fe7fcb1b077b9f72a425b3ecde3"

URI_x86_64_v2_khealthcertificate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khealthcertificate-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khealthcertificate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khealthcertificate}"
SRC_URI[x86_64_v2_khealthcertificate.sha256sum] = "9b2e81c74e7df5c1bf1b5e762a46d2af4b766aa38b1915ecbfafeebbfd49826f"

URI_x86_64_v2_khealthcertificate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khealthcertificate-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khealthcertificate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khealthcertificate-devel}"
SRC_URI[x86_64_v2_khealthcertificate-devel.sha256sum] = "4fb9c7d5b6b46cb2a069280fbf75777255199d863ef2525858d788472a9933bb"

URI_aarch64_khealthcertificate = "${EPEL_MIRROR}/aarch64/Packages/k/khealthcertificate-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_khealthcertificate;unpack=0"
SRC_URI:append = " ${URI_aarch64_khealthcertificate}"
SRC_URI[aarch64_khealthcertificate.sha256sum] = "d5242afca6f20fbc7144697a05e1717ed41a5c13b67426755403a70923265a18"

URI_aarch64_khealthcertificate-devel = "${EPEL_MIRROR}/aarch64/Packages/k/khealthcertificate-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_khealthcertificate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_khealthcertificate-devel}"
SRC_URI[aarch64_khealthcertificate-devel.sha256sum] = "7ae31d3cc7f59841dbbd783ea4cf8a21813207b99518fa83d6ddad2f57992fad"

RDEPENDS:khealthcertificate = " \
 glibc \
 kf6-karchive \
 kf6-kcodecs \
 kf6-ki18n \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:khealthcertificate-devel = " \
 cmake-filesystem \
 khealthcertificate \
 "
