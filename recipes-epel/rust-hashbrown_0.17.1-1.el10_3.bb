# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashbrown"
PV = "0.17.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-hashbrown+allocator-api2-devel \
 rust-hashbrown+default-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+equivalent-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown+raw-entry-devel \
 rust-hashbrown+rayon-devel \
 rust-hashbrown+serde-devel \
 rust-hashbrown-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hashbrown-0.17.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cdf863a282728dbb18f581f6c59ac89c58347fcec31350c80b743ae604354114"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+allocator-api2-devel-0.17.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+allocator-api2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbrown+allocator-api2-devel.sha256sum] = "d59f48976428af38f998a2067c9339084bdbb729cd0640b78db0fea240ebeb03"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+default-devel-0.17.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbrown+default-devel.sha256sum] = "b3abb1b8fc78e2090380382969aee324ec417e42648218082c5e321d65352022"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+default-hasher-devel-0.17.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+default-hasher-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbrown+default-hasher-devel.sha256sum] = "fb1d8bb5764a4fa5bb3bdfc0aea9d14a304ec12cd99b48c5dbf85512f03eab83"
RPROVIDES:rust-hashbrown+default-hasher-devel:append:x86_64_v2 = " virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+equivalent-devel-0.17.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+equivalent-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbrown+equivalent-devel.sha256sum] = "8c6c93cae309528a53f3b353f3190af704844a6136394cb8e89d20af8a0c3a50"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+inline-more-devel-0.17.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+inline-more-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbrown+inline-more-devel.sha256sum] = "48a1850104ac6e2ecfe5bf6d5961e50f432b826438149537caa98a29d01b6500"
RPROVIDES:rust-hashbrown+inline-more-devel:append:x86_64_v2 = " virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+raw-entry-devel-0.17.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+raw-entry-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbrown+raw-entry-devel.sha256sum] = "b548c5133f0f423e976d8d60fd483b7259cf8bb6db06c052c939cd170c947427"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+rayon-devel-0.17.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+rayon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbrown+rayon-devel.sha256sum] = "ebdcddafa618c40f8dfe201934fdd1710762b5d2ff6eef051a552da5a68a9b43"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+serde-devel-0.17.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbrown+serde-devel.sha256sum] = "a7481df4a5b383d95461391c20566001f0199d289a812a5c223a2eb7d3d5b7dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown-devel-0.17.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hashbrown-devel.sha256sum] = "bbd52c3b710a58e9cd02917e834940b3b86d30453b1f13e9425a4f51359e63f0"
RPROVIDES:rust-hashbrown-devel:append:x86_64_v2 = " virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+allocator-api2-devel-0.17.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+allocator-api2-devel;unpack=0"
SRC_URI[aarch64_rust-hashbrown+allocator-api2-devel.sha256sum] = "8b7935e4cc1b194b60783f6e936572cf8133d4bf532acb184e550fb099e98d79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+default-devel-0.17.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+default-devel;unpack=0"
SRC_URI[aarch64_rust-hashbrown+default-devel.sha256sum] = "5b9793a7d13e8915805743163fe6b9457c38a0024e82fb965c69b12e594f8f0b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+default-hasher-devel-0.17.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+default-hasher-devel;unpack=0"
SRC_URI[aarch64_rust-hashbrown+default-hasher-devel.sha256sum] = "73ef2123ea8822e5413455d823f1f9aeef77544844c74a53c80bfc0fbff4ffa6"
RPROVIDES:rust-hashbrown+default-hasher-devel:append:aarch64 = " virtual/crate_hashbrown/default-hasher__ge_0.15.0_with_crate_hashbrown/default-hasher__lt_0.18.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+equivalent-devel-0.17.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+equivalent-devel;unpack=0"
SRC_URI[aarch64_rust-hashbrown+equivalent-devel.sha256sum] = "b2e60c7ff7ce4c3fdad0a77ff714ce59f5827c53d66e9ac17cef3900f8caeaf5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+inline-more-devel-0.17.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+inline-more-devel;unpack=0"
SRC_URI[aarch64_rust-hashbrown+inline-more-devel.sha256sum] = "51cbe035bd7202141d25e40d00196e3187d66f4c3db45acdcb33ab0b3873115f"
RPROVIDES:rust-hashbrown+inline-more-devel:append:aarch64 = " virtual/crate_hashbrown/inline-more__ge_0.15.0_with_crate_hashbrown/inline-more__lt_0.18.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+raw-entry-devel-0.17.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+raw-entry-devel;unpack=0"
SRC_URI[aarch64_rust-hashbrown+raw-entry-devel.sha256sum] = "69d4134b0ac4ab42eea6d7c7a9e0e6c3afa662ce4ebf3654b02e35df4db06d4d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+rayon-devel-0.17.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+rayon-devel;unpack=0"
SRC_URI[aarch64_rust-hashbrown+rayon-devel.sha256sum] = "67b54d103489dafe4d51247a68ffca86b0b1c8aefc6f4125bb320345dd00c913"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+serde-devel-0.17.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown+serde-devel;unpack=0"
SRC_URI[aarch64_rust-hashbrown+serde-devel.sha256sum] = "45de321db90c0782a638a98142fbbe178b0d624e90db47bf5f32bef3e22a77a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown-devel-0.17.1-1.el10_3.noarch.rpm;name=aarch64_rust-hashbrown-devel;unpack=0"
SRC_URI[aarch64_rust-hashbrown-devel.sha256sum] = "d27b5526278664a6f462f5d642ff844c6a983eb58de03c5daadd595ddbd59d7e"
RPROVIDES:rust-hashbrown-devel:append:aarch64 = " virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.18.0~"

RDEPENDS:rust-hashbrown+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2+alloc-devel \
 rust-allocator-api2-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+default-devel = " \
 cargo \
 rust-hashbrown+allocator-api2-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+equivalent-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown+raw-entry-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+default-hasher-devel = " \
 cargo \
 rust-foldhash-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+equivalent-devel = " \
 cargo \
 rust-equivalent-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+inline-more-devel = " \
 cargo \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+raw-entry-devel = " \
 cargo \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+rayon-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-hashbrown+serde-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-hashbrown-devel = " \
 cargo \
 rust \
 "
