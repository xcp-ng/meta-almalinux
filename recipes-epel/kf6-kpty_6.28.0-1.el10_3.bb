# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpty"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kpty \
 kf6-kpty-devel \
 kf6-kpty-doc \
 kf6-kpty-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpty-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d077a0351b89f2908f1dd75f2152596f41f3d99eff2d5b0fe24c940d38872da"

URI_x86_64_v2_kf6-kpty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty}"
SRC_URI[x86_64_v2_kf6-kpty.sha256sum] = "fc7a0a82b35e01cadc66d1a6b814f3eb920c4fa6252c0f9b5364bcea352b9bb2"

URI_x86_64_v2_kf6-kpty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty-devel}"
SRC_URI[x86_64_v2_kf6-kpty-devel.sha256sum] = "75d03fe4cac35a4fd25abe6819af603e7c944eb309e987566df6372ef4f28206"

URI_x86_64_v2_kf6-kpty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty-doc}"
SRC_URI[x86_64_v2_kf6-kpty-doc.sha256sum] = "dd2923b58698b3429e315082eac654de232c5503e1bd07f6689ec479483559cc"

URI_x86_64_v2_kf6-kpty-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpty-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpty-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpty-html}"
SRC_URI[x86_64_v2_kf6-kpty-html.sha256sum] = "758855a1adee5f99bc4fba4106dca5cb59f97073f2cc10729309089659dfe061"

URI_aarch64_kf6-kpty = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kpty;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty}"
SRC_URI[aarch64_kf6-kpty.sha256sum] = "735a4349c6b63ced6da8353cce6de0dcb0ca87f884f37ecfd10afebab96234b2"

URI_aarch64_kf6-kpty-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kpty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty-devel}"
SRC_URI[aarch64_kf6-kpty-devel.sha256sum] = "4a0af7b5e9aef3d646dd2ceb961fc8f6c54c3680b358a276041b682e80c3aa03"

URI_aarch64_kf6-kpty-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kpty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty-doc}"
SRC_URI[aarch64_kf6-kpty-doc.sha256sum] = "8d788421fc283cdb4da2018edcb629f04e8d4a21ce9e2cd6744bc5759dd86492"

URI_aarch64_kf6-kpty-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpty-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kpty-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpty-html}"
SRC_URI[aarch64_kf6-kpty-html.sha256sum] = "edfdb636cd958edc230e6ecfcbadf4eb2986e8793f56dcccfc1ec566b3c41bba"

RDEPENDS:kf6-kpty = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 libutempter \
 qt6-qtbase \
 "
RDEPENDS:kf6-kpty-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kpty \
 "
RDEPENDS:kf6-kpty-doc = " \
 "
RDEPENDS:kf6-kpty-html = " \
 "
