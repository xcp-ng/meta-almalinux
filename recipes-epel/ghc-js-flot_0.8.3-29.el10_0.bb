# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-js-flot"
PV = "0.8.3"
PR = "29.el10_0"
PACKAGES = " \
 ghc-js-flot \
 ghc-js-flot-devel \
 ghc-js-flot-doc \
 ghc-js-flot-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-js-flot-0.8.3-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f81f0c0f6b24c6665751af6c05e9fe96c13d0ec87cde792b121bf4aab8e829b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-flot-0.8.3-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-flot;unpack=0"
SRC_URI[x86_64_v2_ghc-js-flot.sha256sum] = "0eda8f44338500e15b18dd87368a93ebbf1cb1c614409503c46002e709c924ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-flot-devel-0.8.3-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-flot-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-js-flot-devel.sha256sum] = "16e1848fd1c1da8e84523f76279e6df5577fb2af6a6fe8483c41e63b0e0858b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-flot-doc-0.8.3-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-js-flot-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-js-flot-doc.sha256sum] = "313fb341adb2ee58d6e34ace1b8bcfa5308f158d8b9c9acd315155aaed977739"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-flot-prof-0.8.3-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-flot-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-js-flot-prof.sha256sum] = "71ec8b66f075727b56da59e8450c1cab8cbba2bbb35166003f7135aaf71166b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-flot-0.8.3-29.el10_0.aarch64.rpm;name=aarch64_ghc-js-flot;unpack=0"
SRC_URI[aarch64_ghc-js-flot.sha256sum] = "5ee345c6f08a3121cc6a9331d58ebc83ab9b8120f631b418cbdc48e78fac8c56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-flot-devel-0.8.3-29.el10_0.aarch64.rpm;name=aarch64_ghc-js-flot-devel;unpack=0"
SRC_URI[aarch64_ghc-js-flot-devel.sha256sum] = "398f69b249e87ee6d66b89253311bd2a31ab1d07870ed2f7fc933fb0ff213fe5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-flot-doc-0.8.3-29.el10_0.noarch.rpm;name=aarch64_ghc-js-flot-doc;unpack=0"
SRC_URI[aarch64_ghc-js-flot-doc.sha256sum] = "09f5d43236d4de7f80b3298f38e6610fec1297bb227ca883d6185f3f27f7418d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-flot-prof-0.8.3-29.el10_0.aarch64.rpm;name=aarch64_ghc-js-flot-prof;unpack=0"
SRC_URI[aarch64_ghc-js-flot-prof.sha256sum] = "9e8838b5abdf3528e3b0bfc097242bd62db2e6be512fd8786cc44f4ad11c9217"

RDEPENDS:ghc-js-flot = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-js-flot-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-js-flot \
 "
RDEPENDS:ghc-js-flot-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-js-flot-prof = " \
 ghc-base-prof \
 ghc-js-flot-devel \
 "
