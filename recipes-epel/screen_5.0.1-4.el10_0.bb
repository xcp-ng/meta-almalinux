# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "screen"
PV = "5.0.1"
PR = "4.el10_0"
PACKAGES = " \
 screen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/screen-5.0.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c051ccd3ca3249007a01653cd6571ad520c96d4db03e606f3c90d05ceb8be7ac"

URI_x86_64_v2_screen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/screen-5.0.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_screen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_screen}"
SRC_URI[x86_64_v2_screen.sha256sum] = "544c759ab10e67365be17f88ba06513688410faaa5c6b34234a90bc37fa8ab15"

URI_aarch64_screen = "${EPEL_MIRROR}/aarch64/Packages/s/screen-5.0.1-4.el10_0.aarch64.rpm;name=aarch64_screen;unpack=0"
SRC_URI:append = " ${URI_aarch64_screen}"
SRC_URI[aarch64_screen.sha256sum] = "4e9424a51e554257a76e35e8387b08ff68ce24e508709254a3fdb67f35d617f6"

RDEPENDS:screen = " \
 glibc \
 ncurses-libs \
 pam-libs \
 "
