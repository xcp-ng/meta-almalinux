# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktorrent"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ktorrent \
 ktorrent-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktorrent-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2981a61f3aabf3d225056104bf6ff5e3bdf5401906f6e3508ce1b9a57b45f2b"

URI_x86_64_v2_ktorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktorrent-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktorrent}"
SRC_URI[x86_64_v2_ktorrent.sha256sum] = "fd8be07140c499d31d15eacc8a17906f843b3edd773283da5c731c49c3256ad3"

URI_x86_64_v2_ktorrent-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktorrent-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktorrent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktorrent-libs}"
SRC_URI[x86_64_v2_ktorrent-libs.sha256sum] = "44fb55b09ba8bf13d845c3258a97941fec13857069d10393fb32c39794a554d4"

URI_aarch64_ktorrent = "${EPEL_MIRROR}/aarch64/Packages/k/ktorrent-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ktorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktorrent}"
SRC_URI[aarch64_ktorrent.sha256sum] = "c1b7cf0cafd9b92737c881624f030c10d4855f81697e20494b04e63487a4ac06"

URI_aarch64_ktorrent-libs = "${EPEL_MIRROR}/aarch64/Packages/k/ktorrent-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ktorrent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktorrent-libs}"
SRC_URI[aarch64_ktorrent-libs.sha256sum] = "5b14ff095fc3c706647628674692368c6a0822033dfc4b29695a9f251e2a1bfc"

RDEPENDS:ktorrent = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kplotting \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syndication \
 ktorrent-libs \
 libgcc \
 libktorrent \
 libmaxminddb \
 libstdc++ \
 phonon-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 taglib \
 "
RDEPENDS:ktorrent-libs = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktorrent \
 libgcc \
 libktorrent \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
