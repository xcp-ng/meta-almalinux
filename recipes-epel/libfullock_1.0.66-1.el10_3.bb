# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfullock"
PV = "1.0.66"
PR = "1.el10_3"
PACKAGES = " \
 libfullock \
 libfullock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libfullock-1.0.66-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d393cb836966d74f6d59e39c042453dd41f961312a5a11f0ebf8c5a29edd27d"

URI_x86_64_v2_libfullock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfullock-1.0.66-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfullock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfullock}"
SRC_URI[x86_64_v2_libfullock.sha256sum] = "f142080604eee3b4924de41148f9626ea292bdd0fbda4b3de47644c3ebbab6ee"

URI_x86_64_v2_libfullock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfullock-devel-1.0.66-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfullock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfullock-devel}"
SRC_URI[x86_64_v2_libfullock-devel.sha256sum] = "2c52131569f90814b32b12650e092bc189b5cd0eadd4fad70793d49872b0c987"

URI_aarch64_libfullock = "${EPEL_MIRROR}/aarch64/Packages/l/libfullock-1.0.66-1.el10_3.aarch64.rpm;name=aarch64_libfullock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfullock}"
SRC_URI[aarch64_libfullock.sha256sum] = "d40c43d8ecd6efc7964cb5057ed3e30d03532db24d57a497ad82878555519db8"

URI_aarch64_libfullock-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libfullock-devel-1.0.66-1.el10_3.aarch64.rpm;name=aarch64_libfullock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfullock-devel}"
SRC_URI[aarch64_libfullock-devel.sha256sum] = "90ac4fc11207ed68645855850abce4f6d796915923c61363802834e7a672d092"

RDEPENDS:libfullock = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libfullock-devel = " \
 libfullock \
 pkgconf-pkg-config \
 "
