# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cxxopts"
PV = "3.3.1"
PR = "1.el10_2"
PACKAGES = " \
 cxxopts-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cxxopts-3.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fd40bd9afad4c85d9e929ccdc962008f75e72a3ca3110279b220e4bd715ca917"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cxxopts-devel-3.3.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cxxopts-devel;unpack=0"
SRC_URI[x86_64_v2_cxxopts-devel.sha256sum] = "e7a28547de1c415c3e16900524d73ecfb37c915932707f2fbb48886540a9ecd2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cxxopts-devel-3.3.1-1.el10_2.aarch64.rpm;name=aarch64_cxxopts-devel;unpack=0"
SRC_URI[aarch64_cxxopts-devel.sha256sum] = "368dadaaa84fed6e47f9904ddc71ca5b4e142aa899b948d2247d200fa0ce4777"

RDEPENDS:cxxopts-devel = " \
 cmake-filesystem \
 libstdc++-devel \
 pkgconf-pkg-config \
 "
