# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lv2-time"
PV = "0.1.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-lv2-time+default-devel \
 rust-lv2-time-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lv2-time-0.1.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9223a4f8c837cdc866a1032baa041c5e53ee30b2f13217648bdb974376a21bae"

URI_x86_64_v2_rust-lv2-time+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-time+default-devel-0.1.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-time+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-time+default-devel}"
SRC_URI[x86_64_v2_rust-lv2-time+default-devel.sha256sum] = "dae56b42e15cce6e23b24c7879656d833c8237291cbae50b75d802283db8f39c"

URI_x86_64_v2_rust-lv2-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-time-devel-0.1.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-time-devel}"
SRC_URI[x86_64_v2_rust-lv2-time-devel.sha256sum] = "a33f3a9902054495656843a757bbe1085a4b33d02238707211e9539ee42d9929"

URI_aarch64_rust-lv2-time+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-time+default-devel-0.1.3-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-time+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-time+default-devel}"
SRC_URI[aarch64_rust-lv2-time+default-devel.sha256sum] = "fb5d8480e1a66bf16ca9b009294a23e5ee82c9e40df85b9d8585be6105af6b3a"

URI_aarch64_rust-lv2-time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-time-devel-0.1.3-3.el10_0.noarch.rpm;name=aarch64_rust-lv2-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-time-devel}"
SRC_URI[aarch64_rust-lv2-time-devel.sha256sum] = "bb31d125debe36d0b732d6d553f6b7e5e87defa1ed3e927020a70062d29804aa"

RDEPENDS:rust-lv2-time+default-devel = " \
 cargo \
 rust-lv2-time-devel \
 "
RDEPENDS:rust-lv2-time-devel = " \
 cargo \
 rust-lv2-sys+default-devel \
 rust-urid+default-devel \
 "
