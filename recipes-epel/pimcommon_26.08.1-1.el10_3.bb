# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pimcommon"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 pimcommon \
 pimcommon-devel \
 pimcommon-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pimcommon-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1fa667e23ff2fdfd5cc8cca5cd466f3fb02b0eabfc0856e37b056fe4b701d947"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon;unpack=0"
SRC_URI[x86_64_v2_pimcommon.sha256sum] = "8dd9ca61a1f5841ee5adf83c74584e68669326bd0031e44a9925b7ce55232fa0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon-devel;unpack=0"
SRC_URI[x86_64_v2_pimcommon-devel.sha256sum] = "39e752d51bad3618eca825069434ba9c4fb820d888c6f8c03e960b7db280ca79"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-doc-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon-doc;unpack=0"
SRC_URI[x86_64_v2_pimcommon-doc.sha256sum] = "41bbdf4bafb35d0eb9e0d6299b65ab53504349ce6caf4feb50146e9286e63e06"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_pimcommon;unpack=0"
SRC_URI[aarch64_pimcommon.sha256sum] = "c8fffa03beec56f9f209da74f6292ee56d6083f7df49772bcfcea7f9f7868263"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_pimcommon-devel;unpack=0"
SRC_URI[aarch64_pimcommon-devel.sha256sum] = "05c5a55d11713c0122ee77f1aaf679f8ae3f34164ac368db49dc9148b83ea114"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-doc-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_pimcommon-doc;unpack=0"
SRC_URI[aarch64_pimcommon-doc.sha256sum] = "57cdce5616c4f6b1f12b5d4d35d07b7d712b629cad75ff5a8b328f238f748245"

RDEPENDS:pimcommon = " \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 glibc \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kimap \
 kldap \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pimcommon-devel = " \
 akonadi-contacts-devel \
 akonadi-server-devel \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kcontacts-devel \
 kimap-devel \
 ktextaddons-qt6-devel \
 libgcc \
 libstdc++ \
 pimcommon \
 plasma-activities-devel \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pimcommon-doc = " \
 "
