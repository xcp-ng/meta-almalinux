# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-error"
PV = "2.0.1"
PR = "10.el10_0"
PACKAGES = " \
 rust-quick-error+default-devel \
 rust-quick-error-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-error-2.0.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97f26da1cb4f6639f3847cf087b4656b1d860ffdf40d2b48b888c380c8c2a583"

URI_x86_64_v2_rust-quick-error+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-error+default-devel-2.0.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-error+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-error+default-devel}"
SRC_URI[x86_64_v2_rust-quick-error+default-devel.sha256sum] = "d6cd3459baedce5af9939d01ee01dc6e850bb65eabbdde523487ff88a55074c2"

URI_x86_64_v2_rust-quick-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-error-devel-2.0.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-error-devel}"
SRC_URI[x86_64_v2_rust-quick-error-devel.sha256sum] = "c2c190fd13d1897c59979bf8021d9b951c3530ed953cee7f68a0c886c25c7980"

URI_aarch64_rust-quick-error+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-error+default-devel-2.0.1-10.el10_0.noarch.rpm;name=aarch64_rust-quick-error+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-error+default-devel}"
SRC_URI[aarch64_rust-quick-error+default-devel.sha256sum] = "89fbbebdd86f055703f66135bc6d4aadb5ca5ece4b32f0d87d8036df2b22c728"

URI_aarch64_rust-quick-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-error-devel-2.0.1-10.el10_0.noarch.rpm;name=aarch64_rust-quick-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-error-devel}"
SRC_URI[aarch64_rust-quick-error-devel.sha256sum] = "932372de65efc5200734e65742c39b26ddb94b28f6cdb53ec6358fac2fce92cc"

RDEPENDS:rust-quick-error+default-devel = " \
 cargo \
 rust-quick-error-devel \
 "
RDEPENDS:rust-quick-error-devel = " \
 cargo \
 "
