# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-pt"
PV = "0.20131030"
PR = "15.el10"
PACKAGES = " \
 hunspell-pt \
 hunspell-pt-BR \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-pt-0.20131030-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e85306bd74d47a50eec07beda4016d4cd14ae4623a8f3136a7ceb495da2d3af3"

URI_x86_64_v2_hunspell-pt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-pt-0.20131030-15.el10.noarch.rpm;name=x86_64_v2_hunspell-pt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-pt}"
SRC_URI[x86_64_v2_hunspell-pt.sha256sum] = "15df3329b073e9a6656f41fb51aeab20dd5df092537c69661cce95e619a52381"

URI_x86_64_v2_hunspell-pt-BR = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-pt-BR-0.20131030-15.el10.noarch.rpm;name=x86_64_v2_hunspell-pt-BR;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-pt-BR}"
SRC_URI[x86_64_v2_hunspell-pt-BR.sha256sum] = "ed3920e4ecf667aa8ede27c708413194f348d665b24078db90ddb157a02996aa"

URI_aarch64_hunspell-pt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-pt-0.20131030-15.el10.noarch.rpm;name=aarch64_hunspell-pt;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-pt}"
SRC_URI[aarch64_hunspell-pt.sha256sum] = "15df3329b073e9a6656f41fb51aeab20dd5df092537c69661cce95e619a52381"

URI_aarch64_hunspell-pt-BR = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-pt-BR-0.20131030-15.el10.noarch.rpm;name=aarch64_hunspell-pt-BR;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-pt-BR}"
SRC_URI[aarch64_hunspell-pt-BR.sha256sum] = "ed3920e4ecf667aa8ede27c708413194f348d665b24078db90ddb157a02996aa"

RDEPENDS:hunspell-pt = " \
 hunspell \
 "
RDEPENDS:hunspell-pt-BR = " \
 hunspell \
 "
