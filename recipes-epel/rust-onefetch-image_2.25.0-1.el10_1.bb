# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch-image"
PV = "2.25.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-onefetch-image+default-devel \
 rust-onefetch-image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-image-2.25.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50cfb20a2a1cb6d4ccd06cad8271c501c456d2d44b1a2af46dfbdc292f848a32"

URI_x86_64_v2_rust-onefetch-image+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-image+default-devel-2.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-image+default-devel}"
SRC_URI[x86_64_v2_rust-onefetch-image+default-devel.sha256sum] = "2eb0d0301c60e7e907c39c6580dc05e04a8be3c9d0afd2f711556d0abdfe148f"

URI_x86_64_v2_rust-onefetch-image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-image-devel-2.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-image-devel}"
SRC_URI[x86_64_v2_rust-onefetch-image-devel.sha256sum] = "b5e3c37988236243c6aa94e499830d43e6dbcc71fccdeac51df9312197a5481d"

URI_aarch64_rust-onefetch-image+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-image+default-devel-2.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-onefetch-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-image+default-devel}"
SRC_URI[aarch64_rust-onefetch-image+default-devel.sha256sum] = "7190d9708968b67639e6a2861ae488c7039ba9f1f948189675f9d87901df5b46"

URI_aarch64_rust-onefetch-image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-image-devel-2.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-onefetch-image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-image-devel}"
SRC_URI[aarch64_rust-onefetch-image-devel.sha256sum] = "2c383aebee8d6c6c8e33333572e5f514b9b06ee67161b72b53b66c2dc472d2a2"

RDEPENDS:rust-onefetch-image+default-devel = " \
 cargo \
 rust-onefetch-image-devel \
 "
RDEPENDS:rust-onefetch-image-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-base64+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-color_quant+default-devel \
 rust-image+color_quant-devel \
 rust-image+jpeg-devel \
 rust-image+png-devel \
 rust-image+webp-devel \
 rust-image-devel \
 rust-libc+default-devel \
 "
