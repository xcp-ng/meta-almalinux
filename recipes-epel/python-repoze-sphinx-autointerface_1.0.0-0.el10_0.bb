# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-repoze-sphinx-autointerface"
PV = "1.0.0"
PR = "0.el10_0"
PACKAGES = " \
 python3-repoze-sphinx-autointerface \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-repoze-sphinx-autointerface-1.0.0-0.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b23a25e0044007e81df398e3d808cef8a53b047464a14480f2714b9a6775a69"

URI_x86_64_v2_python3-repoze-sphinx-autointerface = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-repoze-sphinx-autointerface-1.0.0-0.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-repoze-sphinx-autointerface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-repoze-sphinx-autointerface}"
SRC_URI[x86_64_v2_python3-repoze-sphinx-autointerface.sha256sum] = "f20f590631d8e0602d69906cf205019e2fb3ce8cd497392e3549df91d454b38b"

URI_aarch64_python3-repoze-sphinx-autointerface = "${EPEL_MIRROR}/aarch64/Packages/p/python3-repoze-sphinx-autointerface-1.0.0-0.el10_0.noarch.rpm;name=aarch64_python3-repoze-sphinx-autointerface;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-repoze-sphinx-autointerface}"
SRC_URI[aarch64_python3-repoze-sphinx-autointerface.sha256sum] = "52fdb24ab0072965b620cb084953ca9ec9a086a495bc321338c8227ed7c62543"

RDEPENDS:python3-repoze-sphinx-autointerface = " \
 python3 \
 python3-setuptools \
 python3-sphinx \
 python3-zope-interface \
 "
