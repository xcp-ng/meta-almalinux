# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum"
PV = "0.27.2"
PR = "2.el10_2"
PACKAGES = " \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-strum+phf-devel \
 rust-strum+std-devel \
 rust-strum+strum_macros-devel \
 rust-strum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum-0.27.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9643fdad67b9e00e2bbcaa1a91fb43a720cef7f269a1dc41121b768526e78b3"

URI_x86_64_v2_rust-strum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+default-devel-0.27.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+default-devel}"
SRC_URI[x86_64_v2_rust-strum+default-devel.sha256sum] = "3dc60d36d4400e16c92e1a2d36535244e6b111568fe3e0ce033510171b61dc0e"

URI_x86_64_v2_rust-strum+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+derive-devel-0.27.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+derive-devel}"
SRC_URI[x86_64_v2_rust-strum+derive-devel.sha256sum] = "a95f695eeebdd84271c23418f105f76568a4181cd03332c66faf176eacfa1e60"

URI_x86_64_v2_rust-strum+phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+phf-devel-0.27.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+phf-devel}"
SRC_URI[x86_64_v2_rust-strum+phf-devel.sha256sum] = "41ff28ec0238661a9add8b561343f0bffe82d73200f7ec7c66901c1d2827e1df"

URI_x86_64_v2_rust-strum+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+std-devel-0.27.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+std-devel}"
SRC_URI[x86_64_v2_rust-strum+std-devel.sha256sum] = "792279aa10936a68badbe9ed7f02b93e72d499170b758fc8b2bacf3583cd01b3"

URI_x86_64_v2_rust-strum+strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+strum_macros-devel-0.27.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum+strum_macros-devel.sha256sum] = "be6bd386a08a4f90f66b2846abbc458e9f8fbdb6101c6be2b95d2e5d4cd29b96"

URI_x86_64_v2_rust-strum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum-devel-0.27.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum-devel}"
SRC_URI[x86_64_v2_rust-strum-devel.sha256sum] = "abdd6afd54b9573e3e453773c517b4ebda0351a43d9366a1fff3c4e5b7c91575"

URI_aarch64_rust-strum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+default-devel-0.27.2-2.el10_2.noarch.rpm;name=aarch64_rust-strum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+default-devel}"
SRC_URI[aarch64_rust-strum+default-devel.sha256sum] = "7c288920d2697c39df19eead74f5b05d6d80086ea55a1fd8af4d770d3592277b"

URI_aarch64_rust-strum+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+derive-devel-0.27.2-2.el10_2.noarch.rpm;name=aarch64_rust-strum+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+derive-devel}"
SRC_URI[aarch64_rust-strum+derive-devel.sha256sum] = "600e09af144ddcd60554a35c65c983d41f07faa6870dd226ff8b1714ba5b1089"

URI_aarch64_rust-strum+phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+phf-devel-0.27.2-2.el10_2.noarch.rpm;name=aarch64_rust-strum+phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+phf-devel}"
SRC_URI[aarch64_rust-strum+phf-devel.sha256sum] = "fc961ea138a4c61afa09958c76f470daaa8e1fe6911fcd82824edac8990288a6"

URI_aarch64_rust-strum+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+std-devel-0.27.2-2.el10_2.noarch.rpm;name=aarch64_rust-strum+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+std-devel}"
SRC_URI[aarch64_rust-strum+std-devel.sha256sum] = "b762be5dd63f6634bdd307f361dfd459111ca29569405f931bc787006b8464e3"

URI_aarch64_rust-strum+strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+strum_macros-devel-0.27.2-2.el10_2.noarch.rpm;name=aarch64_rust-strum+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+strum_macros-devel}"
SRC_URI[aarch64_rust-strum+strum_macros-devel.sha256sum] = "1533009108f35b2d7b5ff11ea923c2d4839e005b47c49e56fbb59a72c5791955"

URI_aarch64_rust-strum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum-devel-0.27.2-2.el10_2.noarch.rpm;name=aarch64_rust-strum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum-devel}"
SRC_URI[aarch64_rust-strum-devel.sha256sum] = "d259af77f59460bd52175a88af654654b6be37a0a9b0be92bdcd4bb41fb04fe2"

RDEPENDS:rust-strum+default-devel = " \
 cargo \
 rust-strum+std-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+derive-devel = " \
 cargo \
 rust-strum+strum_macros-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+phf-devel = " \
 cargo \
 rust-phf+default-devel \
 rust-phf+macros-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+std-devel = " \
 cargo \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+strum_macros-devel = " \
 cargo \
 rust-strum-devel \
 rust-strum_macros+default-devel \
 "
RDEPENDS:rust-strum-devel = " \
 cargo \
 rust \
 "
