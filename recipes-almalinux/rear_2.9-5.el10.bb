# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rear"
PV = "2.9"
PR = "5.el10"
PACKAGES = " \
 rear \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rear-2.9-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac35686489c9834a0f3a6fb2755b2f30eb6daf88869373041a6055891f10531b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rear-2.9-5.el10.x86_64_v2.rpm;name=x86_64_v2_rear;unpack=0"
SRC_URI[x86_64_v2_rear.sha256sum] = "7670b9fd4655116f051607e60d9840dec4807acbf6d1fbed8f184d83aa1c2d51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rear-2.9-5.el10.aarch64.rpm;name=aarch64_rear;unpack=0"
SRC_URI[aarch64_rear.sha256sum] = "15b69f6d87f2e65105a2fb1bc0e7697bb216383bf046eefd054af4a21b74f6c8"

RDEPENDS:rear:x86_64_v2 = " \
 attr \
 bash \
 bc \
 binutils \
 dhcpcd \
 dosfstools \
 ethtool \
 file \
 gawk \
 grub2-efi-x64-modules \
 grub2-tools-extra \
 gzip \
 iproute \
 iputils \
 openssl \
 parted \
 syslinux-extlinux \
 tar \
 util-linux \
 xorriso \
"
RDEPENDS:rear:aarch64 = " \
 attr \
 bash \
 bc \
 binutils \
 dhcpcd \
 dosfstools \
 ethtool \
 file \
 gawk \
 grub2-efi-aa64-modules \
 grub2-tools-extra \
 gzip \
 iproute \
 iputils \
 openssl \
 parted \
 tar \
 util-linux \
 xorriso \
"
