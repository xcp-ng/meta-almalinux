# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdump-anaconda-addon"
PV = "006"
PR = "20.20220714git7ca2d3e.el10"
PACKAGES = " \
 kdump-anaconda-addon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/kdump-anaconda-addon-006-20.20220714git7ca2d3e.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c68065cc37a65c2865c3a7895784ee8675f52e41d0862515fd9d5430e6b8593e"

URI_x86_64_v2_kdump-anaconda-addon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kdump-anaconda-addon-006-20.20220714git7ca2d3e.el10.noarch.rpm;name=x86_64_v2_kdump-anaconda-addon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdump-anaconda-addon}"
SRC_URI[x86_64_v2_kdump-anaconda-addon.sha256sum] = "144ade70d9be03940314e35aefae3c67ef8ff5de91ce2a40f997697f5b6b469c"

URI_aarch64_kdump-anaconda-addon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kdump-anaconda-addon-006-20.20220714git7ca2d3e.el10.noarch.rpm;name=aarch64_kdump-anaconda-addon;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdump-anaconda-addon}"
SRC_URI[aarch64_kdump-anaconda-addon.sha256sum] = "144ade70d9be03940314e35aefae3c67ef8ff5de91ce2a40f997697f5b6b469c"

RDEPENDS:kdump-anaconda-addon = " \
 anaconda \
 hicolor-icon-theme \
 "
