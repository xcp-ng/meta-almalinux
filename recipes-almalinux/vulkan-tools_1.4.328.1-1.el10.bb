# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-tools"
PV = "1.4.328.1"
PR = "1.el10"
PACKAGES = " \
 vulkan-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-tools-1.4.328.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2286ee6b59939be11f73f7985a13bfbea5f531ab3bf77a941200ee7e61eff236"

URI_x86_64_v2_vulkan-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-tools-1.4.328.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-tools}"
SRC_URI[x86_64_v2_vulkan-tools.sha256sum] = "982c7e4a06653c138c47c3f0f623aaa8d6c692f0da4179e14f3b4368f4801647"

URI_aarch64_vulkan-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-tools-1.4.328.1-1.el10.aarch64.rpm;name=aarch64_vulkan-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-tools}"
SRC_URI[aarch64_vulkan-tools.sha256sum] = "8cdef14a4fc363f9f7c2cf1c4c2c22464d43d184949617d4547c47257659a9a5"

RDEPENDS:vulkan-tools = " \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 "
