# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-elixir"
PV = "0.3.4"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-elixir+default-devel \
 rust-tree-sitter-elixir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-elixir-0.3.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "930aca22489de2ddba2f95f7c1d81baf04df81e9f69cfa5f08d9cad632a7eb46"

URI_x86_64_v2_rust-tree-sitter-elixir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elixir+default-devel-0.3.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elixir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elixir+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elixir+default-devel.sha256sum] = "ea0dc57bdc6b66a6ac9c9d065b5a5f846a37d18440726b6507f4d21e592fffaa"

URI_x86_64_v2_rust-tree-sitter-elixir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elixir-devel-0.3.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elixir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elixir-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elixir-devel.sha256sum] = "e4a5ed13de47bf9a00fc17ab1aa1d5f305e8197bfae10f0ddd0628e21fc1f704"

URI_aarch64_rust-tree-sitter-elixir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elixir+default-devel-0.3.4-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-elixir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elixir+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-elixir+default-devel.sha256sum] = "df647919a00882d9da4a0331c4995f74a1bf942a1e11228d60e362e4deaa9edc"

URI_aarch64_rust-tree-sitter-elixir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elixir-devel-0.3.4-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-elixir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elixir-devel}"
SRC_URI[aarch64_rust-tree-sitter-elixir-devel.sha256sum] = "459db2e78184678e5b0c0c43e184bba5ec0b3b20f931e8a3190899fe590982b0"

RDEPENDS:rust-tree-sitter-elixir+default-devel = " \
 cargo \
 rust-tree-sitter-elixir-devel \
 "
RDEPENDS:rust-tree-sitter-elixir-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
