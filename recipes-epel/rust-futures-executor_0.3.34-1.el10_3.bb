# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-executor"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-executor+default-devel \
 rust-futures-executor+std-devel \
 rust-futures-executor+thread-pool-devel \
 rust-futures-executor-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-executor-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c930df438c3753698aac2e0403eb9424fd9f4953743076e1f450aa35b2cf108d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-executor+default-devel.sha256sum] = "80ba77a7457b1ca21a55a09231b748318fc92844fe18cd12d96239f842d79b1a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+std-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-executor+std-devel.sha256sum] = "fec54493a9521d17a9b847ff4180eb98e5996cb24d54c38bbab31931c6618a76"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor+thread-pool-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor+thread-pool-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-executor+thread-pool-devel.sha256sum] = "8e91347140a27785cbd66924051a64a1a1ff9a1d95cf8522f63b90a6940b4e07"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-executor-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-executor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-executor-devel.sha256sum] = "19e4cd33eccf3e9f62dbd976dc160caf984ee19502c81863718ec4b7ab915213"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-executor+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures-executor+default-devel.sha256sum] = "6586f2d72df0f4091388e735d3ca5cd9a95d3fe194ad25a30c16e601bb7b13df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+std-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-executor+std-devel;unpack=0"
SRC_URI[aarch64_rust-futures-executor+std-devel.sha256sum] = "f4bbd24ab5cabc8374408b2ac4a5bf180bedd5fbde36c42c8776629747d24fd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor+thread-pool-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-executor+thread-pool-devel;unpack=0"
SRC_URI[aarch64_rust-futures-executor+thread-pool-devel.sha256sum] = "5a46b3298b5fabf00054c8536438b9f783222cc910f87f8c7a9404e603a287e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-executor-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-executor-devel;unpack=0"
SRC_URI[aarch64_rust-futures-executor-devel.sha256sum] = "4e41b4eaa0b7a949bc788268a5bc8bc5b122fbe21ae9cf1decafa38d31022211"

RDEPENDS:rust-futures-executor+default-devel = " \
 cargo \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures-executor+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-executor-devel \
 rust-futures-task+std-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures-executor+thread-pool-devel = " \
 cargo \
 rust-futures-executor+std-devel \
 rust-futures-executor-devel \
 "
RDEPENDS:rust-futures-executor-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-task-devel \
 rust-futures-util-devel \
 "
