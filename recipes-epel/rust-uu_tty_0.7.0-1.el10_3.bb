# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_tty"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_tty+default-devel \
 rust-uu_tty-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_tty-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee20fc7d45e1b21df8e93769fac4b3ecea67d4d203097e862dd9fa56116b5ccc"

URI_x86_64_v2_rust-uu_tty+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_tty+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_tty+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_tty+default-devel}"
SRC_URI[x86_64_v2_rust-uu_tty+default-devel.sha256sum] = "686a74f20cf8c121502f8ad2d0e6bb954fdf88d72273f7f8816f2799ca7690e9"

URI_x86_64_v2_rust-uu_tty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_tty-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_tty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_tty-devel}"
SRC_URI[x86_64_v2_rust-uu_tty-devel.sha256sum] = "a25183337ad1d589b090f20c2d59d68b96f9503fef4cec5e4c94383f3407b3b3"

URI_aarch64_rust-uu_tty+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_tty+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_tty+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_tty+default-devel}"
SRC_URI[aarch64_rust-uu_tty+default-devel.sha256sum] = "456107f59bda1d193941fa9c7456d15160016a4701f7013425f479720f27f911"

URI_aarch64_rust-uu_tty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_tty-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_tty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_tty-devel}"
SRC_URI[aarch64_rust-uu_tty-devel.sha256sum] = "31855aa1b38bb0d2065a50a7ec66627b6de5eb4e134c6f0b6c0b1ecc7d85fb7a"

RDEPENDS:rust-uu_tty+default-devel = " \
 cargo \
 rust-uu_tty-devel \
 "
RDEPENDS:rust-uu_tty-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-nix0.30+term-devel \
 rust-nix0.30-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 "
