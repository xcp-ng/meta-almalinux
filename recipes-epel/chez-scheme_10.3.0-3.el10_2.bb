# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chez-scheme"
PV = "10.3.0"
PR = "3.el10_2"
PACKAGES = " \
 chez-scheme \
 chez-scheme-devel \
 chez-scheme-examples \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/chez-scheme-10.3.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dabb203e69f6ab152728c37274fedd40ca9f04f4a8e6a56ce35b80d56b1098bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chez-scheme-10.3.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chez-scheme;unpack=0"
SRC_URI[x86_64_v2_chez-scheme.sha256sum] = "469e436a533611651a828f01d3f644e6b2ec5b4d9981a24c2e731cc509f126fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chez-scheme-devel-10.3.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chez-scheme-devel;unpack=0"
SRC_URI[x86_64_v2_chez-scheme-devel.sha256sum] = "e644e261352c19a4795c5d8fae00814f4c5c795ee8186d9c068949b9d8e8152b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chez-scheme-examples-10.3.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_chez-scheme-examples;unpack=0"
SRC_URI[x86_64_v2_chez-scheme-examples.sha256sum] = "a255f4087551594dd73d50b35d4d0756b5f0ad0e48bf8580e9bcf5dd88c2f6b8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chez-scheme-10.3.0-3.el10_2.aarch64.rpm;name=aarch64_chez-scheme;unpack=0"
SRC_URI[aarch64_chez-scheme.sha256sum] = "1cc7df3b8f2aab49fd8884216a3156e595dfd2dcd4dae8c9d99dfad639af116d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chez-scheme-devel-10.3.0-3.el10_2.aarch64.rpm;name=aarch64_chez-scheme-devel;unpack=0"
SRC_URI[aarch64_chez-scheme-devel.sha256sum] = "969e4853d88214e6d56a9c0e63ccd4f2e3ee22aac830d05808710ecfbe22ae51"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chez-scheme-examples-10.3.0-3.el10_2.noarch.rpm;name=aarch64_chez-scheme-examples;unpack=0"
SRC_URI[aarch64_chez-scheme-examples.sha256sum] = "172fd26215405fa7950db0133373af8d70d4cf9f5206b500d15207bc66aa46c7"

RDEPENDS:chez-scheme = " \
 glibc \
 lz4-libs \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:chez-scheme-devel = " \
 chez-scheme \
 "
RDEPENDS:chez-scheme-examples = " \
 chez-scheme \
 "
