# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-r"
PV = "1.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-r+default-devel \
 rust-tree-sitter-r-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-r-1.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad2e1912a56ad1c7ebdabec601b7e0d0c15d22f998bbe42d9a6fe1d1a70408c7"

URI_x86_64_v2_rust-tree-sitter-r+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-r+default-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-r+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-r+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-r+default-devel.sha256sum] = "8e6ff51ea85a4fb3e77a47bb0989421b74aa3b7cf8b8bcae705f4079b699c79d"

URI_x86_64_v2_rust-tree-sitter-r-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-r-devel-1.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-r-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-r-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-r-devel.sha256sum] = "eaeb967997e0cc2a1e1ea1c2e8854fee6b854a6e383fc554008e3830fc34411a"

URI_aarch64_rust-tree-sitter-r+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-r+default-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-r+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-r+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-r+default-devel.sha256sum] = "09b37e259e01454b9d2453cd0f54c38835e77e8ab9ebe83397fa38f01bc6b49f"

URI_aarch64_rust-tree-sitter-r-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-r-devel-1.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-r-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-r-devel}"
SRC_URI[aarch64_rust-tree-sitter-r-devel.sha256sum] = "139c6b91d9ae1338aa17c9984c67b4c508191ad780b39b25f82c76f4206f1e06"

RDEPENDS:rust-tree-sitter-r+default-devel = " \
 cargo \
 rust-tree-sitter-r-devel \
 "
RDEPENDS:rust-tree-sitter-r-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
