# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit-kde"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 polkit-kde \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/polkit-kde-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b8682e6b8b5ab3f7f8d15e5f31a24b09633f2eba36c2b3d07de6a4703753ecbd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-kde-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-kde;unpack=0"
SRC_URI[x86_64_v2_polkit-kde.sha256sum] = "23de763de7e7684121825bc5880f557231d1dcad5cd1a8cc149a5ab6b55cb51d"
RPROVIDES:polkit-kde:append:x86_64_v2 = " virtual/PolicyKit-authentication-agent"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/polkit-kde-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_polkit-kde;unpack=0"
SRC_URI[aarch64_polkit-kde.sha256sum] = "c7e7662ff1b25a943eef53f81ad5a425e4730b50f4eb39f3bb05b42e41b01e59"
RPROVIDES:polkit-kde:append:aarch64 = " virtual/PolicyKit-authentication-agent"

RDEPENDS:polkit-kde = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwindowsystem \
 libstdc++ \
 polkit \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
