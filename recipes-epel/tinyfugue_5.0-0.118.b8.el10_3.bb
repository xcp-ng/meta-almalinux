# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinyfugue"
PV = "5.0"
PR = "0.118.b8.el10_3"
PACKAGES = " \
 tinyfugue \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tinyfugue-5.0-0.118.b8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8844d2130c755b8cdab88289d6a5400e3278e32cf719b4064ba6caadb3918cf"

URI_x86_64_v2_tinyfugue = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyfugue-5.0-0.118.b8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyfugue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyfugue}"
SRC_URI[x86_64_v2_tinyfugue.sha256sum] = "7b51a30a6109be8fc310139fe01a1a1b5828b4cded3e85218aa17fae821440ae"

URI_aarch64_tinyfugue = "${EPEL_MIRROR}/aarch64/Packages/t/tinyfugue-5.0-0.118.b8.el10_3.aarch64.rpm;name=aarch64_tinyfugue;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyfugue}"
SRC_URI[aarch64_tinyfugue.sha256sum] = "96e5221b225420d80f21919578deb407c0ba08e12eeaf43439c3584106cd046b"

RDEPENDS:tinyfugue = " \
 glibc \
 ncurses-libs \
 openssl-libs \
 pcre2 \
 "
