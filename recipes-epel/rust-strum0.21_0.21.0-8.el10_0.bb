# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum0.21"
PV = "0.21.0"
PR = "8.el10_0"
PACKAGES = " \
 rust-strum0.21+default-devel \
 rust-strum0.21+derive-devel \
 rust-strum0.21+strum_macros-devel \
 rust-strum0.21-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum0.21-0.21.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3455f6987068e9a2aab6ec7963377ce6e28740803f50ef3ed9628c28c87fc13"

URI_x86_64_v2_rust-strum0.21+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.21+default-devel-0.21.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.21+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.21+default-devel}"
SRC_URI[x86_64_v2_rust-strum0.21+default-devel.sha256sum] = "a715eee8bd75b1317a277a6192c96a27381d351fd5446532c702742c07b8934d"

URI_x86_64_v2_rust-strum0.21+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.21+derive-devel-0.21.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.21+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.21+derive-devel}"
SRC_URI[x86_64_v2_rust-strum0.21+derive-devel.sha256sum] = "37831353e6b08e4d767c9835cb0bc14675c5599c6548c575329a2f9c18384032"

URI_x86_64_v2_rust-strum0.21+strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.21+strum_macros-devel-0.21.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.21+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.21+strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum0.21+strum_macros-devel.sha256sum] = "ea5d0ff181390cc98fcaea73e0e3ac39006f77a7749b2b853efc8ebfeee5b882"

URI_x86_64_v2_rust-strum0.21-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.21-devel-0.21.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.21-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.21-devel}"
SRC_URI[x86_64_v2_rust-strum0.21-devel.sha256sum] = "1c5d30e408b12dcc2f8d1f0e894452232573754b03843231aa1de9f106f19948"

URI_aarch64_rust-strum0.21+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.21+default-devel-0.21.0-8.el10_0.noarch.rpm;name=aarch64_rust-strum0.21+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.21+default-devel}"
SRC_URI[aarch64_rust-strum0.21+default-devel.sha256sum] = "722f3b018add804e8c957a917e6e459b3a84d668cc89c5bbc406bee47578adc5"

URI_aarch64_rust-strum0.21+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.21+derive-devel-0.21.0-8.el10_0.noarch.rpm;name=aarch64_rust-strum0.21+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.21+derive-devel}"
SRC_URI[aarch64_rust-strum0.21+derive-devel.sha256sum] = "fa0f7b42444fa33e8d2acfc9e3419a662c7d9a42bce953ec958752494abc0473"

URI_aarch64_rust-strum0.21+strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.21+strum_macros-devel-0.21.0-8.el10_0.noarch.rpm;name=aarch64_rust-strum0.21+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.21+strum_macros-devel}"
SRC_URI[aarch64_rust-strum0.21+strum_macros-devel.sha256sum] = "80a8a308d695c2adfe23d140eaf3e598cce705524f671cfd190f6050d90adb32"

URI_aarch64_rust-strum0.21-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.21-devel-0.21.0-8.el10_0.noarch.rpm;name=aarch64_rust-strum0.21-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.21-devel}"
SRC_URI[aarch64_rust-strum0.21-devel.sha256sum] = "5c21064bbe5f8ee99dd8070681f39dd23d158b0e53e3b340f359966fe25b57ff"

RDEPENDS:rust-strum0.21+default-devel = " \
 cargo \
 rust-strum0.21-devel \
 "
RDEPENDS:rust-strum0.21+derive-devel = " \
 cargo \
 rust-strum0.21+strum_macros-devel \
 rust-strum0.21-devel \
 "
RDEPENDS:rust-strum0.21+strum_macros-devel = " \
 cargo \
 rust-strum0.21-devel \
 rust-strum_macros0.21+default-devel \
 "
RDEPENDS:rust-strum0.21-devel = " \
 cargo \
 "
