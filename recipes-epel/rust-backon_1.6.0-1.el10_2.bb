# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-backon"
PV = "1.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-backon+default-devel \
 rust-backon+futures-timer-devel \
 rust-backon+futures-timer-sleep-devel \
 rust-backon+std-blocking-sleep-devel \
 rust-backon+std-devel \
 rust-backon+tokio-devel \
 rust-backon+tokio-sleep-devel \
 rust-backon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-backon-1.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9bb6a52eb4697f8108f0ff3cc82af2306bbbaeaa8cea556f87471f324c44ad2"

URI_x86_64_v2_rust-backon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+default-devel-1.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+default-devel}"
SRC_URI[x86_64_v2_rust-backon+default-devel.sha256sum] = "9b0e5b07a97f5d0d9c7d6713c928136395f080385f9ca989a31f10361e2eb7e7"

URI_x86_64_v2_rust-backon+futures-timer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+futures-timer-devel-1.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+futures-timer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+futures-timer-devel}"
SRC_URI[x86_64_v2_rust-backon+futures-timer-devel.sha256sum] = "9c66a8fd62b008dc4d2089390d0c0d20932bd231f21f6342805fdd26c2ed9283"

URI_x86_64_v2_rust-backon+futures-timer-sleep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+futures-timer-sleep-devel-1.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+futures-timer-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+futures-timer-sleep-devel}"
SRC_URI[x86_64_v2_rust-backon+futures-timer-sleep-devel.sha256sum] = "2ce1ef252779b73b5dd152dc2bc3d77a04ec8dfaffe85140b583ebb5c512c04f"

URI_x86_64_v2_rust-backon+std-blocking-sleep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+std-blocking-sleep-devel-1.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+std-blocking-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+std-blocking-sleep-devel}"
SRC_URI[x86_64_v2_rust-backon+std-blocking-sleep-devel.sha256sum] = "d61559dd8591c812e807400373130f87cf210062dd3a832f1f1ed262181c712b"

URI_x86_64_v2_rust-backon+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+std-devel-1.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+std-devel}"
SRC_URI[x86_64_v2_rust-backon+std-devel.sha256sum] = "f8db98e68cb7a9c88f4e02a286af18e7bc0e300c386b335f1840abc40c1301a1"

URI_x86_64_v2_rust-backon+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+tokio-devel-1.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+tokio-devel}"
SRC_URI[x86_64_v2_rust-backon+tokio-devel.sha256sum] = "0ec8702b49fe69fe52b112679c03d2f453cf55974ed587388d2c73969c4d1646"

URI_x86_64_v2_rust-backon+tokio-sleep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+tokio-sleep-devel-1.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+tokio-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+tokio-sleep-devel}"
SRC_URI[x86_64_v2_rust-backon+tokio-sleep-devel.sha256sum] = "8b25c15af8798cae848d2e3b871277ae47c0bca7f7402c2f58541a06fd9c1fdf"

URI_x86_64_v2_rust-backon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon-devel-1.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon-devel}"
SRC_URI[x86_64_v2_rust-backon-devel.sha256sum] = "68b6f7dddbd32b2ef1843e62cb9be975393e3874b1d699f583f100f5e132efc0"

URI_aarch64_rust-backon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+default-devel-1.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-backon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+default-devel}"
SRC_URI[aarch64_rust-backon+default-devel.sha256sum] = "35e7de93b73f537a63ad53f2a4abeeebeae7d991729a430df72255842d1cb1da"

URI_aarch64_rust-backon+futures-timer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+futures-timer-devel-1.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-backon+futures-timer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+futures-timer-devel}"
SRC_URI[aarch64_rust-backon+futures-timer-devel.sha256sum] = "c7f682ac6fc3bb1c52f54cdfe03afd27100da7ee1a2481d38829b6e075708250"

URI_aarch64_rust-backon+futures-timer-sleep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+futures-timer-sleep-devel-1.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-backon+futures-timer-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+futures-timer-sleep-devel}"
SRC_URI[aarch64_rust-backon+futures-timer-sleep-devel.sha256sum] = "2c6be68b6f46edadf4fbffd0cff236841f82791bdb999f751a71d269b3158a28"

URI_aarch64_rust-backon+std-blocking-sleep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+std-blocking-sleep-devel-1.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-backon+std-blocking-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+std-blocking-sleep-devel}"
SRC_URI[aarch64_rust-backon+std-blocking-sleep-devel.sha256sum] = "1e9dcf6c2f5ce3e4862dd4450334c7ee6c1e5ab6cb46ddd4b85703a2cc31e9e9"

URI_aarch64_rust-backon+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+std-devel-1.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-backon+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+std-devel}"
SRC_URI[aarch64_rust-backon+std-devel.sha256sum] = "2615a178ce6a5aa10733b54dcb497305cd3904a1639e34b3de35d947a72f6e60"

URI_aarch64_rust-backon+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+tokio-devel-1.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-backon+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+tokio-devel}"
SRC_URI[aarch64_rust-backon+tokio-devel.sha256sum] = "9b430f0f24a3a205f4f6cc221d2cff5a2635524f8f9956c174e2395073c7aef1"

URI_aarch64_rust-backon+tokio-sleep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+tokio-sleep-devel-1.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-backon+tokio-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+tokio-sleep-devel}"
SRC_URI[aarch64_rust-backon+tokio-sleep-devel.sha256sum] = "c0d1b8a7354e8cdc397e1b9a4d67e5505c3dfcacc9bf002ce0bbcb7f5916bc02"

URI_aarch64_rust-backon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon-devel-1.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-backon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon-devel}"
SRC_URI[aarch64_rust-backon-devel.sha256sum] = "0b43bc073a856ff0004444e711e4914f19a365da0bb6b93860fb518f9d13253a"

RDEPENDS:rust-backon+default-devel = " \
 cargo \
 rust-backon+std-blocking-sleep-devel \
 rust-backon+std-devel \
 rust-backon+tokio-sleep-devel \
 rust-backon-devel \
 "
RDEPENDS:rust-backon+futures-timer-devel = " \
 cargo \
 rust-backon-devel \
 rust-futures-timer+default-devel \
 "
RDEPENDS:rust-backon+futures-timer-sleep-devel = " \
 cargo \
 rust-backon+futures-timer-devel \
 rust-backon-devel \
 "
RDEPENDS:rust-backon+std-blocking-sleep-devel = " \
 cargo \
 rust-backon-devel \
 "
RDEPENDS:rust-backon+std-devel = " \
 cargo \
 rust-backon-devel \
 rust-fastrand+std-devel \
 "
RDEPENDS:rust-backon+tokio-devel = " \
 cargo \
 rust-backon-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-backon+tokio-sleep-devel = " \
 cargo \
 rust-backon-devel \
 rust-tokio+default-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-backon-devel = " \
 cargo \
 rust \
 rust-fastrand-devel \
 "
