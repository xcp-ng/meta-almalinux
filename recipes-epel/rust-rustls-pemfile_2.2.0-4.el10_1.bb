# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-pemfile"
PV = "2.2.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-rustls-pemfile+default-devel \
 rust-rustls-pemfile+std-devel \
 rust-rustls-pemfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-pemfile-2.2.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25ff212472182d4150687ccd72ca90852a67f342cec15fe4c7224e1b026b6629"

URI_x86_64_v2_rust-rustls-pemfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pemfile+default-devel-2.2.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pemfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pemfile+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-pemfile+default-devel.sha256sum] = "3fcb79a832920c50863b4f70bd80bb647e430aeebaf12ec2b660b30783941d0a"

URI_x86_64_v2_rust-rustls-pemfile+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pemfile+std-devel-2.2.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pemfile+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pemfile+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-pemfile+std-devel.sha256sum] = "345c21afe8c158b8db06b536a70ca09e144b8bb90ba9afe3fbf1d278a32cfc45"

URI_x86_64_v2_rust-rustls-pemfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pemfile-devel-2.2.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pemfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pemfile-devel}"
SRC_URI[x86_64_v2_rust-rustls-pemfile-devel.sha256sum] = "6f515502ba3ebc03d7d8a351ee7d440eeb80c46056b1362fc0b418f9813933a4"

URI_aarch64_rust-rustls-pemfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pemfile+default-devel-2.2.0-4.el10_1.noarch.rpm;name=aarch64_rust-rustls-pemfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pemfile+default-devel}"
SRC_URI[aarch64_rust-rustls-pemfile+default-devel.sha256sum] = "7561c8782609f66951677dcc2513280fd8c12af4e32011a5434efe2e5458faca"

URI_aarch64_rust-rustls-pemfile+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pemfile+std-devel-2.2.0-4.el10_1.noarch.rpm;name=aarch64_rust-rustls-pemfile+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pemfile+std-devel}"
SRC_URI[aarch64_rust-rustls-pemfile+std-devel.sha256sum] = "d7a12f1efc3b1e962e8d50736e8e8a43f14b6340f580168ba33a0fbfc2d1a0a2"

URI_aarch64_rust-rustls-pemfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pemfile-devel-2.2.0-4.el10_1.noarch.rpm;name=aarch64_rust-rustls-pemfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pemfile-devel}"
SRC_URI[aarch64_rust-rustls-pemfile-devel.sha256sum] = "7c9ad1418ad4ad289e5824bd28421538848001a947021a0fbab340ba1a494d57"

RDEPENDS:rust-rustls-pemfile+default-devel = " \
 cargo \
 rust-rustls-pemfile+std-devel \
 rust-rustls-pemfile-devel \
 "
RDEPENDS:rust-rustls-pemfile+std-devel = " \
 cargo \
 rust-rustls-pemfile-devel \
 rust-rustls-pki-types+std-devel \
 "
RDEPENDS:rust-rustls-pemfile-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 "
