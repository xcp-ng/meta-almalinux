# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcupsfilters"
PE = "1"
PV = "2.0.0"
PR = "13.el10_2"
PACKAGES = " \
 libcupsfilters \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libcupsfilters-2.0.0-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c9c857e475b629be4abe6c1b75ec248a90362fa3784a62a94a2046a066ea71a"

URI_x86_64_v2_libcupsfilters = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcupsfilters-2.0.0-13.el10_2.x86_64_v2.rpm;name=x86_64_v2_libcupsfilters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcupsfilters}"
SRC_URI[x86_64_v2_libcupsfilters.sha256sum] = "4278b3da47132cb9285f3f50bc35b3173b58aed9d65a5e4a9de8e139bad6bebd"

URI_aarch64_libcupsfilters = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcupsfilters-2.0.0-13.el10_2.aarch64.rpm;name=aarch64_libcupsfilters;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcupsfilters}"
SRC_URI[aarch64_libcupsfilters.sha256sum] = "650495fc44c0f4e05c0c8f3d1a67ece6b91aa52c4db1633f2ba8231493362ae7"

RDEPENDS:libcupsfilters = " \
 colord \
 cups-filesystem \
 cups-libs \
 dbus-libs \
 fontconfig \
 ghostscript \
 glibc \
 lcms2 \
 libexif \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 poppler-cpp \
 qpdf-libs \
 "
