# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-control-center"
PV = "47.7"
PR = "1.el10"
PACKAGES = " \
 gnome-control-center \
 gnome-control-center-filesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-control-center-47.7-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48ef0fc75d8e7c1e4e68c48f943a81b6224d547fba3903b90192dae3ca070fc6"

URI_x86_64_v2_gnome-control-center = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-control-center-47.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-control-center;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-control-center}"
SRC_URI[x86_64_v2_gnome-control-center.sha256sum] = "3b9e1dbcecab4d0c16ddfb2a3f4b97093c927ed8a60be465d3e2f99daee74523"

URI_x86_64_v2_gnome-control-center-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-control-center-filesystem-47.7-1.el10.noarch.rpm;name=x86_64_v2_gnome-control-center-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-control-center-filesystem}"
SRC_URI[x86_64_v2_gnome-control-center-filesystem.sha256sum] = "10f02bcbfc4bf92b10bda6d85303d014cc24c8cb2502cfa6ebff9a4e1e0fb3b3"

URI_aarch64_gnome-control-center = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-control-center-47.7-1.el10.aarch64.rpm;name=aarch64_gnome-control-center;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-control-center}"
SRC_URI[aarch64_gnome-control-center.sha256sum] = "79572c80d1c9172d9edf050ecadb62d7caa254f3a131149f90fd4598b012be51"

URI_aarch64_gnome-control-center-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-control-center-filesystem-47.7-1.el10.noarch.rpm;name=aarch64_gnome-control-center-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-control-center-filesystem}"
SRC_URI[aarch64_gnome-control-center-filesystem.sha256sum] = "10f02bcbfc4bf92b10bda6d85303d014cc24c8cb2502cfa6ebff9a4e1e0fb3b3"

RDEPENDS:gnome-control-center = " \
 ModemManager-glib \
 NetworkManager-libnm \
 accountsservice \
 accountsservice-libs \
 alsa-lib \
 cairo \
 colord \
 colord-gtk4 \
 colord-libs \
 cups-libs \
 cups-pk-helper \
 dbus \
 fontconfig \
 gcr-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-bluetooth-libs \
 gnome-control-center-filesystem \
 gnome-desktop4 \
 gnome-online-accounts \
 gnome-settings-daemon \
 gnutls \
 graphene \
 gsettings-desktop-schemas \
 gsound \
 gtk4 \
 ibus-libs \
 iso-codes \
 json-glib \
 krb5-libs \
 libX11 \
 libXi \
 libadwaita \
 libepoxy \
 libgcc \
 libgtop2 \
 libgudev \
 libnma-gtk4 \
 libpwquality \
 libsecret \
 libsmbclient \
 libsoup3 \
 libudisks2 \
 libwacom \
 libxml2 \
 pango \
 pkgconf-pkg-config \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 tecla \
 upower \
 upower-libs \
 "
RDEPENDS:gnome-control-center-filesystem = " \
 "
