# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksanecore"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ksanecore \
 ksanecore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksanecore-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d4b84eafd2158eabe9ed8a6d0b1d5969354f5f4a0b6f0541aa97aff0ee96914"

URI_x86_64_v2_ksanecore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksanecore-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksanecore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksanecore}"
SRC_URI[x86_64_v2_ksanecore.sha256sum] = "20f13047a09cb94925a2681d56a5ba5a3a6b1b75ee5251cdc4423fec1c3a5438"

URI_x86_64_v2_ksanecore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksanecore-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksanecore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksanecore-devel}"
SRC_URI[x86_64_v2_ksanecore-devel.sha256sum] = "c7ed4fea58117943c435a92145d4cc0d6f9fdd4f966768d23f994c214061d739"

URI_aarch64_ksanecore = "${EPEL_MIRROR}/aarch64/Packages/k/ksanecore-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ksanecore;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksanecore}"
SRC_URI[aarch64_ksanecore.sha256sum] = "e9941a807e7ef84192739cb7d92ecd164e281fcbae52346c4990605b49c3d112"

URI_aarch64_ksanecore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ksanecore-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ksanecore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksanecore-devel}"
SRC_URI[aarch64_ksanecore-devel.sha256sum] = "a03e836cdc7f21d3e86b5f5696fa3f7bea67cc72ede080232f1bbec98dfe4644"

RDEPENDS:ksanecore = " \
 glibc \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 sane-backends-libs \
 "
RDEPENDS:ksanecore-devel = " \
 cmake-filesystem \
 ksanecore \
 qt6-qtbase-devel \
 "
