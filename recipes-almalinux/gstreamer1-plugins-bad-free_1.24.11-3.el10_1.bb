# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-bad-free"
PV = "1.24.11"
PR = "3.el10_1"
PACKAGES = " \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-bad-free-devel \
 gstreamer1-plugins-bad-free-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-bad-free-1.24.11-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cc3fa62e8a2b06bf20731604ef9b17e7b6adeb4affff6d763d25b69aec34ffc"

URI_x86_64_v2_gstreamer1-plugins-bad-free = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-1.24.11-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free.sha256sum] = "ee5f638f83764973c23b66a6760fb0486d888fe6cce248421faa1365acf99896"

URI_x86_64_v2_gstreamer1-plugins-bad-free-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-devel-1.24.11-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free-devel}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free-devel.sha256sum] = "c7729f1b3ca3f71fa73c3c6581e626a6d7c6b07d00408880c882eed3c687555b"

URI_x86_64_v2_gstreamer1-plugins-bad-free-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-libs-1.24.11-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free-libs}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free-libs.sha256sum] = "8977b7b1c1d6d7cc7f52036aa765f52291489ac329dbc94b92b7405f8722e049"

URI_aarch64_gstreamer1-plugins-bad-free = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-bad-free-1.24.11-3.el10_1.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free.sha256sum] = "4054f2340ced3518f1897262efd17859bfe949e64037aaab61f559a3c1654d78"

URI_aarch64_gstreamer1-plugins-bad-free-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gstreamer1-plugins-bad-free-devel-1.24.11-3.el10_1.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free-devel}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free-devel.sha256sum] = "3920bd8e5276244b4e1ad8c553cf4c01b85f8ca0b6aab288a3867c0aef395c31"

URI_aarch64_gstreamer1-plugins-bad-free-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-bad-free-libs-1.24.11-3.el10_1.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free-libs}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free-libs.sha256sum] = "fed60443c8904c618c9a2a9b83fbf1ec532cf24be9ec9d825cda9c47ae3aa2c3"

RDEPENDS:gstreamer1-plugins-bad-free = " \
 bzip2-libs \
 cairo \
 fdk-aac-free \
 glib2 \
 glibc \
 gsm \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk3 \
 json-glib \
 lcms2 \
 libdrm \
 libdvdnav \
 libdvdread \
 libgcc \
 libgudev \
 liblc3 \
 librsvg2 \
 libsndfile \
 libsrtp \
 libstdc++ \
 libusb1 \
 libva \
 libwayland-client \
 libwebp \
 libxml2 \
 openssl-libs \
 opus \
 orc \
 pango \
 soundtouch \
 vulkan-loader \
 webrtc-audio-processing \
 "
RDEPENDS:gstreamer1-plugins-bad-free-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-bad-free-devel \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base-devel \
 libdrm-devel \
 libva-devel \
 pkgconf-pkg-config \
 vulkan-loader-devel \
 wayland-devel \
 "
RDEPENDS:gstreamer1-plugins-bad-free-libs = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libdrm \
 libgcc \
 libstdc++ \
 libva \
 libwayland-client \
 vulkan-loader \
 "
