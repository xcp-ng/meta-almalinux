# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-builder"
PV = "3.3.0"
PR = "3.el10_2"
PACKAGES = " \
 rubygem-builder \
 rubygem-builder-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-builder-3.3.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ab68685bf6137fe26e0ff4d2f78aeefb5856f218e13be45542b2aff2f52a508"

URI_x86_64_v2_rubygem-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-builder-3.3.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-builder}"
SRC_URI[x86_64_v2_rubygem-builder.sha256sum] = "f6af2c1924d1f9018650b52954d53111b73c4e6f62bac25fb2ed9f74544a0f62"

URI_x86_64_v2_rubygem-builder-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-builder-doc-3.3.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-builder-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-builder-doc}"
SRC_URI[x86_64_v2_rubygem-builder-doc.sha256sum] = "c2ae9767386753774105f156752f1b27908184f2d792b95429547f34aa8e407b"

URI_aarch64_rubygem-builder = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-builder-3.3.0-3.el10_2.noarch.rpm;name=aarch64_rubygem-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-builder}"
SRC_URI[aarch64_rubygem-builder.sha256sum] = "36a14fc44fe0fe9378bb1d2426a578b7b98707ca48ea7e0d8719085a24581e73"

URI_aarch64_rubygem-builder-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-builder-doc-3.3.0-3.el10_2.noarch.rpm;name=aarch64_rubygem-builder-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-builder-doc}"
SRC_URI[aarch64_rubygem-builder-doc.sha256sum] = "801c0a9b146116b29c04b7748a1dad769e75ed3be4b99b837734a7fbdd6e2b45"

RDEPENDS:rubygem-builder = " \
 rubygems \
 "
RDEPENDS:rubygem-builder-doc = " \
 rubygem-builder \
 "
