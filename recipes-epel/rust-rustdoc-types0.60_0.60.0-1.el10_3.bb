# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustdoc-types0.60"
PV = "0.60.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustdoc-types0.60+default-devel \
 rust-rustdoc-types0.60+rkyv_0_8-devel \
 rust-rustdoc-types0.60+rustc-hash-devel \
 rust-rustdoc-types0.60-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustdoc-types0.60-0.60.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1042e1b7c1f0f7e593e11dc6985ca925c418db0782e7eb5c164784b49bf3658f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types0.60+default-devel-0.60.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types0.60+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types0.60+default-devel.sha256sum] = "d0a46396414fd1af4fc2f36b730f7a7c7f72e2d40b5fe5e3f2d9448d583c07f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types0.60+rkyv_0_8-devel-0.60.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types0.60+rkyv_0_8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types0.60+rkyv_0_8-devel.sha256sum] = "47b5af94557b6283d7965c486daa693e8a06f486d8104442c53cb11007d23dc4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types0.60+rustc-hash-devel-0.60.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types0.60+rustc-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types0.60+rustc-hash-devel.sha256sum] = "231be1a4d6e470860d2c929f92c59e8e8d3740142de92376ef463b7be197da96"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types0.60-devel-0.60.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types0.60-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types0.60-devel.sha256sum] = "990db6a0000f9e49021ac959a402c24eaacfc3f60feb3175ad1ece1b7533b9e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types0.60+default-devel-0.60.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types0.60+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types0.60+default-devel.sha256sum] = "5bb643101ae90c5ccad3fd1dd1e541f99bf88a1489e322016bcbe4518970f168"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types0.60+rkyv_0_8-devel-0.60.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types0.60+rkyv_0_8-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types0.60+rkyv_0_8-devel.sha256sum] = "18d12ebebbd87ad4b9b4a3967584b4f39b33973f09c5380dbb59649493786f6f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types0.60+rustc-hash-devel-0.60.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types0.60+rustc-hash-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types0.60+rustc-hash-devel.sha256sum] = "847faf10ac969ba6e941b79f96911a6394b0be3e3a7499fb3b2487e54573860c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types0.60-devel-0.60.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types0.60-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types0.60-devel.sha256sum] = "c4c4340f5bec5409f5b7f40f6b530167a483986a984d5efa4ba70a3366cd5e04"

RDEPENDS:rust-rustdoc-types0.60+default-devel = " \
 cargo \
 rust-rustdoc-types0.60-devel \
 "
RDEPENDS:rust-rustdoc-types0.60+rkyv_0_8-devel = " \
 cargo \
 rust-rkyv+default-devel \
 rust-rustdoc-types0.60-devel \
 "
RDEPENDS:rust-rustdoc-types0.60+rustc-hash-devel = " \
 cargo \
 rust-rustc-hash+default-devel \
 rust-rustdoc-types0.60-devel \
 "
RDEPENDS:rust-rustdoc-types0.60-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
