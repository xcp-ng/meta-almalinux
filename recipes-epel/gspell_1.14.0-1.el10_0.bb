# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gspell"
PV = "1.14.0"
PR = "1.el10_0"
PACKAGES = " \
 gspell \
 gspell-devel \
 gspell-doc \
 gspell-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gspell-1.14.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4d699e05053a5bf3bc1e0993b9644fbb572a46b484ad259199ae097a4643f4f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gspell-1.14.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gspell;unpack=0"
SRC_URI[x86_64_v2_gspell.sha256sum] = "8811f2cb470c942d2826fb0916a3cd47f6ac084b51bf9fd28f8b8c81672ccc68"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gspell-devel-1.14.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gspell-devel;unpack=0"
SRC_URI[x86_64_v2_gspell-devel.sha256sum] = "65cff3b83c4e7d07517983059f0dcab7a73689f78b9f114a788365592d0db2e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gspell-doc-1.14.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gspell-doc;unpack=0"
SRC_URI[x86_64_v2_gspell-doc.sha256sum] = "64b1591e0f6c2cff43775ee39ad3600f215e232c59bf3d1124ba4f32545b8f0d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gspell-tests-1.14.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gspell-tests;unpack=0"
SRC_URI[x86_64_v2_gspell-tests.sha256sum] = "9e19cd45b64dc25955865fcded02cd64eccba0ee895de8812161b6eb3436d7e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gspell-1.14.0-1.el10_0.aarch64.rpm;name=aarch64_gspell;unpack=0"
SRC_URI[aarch64_gspell.sha256sum] = "86fd4583e279f8d9c58c4424e788618800ab61bc192cd030b4ae789c2ecc4e2d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gspell-devel-1.14.0-1.el10_0.aarch64.rpm;name=aarch64_gspell-devel;unpack=0"
SRC_URI[aarch64_gspell-devel.sha256sum] = "2f2047f11080afaee558266f8f1374c7af8dd55e963b6543fcf79aaed811560f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gspell-doc-1.14.0-1.el10_0.noarch.rpm;name=aarch64_gspell-doc;unpack=0"
SRC_URI[aarch64_gspell-doc.sha256sum] = "1af0e3ebaf8b89b481aa4c417c0b81ce12c52c7d195aa6d0831e9260597d3c8e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gspell-tests-1.14.0-1.el10_0.aarch64.rpm;name=aarch64_gspell-tests;unpack=0"
SRC_URI[aarch64_gspell-tests.sha256sum] = "548e2babeb630778f3aa73ef5b96ac6ff33e9feb6a09daddfb236f8432ec2a57"

RDEPENDS:gspell = " \
 enchant2 \
 glib2 \
 glibc \
 gtk3 \
 iso-codes \
 libicu \
 pango \
 "
RDEPENDS:gspell-devel = " \
 enchant2-devel \
 glib2 \
 glib2-devel \
 glibc \
 gspell \
 gtk3 \
 gtk3-devel \
 libicu-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gspell-doc = " \
 gspell \
 "
RDEPENDS:gspell-tests = " \
 enchant2 \
 glib2 \
 glibc \
 gspell \
 gtk3 \
 libicu \
 pango \
 "
