# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-aliyun-oss"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-reqsign-aliyun-oss+default-devel \
 rust-reqsign-aliyun-oss-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-aliyun-oss-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ccd8c0a17fa4af5a2c79d5772730a95618767d45ad9204020f32ca0a64ade97"

URI_x86_64_v2_rust-reqsign-aliyun-oss+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aliyun-oss+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aliyun-oss+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aliyun-oss+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aliyun-oss+default-devel.sha256sum] = "231b7cf2db5a1a5a9b353daa3df6af972d46a2446cba84416ba2c31b20dd7bf7"

URI_x86_64_v2_rust-reqsign-aliyun-oss-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aliyun-oss-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aliyun-oss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aliyun-oss-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aliyun-oss-devel.sha256sum] = "2402c9e5c7dbc9432c181c8eda38d4bfda3c0ba71b7c92e7fc6600e89619f3d3"

URI_aarch64_rust-reqsign-aliyun-oss+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aliyun-oss+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-aliyun-oss+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aliyun-oss+default-devel}"
SRC_URI[aarch64_rust-reqsign-aliyun-oss+default-devel.sha256sum] = "3bafec4643e8d6f7d489e702f9bcad8bc02f61b8605822dd904d8788f61ad83e"

URI_aarch64_rust-reqsign-aliyun-oss-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aliyun-oss-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-aliyun-oss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aliyun-oss-devel}"
SRC_URI[aarch64_rust-reqsign-aliyun-oss-devel.sha256sum] = "93865ec3e3d7b5211240fbc83a49f5b69f8ed73622e233ddd453d98fd01b3288"

RDEPENDS:rust-reqsign-aliyun-oss+default-devel = " \
 cargo \
 rust-reqsign-aliyun-oss-devel \
 "
RDEPENDS:rust-reqsign-aliyun-oss-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqwest+json-devel \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
