# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook"
PV = "0.3.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-signal-hook+cc-devel \
 rust-signal-hook+channel-devel \
 rust-signal-hook+default-devel \
 rust-signal-hook+extended-siginfo-devel \
 rust-signal-hook+extended-siginfo-raw-devel \
 rust-signal-hook+iterator-devel \
 rust-signal-hook-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook-0.3.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ecde35871450f9d826c17b016a22116cf99a5895f19339df48076e34e432776"

URI_x86_64_v2_rust-signal-hook+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+cc-devel-0.3.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+cc-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+cc-devel.sha256sum] = "26fc902e0ad4e9fc4a877011d8bc9dd68f529abae11f60531063df9946f798a3"

URI_x86_64_v2_rust-signal-hook+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+channel-devel-0.3.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+channel-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+channel-devel.sha256sum] = "0d26e1683a5ebedd3d54015cf29b0add3a30d37bd1f08b00947ffad4ddf2bd92"

URI_x86_64_v2_rust-signal-hook+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+default-devel-0.3.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+default-devel.sha256sum] = "d48cbeb05c0e33b8ab387722398f2b29e44e3ed1a33d0f2802e0a4806ad43dfe"

URI_x86_64_v2_rust-signal-hook+extended-siginfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+extended-siginfo-devel-0.3.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+extended-siginfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+extended-siginfo-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+extended-siginfo-devel.sha256sum] = "00c6d3c5452404683250647519f0e8e0e1f524d686c1e8cd41ddb94581da0fcb"

URI_x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+extended-siginfo-raw-devel-0.3.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+extended-siginfo-raw-devel.sha256sum] = "44231bab311fcfd9f89b56d9ff2f008a9954bf2dde667a4c484b2568d5575a9d"

URI_x86_64_v2_rust-signal-hook+iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook+iterator-devel-0.3.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook+iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook+iterator-devel}"
SRC_URI[x86_64_v2_rust-signal-hook+iterator-devel.sha256sum] = "2fc730cf0ec6d0eb9185cf5974883a3306271a07a825d95b13cc8a5739e3d759"

URI_x86_64_v2_rust-signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-devel-0.3.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-devel.sha256sum] = "0966baf7d6b2b35841ae277cc3976702bc6d5e22279d368094fe6b6acfb4aa00"

URI_aarch64_rust-signal-hook+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+cc-devel-0.3.18-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+cc-devel}"
SRC_URI[aarch64_rust-signal-hook+cc-devel.sha256sum] = "d87319541aa183c63f67fd27e2d2639952406aab462d9c79708fd225b286acdd"

URI_aarch64_rust-signal-hook+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+channel-devel-0.3.18-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+channel-devel}"
SRC_URI[aarch64_rust-signal-hook+channel-devel.sha256sum] = "2d7c59c6d66bc56cd1ed1daeb1b919bcf770c5210162f3b7cd07b5536ddd18e8"

URI_aarch64_rust-signal-hook+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+default-devel-0.3.18-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+default-devel}"
SRC_URI[aarch64_rust-signal-hook+default-devel.sha256sum] = "76fcf50cb0026568bf28142e5eaa85a6d655f1e66d26181af5da6f5e614f80ae"

URI_aarch64_rust-signal-hook+extended-siginfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+extended-siginfo-devel-0.3.18-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook+extended-siginfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+extended-siginfo-devel}"
SRC_URI[aarch64_rust-signal-hook+extended-siginfo-devel.sha256sum] = "f4baf0bc515d16652b96a91e2f4c39506c540c7a7e85807c03009faccc43f229"

URI_aarch64_rust-signal-hook+extended-siginfo-raw-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+extended-siginfo-raw-devel-0.3.18-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook+extended-siginfo-raw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+extended-siginfo-raw-devel}"
SRC_URI[aarch64_rust-signal-hook+extended-siginfo-raw-devel.sha256sum] = "dfb90a5e45844291ca823dc5e8cc3373b2ecc7317054ef4b92515353af16123c"

URI_aarch64_rust-signal-hook+iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook+iterator-devel-0.3.18-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook+iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook+iterator-devel}"
SRC_URI[aarch64_rust-signal-hook+iterator-devel.sha256sum] = "968931ab420117b42b810e055439d63b96db92de0128dc267914f552f3e103af"

URI_aarch64_rust-signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-devel-0.3.18-1.el10_1.noarch.rpm;name=aarch64_rust-signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-devel}"
SRC_URI[aarch64_rust-signal-hook-devel.sha256sum] = "5ebd4a01583269a6be7861c0c8198b5f8a11842aef1f97c7a0b4cfa3739287da"

RDEPENDS:rust-signal-hook+cc-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+channel-devel = " \
 cargo \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+default-devel = " \
 cargo \
 rust-signal-hook+channel-devel \
 rust-signal-hook+iterator-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+extended-siginfo-devel = " \
 cargo \
 rust-signal-hook+channel-devel \
 rust-signal-hook+extended-siginfo-raw-devel \
 rust-signal-hook+iterator-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+extended-siginfo-raw-devel = " \
 cargo \
 rust-signal-hook+cc-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook+iterator-devel = " \
 cargo \
 rust-signal-hook+channel-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-signal-hook-devel = " \
 bash \
 cargo \
 rust-libc+default-devel \
 rust-signal-hook-registry+default-devel \
 "
