# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum"
PV = "0.27.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-strum+phf-devel \
 rust-strum+std-devel \
 rust-strum+strum_macros-devel \
 rust-strum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum-0.27.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ce473b381cfd9814c729d0a3d15ad24db7317e58501315267a19ae00cabc3a8"

URI_x86_64_v2_rust-strum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+default-devel-0.27.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+default-devel}"
SRC_URI[x86_64_v2_rust-strum+default-devel.sha256sum] = "4f25453e8c23ec5637b2318436ae18e47426a3e0194b718bd210532a4713fd9e"

URI_x86_64_v2_rust-strum+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+derive-devel-0.27.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+derive-devel}"
SRC_URI[x86_64_v2_rust-strum+derive-devel.sha256sum] = "2e158715a3f36df9bd5e10007829c44082d4da2d9d4d4112abb2d1da6fab10dc"

URI_x86_64_v2_rust-strum+phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+phf-devel-0.27.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+phf-devel}"
SRC_URI[x86_64_v2_rust-strum+phf-devel.sha256sum] = "3443028daa3854ab31b61a342d6a67e41cf2080ac69eed13a1f2e2edab17655d"

URI_x86_64_v2_rust-strum+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+std-devel-0.27.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+std-devel}"
SRC_URI[x86_64_v2_rust-strum+std-devel.sha256sum] = "aa3d1a926476354eea83ddc4ad5df0cee5be4df24832f2660e0ede2528d54b1d"

URI_x86_64_v2_rust-strum+strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+strum_macros-devel-0.27.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum+strum_macros-devel.sha256sum] = "67b2fe022012d9f046ce6737860f5546eae280f97a72391f22c5169233f0be53"

URI_x86_64_v2_rust-strum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum-devel-0.27.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum-devel}"
SRC_URI[x86_64_v2_rust-strum-devel.sha256sum] = "c707afeea3141ed88d5bb30dc8fbce67c3bab78b6b778885cd4717e5f013064e"

URI_aarch64_rust-strum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+default-devel-0.27.1-1.el10_1.noarch.rpm;name=aarch64_rust-strum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+default-devel}"
SRC_URI[aarch64_rust-strum+default-devel.sha256sum] = "70094a04aafe68a0e724064f340e5369a865f41fc30139c13a8a57c60134a5a6"

URI_aarch64_rust-strum+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+derive-devel-0.27.1-1.el10_1.noarch.rpm;name=aarch64_rust-strum+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+derive-devel}"
SRC_URI[aarch64_rust-strum+derive-devel.sha256sum] = "58678ba3715ddbea3bd62d7316765c633ed10bd7b6b365d0cdef90dbf7de0b8e"

URI_aarch64_rust-strum+phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+phf-devel-0.27.1-1.el10_1.noarch.rpm;name=aarch64_rust-strum+phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+phf-devel}"
SRC_URI[aarch64_rust-strum+phf-devel.sha256sum] = "eeb9a11781b3db9edc7a3493da45a40fd1d8cfdd11b9e5246fec294802753b28"

URI_aarch64_rust-strum+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+std-devel-0.27.1-1.el10_1.noarch.rpm;name=aarch64_rust-strum+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+std-devel}"
SRC_URI[aarch64_rust-strum+std-devel.sha256sum] = "4fe0ce47af5b126d5c3a0a215731cc3e36b00a3df6d8fe3972b89d87e5f6eea3"

URI_aarch64_rust-strum+strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+strum_macros-devel-0.27.1-1.el10_1.noarch.rpm;name=aarch64_rust-strum+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+strum_macros-devel}"
SRC_URI[aarch64_rust-strum+strum_macros-devel.sha256sum] = "6054e1261be9667ec44e8b45f98a4bc8826a03dfbdf1c99f2c762ca363a1305d"

URI_aarch64_rust-strum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum-devel-0.27.1-1.el10_1.noarch.rpm;name=aarch64_rust-strum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum-devel}"
SRC_URI[aarch64_rust-strum-devel.sha256sum] = "c9b9caae743f6edb0c220cbdcae1315f9bd93a0696d2524b111c0a96c07cc830"

RDEPENDS:rust-strum+default-devel = " \
 cargo \
 rust-strum+std-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+derive-devel = " \
 cargo \
 rust-strum+strum_macros-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+phf-devel = " \
 cargo \
 rust-phf+default-devel \
 rust-phf+macros-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+std-devel = " \
 cargo \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+strum_macros-devel = " \
 cargo \
 rust-strum-devel \
 rust-strum_macros+default-devel \
 "
RDEPENDS:rust-strum-devel = " \
 cargo \
 rust \
 "
