# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hash32_0.2"
PV = "0.2.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-hash32_0.2+default-devel \
 rust-hash32_0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hash32_0.2-0.2.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87faca69583a78219f8f907d5e0141868caf7ddc69cf31751fd9654e925b0ab7"

URI_x86_64_v2_rust-hash32_0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hash32_0.2+default-devel-0.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hash32_0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hash32_0.2+default-devel}"
SRC_URI[x86_64_v2_rust-hash32_0.2+default-devel.sha256sum] = "4574b59b3f98af14bb2b43dcbba14da31a9e0c7e32d9f0023c4a8a66edfe7529"

URI_x86_64_v2_rust-hash32_0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hash32_0.2-devel-0.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hash32_0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hash32_0.2-devel}"
SRC_URI[x86_64_v2_rust-hash32_0.2-devel.sha256sum] = "abb51a9b66845940114eddf65b08566cd6799f030cb5c71df983c0a9e1b85e53"

URI_aarch64_rust-hash32_0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hash32_0.2+default-devel-0.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-hash32_0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hash32_0.2+default-devel}"
SRC_URI[aarch64_rust-hash32_0.2+default-devel.sha256sum] = "f2c29081bb1c145d0045aea0641a69f443fc5a6d4652ae5d0affa4d615fe6f61"

URI_aarch64_rust-hash32_0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hash32_0.2-devel-0.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-hash32_0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hash32_0.2-devel}"
SRC_URI[aarch64_rust-hash32_0.2-devel.sha256sum] = "e84c0cf3d00c733642f9ec1ac453b68dea008b79222757e0aff1c3ddec0ac3c5"

RDEPENDS:rust-hash32_0.2+default-devel = " \
 cargo \
 rust-hash32_0.2-devel \
 "
RDEPENDS:rust-hash32_0.2-devel = " \
 cargo \
 rust-byteorder-devel \
 "
