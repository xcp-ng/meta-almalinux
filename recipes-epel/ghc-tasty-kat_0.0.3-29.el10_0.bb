# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tasty-kat"
PV = "0.0.3"
PR = "29.el10_0"
PACKAGES = " \
 ghc-tasty-kat \
 ghc-tasty-kat-devel \
 ghc-tasty-kat-doc \
 ghc-tasty-kat-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tasty-kat-0.0.3-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5a102ee7c0690759ab626573e91fbc042456cd697d5271ba3cfdee0adde203f"

URI_x86_64_v2_ghc-tasty-kat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-kat-0.0.3-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-kat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-kat}"
SRC_URI[x86_64_v2_ghc-tasty-kat.sha256sum] = "9e18c83ecaf217d79511f1570449ac5a44b1c358c6f961c0d269b1ee4a1598fa"

URI_x86_64_v2_ghc-tasty-kat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-kat-devel-0.0.3-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-kat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-kat-devel}"
SRC_URI[x86_64_v2_ghc-tasty-kat-devel.sha256sum] = "9402e05422ed16b63bd23069edc702937500f892f830712c013b8f3ca99f8c0d"

URI_x86_64_v2_ghc-tasty-kat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-kat-doc-0.0.3-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tasty-kat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-kat-doc}"
SRC_URI[x86_64_v2_ghc-tasty-kat-doc.sha256sum] = "7e67996560b59229542a15ff0e62b9a7f4a11856ef165d4f199fff4a96951c2f"

URI_x86_64_v2_ghc-tasty-kat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-kat-prof-0.0.3-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-kat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-kat-prof}"
SRC_URI[x86_64_v2_ghc-tasty-kat-prof.sha256sum] = "e0f2f4ced88aac64beb13896e2de279d0679d1cc13369492f60df6653c0ee412"

URI_aarch64_ghc-tasty-kat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-kat-0.0.3-29.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-kat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-kat}"
SRC_URI[aarch64_ghc-tasty-kat.sha256sum] = "ee6604d6af5fd74e086f2a318e78b0506943ef40a2f0eab21d9344fb6a242c78"

URI_aarch64_ghc-tasty-kat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-kat-devel-0.0.3-29.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-kat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-kat-devel}"
SRC_URI[aarch64_ghc-tasty-kat-devel.sha256sum] = "4d29b444ebf45787d44becd61b1fc46c6850ea0ad39311d18fb4d71856c0ebaf"

URI_aarch64_ghc-tasty-kat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-kat-doc-0.0.3-29.el10_0.noarch.rpm;name=aarch64_ghc-tasty-kat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-kat-doc}"
SRC_URI[aarch64_ghc-tasty-kat-doc.sha256sum] = "054f3eeb6c1f041e1c78a3043b14ce7e2c31a0690898a6979b615fe1e706afcb"

URI_aarch64_ghc-tasty-kat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-kat-prof-0.0.3-29.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-kat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-kat-prof}"
SRC_URI[aarch64_ghc-tasty-kat-prof.sha256sum] = "2a48cefd218be9e31e1c3e843b4911326bcca922e50e7e35146e8b43c8b6cc77"

RDEPENDS:ghc-tasty-kat = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-optparse-applicative \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-process \
 ghc-stm \
 ghc-tagged \
 ghc-tasty \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tasty-kat-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-tasty-devel \
 ghc-tasty-kat \
 "
RDEPENDS:ghc-tasty-kat-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tasty-kat-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-tasty-kat-devel \
 ghc-tasty-prof \
 "
