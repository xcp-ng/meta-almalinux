# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossterm"
PV = "0.28.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-crossterm+bracketed-paste-devel \
 rust-crossterm+default-devel \
 rust-crossterm+event-stream-devel \
 rust-crossterm+events-devel \
 rust-crossterm+filedescriptor-devel \
 rust-crossterm+libc-devel \
 rust-crossterm+serde-devel \
 rust-crossterm+use-dev-tty-devel \
 rust-crossterm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossterm-0.28.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95927ab223258b9f68ae3e8aa88fd06b401c50ef4455bc352ec6bf43ad87d323"

URI_x86_64_v2_rust-crossterm+bracketed-paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+bracketed-paste-devel-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+bracketed-paste-devel}"
SRC_URI[x86_64_v2_rust-crossterm+bracketed-paste-devel.sha256sum] = "868f1298bd7a6fb4a5a8e914f867c8db6a5c595d7a9304e96785bdf988f82b2a"

URI_x86_64_v2_rust-crossterm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+default-devel-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+default-devel}"
SRC_URI[x86_64_v2_rust-crossterm+default-devel.sha256sum] = "2c6c0c9ed911411d256d878c043bf40510c1a82f79851763cccf966c1dcfcce3"

URI_x86_64_v2_rust-crossterm+event-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+event-stream-devel-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+event-stream-devel}"
SRC_URI[x86_64_v2_rust-crossterm+event-stream-devel.sha256sum] = "d8076a7db44d1350c5c1dc2604daf07c18c32f091149f1ea261a2348166ca47e"

URI_x86_64_v2_rust-crossterm+events-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+events-devel-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+events-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+events-devel}"
SRC_URI[x86_64_v2_rust-crossterm+events-devel.sha256sum] = "e2c03423ae946a5048388901d0b6a0f0edd172d93d0755e78d49347987769234"

URI_x86_64_v2_rust-crossterm+filedescriptor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+filedescriptor-devel-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+filedescriptor-devel}"
SRC_URI[x86_64_v2_rust-crossterm+filedescriptor-devel.sha256sum] = "8ce8c6c30c1c3d583cdc42b4eabf4932804e844851da2e629c72e8d5277f91ca"

URI_x86_64_v2_rust-crossterm+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+libc-devel-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+libc-devel}"
SRC_URI[x86_64_v2_rust-crossterm+libc-devel.sha256sum] = "173e82c14a65a679b4db5d3dc80540bc2063f5ca03e90c3d4461a50b60d721bb"

URI_x86_64_v2_rust-crossterm+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+serde-devel-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+serde-devel}"
SRC_URI[x86_64_v2_rust-crossterm+serde-devel.sha256sum] = "b651aeaa59f76bbae7484ff2dba3461ff91186e6fb07cfae699be86529f390b7"

URI_x86_64_v2_rust-crossterm+use-dev-tty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm+use-dev-tty-devel-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm+use-dev-tty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm+use-dev-tty-devel}"
SRC_URI[x86_64_v2_rust-crossterm+use-dev-tty-devel.sha256sum] = "e6c695541a790b85d94bdf840b490a4535cf0de03dffd60536689745b5d855f8"

URI_x86_64_v2_rust-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm-devel-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm-devel}"
SRC_URI[x86_64_v2_rust-crossterm-devel.sha256sum] = "ec3205b0f8bd21425057a3e3503105854135b0a4b27bda8d777dab9bf309b9c2"

URI_aarch64_rust-crossterm+bracketed-paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+bracketed-paste-devel-0.28.1-2.el10_0.noarch.rpm;name=aarch64_rust-crossterm+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+bracketed-paste-devel}"
SRC_URI[aarch64_rust-crossterm+bracketed-paste-devel.sha256sum] = "477a0f93a099d36d6a81fc8d033e3d9547c76826d8a1d6e60c5b6bd6616ec9d1"

URI_aarch64_rust-crossterm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+default-devel-0.28.1-2.el10_0.noarch.rpm;name=aarch64_rust-crossterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+default-devel}"
SRC_URI[aarch64_rust-crossterm+default-devel.sha256sum] = "83fcebeeb6af20647afaafe2eca6dd554443e8a37e62878d72bf4982b3f50366"

URI_aarch64_rust-crossterm+event-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+event-stream-devel-0.28.1-2.el10_0.noarch.rpm;name=aarch64_rust-crossterm+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+event-stream-devel}"
SRC_URI[aarch64_rust-crossterm+event-stream-devel.sha256sum] = "4bc936619be5818ed605b499c0f84f517c21c3e9f903ae3a56f84d6cd2b638a2"

URI_aarch64_rust-crossterm+events-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+events-devel-0.28.1-2.el10_0.noarch.rpm;name=aarch64_rust-crossterm+events-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+events-devel}"
SRC_URI[aarch64_rust-crossterm+events-devel.sha256sum] = "cf5f94e965cdb5f1f906bcae31a4f3827f85d9c976d10e5f4a5b82d4ad9f58af"

URI_aarch64_rust-crossterm+filedescriptor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+filedescriptor-devel-0.28.1-2.el10_0.noarch.rpm;name=aarch64_rust-crossterm+filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+filedescriptor-devel}"
SRC_URI[aarch64_rust-crossterm+filedescriptor-devel.sha256sum] = "130513eb50cf2fcb0b95b1f2b840d26483cc5ad48d0838a9d839050c8eee5e13"

URI_aarch64_rust-crossterm+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+libc-devel-0.28.1-2.el10_0.noarch.rpm;name=aarch64_rust-crossterm+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+libc-devel}"
SRC_URI[aarch64_rust-crossterm+libc-devel.sha256sum] = "16a7673841354b1021cc162b3c4aac6f00f126881b614a8378b7b81f26890837"

URI_aarch64_rust-crossterm+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+serde-devel-0.28.1-2.el10_0.noarch.rpm;name=aarch64_rust-crossterm+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+serde-devel}"
SRC_URI[aarch64_rust-crossterm+serde-devel.sha256sum] = "ae1cac8df86b2a1146893919754921a7cf4d3e7446d84c452e1927a9dadc29bb"

URI_aarch64_rust-crossterm+use-dev-tty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm+use-dev-tty-devel-0.28.1-2.el10_0.noarch.rpm;name=aarch64_rust-crossterm+use-dev-tty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm+use-dev-tty-devel}"
SRC_URI[aarch64_rust-crossterm+use-dev-tty-devel.sha256sum] = "13bbcc7aa363c3a36855aab8e3dc17ac85782626ba97f90b1797139181987d4d"

URI_aarch64_rust-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm-devel-0.28.1-2.el10_0.noarch.rpm;name=aarch64_rust-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm-devel}"
SRC_URI[aarch64_rust-crossterm-devel.sha256sum] = "1adb23214c96d17b9e3629613f3bfc5ec8b8f3ee6491702ea83e460bf241937c"

RDEPENDS:rust-crossterm+bracketed-paste-devel = " \
 cargo \
 rust-crossterm-devel \
 "
RDEPENDS:rust-crossterm+default-devel = " \
 cargo \
 rust-crossterm+bracketed-paste-devel \
 rust-crossterm+events-devel \
 rust-crossterm-devel \
 "
RDEPENDS:rust-crossterm+event-stream-devel = " \
 cargo \
 rust-crossterm+events-devel \
 rust-crossterm-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-crossterm+events-devel = " \
 cargo \
 rust-crossterm-devel \
 rust-mio+default-devel \
 rust-mio+os-poll-devel \
 rust-signal-hook+default-devel \
 rust-signal-hook-mio+default-devel \
 rust-signal-hook-mio+support-v1_0-devel \
 "
RDEPENDS:rust-crossterm+filedescriptor-devel = " \
 cargo \
 rust-crossterm-devel \
 rust-filedescriptor+default-devel \
 "
RDEPENDS:rust-crossterm+libc-devel = " \
 cargo \
 rust-crossterm-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-crossterm+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-crossterm-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-crossterm+use-dev-tty-devel = " \
 cargo \
 rust-crossterm+filedescriptor-devel \
 rust-crossterm-devel \
 rust-rustix+process-devel \
 "
RDEPENDS:rust-crossterm-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-parking_lot+default-devel \
 rust-rustix+std-devel \
 rust-rustix+stdio-devel \
 rust-rustix+termios-devel \
 rust-rustix-devel \
 "
