# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch-image"
PV = "2.27.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-onefetch-image+default-devel \
 rust-onefetch-image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-image-2.27.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47d78c5c3de52f6b30083c1ed43c5078572fe9b5b24baf9d924e0219d6bab861"

URI_x86_64_v2_rust-onefetch-image+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-image+default-devel-2.27.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-image+default-devel}"
SRC_URI[x86_64_v2_rust-onefetch-image+default-devel.sha256sum] = "a4ce63f22196e79e3426bacf0cd40eb6fce951744b4f38b27eb510af7ade8fa0"

URI_x86_64_v2_rust-onefetch-image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-image-devel-2.27.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-image-devel}"
SRC_URI[x86_64_v2_rust-onefetch-image-devel.sha256sum] = "bbd39a65d5855bba2017d20a899a5ced7f3f260bb173fdc279c2d3d991601695"

URI_aarch64_rust-onefetch-image+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-image+default-devel-2.27.1-1.el10_2.noarch.rpm;name=aarch64_rust-onefetch-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-image+default-devel}"
SRC_URI[aarch64_rust-onefetch-image+default-devel.sha256sum] = "923699f1c26e74fb34d2122f6d8966345f422cc0147de92f402d5e4f464027f1"

URI_aarch64_rust-onefetch-image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-image-devel-2.27.1-1.el10_2.noarch.rpm;name=aarch64_rust-onefetch-image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-image-devel}"
SRC_URI[aarch64_rust-onefetch-image-devel.sha256sum] = "3cf8263e859e91866af3f941de9b8d11d8ddaba915d8747332e442b9e4eaff44"

RDEPENDS:rust-onefetch-image+default-devel = " \
 cargo \
 rust-onefetch-image-devel \
 "
RDEPENDS:rust-onefetch-image-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-base64+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-color_quant+default-devel \
 rust-image+color_quant-devel \
 rust-image+jpeg-devel \
 rust-image+png-devel \
 rust-image+webp-devel \
 rust-image-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+termios-devel \
 "
