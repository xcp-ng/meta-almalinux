# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "avahi"
PV = "0.9~rc2"
PR = "2.el10"
PACKAGES = " \
 avahi \
 avahi-compat-howl \
 avahi-compat-howl-devel \
 avahi-compat-libdns_sd \
 avahi-compat-libdns_sd-devel \
 avahi-devel \
 avahi-glib \
 avahi-glib-devel \
 avahi-gobject \
 avahi-libs \
 avahi-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/avahi-0.9~rc2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed1d10e80eda15e1124ff9b31e10bbd1acc2e64b8a0e3c163ed30fb6db65c85e"

URI_x86_64_v2_avahi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/avahi-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi}"
SRC_URI[x86_64_v2_avahi.sha256sum] = "76006f425d4917fe176f5bfcf01aac30110bdf76cc263471a86ba215d503b74c"

URI_x86_64_v2_avahi-compat-howl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-howl-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-howl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-howl}"
SRC_URI[x86_64_v2_avahi-compat-howl.sha256sum] = "e8eceae1f18bab4a251572f4d7fd376c4c5af4c2b175f50aceb01bb37cdabf47"

URI_x86_64_v2_avahi-compat-howl-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-howl-devel-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-howl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-howl-devel}"
SRC_URI[x86_64_v2_avahi-compat-howl-devel.sha256sum] = "f0d1b30297c0b11003336ce207ce854f964bb92676fa0014bc97974c8feb55a8"

URI_x86_64_v2_avahi-compat-libdns_sd = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-libdns_sd-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-libdns_sd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-libdns_sd}"
SRC_URI[x86_64_v2_avahi-compat-libdns_sd.sha256sum] = "6f195408b1c3b4c3ec12eba429e9fd7977db05edceb47be77a4d5648a3376465"

URI_x86_64_v2_avahi-compat-libdns_sd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-libdns_sd-devel-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-libdns_sd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-libdns_sd-devel}"
SRC_URI[x86_64_v2_avahi-compat-libdns_sd-devel.sha256sum] = "9565131ac4cf61aeab0b68898b886ebfa2adcdea9b56e6103d311fc90fd6a6eb"

URI_x86_64_v2_avahi-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-devel-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-devel}"
SRC_URI[x86_64_v2_avahi-devel.sha256sum] = "a525ccd49099fcf4a423c7fc8143cbf7bef67136d6692fcd42a65e625ac7297d"

URI_x86_64_v2_avahi-glib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-glib-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-glib}"
SRC_URI[x86_64_v2_avahi-glib.sha256sum] = "36c252280c90ad63c717fc463ac46430e5929195801b4638926e5d681d995215"

URI_x86_64_v2_avahi-glib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-glib-devel-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-glib-devel}"
SRC_URI[x86_64_v2_avahi-glib-devel.sha256sum] = "829c3d8d2bc7700f5b7890a43e1f7e9ccdc4a21045f49ddca4b921483392e2fc"

URI_x86_64_v2_avahi-gobject = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-gobject-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-gobject;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-gobject}"
SRC_URI[x86_64_v2_avahi-gobject.sha256sum] = "924dfb879a8ad996b5b3d1e8182b6dcbcaa71f86ca8803223d60021e8039363f"

URI_x86_64_v2_avahi-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/avahi-libs-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-libs}"
SRC_URI[x86_64_v2_avahi-libs.sha256sum] = "6d5c24fa8f8fee0b491615b4e2c79eb2021afb10dbe8799f045a15725d0edb0b"

URI_x86_64_v2_avahi-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-tools-0.9~rc2-2.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-tools}"
SRC_URI[x86_64_v2_avahi-tools.sha256sum] = "a4e52f8c167b47e4d3f76cf01dc43cefd0e7c5760204b1b23ab183666576f5af"

URI_aarch64_avahi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/avahi-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi}"
SRC_URI[aarch64_avahi.sha256sum] = "9a77a9df53c69512881bb147b9df4dc1eaa24997227dc1a325f5a9d41dae1914"

URI_aarch64_avahi-compat-howl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-howl-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi-compat-howl;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-howl}"
SRC_URI[aarch64_avahi-compat-howl.sha256sum] = "fff9fb1c52f75d109ea8a1f59eff1edb45202d3a0c68c0f96eeb8f885edd86af"

URI_aarch64_avahi-compat-howl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-howl-devel-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi-compat-howl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-howl-devel}"
SRC_URI[aarch64_avahi-compat-howl-devel.sha256sum] = "6f45623e5bbfe8dc596c0edde5de62f025a534b1072bd961bdbb721288510b61"

URI_aarch64_avahi-compat-libdns_sd = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-libdns_sd-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi-compat-libdns_sd;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-libdns_sd}"
SRC_URI[aarch64_avahi-compat-libdns_sd.sha256sum] = "323d74f6eed156593f1a18f43ea2f4aa41dd1d77c0811d899bbc66ddcc4a9602"

URI_aarch64_avahi-compat-libdns_sd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-libdns_sd-devel-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi-compat-libdns_sd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-libdns_sd-devel}"
SRC_URI[aarch64_avahi-compat-libdns_sd-devel.sha256sum] = "06148444506d23bfba65afc102e22cb7af30c5abbff50aab294de6cb8bc79c94"

URI_aarch64_avahi-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-devel-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-devel}"
SRC_URI[aarch64_avahi-devel.sha256sum] = "b6e47504b0fce75f68ea7b0d660ecbf20650b085f0d0b97dbc7784e1555e4a0d"

URI_aarch64_avahi-glib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-glib-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-glib}"
SRC_URI[aarch64_avahi-glib.sha256sum] = "bdeeb9bfb01cb95c303792cdeaa60841628c644561663c2b8715195ae2f34db4"

URI_aarch64_avahi-glib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-glib-devel-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-glib-devel}"
SRC_URI[aarch64_avahi-glib-devel.sha256sum] = "e11c6f71a44dfb57dbbcc8e11539a256b33955148e996094ab7e813a5cf76417"

URI_aarch64_avahi-gobject = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-gobject-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi-gobject;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-gobject}"
SRC_URI[aarch64_avahi-gobject.sha256sum] = "669501cc6645850c4e3dc7f10d6ccebddbe5154c177125bf4dcec16e5188908c"

URI_aarch64_avahi-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/avahi-libs-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-libs}"
SRC_URI[aarch64_avahi-libs.sha256sum] = "c12bc3968ecad428f38e2eb98cd2ef4ca6e2f3ba82e688ff8ad1068bc3d01fa8"

URI_aarch64_avahi-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-tools-0.9~rc2-2.el10.aarch64.rpm;name=aarch64_avahi-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-tools}"
SRC_URI[aarch64_avahi-tools.sha256sum] = "54339215c484cf0b1c85749352d44349fc5b456b8f0c2be5ad08fd15845cb3d6"

RDEPENDS:avahi = " \
 avahi-libs \
 bash \
 dbus \
 dbus-libs \
 expat \
 glibc \
 libcap \
 libdaemon \
 shadow-utils \
 systemd-libs \
 virtual/coreutils \
 "
RDEPENDS:avahi-compat-howl = " \
 avahi-libs \
 dbus-libs \
 glibc \
 "
RDEPENDS:avahi-compat-howl-devel = " \
 avahi-compat-howl \
 avahi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-compat-libdns_sd = " \
 avahi-libs \
 dbus-libs \
 glibc \
 "
RDEPENDS:avahi-compat-libdns_sd-devel = " \
 avahi-compat-libdns_sd \
 avahi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-devel = " \
 avahi \
 avahi-libs \
 dbus-devel \
 libevent-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-glib = " \
 avahi-libs \
 glib2 \
 glibc \
 "
RDEPENDS:avahi-glib-devel = " \
 avahi-devel \
 avahi-glib \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-gobject = " \
 avahi-glib \
 avahi-libs \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:avahi-libs = " \
 dbus-libs \
 glibc \
 libevent \
 "
RDEPENDS:avahi-tools = " \
 avahi \
 avahi-libs \
 gdbm-libs \
 glibc \
 "
