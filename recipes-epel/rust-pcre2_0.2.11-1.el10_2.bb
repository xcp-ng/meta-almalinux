# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pcre2"
PV = "0.2.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-pcre2+default-devel \
 rust-pcre2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pcre2-0.2.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de70a51e0e60bd865b5d8650b6baa30e45bc97f97cd71e4994c7fb840d708cbb"

URI_x86_64_v2_rust-pcre2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcre2+default-devel-0.2.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcre2+default-devel}"
SRC_URI[x86_64_v2_rust-pcre2+default-devel.sha256sum] = "5e7b2edeaad40546cc8cafb48648168722aa22b63600fdef2993ef7f2c055622"

URI_x86_64_v2_rust-pcre2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcre2-devel-0.2.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcre2-devel}"
SRC_URI[x86_64_v2_rust-pcre2-devel.sha256sum] = "ce2cf4dd2b065be756695bf0a99e0b4dba4f909da41ec3d695dc09e45fdaffc7"

URI_aarch64_rust-pcre2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcre2+default-devel-0.2.11-1.el10_2.noarch.rpm;name=aarch64_rust-pcre2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcre2+default-devel}"
SRC_URI[aarch64_rust-pcre2+default-devel.sha256sum] = "1c6c44ae73ff7feff37749f7834f32885f1d7c6adb3de3c7c473d42340f240e9"

URI_aarch64_rust-pcre2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcre2-devel-0.2.11-1.el10_2.noarch.rpm;name=aarch64_rust-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcre2-devel}"
SRC_URI[aarch64_rust-pcre2-devel.sha256sum] = "c320554233540040f9760972e653cf3b2029d67a790abe90ec7e46fca0df141d"

RDEPENDS:rust-pcre2+default-devel = " \
 cargo \
 rust-pcre2-devel \
 "
RDEPENDS:rust-pcre2-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-pcre2-sys+default-devel \
 "
