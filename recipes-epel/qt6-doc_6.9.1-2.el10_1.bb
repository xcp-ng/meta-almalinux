# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-doc"
PV = "6.9.1"
PR = "2.el10_1"
PACKAGES = " \
 qt6-doc \
 qt6-doc-devel \
 qt6-doc-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-doc-6.9.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5dfbdbf14c1c81536698fcfd7958d51480034f61883767614bec0c49f22c8b8"

URI_x86_64_v2_qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-doc-6.9.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doc}"
SRC_URI[x86_64_v2_qt6-doc.sha256sum] = "c0aedbf1f343f352cf9bd53595722b04e8df324396df773c35d74c866db29943"

URI_x86_64_v2_qt6-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-doc-devel-6.9.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt6-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doc-devel}"
SRC_URI[x86_64_v2_qt6-doc-devel.sha256sum] = "977079674f5e4da50e208a7fdd9cb67649184a0e5061a78f3fabf2c5ac6d009a"

URI_x86_64_v2_qt6-doc-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-doc-html-6.9.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt6-doc-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doc-html}"
SRC_URI[x86_64_v2_qt6-doc-html.sha256sum] = "e4f3d254a9433f99cc334d39e69e435e1ef7c3913849bf66fbfc74e2db4ad9d8"

URI_aarch64_qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-doc-6.9.1-2.el10_1.noarch.rpm;name=aarch64_qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doc}"
SRC_URI[aarch64_qt6-doc.sha256sum] = "a6a3b34d92c9d6e27b3de627207b38e9ec173e04c73b0279cb9ba0799e32183b"

URI_aarch64_qt6-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-doc-devel-6.9.1-2.el10_1.noarch.rpm;name=aarch64_qt6-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doc-devel}"
SRC_URI[aarch64_qt6-doc-devel.sha256sum] = "a450963a6e1287ef7955f8eaf0b46c3bf90e38d2d0f39ca579ccbf8a452061cf"

URI_aarch64_qt6-doc-html = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-doc-html-6.9.1-2.el10_1.noarch.rpm;name=aarch64_qt6-doc-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doc-html}"
SRC_URI[aarch64_qt6-doc-html.sha256sum] = "81aaf1408d1413644a7b88ef3608aab2e5dea7a3683dc1cd74267290595f7c32"

RDEPENDS:qt6-doc = " \
 "
RDEPENDS:qt6-doc-devel = " \
 "
RDEPENDS:qt6-doc-html = " \
 "
