# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-macros"
PV = "0.8.6"
PR = "4.el10_3"
PACKAGES = " \
 rust-sqlx-macros+_rt-tokio-devel \
 rust-sqlx-macros+_tls-native-tls-devel \
 rust-sqlx-macros+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-macros+_tls-rustls-ring-webpki-devel \
 rust-sqlx-macros+bigdecimal-devel \
 rust-sqlx-macros+bit-vec-devel \
 rust-sqlx-macros+chrono-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+derive-devel \
 rust-sqlx-macros+ipnet-devel \
 rust-sqlx-macros+ipnetwork-devel \
 rust-sqlx-macros+json-devel \
 rust-sqlx-macros+mac_address-devel \
 rust-sqlx-macros+macros-devel \
 rust-sqlx-macros+migrate-devel \
 rust-sqlx-macros+mysql-devel \
 rust-sqlx-macros+postgres-devel \
 rust-sqlx-macros+rust_decimal-devel \
 rust-sqlx-macros+sqlite-devel \
 rust-sqlx-macros+sqlite-unbundled-devel \
 rust-sqlx-macros+time-devel \
 rust-sqlx-macros+uuid-devel \
 rust-sqlx-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-macros-0.8.6-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0d3f4d99b7e7332d78c2091b9f4f94d5d1365e6038ec75f0bd1fb3de6a3a766"

URI_x86_64_v2_rust-sqlx-macros+_rt-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+_rt-tokio-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+_rt-tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+_rt-tokio-devel.sha256sum] = "6be568461660111453f4b2a4f0b44743f8127c26693b9e0ba3dc517ccfc844dc"

URI_x86_64_v2_rust-sqlx-macros+_tls-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+_tls-native-tls-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+_tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+_tls-native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+_tls-native-tls-devel.sha256sum] = "97058b3487d9a7d3718758d03b5dfa2f60313f46468d2bd20d23f26ca6f8408c"

URI_x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+_tls-rustls-ring-native-roots-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel.sha256sum] = "8fea9ac913c68c5ae459d900735864b23dfd324bf4364c7a86eef7b34b098ef4"

URI_x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+_tls-rustls-ring-webpki-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-webpki-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+_tls-rustls-ring-webpki-devel.sha256sum] = "13b3de16ee095f28b5cc56b1a8aede229cb816c31ea676ae6bf8693a4526a395"

URI_x86_64_v2_rust-sqlx-macros+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+bigdecimal-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+bigdecimal-devel.sha256sum] = "7a23adbbb3ba109ede9986eefab020b5e8ede556d5a3e650433781f552aea523"

URI_x86_64_v2_rust-sqlx-macros+bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+bit-vec-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+bit-vec-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+bit-vec-devel.sha256sum] = "7172a80d9debdbeec98950ca5f1325047dce006a03e98a5d7a0a2560b1a14f73"

URI_x86_64_v2_rust-sqlx-macros+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+chrono-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+chrono-devel.sha256sum] = "0b0898bc757e7062a53ab499356704f93accb75d81511d51e6b3f3959bc18952"

URI_x86_64_v2_rust-sqlx-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+default-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+default-devel.sha256sum] = "48c266a200b7e8a330d43a0f07ff0cb91d854fb3d6fa180cfc15dcfe5ef43224"

URI_x86_64_v2_rust-sqlx-macros+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+derive-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+derive-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+derive-devel.sha256sum] = "31687545b4e4c53e9182630c1adbc7132f1d9f2f18f76eee348ede360ab28291"

URI_x86_64_v2_rust-sqlx-macros+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+ipnet-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+ipnet-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+ipnet-devel.sha256sum] = "c96ad542ad9dc27510e4cfe71e7d41fcd5279a1bb41b5efb36a04312856a176c"

URI_x86_64_v2_rust-sqlx-macros+ipnetwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+ipnetwork-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+ipnetwork-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+ipnetwork-devel.sha256sum] = "b70e16adf17dd996aa98372f50804c5813f5a722a95733f08b9d18d765675689"

URI_x86_64_v2_rust-sqlx-macros+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+json-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+json-devel.sha256sum] = "5a0dc73a5978b82c6c75fa611e6a3858083ca39e53619c251ef270ab3e2a3620"

URI_x86_64_v2_rust-sqlx-macros+mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+mac_address-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+mac_address-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+mac_address-devel.sha256sum] = "90beb383bf9820c28051c864c4c5345f884b890063ddca36d3a1ebb07119af17"

URI_x86_64_v2_rust-sqlx-macros+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+macros-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+macros-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+macros-devel.sha256sum] = "d704fa893ef62866aff1cfa9a511d7032fb12f0054040903f95fc8171e90545c"

URI_x86_64_v2_rust-sqlx-macros+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+migrate-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+migrate-devel.sha256sum] = "67365a3f1bb4d1d123b110e45ffabca8dffc85eaf94d7a97a22a73c6e48c7819"

URI_x86_64_v2_rust-sqlx-macros+mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+mysql-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+mysql-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+mysql-devel.sha256sum] = "8bfcbe5d605d6c17e71d859c40404e6a548834b3d8ca6352bbab4976d71f7bbc"

URI_x86_64_v2_rust-sqlx-macros+postgres-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+postgres-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+postgres-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+postgres-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+postgres-devel.sha256sum] = "eb8315a8683d057fe1b86b9932a3c2c6247a0d9ad56b828a84141be81b558efe"

URI_x86_64_v2_rust-sqlx-macros+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+rust_decimal-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+rust_decimal-devel.sha256sum] = "feb3442e8803bbd8aa1e61600941b94155a70286c8cff772f8577c5a3b26f4d0"

URI_x86_64_v2_rust-sqlx-macros+sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+sqlite-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+sqlite-devel.sha256sum] = "18b13a828166d15bf8978416a3b19eaed25744c7545eae494b75d9eef475a791"

URI_x86_64_v2_rust-sqlx-macros+sqlite-unbundled-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+sqlite-unbundled-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+sqlite-unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+sqlite-unbundled-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+sqlite-unbundled-devel.sha256sum] = "04b918ead673a5f8dd2b589c651aa5adc02c8d619b2285a97ab9a9e87d0cb60b"

URI_x86_64_v2_rust-sqlx-macros+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+time-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+time-devel.sha256sum] = "d75b5debcaf9af62020bdd4d828e1715f0d822c6cfc0b145d27e0c18770ce64b"

URI_x86_64_v2_rust-sqlx-macros+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros+uuid-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros+uuid-devel.sha256sum] = "fc9bb5af798b48257b4ec84371cffad61eba7772944e6a467e8bf12b66a6bea7"

URI_x86_64_v2_rust-sqlx-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-macros-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-macros-devel}"
SRC_URI[x86_64_v2_rust-sqlx-macros-devel.sha256sum] = "f3fb17ec7b1392a5fec138b20cc510a588cc8a9db28888d1ab18ba4f6ebc4f86"

URI_aarch64_rust-sqlx-macros+_rt-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+_rt-tokio-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+_rt-tokio-devel}"
SRC_URI[aarch64_rust-sqlx-macros+_rt-tokio-devel.sha256sum] = "cf0efea0001d8a0c2358fc6bb83ad9f1d7dde04eb220a4e4f0b03c1d8cce2931"

URI_aarch64_rust-sqlx-macros+_tls-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+_tls-native-tls-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+_tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+_tls-native-tls-devel}"
SRC_URI[aarch64_rust-sqlx-macros+_tls-native-tls-devel.sha256sum] = "4a046f1d6d8d7f92d150bf122da68d93006571c6b8ba65b6d1fe8a3acaf383e9"

URI_aarch64_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+_tls-rustls-ring-native-roots-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel}"
SRC_URI[aarch64_rust-sqlx-macros+_tls-rustls-ring-native-roots-devel.sha256sum] = "3b0e781ef9b6e193ab1bf828d7a323fe2fa9f35119c42434cd5c739f3d980024"

URI_aarch64_rust-sqlx-macros+_tls-rustls-ring-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+_tls-rustls-ring-webpki-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+_tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+_tls-rustls-ring-webpki-devel}"
SRC_URI[aarch64_rust-sqlx-macros+_tls-rustls-ring-webpki-devel.sha256sum] = "763bf0262582992f6b6035f5309098eb6bb37e270baddf9c9654fd1c1fb26a9b"

URI_aarch64_rust-sqlx-macros+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+bigdecimal-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx-macros+bigdecimal-devel.sha256sum] = "a1d6b9ff9adfbb9563019406b0836c1aeab2698b6ed070d8e5b4e4ab29a57d12"

URI_aarch64_rust-sqlx-macros+bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+bit-vec-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+bit-vec-devel}"
SRC_URI[aarch64_rust-sqlx-macros+bit-vec-devel.sha256sum] = "69ca9970eea5695de1a9052cf223f3118c15788dbdb35da60362273e590e6bba"

URI_aarch64_rust-sqlx-macros+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+chrono-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-macros+chrono-devel.sha256sum] = "92cd4d3f2501827dba52709dd34372cbb5c6848473ca3cd6a0c3e7ed89633960"

URI_aarch64_rust-sqlx-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+default-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+default-devel}"
SRC_URI[aarch64_rust-sqlx-macros+default-devel.sha256sum] = "3b2192fd5be22b31c1094074ce16a58100b33c5b089101c9bab8d51d1e2097de"

URI_aarch64_rust-sqlx-macros+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+derive-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+derive-devel}"
SRC_URI[aarch64_rust-sqlx-macros+derive-devel.sha256sum] = "6d84bb3a73b1678183626d354f486b6c5d1f9ffd9f2438195f13b9c96d724d74"

URI_aarch64_rust-sqlx-macros+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+ipnet-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+ipnet-devel}"
SRC_URI[aarch64_rust-sqlx-macros+ipnet-devel.sha256sum] = "faab199e538be025326a0b265df719081cfa2c0240929189258ec6eadecdf903"

URI_aarch64_rust-sqlx-macros+ipnetwork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+ipnetwork-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+ipnetwork-devel}"
SRC_URI[aarch64_rust-sqlx-macros+ipnetwork-devel.sha256sum] = "3ec42a4a90a165ff9fef1b857147557be0ddffc7023a273fdb16828b2b747bea"

URI_aarch64_rust-sqlx-macros+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+json-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+json-devel}"
SRC_URI[aarch64_rust-sqlx-macros+json-devel.sha256sum] = "1dbf783f5db01baf8f6c1bf0b884ed637c434e0bbb8daa0b5934f2e06c2954e2"

URI_aarch64_rust-sqlx-macros+mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+mac_address-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+mac_address-devel}"
SRC_URI[aarch64_rust-sqlx-macros+mac_address-devel.sha256sum] = "4b2b35d2fdeb0a68caf992961b61011c6a82143af3d04cd735357ce2d1300876"

URI_aarch64_rust-sqlx-macros+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+macros-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+macros-devel}"
SRC_URI[aarch64_rust-sqlx-macros+macros-devel.sha256sum] = "7bd5ac135c8d326457732edbae6196a23a0a3e20b34ea70ecb29ae60728ccdca"

URI_aarch64_rust-sqlx-macros+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+migrate-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-macros+migrate-devel.sha256sum] = "7541ee13dbf80c60c2658a39fd4724c310b2f6d3af0d55613a1841a40443dd63"

URI_aarch64_rust-sqlx-macros+mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+mysql-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+mysql-devel}"
SRC_URI[aarch64_rust-sqlx-macros+mysql-devel.sha256sum] = "a4f2428a70b08bd958ee2c82b9b25280d91bf2c656f823ae23fdb45ef6dcb02c"

URI_aarch64_rust-sqlx-macros+postgres-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+postgres-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+postgres-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+postgres-devel}"
SRC_URI[aarch64_rust-sqlx-macros+postgres-devel.sha256sum] = "bfd814e4fb95b8ab439af75d60ee1b6dbd382384c20bb71b1133b4dd423b2329"

URI_aarch64_rust-sqlx-macros+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+rust_decimal-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx-macros+rust_decimal-devel.sha256sum] = "3e62988822eb4767f4715a58adfa7c9564ba2d8fa98596070bfad1e6681397a3"

URI_aarch64_rust-sqlx-macros+sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+sqlite-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+sqlite-devel}"
SRC_URI[aarch64_rust-sqlx-macros+sqlite-devel.sha256sum] = "9b62e3468c90ff1910a93406a88e5f60045e58227da88a2aae5cc0cd2e0cc847"

URI_aarch64_rust-sqlx-macros+sqlite-unbundled-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+sqlite-unbundled-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+sqlite-unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+sqlite-unbundled-devel}"
SRC_URI[aarch64_rust-sqlx-macros+sqlite-unbundled-devel.sha256sum] = "59cc420558ebc159787cb5fd61ac33dcd8f2004f76e06cb2fe653685afa41da9"

URI_aarch64_rust-sqlx-macros+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+time-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+time-devel}"
SRC_URI[aarch64_rust-sqlx-macros+time-devel.sha256sum] = "be5a2d99ebaae0a1e8530c130a0d9a7a3ac642bdd30a68dd53b5c6aa94798199"

URI_aarch64_rust-sqlx-macros+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros+uuid-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-macros+uuid-devel.sha256sum] = "dca1cffda5b8b470fade422d6c88227f164c9933bd00c14a0fec00b32ef39371"

URI_aarch64_rust-sqlx-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-macros-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-macros-devel}"
SRC_URI[aarch64_rust-sqlx-macros-devel.sha256sum] = "178811322f061a143107dbd064e5b4d5b3d2a75300d2112e22c38dd690e9ac97"

RDEPENDS:rust-sqlx-macros+_rt-tokio-devel = " \
 cargo \
 rust-sqlx-macros-core+_rt-tokio-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+_tls-native-tls-devel = " \
 cargo \
 rust-sqlx-macros-core+_tls-native-tls-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+_tls-rustls-ring-native-roots-devel = " \
 cargo \
 rust-sqlx-macros-core+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+_tls-rustls-ring-webpki-devel = " \
 cargo \
 rust-sqlx-macros-core+_tls-rustls-ring-webpki-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+bigdecimal-devel = " \
 cargo \
 rust-sqlx-macros-core+bigdecimal-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+bit-vec-devel = " \
 cargo \
 rust-sqlx-macros-core+bit-vec-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+chrono-devel = " \
 cargo \
 rust-sqlx-macros-core+chrono-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+default-devel = " \
 cargo \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+derive-devel = " \
 cargo \
 rust-sqlx-macros-core+derive-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+ipnet-devel = " \
 cargo \
 rust-sqlx-macros-core+ipnet-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+ipnetwork-devel = " \
 cargo \
 rust-sqlx-macros-core+ipnetwork-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+json-devel = " \
 cargo \
 rust-sqlx-macros-core+json-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+mac_address-devel = " \
 cargo \
 rust-sqlx-macros-core+mac_address-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+macros-devel = " \
 cargo \
 rust-sqlx-macros-core+macros-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+migrate-devel = " \
 cargo \
 rust-sqlx-macros-core+migrate-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+mysql-devel = " \
 cargo \
 rust-sqlx-macros-core+mysql-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+postgres-devel = " \
 cargo \
 rust-sqlx-macros-core+postgres-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+rust_decimal-devel = " \
 cargo \
 rust-sqlx-macros-core+rust_decimal-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+sqlite-devel = " \
 cargo \
 rust-sqlx-macros-core+sqlite-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+sqlite-unbundled-devel = " \
 cargo \
 rust-sqlx-macros-core+sqlite-unbundled-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+time-devel = " \
 cargo \
 rust-sqlx-macros-core+time-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros+uuid-devel = " \
 cargo \
 rust-sqlx-macros-core+uuid-devel \
 rust-sqlx-macros-devel \
 "
RDEPENDS:rust-sqlx-macros-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-sqlx-core+any-devel \
 rust-sqlx-core+default-devel \
 rust-sqlx-macros-core+default-devel \
 rust-syn2+parsing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2-devel \
 "
