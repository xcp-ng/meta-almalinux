# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3_0.24"
PV = "0.24.2"
PR = "5.el10_1"
PACKAGES = " \
 rust-pyo3_0.24+abi3-devel \
 rust-pyo3_0.24+abi3-py310-devel \
 rust-pyo3_0.24+abi3-py311-devel \
 rust-pyo3_0.24+abi3-py312-devel \
 rust-pyo3_0.24+abi3-py313-devel \
 rust-pyo3_0.24+abi3-py37-devel \
 rust-pyo3_0.24+abi3-py38-devel \
 rust-pyo3_0.24+abi3-py39-devel \
 rust-pyo3_0.24+anyhow-devel \
 rust-pyo3_0.24+auto-initialize-devel \
 rust-pyo3_0.24+chrono-devel \
 rust-pyo3_0.24+chrono-tz-devel \
 rust-pyo3_0.24+default-devel \
 rust-pyo3_0.24+either-devel \
 rust-pyo3_0.24+experimental-async-devel \
 rust-pyo3_0.24+experimental-inspect-devel \
 rust-pyo3_0.24+extension-module-devel \
 rust-pyo3_0.24+eyre-devel \
 rust-pyo3_0.24+full-devel \
 rust-pyo3_0.24+hashbrown-devel \
 rust-pyo3_0.24+indexmap-devel \
 rust-pyo3_0.24+indoc-devel \
 rust-pyo3_0.24+inventory-devel \
 rust-pyo3_0.24+jiff-02-devel \
 rust-pyo3_0.24+macros-devel \
 rust-pyo3_0.24+multiple-pymethods-devel \
 rust-pyo3_0.24+nightly-devel \
 rust-pyo3_0.24+num-bigint-devel \
 rust-pyo3_0.24+num-complex-devel \
 rust-pyo3_0.24+num-rational-devel \
 rust-pyo3_0.24+py-clone-devel \
 rust-pyo3_0.24+pyo3-macros-devel \
 rust-pyo3_0.24+rust_decimal-devel \
 rust-pyo3_0.24+serde-devel \
 rust-pyo3_0.24+smallvec-devel \
 rust-pyo3_0.24+unindent-devel \
 rust-pyo3_0.24+uuid-devel \
 rust-pyo3_0.24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3_0.24-0.24.2-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4d6c1c345d61eae0c6eff440bf67354442c331a7f61ba394f9957d293b74e9b"

URI_x86_64_v2_rust-pyo3_0.24+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+abi3-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+abi3-devel.sha256sum] = "82d4d531c9367459e73d89438e5cf32ee567ca3a66d28b43076742b088caf6e8"

URI_x86_64_v2_rust-pyo3_0.24+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+abi3-py310-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+abi3-py310-devel.sha256sum] = "c60ddc7489d8424499d96d9072c2ae335b246c77595d48ed3af3c57b759e8b9c"

URI_x86_64_v2_rust-pyo3_0.24+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+abi3-py311-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+abi3-py311-devel.sha256sum] = "c0a6dff3ffd6b681edd6b18566bcbca9a1092b68fc72b3b6b9035babe87a157b"

URI_x86_64_v2_rust-pyo3_0.24+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+abi3-py312-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+abi3-py312-devel.sha256sum] = "e61c557fd07be5d906632638148482973b827b09ba0d395d2640ccf3dd198287"

URI_x86_64_v2_rust-pyo3_0.24+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+abi3-py313-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+abi3-py313-devel.sha256sum] = "745ccf9c33f84c0bd950243f4831fc000d83731e4326630ef007cf7475eb01e2"

URI_x86_64_v2_rust-pyo3_0.24+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+abi3-py37-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+abi3-py37-devel.sha256sum] = "a75e3ef7109f002eda8b3b7d10a53d1e6b482ecb6ccd37743fe93d52fc938585"

URI_x86_64_v2_rust-pyo3_0.24+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+abi3-py38-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+abi3-py38-devel.sha256sum] = "909ff3886236ff87f9c6c993fc05c4c19b5a3b197e975ce87b703dcc7c830475"

URI_x86_64_v2_rust-pyo3_0.24+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+abi3-py39-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+abi3-py39-devel.sha256sum] = "4c2d84a2c40dfd55558fd58fb3dbf4b5238f427799d9f7822c50afbf54e9d4f0"

URI_x86_64_v2_rust-pyo3_0.24+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+anyhow-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+anyhow-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+anyhow-devel.sha256sum] = "5371ea6f4d414a3a6ad8b9a9d67536ad9d06fde848b5e07908f7a1f9a384773b"

URI_x86_64_v2_rust-pyo3_0.24+auto-initialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+auto-initialize-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+auto-initialize-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+auto-initialize-devel.sha256sum] = "246c1e95df512737329aaf25f25cd3bb3fbecfe5cb42f81159c4340261c04556"

URI_x86_64_v2_rust-pyo3_0.24+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+chrono-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+chrono-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+chrono-devel.sha256sum] = "991df1724ff91ed291a916e0ed3e356d4838cd2ffe7fc3444de56164c4bb5a4c"

URI_x86_64_v2_rust-pyo3_0.24+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+chrono-tz-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+chrono-tz-devel.sha256sum] = "0a0f5634664c30f14cdb1ea1585f03ef0c4cba87d2bfc6b1d8f66fd99e500ce4"

URI_x86_64_v2_rust-pyo3_0.24+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+default-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+default-devel.sha256sum] = "7259d7a88e50d63e715f46468d8b6da7f99f4f2e4d4b40fa862018037a321ed2"

URI_x86_64_v2_rust-pyo3_0.24+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+either-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+either-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+either-devel.sha256sum] = "233d9e7e077dc09e7baadbc6e3d50e4a7e4a14ef7f6dd0d9dfacdae891b48b81"

URI_x86_64_v2_rust-pyo3_0.24+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+experimental-async-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+experimental-async-devel.sha256sum] = "3a2d22746a687a28f289cb9f11afa0fe3eb5e19825c199ce443bf9dd76dbcf6f"

URI_x86_64_v2_rust-pyo3_0.24+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+experimental-inspect-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+experimental-inspect-devel.sha256sum] = "f1a554f208d2930005238dbc83ba7ba63029b2a4d1e8bf2a371043b5cc1014a7"

URI_x86_64_v2_rust-pyo3_0.24+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+extension-module-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+extension-module-devel.sha256sum] = "1fa63bfbfe9b989cfabd9e4a5c048080b04c5879bca2f45dd74487b668be6b00"

URI_x86_64_v2_rust-pyo3_0.24+eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+eyre-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+eyre-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+eyre-devel.sha256sum] = "cd9aefc37e2492b790158aff5fd018e6743710826b7f5e888ef7da9a268969a6"

URI_x86_64_v2_rust-pyo3_0.24+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+full-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+full-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+full-devel.sha256sum] = "4322d9a9f1ae8c6cb0b818e9f98223f4672ea2a5b21672b993d01525ae06b5a2"

URI_x86_64_v2_rust-pyo3_0.24+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+hashbrown-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+hashbrown-devel.sha256sum] = "b408314ce8ac1c4e866cbe309ed2f1cac3ae38ce869266b4b58ce57689dfc0b6"

URI_x86_64_v2_rust-pyo3_0.24+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+indexmap-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+indexmap-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+indexmap-devel.sha256sum] = "cfcfb909c9b935627a1ac64509a0b0032d55eb573ff2a1878039369bf1084ed1"

URI_x86_64_v2_rust-pyo3_0.24+indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+indoc-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+indoc-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+indoc-devel.sha256sum] = "3acef755e1c9ab45316e70ca2a9c3fb9f6f7381cf20a74190df4083b9b29f091"

URI_x86_64_v2_rust-pyo3_0.24+inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+inventory-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+inventory-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+inventory-devel.sha256sum] = "0063680388a88569eb57bbb94edda9a637f3a6204cec18be324590414f7b4f22"

URI_x86_64_v2_rust-pyo3_0.24+jiff-02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+jiff-02-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+jiff-02-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+jiff-02-devel.sha256sum] = "145a3e14dd6d782d1ef2bd71c57ecaa418466e3bfdb9927afcf0fe756ffc5d58"

URI_x86_64_v2_rust-pyo3_0.24+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+macros-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+macros-devel.sha256sum] = "e71f1d1ce15a12bafc7b0ad0b46e56af3f50d6c47d956d9a1fb94494b85feed6"

URI_x86_64_v2_rust-pyo3_0.24+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+multiple-pymethods-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+multiple-pymethods-devel.sha256sum] = "88205c54698b1d00daecc3f5c262fd37e85e2a89afe91051c3289ba34f995e2c"

URI_x86_64_v2_rust-pyo3_0.24+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+nightly-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+nightly-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+nightly-devel.sha256sum] = "08f777822d6cda8e763391068697cd2b8872dbf88c2611a9428b21c21edff968"

URI_x86_64_v2_rust-pyo3_0.24+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+num-bigint-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+num-bigint-devel.sha256sum] = "46d20f29a9292c388de69912695e0484392e0aec359f85ced41101aa0030d9a6"

URI_x86_64_v2_rust-pyo3_0.24+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+num-complex-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+num-complex-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+num-complex-devel.sha256sum] = "9a164778e458c58d44e98425e2d1ceb6e4d0ae3626b88fd42ed4c631a190233e"

URI_x86_64_v2_rust-pyo3_0.24+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+num-rational-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+num-rational-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+num-rational-devel.sha256sum] = "bd600c5e101fa7fd473ece9d96bd0085bab325048c34e2d1010f99d93958878d"

URI_x86_64_v2_rust-pyo3_0.24+py-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+py-clone-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+py-clone-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+py-clone-devel.sha256sum] = "c72ea83189a2a3dc7df5af9b83a86151fb7f912ce48422f8a90ed9e4129843dd"

URI_x86_64_v2_rust-pyo3_0.24+pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+pyo3-macros-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+pyo3-macros-devel.sha256sum] = "8510d4dfa7b81a1f9846cb82e806f8ba7ea9a28dd532e9fd6114d7cfa5523659"

URI_x86_64_v2_rust-pyo3_0.24+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+rust_decimal-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+rust_decimal-devel.sha256sum] = "c963b53baae28ad7d25fb5cfdd95652e297d457720c07203dafbd19be228735d"

URI_x86_64_v2_rust-pyo3_0.24+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+serde-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+serde-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+serde-devel.sha256sum] = "20dec4ee2f8b2f6e8f303768a961ee116879f6db2e8c0c6da5b142e9cde46f4f"

URI_x86_64_v2_rust-pyo3_0.24+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+smallvec-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+smallvec-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+smallvec-devel.sha256sum] = "7da82e3273a88c835f19773be6a8349d794b30df2fd3cec8224d75345a8ec9e4"

URI_x86_64_v2_rust-pyo3_0.24+unindent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+unindent-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+unindent-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+unindent-devel.sha256sum] = "5e86d971788375e2b241a2ecbe619bc1b15729bfed653cd16cbf6bbc2ed6c86f"

URI_x86_64_v2_rust-pyo3_0.24+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24+uuid-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24+uuid-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24+uuid-devel.sha256sum] = "3488452383341129745a56c138cb73d3aea2c200f99c622670e484fb12b27252"

URI_x86_64_v2_rust-pyo3_0.24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.24-devel-0.24.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.24-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.24-devel.sha256sum] = "74214f81410683a43f9170ec43149827b6274c3e3ca5cc9eff653666cd562be7"

URI_aarch64_rust-pyo3_0.24+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+abi3-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+abi3-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+abi3-devel.sha256sum] = "74da048de7d9c74253e5e5cdbd3744863b109b53fd2ac61b5b8e5c37c88f1d18"

URI_aarch64_rust-pyo3_0.24+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+abi3-py310-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+abi3-py310-devel.sha256sum] = "0f1d9352d4a6c8e2f9fe9f965b5787bc75b03c0937ca62c569e0336e2cdbfec7"

URI_aarch64_rust-pyo3_0.24+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+abi3-py311-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+abi3-py311-devel.sha256sum] = "135f7eacf8c0d7d772a2486ba90c0273519c51d4b2ff8850141bfa9f120e6395"

URI_aarch64_rust-pyo3_0.24+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+abi3-py312-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+abi3-py312-devel.sha256sum] = "ddeecfbf370d3a3bdcf41bf48b6122bfaf7d4b5ec0ee92f0b86bf9ce72a2720d"

URI_aarch64_rust-pyo3_0.24+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+abi3-py313-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+abi3-py313-devel.sha256sum] = "873655121eb84cd597cc1c851820ff68c34df562beaed125cb120ffb59292381"

URI_aarch64_rust-pyo3_0.24+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+abi3-py37-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+abi3-py37-devel.sha256sum] = "a45cf1c60e4e3bfd5e383314406f89d9dc71eb64abc5e1a922506851265fc8c8"

URI_aarch64_rust-pyo3_0.24+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+abi3-py38-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+abi3-py38-devel.sha256sum] = "284ee8f925168e12c1f6793a7704bae72669c3aba34d989460187f1de05288fd"

URI_aarch64_rust-pyo3_0.24+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+abi3-py39-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+abi3-py39-devel.sha256sum] = "acba8cfc667f31347ae39985d37d7ca2583d500868ca64de32d663fb314317f5"

URI_aarch64_rust-pyo3_0.24+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+anyhow-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+anyhow-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+anyhow-devel.sha256sum] = "3e134d9ef1495a8c0097aa48236ea9f08f51661237906cfc4e0a7ee186ef941c"

URI_aarch64_rust-pyo3_0.24+auto-initialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+auto-initialize-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+auto-initialize-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+auto-initialize-devel.sha256sum] = "7686abb1eb5481f649d9511845584c180b6556f602e376c32636de31ca065747"

URI_aarch64_rust-pyo3_0.24+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+chrono-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+chrono-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+chrono-devel.sha256sum] = "befc3de809541b74cc2ed4a40a374e56db7078fea6c623a8df12a19d9529b243"

URI_aarch64_rust-pyo3_0.24+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+chrono-tz-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+chrono-tz-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+chrono-tz-devel.sha256sum] = "df06c6bf1317fe059bebedd3ce9f5d45984811d57cdf458872f100ca33095691"

URI_aarch64_rust-pyo3_0.24+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+default-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+default-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+default-devel.sha256sum] = "21179550ac47c5e786fe8f194c8a2d0e902209473424e5905c6dc891f5f89011"

URI_aarch64_rust-pyo3_0.24+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+either-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+either-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+either-devel.sha256sum] = "0c6d9ccbc20d88d76df71aec572629211802ae442b721ecf8c02e2c24301995b"

URI_aarch64_rust-pyo3_0.24+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+experimental-async-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+experimental-async-devel.sha256sum] = "14473f43d2fa68d176165b0ed1d3baf466597f390303425499d0486a6511cfcf"

URI_aarch64_rust-pyo3_0.24+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+experimental-inspect-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+experimental-inspect-devel.sha256sum] = "40e8699ed0b93475b871ff20c2dc72e2cbb56079eee7ad5acd52825d8a15a1c5"

URI_aarch64_rust-pyo3_0.24+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+extension-module-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+extension-module-devel.sha256sum] = "694a87a9a070528dc6a17500da07da913adf079e86a7f7f4b22787575f39de11"

URI_aarch64_rust-pyo3_0.24+eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+eyre-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+eyre-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+eyre-devel.sha256sum] = "9fcf65aa948b289c4e845284b9160904adf9c9eebdc3acd37c04ee568dbaf661"

URI_aarch64_rust-pyo3_0.24+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+full-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+full-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+full-devel.sha256sum] = "e104504f2dc6102bc56bba43bd88d85c8c16fe2f14a1accef29a30beb8f1b35d"

URI_aarch64_rust-pyo3_0.24+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+hashbrown-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+hashbrown-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+hashbrown-devel.sha256sum] = "dab4c7e8caf9c3fbf08d7adf3abeb0d58ed59c248eec6cfb424b97235f060fc0"

URI_aarch64_rust-pyo3_0.24+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+indexmap-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+indexmap-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+indexmap-devel.sha256sum] = "2c95a9fdc04560d731be03982d4aab7b307f8e04a44bd43b7732cb5dcaf387ae"

URI_aarch64_rust-pyo3_0.24+indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+indoc-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+indoc-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+indoc-devel.sha256sum] = "e8ae0f195fdcaa6e43d86bc44080aca69257c05ba53981f177211f5753874b23"

URI_aarch64_rust-pyo3_0.24+inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+inventory-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+inventory-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+inventory-devel.sha256sum] = "8f305f771e9e96e656b394a876847506c348d4d2f0473a5c948c97a2ecb62372"

URI_aarch64_rust-pyo3_0.24+jiff-02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+jiff-02-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+jiff-02-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+jiff-02-devel.sha256sum] = "6aee1aba410cbb5c2d2c06bd18a18eddbf17cac629c9edf359d025be760bff35"

URI_aarch64_rust-pyo3_0.24+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+macros-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+macros-devel.sha256sum] = "546a42902c65d7ccd4a9d28f07759cbb2b9d80bdd126d3fc0ed745a687140d3b"

URI_aarch64_rust-pyo3_0.24+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+multiple-pymethods-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+multiple-pymethods-devel.sha256sum] = "ec2ee9527a99bacbc326929a7cc2f0e856450be51e3a7c9208c99dd0f15081f5"

URI_aarch64_rust-pyo3_0.24+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+nightly-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+nightly-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+nightly-devel.sha256sum] = "a63f46d245c3d8dbb4233d4fa4b430acff8dd275d1bcf6942ec3982bd700eb4e"

URI_aarch64_rust-pyo3_0.24+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+num-bigint-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+num-bigint-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+num-bigint-devel.sha256sum] = "f117cdfa88f23a8feb3854550838da6abc1b77c0001dd683b32d1ddeff6882e7"

URI_aarch64_rust-pyo3_0.24+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+num-complex-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+num-complex-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+num-complex-devel.sha256sum] = "d2edbb295db523fc8141c07e91acc4c96ad3b6f0af2f73b3151fd5883070db16"

URI_aarch64_rust-pyo3_0.24+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+num-rational-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+num-rational-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+num-rational-devel.sha256sum] = "18ea04000a11f9b90ad4ed34a98ebae0027868cf892715ca7d05d9bf48aeb97c"

URI_aarch64_rust-pyo3_0.24+py-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+py-clone-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+py-clone-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+py-clone-devel.sha256sum] = "540a4e7bedcdf89a0e357ab83e97ca52ba8503db6fdc80f53c7629d8b88abd08"

URI_aarch64_rust-pyo3_0.24+pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+pyo3-macros-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+pyo3-macros-devel.sha256sum] = "fb266fa26517b6dba1ae54972b1fef64fe9f569ea596e3aa839251885a66826e"

URI_aarch64_rust-pyo3_0.24+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+rust_decimal-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+rust_decimal-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+rust_decimal-devel.sha256sum] = "3a1e49e7ef37c0871e6936e6e7a67c8b44af40981bee4e893df89c571b6fea63"

URI_aarch64_rust-pyo3_0.24+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+serde-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+serde-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+serde-devel.sha256sum] = "8609bd9fb5277c11f96bcaa04a456b63018abe3fe24a2a443d3afc4d3771ad7e"

URI_aarch64_rust-pyo3_0.24+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+smallvec-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+smallvec-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+smallvec-devel.sha256sum] = "c08fa3b33b2fcfc27a53e59d844528682d30c9c7b2ada1dac947187212f3020a"

URI_aarch64_rust-pyo3_0.24+unindent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+unindent-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+unindent-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+unindent-devel.sha256sum] = "ec58dd2af2d2a49f6ab1a32e13cefdab0773539fd5e57d8509073bf3173f11a7"

URI_aarch64_rust-pyo3_0.24+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24+uuid-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24+uuid-devel}"
SRC_URI[aarch64_rust-pyo3_0.24+uuid-devel.sha256sum] = "37ffe662cb584c1af4e7f4ab5f265a30f6ce9c85837e760de055bebd5a4571d0"

URI_aarch64_rust-pyo3_0.24-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.24-devel-0.24.2-5.el10_1.noarch.rpm;name=aarch64_rust-pyo3_0.24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.24-devel}"
SRC_URI[aarch64_rust-pyo3_0.24-devel.sha256sum] = "b98e9b8aa4e8f100521137b23a2ebbf1169462b4521e7ecb61c5697c4ba4d394"

RDEPENDS:rust-pyo3_0.24+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py310-devel \
 rust-pyo3_0.24+abi3-py311-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py311-devel \
 rust-pyo3_0.24+abi3-py312-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py312-devel \
 rust-pyo3_0.24+abi3-py313-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py313-devel \
 rust-pyo3_0.24+abi3-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py37-devel \
 rust-pyo3_0.24+abi3-py38-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py38-devel \
 rust-pyo3_0.24+abi3-py39-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py39-devel \
 rust-pyo3_0.24+abi3-py310-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+auto-initialize-devel = " \
 cargo \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+default-devel = " \
 cargo \
 rust-pyo3_0.24+macros-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros0.24+default-devel \
 rust-pyo3-macros0.24+experimental-async-devel \
 rust-pyo3_0.24+macros-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+experimental-inspect-devel = " \
 cargo \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.24+extension-module-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+full-devel = " \
 cargo \
 rust-pyo3_0.24+anyhow-devel \
 rust-pyo3_0.24+chrono-devel \
 rust-pyo3_0.24+chrono-tz-devel \
 rust-pyo3_0.24+either-devel \
 rust-pyo3_0.24+experimental-async-devel \
 rust-pyo3_0.24+experimental-inspect-devel \
 rust-pyo3_0.24+eyre-devel \
 rust-pyo3_0.24+hashbrown-devel \
 rust-pyo3_0.24+indexmap-devel \
 rust-pyo3_0.24+macros-devel \
 rust-pyo3_0.24+num-bigint-devel \
 rust-pyo3_0.24+num-complex-devel \
 rust-pyo3_0.24+num-rational-devel \
 rust-pyo3_0.24+py-clone-devel \
 rust-pyo3_0.24+rust_decimal-devel \
 rust-pyo3_0.24+serde-devel \
 rust-pyo3_0.24+smallvec-devel \
 rust-pyo3_0.24+uuid-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+hashbrown-devel = " \
 cargo \
 rust-pyo3_0.24-devel \
 virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ \
 "
RDEPENDS:rust-pyo3_0.24+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+indoc-devel = " \
 cargo \
 rust-indoc+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+macros-devel = " \
 cargo \
 rust-pyo3_0.24+indoc-devel \
 rust-pyo3_0.24+pyo3-macros-devel \
 rust-pyo3_0.24+unindent-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.24+default-devel \
 rust-pyo3-macros0.24+multiple-pymethods-devel \
 rust-pyo3_0.24+inventory-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+nightly-devel = " \
 cargo \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+py-clone-devel = " \
 cargo \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-macros0.24+default-devel \
 rust-pyo3_0.24-devel \
 "
RDEPENDS:rust-pyo3_0.24+rust_decimal-devel = " \
 cargo \
 rust-pyo3_0.24-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3_0.24+serde-devel = " \
 cargo \
 rust-pyo3_0.24-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3_0.24+smallvec-devel = " \
 cargo \
 rust-pyo3_0.24-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3_0.24+unindent-devel = " \
 cargo \
 rust-pyo3_0.24-devel \
 rust-unindent+default-devel \
 "
RDEPENDS:rust-pyo3_0.24+uuid-devel = " \
 cargo \
 rust-pyo3_0.24-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-pyo3_0.24-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-memoffset+default-devel \
 rust-once_cell+default-devel \
 rust-pyo3-build-config0.24+default-devel \
 rust-pyo3-build-config0.24+resolve-config-devel \
 rust-pyo3-ffi0.24+default-devel \
 "
