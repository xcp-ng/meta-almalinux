# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-what"
PV = "1.27"
PR = "3.el10"
PACKAGES = " \
 virt-what \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/virt-what-1.27-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e85341dcdd414fe958b54bf1b0219d84b316151a3554ac60d556efc0a4caefc8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/virt-what-1.27-3.el10.x86_64_v2.rpm;name=x86_64_v2_virt-what;unpack=0"
SRC_URI[x86_64_v2_virt-what.sha256sum] = "7162663663f66f5b6fd7eb2a024c54eaf432a5fd5d9a49901dd10ebc9a793325"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/virt-what-1.27-3.el10.aarch64.rpm;name=aarch64_virt-what;unpack=0"
SRC_URI[aarch64_virt-what.sha256sum] = "83153297d7beeef95ca6ccdf32e020bb11b289d6beb71321a587333ddac5a436"

RDEPENDS:virt-what = " \
 bash \
 dmidecode \
 glibc \
 util-linux \
 which \
 "
