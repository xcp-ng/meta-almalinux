# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros-backend0.24"
PV = "0.24.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-macros-backend0.24+default-devel \
 rust-pyo3-macros-backend0.24+experimental-async-devel \
 rust-pyo3-macros-backend0.24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-backend0.24-0.24.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d59c5db330f109fa2e4212973cbc9775731fa6d5e91cf1efbcc187e6a8c1fcea"

URI_x86_64_v2_rust-pyo3-macros-backend0.24+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.24+default-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.24+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.24+default-devel.sha256sum] = "d4e2c9739ae9e9b73e86f4d390215cc4f15681961d4873133309f06ef5eedcc4"

URI_x86_64_v2_rust-pyo3-macros-backend0.24+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.24+experimental-async-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.24+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.24+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.24+experimental-async-devel.sha256sum] = "ae05db1304056129d858362d7fbd6045a163d26a758fa68ddf136dec0b3b8a78"

URI_x86_64_v2_rust-pyo3-macros-backend0.24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.24-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.24-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.24-devel.sha256sum] = "86a1edac0b5bc911df39f076a1610acf07bf6a9ba591044714a679f34e9a97a3"

URI_aarch64_rust-pyo3-macros-backend0.24+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.24+default-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.24+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.24+default-devel.sha256sum] = "1178b7ddae2594d0e5e0d0162a25bf5767df87e5b307b71a1185d126c42126ba"

URI_aarch64_rust-pyo3-macros-backend0.24+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.24+experimental-async-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.24+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.24+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.24+experimental-async-devel.sha256sum] = "1a167b6474f381748660e9d70e5e92fc2a71b63a152a2562fa67528bba57b076"

URI_aarch64_rust-pyo3-macros-backend0.24-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.24-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.24-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.24-devel.sha256sum] = "3291f4710392d0e0d0ef0817375bfc89d97b85f7d324d71893411acc289be6d0"

RDEPENDS:rust-pyo3-macros-backend0.24+default-devel = " \
 cargo \
 rust-pyo3-macros-backend0.24-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.24+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.24-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.24-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2-devel \
 rust-pyo3-build-config0.24+default-devel \
 rust-pyo3-build-config0.24+resolve-config-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
