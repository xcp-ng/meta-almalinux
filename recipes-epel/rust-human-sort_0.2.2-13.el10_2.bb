# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-human-sort"
PV = "0.2.2"
PR = "13.el10_2"
PACKAGES = " \
 rust-human-sort+default-devel \
 rust-human-sort-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-human-sort-0.2.2-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38a0a81c1e594fc2f334b546b30d80d6c875437ba19688f78985bd43bafe5534"

URI_x86_64_v2_rust-human-sort+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-sort+default-devel-0.2.2-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-sort+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-sort+default-devel}"
SRC_URI[x86_64_v2_rust-human-sort+default-devel.sha256sum] = "b29568b3716e184d9b87973f14ac964d8dc4c4b1504016abc65c4383879f847a"

URI_x86_64_v2_rust-human-sort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human-sort-devel-0.2.2-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human-sort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human-sort-devel}"
SRC_URI[x86_64_v2_rust-human-sort-devel.sha256sum] = "4f7a2bf5b5a9b5ba2759cae483ea36203c325b644ae1e52dd575f2904b3831a1"

URI_aarch64_rust-human-sort+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-sort+default-devel-0.2.2-13.el10_2.noarch.rpm;name=aarch64_rust-human-sort+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-sort+default-devel}"
SRC_URI[aarch64_rust-human-sort+default-devel.sha256sum] = "df36c654cb9cdb8e58229ac0cbab398fc424258662172023e10594b28245e24a"

URI_aarch64_rust-human-sort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human-sort-devel-0.2.2-13.el10_2.noarch.rpm;name=aarch64_rust-human-sort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human-sort-devel}"
SRC_URI[aarch64_rust-human-sort-devel.sha256sum] = "5dbe3deac23d6510f83d089a680ca09cb2d9c7f58c80ac483fe89e2bf4e61841"

RDEPENDS:rust-human-sort+default-devel = " \
 cargo \
 rust-human-sort-devel \
 "
RDEPENDS:rust-human-sort-devel = " \
 cargo \
 "
