# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinxcontrib-spelling"
PV = "7.3.3"
PR = "17.el10_3"
PACKAGES = " \
 python3-sphinxcontrib-spelling \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinxcontrib-spelling-7.3.3-17.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3b32a54b37c47c446adb2ae6ed7d4257da9f9741a1ea5d46a53f53f6cea416e"

URI_x86_64_v2_python3-sphinxcontrib-spelling = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinxcontrib-spelling-7.3.3-17.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinxcontrib-spelling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinxcontrib-spelling}"
SRC_URI[x86_64_v2_python3-sphinxcontrib-spelling.sha256sum] = "4e71cf61cdc3a120c5e0fe46885b7f55b6368c1c4f322ec9a7762b0e731f8783"

URI_aarch64_python3-sphinxcontrib-spelling = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinxcontrib-spelling-7.3.3-17.el10_3.noarch.rpm;name=aarch64_python3-sphinxcontrib-spelling;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinxcontrib-spelling}"
SRC_URI[aarch64_python3-sphinxcontrib-spelling.sha256sum] = "76af0074c38f2bbc41d761b2e88e688fcdedc1689c6d0406eef18436bd97541b"

RDEPENDS:python3-sphinxcontrib-spelling = " \
 python3 \
 python3-enchant \
 python3-sphinx \
 "
