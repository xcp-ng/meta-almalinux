# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-ansible-posix"
PV = "2.2.1"
PR = "1.el10_2"
PACKAGES = " \
 ansible-collection-ansible-posix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-ansible-posix-2.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01e20014955756ccbed0af8155ac7ca45c8d0880eff515e24b9af396501ee0b2"

URI_x86_64_v2_ansible-collection-ansible-posix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-ansible-posix-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-ansible-posix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-ansible-posix}"
SRC_URI[x86_64_v2_ansible-collection-ansible-posix.sha256sum] = "27eaedb22f3160438462eb9fca35b1d284ce7acd69386d709c69a0c55ae1cf9d"

URI_aarch64_ansible-collection-ansible-posix = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-ansible-posix-2.2.1-1.el10_2.noarch.rpm;name=aarch64_ansible-collection-ansible-posix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-ansible-posix}"
SRC_URI[aarch64_ansible-collection-ansible-posix.sha256sum] = "eda5e2e90a0e5ba37c172f39f2f0c3a454e7d1a0799e813e1b79f899d9cea5fa"

RDEPENDS:ansible-collection-ansible-posix = " \
 ansible-core \
 "
