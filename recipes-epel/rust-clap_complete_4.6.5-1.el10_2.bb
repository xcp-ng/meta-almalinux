# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_complete"
PV = "4.6.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-clap_complete+debug-devel \
 rust-clap_complete+default-devel \
 rust-clap_complete+unstable-doc-devel \
 rust-clap_complete+unstable-dynamic-devel \
 rust-clap_complete-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_complete-4.6.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d453317b94c67dc4a17a63134020a1c8777a959913cc426a0252e789242e587c"

URI_x86_64_v2_rust-clap_complete+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+debug-devel-4.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+debug-devel.sha256sum] = "20af58a75d0b116cd3f3ddd7a7367a933822f7426954d07cea79e3e26771f257"

URI_x86_64_v2_rust-clap_complete+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+default-devel-4.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+default-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+default-devel.sha256sum] = "a28087e224e8cc36f15a4f5aed13ec25ccfd7882e59a96a2a8ffd5213a2a86ab"

URI_x86_64_v2_rust-clap_complete+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+unstable-doc-devel-4.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+unstable-doc-devel.sha256sum] = "0a332f8938da37612dc7b1b29c007dc0cc51fcc782fe63a03412bb63350f8bc0"

URI_x86_64_v2_rust-clap_complete+unstable-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+unstable-dynamic-devel-4.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+unstable-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+unstable-dynamic-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+unstable-dynamic-devel.sha256sum] = "8aeaa78c8eef839ff4860642991d47358a0c55fb7d5a601470c792dc45aeb408"

URI_x86_64_v2_rust-clap_complete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete-devel-4.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete-devel}"
SRC_URI[x86_64_v2_rust-clap_complete-devel.sha256sum] = "6349afa5a5329084b32779602805a9fb4b69b7917bee12ea4c11f12747800dc7"

URI_aarch64_rust-clap_complete+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+debug-devel-4.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-clap_complete+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+debug-devel}"
SRC_URI[aarch64_rust-clap_complete+debug-devel.sha256sum] = "91489593202b42a9a5adc1ab76ea38441b434278156cb28c77f5249ee49e09d1"

URI_aarch64_rust-clap_complete+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+default-devel-4.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-clap_complete+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+default-devel}"
SRC_URI[aarch64_rust-clap_complete+default-devel.sha256sum] = "b5779623f97928d69d199471422f57e9fcd8a6627c05d3ff9ae75ac405dbed19"

URI_aarch64_rust-clap_complete+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+unstable-doc-devel-4.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-clap_complete+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap_complete+unstable-doc-devel.sha256sum] = "fbc00c49ca03cfb3ef9cd45da45fa7567f8ff342ecee91153f6fef0ecaece9f4"

URI_aarch64_rust-clap_complete+unstable-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+unstable-dynamic-devel-4.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-clap_complete+unstable-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+unstable-dynamic-devel}"
SRC_URI[aarch64_rust-clap_complete+unstable-dynamic-devel.sha256sum] = "5db7e09fd5e72ec4cd27105026e02d45e2893d027017f3c209fc519f7684a089"

URI_aarch64_rust-clap_complete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete-devel-4.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete-devel}"
SRC_URI[aarch64_rust-clap_complete-devel.sha256sum] = "3da5ec990ae22bfa4c979f88dc3d9982fec7c0275a6108ee45bc86143e975b95"

RDEPENDS:rust-clap_complete+debug-devel = " \
 cargo \
 rust-clap+debug-devel \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+default-devel = " \
 cargo \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+unstable-doc-devel = " \
 cargo \
 rust-clap_complete+unstable-dynamic-devel \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+unstable-dynamic-devel = " \
 cargo \
 rust-clap+unstable-ext-devel \
 rust-clap_complete-devel \
 rust-clap_lex+default-devel \
 rust-is_executable+default-devel \
 rust-shlex+default-devel \
 "
RDEPENDS:rust-clap_complete-devel = " \
 cargo \
 rust \
 rust-clap+std-devel \
 rust-clap-devel \
 "
