# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gmpy2"
PV = "2.2.1"
PR = "1.el10_0"
PACKAGES = " \
 python-gmpy2-doc \
 python3-gmpy2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-gmpy2-2.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0aaa80c4ef4636a31c174ee3c459dc3fb05a575fe088fcd1e14d8168a6424b6"

URI_x86_64_v2_python-gmpy2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-gmpy2-doc-2.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-gmpy2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-gmpy2-doc}"
SRC_URI[x86_64_v2_python-gmpy2-doc.sha256sum] = "70ea94a16d6bc9a8d08987f355e6a64c72d61b910ef50610209173f339d543ca"

URI_x86_64_v2_python3-gmpy2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gmpy2-2.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-gmpy2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gmpy2}"
SRC_URI[x86_64_v2_python3-gmpy2.sha256sum] = "c0df64b5b1f82b1c7348c60ede951dd3062ccebd1b27553b60dcda22520d70ba"

URI_aarch64_python-gmpy2-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-gmpy2-doc-2.2.1-1.el10_0.noarch.rpm;name=aarch64_python-gmpy2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-gmpy2-doc}"
SRC_URI[aarch64_python-gmpy2-doc.sha256sum] = "4ab564032b9e17fcef16885bef643309af4e463c56e6cc38e02e7738a2651b63"

URI_aarch64_python3-gmpy2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gmpy2-2.2.1-1.el10_0.aarch64.rpm;name=aarch64_python3-gmpy2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gmpy2}"
SRC_URI[aarch64_python3-gmpy2.sha256sum] = "82c71465ef802b53888458bf7821d339743b0a898c6b57ef75e0d4fa76cefa1b"

RDEPENDS:python-gmpy2-doc = " \
 "
RDEPENDS:python3-gmpy2 = " \
 glibc \
 gmp \
 libmpc \
 mpfr \
 python3 \
 "
