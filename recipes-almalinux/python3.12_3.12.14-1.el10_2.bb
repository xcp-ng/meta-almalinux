# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.12"
PV = "3.12.14"
PR = "1.el10_2"
PACKAGES = " \
 python-unversioned-command \
 python3 \
 python3-debug \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python3.12-3.12.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a7cfb772f832f70a46195a40b30ed90b1fbe94c878b114b01cb04855ce3a83fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-unversioned-command-3.12.14-1.el10_2.noarch.rpm;name=x86_64_v2_python-unversioned-command;unpack=0"
SRC_URI[x86_64_v2_python-unversioned-command.sha256sum] = "432002d2f2d16400a23c31dbfa20b3800372adba8054dfdfcb8877898640e6a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-3.12.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3;unpack=0"
SRC_URI[x86_64_v2_python3.sha256sum] = "803d167dddf4e268001e42d50b96b1902326a20c1a597f08c7a39ea24fde7ff7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-debug-3.12.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-debug;unpack=0"
SRC_URI[x86_64_v2_python3-debug.sha256sum] = "63f95d993cbac755ac91e6c5f73d8dc5017d8be62582be98b7d9c03fa47e9346"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-devel-3.12.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-devel;unpack=0"
SRC_URI[x86_64_v2_python3-devel.sha256sum] = "5815e14aac1297033c18aef37d186e618e68eb430ab8710d39ad59f30dcfa66a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-idle-3.12.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-idle;unpack=0"
SRC_URI[x86_64_v2_python3-idle.sha256sum] = "4ab632bcf36a5064910de9543ca95372e7100f934d41d308f6c25925bb56ca7e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libs-3.12.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-libs;unpack=0"
SRC_URI[x86_64_v2_python3-libs.sha256sum] = "ffba5760a323e31a0831b04ffba6fefe5bde34c72eabff6d95e7ee8e2249ecf3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-test-3.12.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-test;unpack=0"
SRC_URI[x86_64_v2_python3-test.sha256sum] = "1f260b635c1d1e98f59ad3ed8cc7b69f2804b3dfa5105329fecedc95870871e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tkinter-3.12.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-tkinter;unpack=0"
SRC_URI[x86_64_v2_python3-tkinter.sha256sum] = "6ec8c395063b2b5412a30939532c5bc79ef85c8201d17c0ab970bb4c43d1763a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-unversioned-command-3.12.14-1.el10_2.noarch.rpm;name=aarch64_python-unversioned-command;unpack=0"
SRC_URI[aarch64_python-unversioned-command.sha256sum] = "432002d2f2d16400a23c31dbfa20b3800372adba8054dfdfcb8877898640e6a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-3.12.14-1.el10_2.aarch64.rpm;name=aarch64_python3;unpack=0"
SRC_URI[aarch64_python3.sha256sum] = "9d34c9eb86e851b2604364995c8b6f47ae3549f67163c9fec60ec4ee7e3e8dee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-debug-3.12.14-1.el10_2.aarch64.rpm;name=aarch64_python3-debug;unpack=0"
SRC_URI[aarch64_python3-debug.sha256sum] = "4f4ac3544f936317711ec7849dda248fbafdaff23b2641d3d12f1d92299d4c04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-devel-3.12.14-1.el10_2.aarch64.rpm;name=aarch64_python3-devel;unpack=0"
SRC_URI[aarch64_python3-devel.sha256sum] = "aa62573ea1fd2fa387fc07ef60607e03406415f74ffe311bcb52fe109bfe156a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-idle-3.12.14-1.el10_2.aarch64.rpm;name=aarch64_python3-idle;unpack=0"
SRC_URI[aarch64_python3-idle.sha256sum] = "97f6d332bbb662d060ba71f117c48bed55a55815b7ef06ad530f4d9e1337a761"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libs-3.12.14-1.el10_2.aarch64.rpm;name=aarch64_python3-libs;unpack=0"
SRC_URI[aarch64_python3-libs.sha256sum] = "08cfb7bf64453fe1a3c76ede235dd4947fa21c63deb7bfc77fbeaf68341ee308"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-test-3.12.14-1.el10_2.aarch64.rpm;name=aarch64_python3-test;unpack=0"
SRC_URI[aarch64_python3-test.sha256sum] = "1f52a5ed8637a5f94e301974d92ac18c36e7df23fd391dc7f55224da045128fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tkinter-3.12.14-1.el10_2.aarch64.rpm;name=aarch64_python3-tkinter;unpack=0"
SRC_URI[aarch64_python3-tkinter.sha256sum] = "13b8c93542c4dd0a85473742b5bca21435fdd93d7ed68e77d1de29e953b057ee"

RDEPENDS:python-unversioned-command = " \
 python3 \
 "
RDEPENDS:python3 = " \
 glibc \
 python3-libs \
 "
RDEPENDS:python3-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3 \
 python3-libs \
 python3-rpm-generators \
 python3-rpm-macros \
 "
RDEPENDS:python3-idle = " \
 python3 \
 python3-tkinter \
 "
RDEPENDS:python3-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-test = " \
 bash \
 glibc \
 python3 \
 python3-libs \
 python3-setuptools-wheel \
 python3-wheel-wheel \
 "
RDEPENDS:python3-tkinter = " \
 glibc \
 python3 \
 tcl \
 tk \
 "
