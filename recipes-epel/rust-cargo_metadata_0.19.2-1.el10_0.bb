# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_metadata"
PV = "0.19.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-cargo_metadata+builder-devel \
 rust-cargo_metadata+default-devel \
 rust-cargo_metadata+derive_builder-devel \
 rust-cargo_metadata+unstable-devel \
 rust-cargo_metadata-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_metadata-0.19.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6c98efc9e5037eebbc7d03efe6107fa7293dc30616686ff89dca28f8413f5dd"

URI_x86_64_v2_rust-cargo_metadata+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+builder-devel-0.19.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+builder-devel.sha256sum] = "26718097bb5c245faeb8c7854eb04ba53412e3fbb5e193a94425be691cd5d9ad"

URI_x86_64_v2_rust-cargo_metadata+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+default-devel-0.19.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+default-devel.sha256sum] = "76366f20fbef7af506547fb445d2d7e5260bec27fafa785552d93cec5b2c44d9"

URI_x86_64_v2_rust-cargo_metadata+derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+derive_builder-devel-0.19.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+derive_builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+derive_builder-devel.sha256sum] = "00b9cd9afb7dcabe209a50618486fcca642a7353c4b506b1a2b923910d4efb0e"

URI_x86_64_v2_rust-cargo_metadata+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+unstable-devel-0.19.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+unstable-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+unstable-devel.sha256sum] = "1369fd8b4e9a83002dc19e80e724a21b1fbbf2c78224d78ffa42a1377874dd39"

URI_x86_64_v2_rust-cargo_metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata-devel-0.19.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata-devel.sha256sum] = "af16a15c30e49e6a488ec39fe0f3dba42364a7cd48b2bc403acb60c38ce30cd6"

URI_aarch64_rust-cargo_metadata+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+builder-devel-0.19.2-1.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata+builder-devel.sha256sum] = "9110669523a3148eb028407b2b5e8df4152d60291d6bcdc90610fd2aef0e9073"

URI_aarch64_rust-cargo_metadata+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+default-devel-0.19.2-1.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+default-devel}"
SRC_URI[aarch64_rust-cargo_metadata+default-devel.sha256sum] = "407091b966fdaf1fd020df2bbe9fdbcbc6054aff59da59818b22b0d36cbf68d0"

URI_aarch64_rust-cargo_metadata+derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+derive_builder-devel-0.19.2-1.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+derive_builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata+derive_builder-devel.sha256sum] = "2fba08c2e0f09bd052df2af51fe7a4a95455d661f5853ada64e9bfc338d783be"

URI_aarch64_rust-cargo_metadata+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+unstable-devel-0.19.2-1.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+unstable-devel}"
SRC_URI[aarch64_rust-cargo_metadata+unstable-devel.sha256sum] = "1a97b82c7894fe49e9809f46b9ac31f840e22f73c0bc445f92ea2a5896f692d1"

URI_aarch64_rust-cargo_metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata-devel-0.19.2-1.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata-devel}"
SRC_URI[aarch64_rust-cargo_metadata-devel.sha256sum] = "797cdba1d3c8f941b62ec425761d1e984981c8eae3ac14d28d4344eaf3bfd0b1"

RDEPENDS:rust-cargo_metadata+builder-devel = " \
 cargo \
 rust-cargo_metadata+derive_builder-devel \
 rust-cargo_metadata-devel \
 "
RDEPENDS:rust-cargo_metadata+default-devel = " \
 cargo \
 rust-cargo_metadata-devel \
 "
RDEPENDS:rust-cargo_metadata+derive_builder-devel = " \
 cargo \
 rust-cargo_metadata-devel \
 rust-derive_builder+default-devel \
 "
RDEPENDS:rust-cargo_metadata+unstable-devel = " \
 cargo \
 rust-cargo_metadata-devel \
 "
RDEPENDS:rust-cargo_metadata-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-camino+serde1-devel \
 rust-cargo-platform+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-thiserror+default-devel \
 "
