# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-miette"
PV = "7.6.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-miette+default-devel \
 rust-miette+derive-devel \
 rust-miette+fancy-base-devel \
 rust-miette+fancy-devel \
 rust-miette+fancy-no-backtrace-devel \
 rust-miette+fancy-no-syscall-devel \
 rust-miette+no-format-args-capture-devel \
 rust-miette+serde-devel \
 rust-miette+syntect-highlighter-devel \
 rust-miette-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-miette-7.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "faa4fbd5b8328ad45488d23fc6c28b3f62ff7ada446a6cc7e37f882c3d9ab479"

URI_x86_64_v2_rust-miette+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+default-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+default-devel}"
SRC_URI[x86_64_v2_rust-miette+default-devel.sha256sum] = "bdabfc5c621b55b6cac3852e3f2cd2d57d9934ac553d9a9078cabe8b36a93474"

URI_x86_64_v2_rust-miette+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+derive-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+derive-devel}"
SRC_URI[x86_64_v2_rust-miette+derive-devel.sha256sum] = "581546d376b07f8e7cb840489375625d49528c569aa26fc975bec02f83b0c18f"

URI_x86_64_v2_rust-miette+fancy-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-base-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-base-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-base-devel.sha256sum] = "73bb302f5871aef6313fe013c3c967d6c66b6fc2e6f32f2609dae1d35a26bab7"

URI_x86_64_v2_rust-miette+fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-devel.sha256sum] = "3f50787f2b2435691c1f9f95283a0d7961aa588525782641e25d653fbe9f9c44"

URI_x86_64_v2_rust-miette+fancy-no-backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-no-backtrace-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-no-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-no-backtrace-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-no-backtrace-devel.sha256sum] = "f14b3471954b5ed62a8f60052d98d5375c4fc29445e52121fcda27db7cf734d1"

URI_x86_64_v2_rust-miette+fancy-no-syscall-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-no-syscall-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-no-syscall-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-no-syscall-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-no-syscall-devel.sha256sum] = "7c971381d20b758f691d26032e86df599a1fe92b66257e309293375b3af6c15f"

URI_x86_64_v2_rust-miette+no-format-args-capture-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+no-format-args-capture-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+no-format-args-capture-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+no-format-args-capture-devel}"
SRC_URI[x86_64_v2_rust-miette+no-format-args-capture-devel.sha256sum] = "b628236eea73a7764ac0e7b5aef27a879ed16ed0da29d6dca4e0744cbf376ccb"

URI_x86_64_v2_rust-miette+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+serde-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+serde-devel}"
SRC_URI[x86_64_v2_rust-miette+serde-devel.sha256sum] = "d08e89b605ab5e797e1af8488f3b96dbed1527e2dcdd4feb72e6b2f1203fe5dd"

URI_x86_64_v2_rust-miette+syntect-highlighter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+syntect-highlighter-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+syntect-highlighter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+syntect-highlighter-devel}"
SRC_URI[x86_64_v2_rust-miette+syntect-highlighter-devel.sha256sum] = "26e45c1cef89e280b106c11697f5341b95790f61214d26bb1b0b0d46a65cffb4"

URI_x86_64_v2_rust-miette-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette-devel-7.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette-devel}"
SRC_URI[x86_64_v2_rust-miette-devel.sha256sum] = "129c4f3bc394d43137a7ab0477b373c76fce214c7f3035e9d3b1c936c9ecd73f"

URI_aarch64_rust-miette+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+default-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+default-devel}"
SRC_URI[aarch64_rust-miette+default-devel.sha256sum] = "923a9e22fc9c379cdd7c0f2262f6d51856093a06f1cb9664034fe1bef3a26bce"

URI_aarch64_rust-miette+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+derive-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+derive-devel}"
SRC_URI[aarch64_rust-miette+derive-devel.sha256sum] = "c88d249ed23a14d102c05aaa846dcc098d6f23400610720d84a91e1df0d821b7"

URI_aarch64_rust-miette+fancy-base-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-base-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette+fancy-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-base-devel}"
SRC_URI[aarch64_rust-miette+fancy-base-devel.sha256sum] = "aac471118f02912c7410d6a684e4ff0dba14892786b53d6de963c1d2a85b820e"

URI_aarch64_rust-miette+fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette+fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-devel}"
SRC_URI[aarch64_rust-miette+fancy-devel.sha256sum] = "5d9eb8fb3dec792a20bfe9240b6e7706d33b2e889ccb5074ea77f456fbe5efbe"

URI_aarch64_rust-miette+fancy-no-backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-no-backtrace-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette+fancy-no-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-no-backtrace-devel}"
SRC_URI[aarch64_rust-miette+fancy-no-backtrace-devel.sha256sum] = "ceab8e47cb6c3f3f40268383e2bbc4a923dfd9679d5d8cd7e6fb76e86d15969c"

URI_aarch64_rust-miette+fancy-no-syscall-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-no-syscall-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette+fancy-no-syscall-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-no-syscall-devel}"
SRC_URI[aarch64_rust-miette+fancy-no-syscall-devel.sha256sum] = "dcb546f9c5d4d461fa7d81267cfe29c2e963874613e5f49cb9501ab345a74589"

URI_aarch64_rust-miette+no-format-args-capture-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+no-format-args-capture-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette+no-format-args-capture-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+no-format-args-capture-devel}"
SRC_URI[aarch64_rust-miette+no-format-args-capture-devel.sha256sum] = "07c21cb0688428cf970f961bc87364fd9c2e1c6b76eef1a40f57097d332d2050"

URI_aarch64_rust-miette+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+serde-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+serde-devel}"
SRC_URI[aarch64_rust-miette+serde-devel.sha256sum] = "863d72b48b7f8c5eaaf4f9e69666531fe49184899d8ce955865a9be02e2b5b13"

URI_aarch64_rust-miette+syntect-highlighter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+syntect-highlighter-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette+syntect-highlighter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+syntect-highlighter-devel}"
SRC_URI[aarch64_rust-miette+syntect-highlighter-devel.sha256sum] = "0bb435d6f95bf69cbf31e5c3be91bbf8e8746b94b564fd81281e0e9566a86922"

URI_aarch64_rust-miette-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette-devel-7.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-miette-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette-devel}"
SRC_URI[aarch64_rust-miette-devel.sha256sum] = "b40c9a5a1f3db4c398a6897e948a454e26025d798d80b5a4f7a8700729030e47"

RDEPENDS:rust-miette+default-devel = " \
 cargo \
 rust-miette+derive-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+derive-devel = " \
 cargo \
 rust-miette-derive+default-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+fancy-base-devel = " \
 cargo \
 rust-miette-devel \
 rust-owo-colors+default-devel \
 rust-textwrap+unicode-linebreak-devel \
 rust-textwrap+unicode-width-devel \
 rust-textwrap-devel \
 "
RDEPENDS:rust-miette+fancy-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-backtrace-ext+default-devel \
 rust-miette+fancy-no-backtrace-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+fancy-no-backtrace-devel = " \
 cargo \
 rust-miette+fancy-base-devel \
 rust-miette-devel \
 rust-supports-color+default-devel \
 rust-supports-hyperlinks+default-devel \
 rust-supports-unicode+default-devel \
 rust-terminal_size+default-devel \
 "
RDEPENDS:rust-miette+fancy-no-syscall-devel = " \
 cargo \
 rust-miette+fancy-base-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+no-format-args-capture-devel = " \
 cargo \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+serde-devel = " \
 cargo \
 rust-miette-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-miette+syntect-highlighter-devel = " \
 cargo \
 rust-miette+fancy-no-backtrace-devel \
 rust-miette-devel \
 rust-syntect+default-devel \
 "
RDEPENDS:rust-miette-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-unicode-width0.1+default-devel \
 "
