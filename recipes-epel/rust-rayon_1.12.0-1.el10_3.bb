# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rayon"
PV = "1.12.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-rayon+default-devel \
 rust-rayon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rayon-1.12.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b173bb5ddb0298948bc75e3cec1815184780d91d528eef0a438c2e3f4a8c3a25"

URI_x86_64_v2_rust-rayon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rayon+default-devel-1.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rayon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rayon+default-devel}"
SRC_URI[x86_64_v2_rust-rayon+default-devel.sha256sum] = "cbbbe4fda62f13abfd2695025c20415e912c7589c47d6af23e4e2e5bbe6e84b4"

URI_x86_64_v2_rust-rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rayon-devel-1.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rayon-devel}"
SRC_URI[x86_64_v2_rust-rayon-devel.sha256sum] = "e5705bde4f44172d2f1e79eff0dfa1d9137210e349e714cfdb3d9b2768cfd680"

URI_aarch64_rust-rayon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rayon+default-devel-1.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-rayon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rayon+default-devel}"
SRC_URI[aarch64_rust-rayon+default-devel.sha256sum] = "559c9081a2576965efa044dad1e4b595b58b9a1cd30b32e4cc80a9273037ad02"

URI_aarch64_rust-rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rayon-devel-1.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rayon-devel}"
SRC_URI[aarch64_rust-rayon-devel.sha256sum] = "f6008d51b87b2ab35db43b6327a881e0f894607420f227029af1e420c65d329b"

RDEPENDS:rust-rayon+default-devel = " \
 cargo \
 rust-rayon-devel \
 "
RDEPENDS:rust-rayon-devel = " \
 cargo \
 rust \
 rust-either-devel \
 rust-rayon-core+default-devel \
 "
