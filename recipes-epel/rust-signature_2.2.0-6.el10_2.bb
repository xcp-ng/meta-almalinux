# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signature"
PV = "2.2.0"
PR = "6.el10_2"
PACKAGES = " \
 rust-signature+alloc-devel \
 rust-signature+default-devel \
 rust-signature+derive-devel \
 rust-signature+digest-devel \
 rust-signature+rand_core-devel \
 rust-signature+std-devel \
 rust-signature-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signature-2.2.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6c5563497e825807d17e83893d042abb623ce27804004274a3a55051e5467a5"

URI_x86_64_v2_rust-signature+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+alloc-devel-2.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+alloc-devel}"
SRC_URI[x86_64_v2_rust-signature+alloc-devel.sha256sum] = "fb79ba3bbee12c04683235a910940b6ba01fcd38ec237b88cf90b148056c8226"

URI_x86_64_v2_rust-signature+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+default-devel-2.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+default-devel}"
SRC_URI[x86_64_v2_rust-signature+default-devel.sha256sum] = "6ae76b991dec933ea30097f1672630548ba509caa156ea00a1dc2673bf15b450"

URI_x86_64_v2_rust-signature+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+derive-devel-2.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+derive-devel}"
SRC_URI[x86_64_v2_rust-signature+derive-devel.sha256sum] = "bf043ae6d2fb5f02ec10b675737949540564688b6ee2efd9d4794df15b71e35b"

URI_x86_64_v2_rust-signature+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+digest-devel-2.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+digest-devel}"
SRC_URI[x86_64_v2_rust-signature+digest-devel.sha256sum] = "e9f6a3979d0740f1c18a22f174497ffe44d891761da91d730687ddfb8cac1bb6"

URI_x86_64_v2_rust-signature+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+rand_core-devel-2.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+rand_core-devel}"
SRC_URI[x86_64_v2_rust-signature+rand_core-devel.sha256sum] = "5ffc7ca51b335d1e6cd8aa9b7c56a4f6a4c2dc9d0bdf73328c3e92eda61d0b57"

URI_x86_64_v2_rust-signature+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature+std-devel-2.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature+std-devel}"
SRC_URI[x86_64_v2_rust-signature+std-devel.sha256sum] = "17b40ee4b2ffc316f34ccc0e00ffe29e44275cc50c9ca557642c91afb95a393a"

URI_x86_64_v2_rust-signature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signature-devel-2.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signature-devel}"
SRC_URI[x86_64_v2_rust-signature-devel.sha256sum] = "3cdcaf6a498945308180c00691298280287cd305003bd613d3bb6c7a88ae6b58"

URI_aarch64_rust-signature+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+alloc-devel-2.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-signature+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+alloc-devel}"
SRC_URI[aarch64_rust-signature+alloc-devel.sha256sum] = "687f066ce18140c178a9bf3787f4cfeca0d57837dcf2e09fb5474376caa79d8c"

URI_aarch64_rust-signature+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+default-devel-2.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-signature+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+default-devel}"
SRC_URI[aarch64_rust-signature+default-devel.sha256sum] = "d8078d761e8ffde37b18de1cd6c75403f5631195f35965d452ca2161e10f3b0d"

URI_aarch64_rust-signature+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+derive-devel-2.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-signature+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+derive-devel}"
SRC_URI[aarch64_rust-signature+derive-devel.sha256sum] = "412c5f528d1831c6beb68f9db525fb2ef427e94c2404d85a2f63c90d4d047f21"

URI_aarch64_rust-signature+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+digest-devel-2.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-signature+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+digest-devel}"
SRC_URI[aarch64_rust-signature+digest-devel.sha256sum] = "34b86be74acdae74a41f5a6adb73712e7c9bbfeec6071798ce07f755964d0ab4"

URI_aarch64_rust-signature+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+rand_core-devel-2.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-signature+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+rand_core-devel}"
SRC_URI[aarch64_rust-signature+rand_core-devel.sha256sum] = "75f7598384aca09bcd4af25e4466ed7ba16d8fbab10c9d0fe0b0f116f31531db"

URI_aarch64_rust-signature+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature+std-devel-2.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-signature+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature+std-devel}"
SRC_URI[aarch64_rust-signature+std-devel.sha256sum] = "a8f25ff47bb5af802588e1399ba854f263d3b06caae167a2989726b065441b12"

URI_aarch64_rust-signature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signature-devel-2.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-signature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signature-devel}"
SRC_URI[aarch64_rust-signature-devel.sha256sum] = "0789f3209518f281cbf68c0a3c966d683d8c41ddc61b1347f239fc8b11a01053"

RDEPENDS:rust-signature+alloc-devel = " \
 cargo \
 rust-signature-devel \
 "
RDEPENDS:rust-signature+default-devel = " \
 cargo \
 rust-signature-devel \
 "
RDEPENDS:rust-signature+derive-devel = " \
 cargo \
 rust-signature-devel \
 rust-signature_derive+default-devel \
 "
RDEPENDS:rust-signature+digest-devel = " \
 cargo \
 rust-digest-devel \
 rust-signature-devel \
 "
RDEPENDS:rust-signature+rand_core-devel = " \
 cargo \
 rust-rand_core0.6-devel \
 rust-signature-devel \
 "
RDEPENDS:rust-signature+std-devel = " \
 cargo \
 rust-rand_core0.6+std-devel \
 rust-rand_core0.6-devel \
 rust-signature+alloc-devel \
 rust-signature-devel \
 "
RDEPENDS:rust-signature-devel = " \
 cargo \
 rust \
 "
