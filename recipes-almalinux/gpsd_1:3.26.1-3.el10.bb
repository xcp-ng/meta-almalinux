# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd"
PE = "1"
PV = "3.26.1"
PR = "3.el10"
PACKAGES = " \
 gpsd \
 gpsd-clients \
 python3-gpsd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gpsd-3.26.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aad20ca0c14b0e7bee91107a058751389e497830e5ddc2bcd63cd0a0cf532a53"

URI_x86_64_v2_gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-3.26.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd}"
SRC_URI[x86_64_v2_gpsd.sha256sum] = "022f4eaf736c30f4468681741b3807d3584841061f113b22a26d56ee77b7aa9c"

URI_x86_64_v2_gpsd-clients = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-clients-3.26.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_gpsd-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd-clients}"
SRC_URI[x86_64_v2_gpsd-clients.sha256sum] = "edbdf3ef5c815c2b04820436c1432872d2c2e8ee0ae696dff1956dcfae8590c5"

URI_x86_64_v2_python3-gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-gpsd-3.26.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gpsd}"
SRC_URI[x86_64_v2_python3-gpsd.sha256sum] = "065b68c7416dc99727042cf8da08f92463a1e7e610e674292de70812eadf3131"

URI_aarch64_gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-3.26.1-3.el10.aarch64.rpm;name=aarch64_gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd}"
SRC_URI[aarch64_gpsd.sha256sum] = "7980eaeebc7c03f556bd1f2a1b1bca319fd24d7302f13f73b6e0c69da51fb2f6"

URI_aarch64_gpsd-clients = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-clients-3.26.1-3.el10.aarch64.rpm;name=aarch64_gpsd-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-clients}"
SRC_URI[aarch64_gpsd-clients.sha256sum] = "0c081dfcaeb31fe514736ab37a8cd87eb3acc37c62dcc365df4215fcde32f085"

URI_aarch64_python3-gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-gpsd-3.26.1-3.el10.aarch64.rpm;name=aarch64_python3-gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gpsd}"
SRC_URI[aarch64_python3-gpsd.sha256sum] = "d89906e3d865fc3fa7b562b50c414c5968f6e56560a698720ab2b7bf46c430d1"

RDEPENDS:gpsd = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 systemd \
 systemd-udev \
 "
RDEPENDS:gpsd-clients = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 python3 \
 python3-gpsd \
 "
RDEPENDS:python3-gpsd = " \
 glibc \
 python3 \
 python3-pyserial \
 "
