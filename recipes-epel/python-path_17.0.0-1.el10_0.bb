# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-path"
PV = "17.0.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-path \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-path-17.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2f96065f99713723c9dd2a67e49e32416e02426cd71643ea54da73e8d11c12a"

URI_x86_64_v2_python3-path = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-path-17.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-path;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-path}"
SRC_URI[x86_64_v2_python3-path.sha256sum] = "d0b919528757fbffcdb3b3fdf9754b7317e89ec8783dd8ff960aaab49168b49f"

URI_aarch64_python3-path = "${EPEL_MIRROR}/aarch64/Packages/p/python3-path-17.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-path;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-path}"
SRC_URI[aarch64_python3-path.sha256sum] = "2a15ca8652475d8c2d30ffc1f7fdfb041a43832e12030fb37b2174890b36e386"

RDEPENDS:python3-path = " \
 python3 \
 "
