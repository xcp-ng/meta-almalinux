# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-simple-cabal"
PV = "0.2.1"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 ghc-simple-cabal \
 ghc-simple-cabal-devel \
 ghc-simple-cabal-doc \
"
PACKAGES:aarch64 = " \
 ghc-simple-cabal \
 ghc-simple-cabal-devel \
 ghc-simple-cabal-doc \
 ghc-simple-cabal-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-simple-cabal-0.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d340dd34506b488d9191dc636cf1a01fe238c312b276277bd142dde64546eb2d"

URI_x86_64_v2_ghc-simple-cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cabal-0.2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cabal}"
SRC_URI[x86_64_v2_ghc-simple-cabal.sha256sum] = "3edf8a6d3304f619ecefab533c97d0c0147370213db067b055912ee8ec9f9e8d"

URI_x86_64_v2_ghc-simple-cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cabal-devel-0.2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-simple-cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cabal-devel}"
SRC_URI[x86_64_v2_ghc-simple-cabal-devel.sha256sum] = "50308240896d23a2da9254c222d2542d96245df40f71962a11ebd25a99685adf"

URI_x86_64_v2_ghc-simple-cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-simple-cabal-doc-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-simple-cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-simple-cabal-doc}"
SRC_URI[x86_64_v2_ghc-simple-cabal-doc.sha256sum] = "7931f12e4b205241ca89574c3f8a1e2bcd8fc3976b579a1cb469c682a01ef8d6"

URI_aarch64_ghc-simple-cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cabal-0.2.1-1.el10_2.aarch64.rpm;name=aarch64_ghc-simple-cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cabal}"
SRC_URI[aarch64_ghc-simple-cabal.sha256sum] = "977b4810de9705a20584089e5ed0092e877faaca6e048a35574259d39d16a6a5"

URI_aarch64_ghc-simple-cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cabal-devel-0.2.1-1.el10_2.aarch64.rpm;name=aarch64_ghc-simple-cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cabal-devel}"
SRC_URI[aarch64_ghc-simple-cabal-devel.sha256sum] = "af7b6a2f33deb1a8e11d774f3cad7fd22db16c4f7d3fbe943b9d6f9fda894e25"

URI_aarch64_ghc-simple-cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cabal-doc-0.2.1-1.el10_2.noarch.rpm;name=aarch64_ghc-simple-cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cabal-doc}"
SRC_URI[aarch64_ghc-simple-cabal-doc.sha256sum] = "f7ee561544d7e64616314cc4b1053ba19f0c785ba0b9f55952d2301e8122d415"

URI_aarch64_ghc-simple-cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-simple-cabal-prof-0.2.1-1.el10_2.aarch64.rpm;name=aarch64_ghc-simple-cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-simple-cabal-prof}"
SRC_URI[aarch64_ghc-simple-cabal-prof.sha256sum] = "ffe307d23d5be126bb6a06ef92d8668792f423a6a74dd9ee9d654381e85ec5af"

RDEPENDS:ghc-simple-cabal = " \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-simple-cabal-devel = " \
 ghc-Cabal-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-simple-cabal \
 "
RDEPENDS:ghc-simple-cabal-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-simple-cabal-prof = " \
 ghc-Cabal-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-simple-cabal-devel \
 "
