# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samdump2"
PV = "3.0.0"
PR = "29.el10_0"
PACKAGES = " \
 samdump2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/samdump2-3.0.0-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a09b3c963e3f3971ac3df53fbeaaec4390c2a87055d7b6897da30a9243b82e8"

URI_x86_64_v2_samdump2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/samdump2-3.0.0-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_samdump2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samdump2}"
SRC_URI[x86_64_v2_samdump2.sha256sum] = "1cd01bc730d718d82ff5dd9fe25c7f44c10a53c8eb6458cf25414e18ae07d42c"

URI_aarch64_samdump2 = "${EPEL_MIRROR}/aarch64/Packages/s/samdump2-3.0.0-29.el10_0.aarch64.rpm;name=aarch64_samdump2;unpack=0"
SRC_URI:append = " ${URI_aarch64_samdump2}"
SRC_URI[aarch64_samdump2.sha256sum] = "12fe3f19bf4190f20f35fa59d05a155039987611457cce7240378d211877118c"

RDEPENDS:samdump2 = " \
 glibc \
 openssl-libs \
 "
