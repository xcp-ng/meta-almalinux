# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "realtime-tests"
PV = "2.9"
PR = "1.el10"
PACKAGES = " \
 realtime-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/realtime-tests-2.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57b60f2729b345597840f29a92ef825871cfcf52e52d50089c152c76e7e203a6"

URI_x86_64_v2_realtime-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/realtime-tests-2.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_realtime-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_realtime-tests}"
SRC_URI[x86_64_v2_realtime-tests.sha256sum] = "396db07f3f2976dd8f5514d25e3d9c816a02597572e846532e0e2b7def01f5a9"

URI_aarch64_realtime-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/realtime-tests-2.9-1.el10.aarch64.rpm;name=aarch64_realtime-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_realtime-tests}"
SRC_URI[aarch64_realtime-tests.sha256sum] = "c10e0adb3a2dde9ea33a74841a06bef2ca3ce0292d73f90fea6e481c48338140"

RDEPENDS:realtime-tests = " \
 bash \
 bc \
 glibc \
 kernel-tools-libs \
 numactl-libs \
 python3 \
 "
