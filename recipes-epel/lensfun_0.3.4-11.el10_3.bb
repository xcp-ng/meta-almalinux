# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lensfun"
PV = "0.3.4"
PR = "11.el10_3"
PACKAGES = " \
 lensfun \
 lensfun-devel \
 lensfun-tools \
 python3-lensfun \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lensfun-0.3.4-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72ea00f87498234c241f7acecd3948ca4ab642aec76032b461ae9dfed9b5337d"

URI_x86_64_v2_lensfun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lensfun-0.3.4-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lensfun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lensfun}"
SRC_URI[x86_64_v2_lensfun.sha256sum] = "e706e9eb72fa4dad4be02c47f5572635f93a32602ff90ea07dd9a9a59a19f800"

URI_x86_64_v2_lensfun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lensfun-devel-0.3.4-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lensfun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lensfun-devel}"
SRC_URI[x86_64_v2_lensfun-devel.sha256sum] = "571fa903be5871529f66a80971ec720c9069f27f5679315fd4b95941ff66231b"

URI_x86_64_v2_lensfun-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lensfun-tools-0.3.4-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lensfun-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lensfun-tools}"
SRC_URI[x86_64_v2_lensfun-tools.sha256sum] = "1554dd624677696dffc8b0844d388ef6d3d875228631798e6c618fc9d093ee03"

URI_x86_64_v2_python3-lensfun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lensfun-0.3.4-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lensfun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lensfun}"
SRC_URI[x86_64_v2_python3-lensfun.sha256sum] = "61242813a13f47a51ddaa246e9f10ee58efd9a1fd11cff26fab1216e53acc196"

URI_aarch64_lensfun = "${EPEL_MIRROR}/aarch64/Packages/l/lensfun-0.3.4-11.el10_3.aarch64.rpm;name=aarch64_lensfun;unpack=0"
SRC_URI:append = " ${URI_aarch64_lensfun}"
SRC_URI[aarch64_lensfun.sha256sum] = "0d74080086d56595d31d2df1b864f403fcb09c8690d0bd55bb500d09d173b5c6"

URI_aarch64_lensfun-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lensfun-devel-0.3.4-11.el10_3.aarch64.rpm;name=aarch64_lensfun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lensfun-devel}"
SRC_URI[aarch64_lensfun-devel.sha256sum] = "3c9cf28694814ec82f91d4bd6529d80dc94a79664744c51267739c01385cd330"

URI_aarch64_lensfun-tools = "${EPEL_MIRROR}/aarch64/Packages/l/lensfun-tools-0.3.4-11.el10_3.aarch64.rpm;name=aarch64_lensfun-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_lensfun-tools}"
SRC_URI[aarch64_lensfun-tools.sha256sum] = "e44c4f1f89eb52a85c3241c7428653b42a5593ec0b267ca2f2070478916c8e41"

URI_aarch64_python3-lensfun = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lensfun-0.3.4-11.el10_3.aarch64.rpm;name=aarch64_python3-lensfun;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lensfun}"
SRC_URI[aarch64_python3-lensfun.sha256sum] = "5d22b38c6a7012a25e264e8143a3db05526d285295b4bfc815299145880171a3"

RDEPENDS:lensfun = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:lensfun-devel = " \
 glib2-devel \
 lensfun \
 pkgconf-pkg-config \
 "
RDEPENDS:lensfun-tools = " \
 python3 \
 python3-lensfun \
 "
RDEPENDS:python3-lensfun = " \
 lensfun \
 python3 \
 "
