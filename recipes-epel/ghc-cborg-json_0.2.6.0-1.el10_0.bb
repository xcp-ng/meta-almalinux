# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cborg-json"
PV = "0.2.6.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-cborg-json \
 ghc-cborg-json-devel \
 ghc-cborg-json-doc \
 ghc-cborg-json-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cborg-json-0.2.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48d7b7567b9f29afc95fecad2a42ed9417b2ac00c6eddd4c580c724779fc5432"

URI_x86_64_v2_ghc-cborg-json = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cborg-json-0.2.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cborg-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cborg-json}"
SRC_URI[x86_64_v2_ghc-cborg-json.sha256sum] = "edded5d4e2ad14dc255ad9a7c06c6c83db8225c30ac7cc8a232576c41625fe83"

URI_x86_64_v2_ghc-cborg-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cborg-json-devel-0.2.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cborg-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cborg-json-devel}"
SRC_URI[x86_64_v2_ghc-cborg-json-devel.sha256sum] = "c69ef4111f4fb3982dbfed4a4ff6cf6e69e8472395d730381a7286d988bac47a"

URI_x86_64_v2_ghc-cborg-json-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cborg-json-doc-0.2.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cborg-json-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cborg-json-doc}"
SRC_URI[x86_64_v2_ghc-cborg-json-doc.sha256sum] = "a6d0dfdee2bb45e2eb209e451fb9a047cfdfc9df1a83f01eaba676e45a53c364"

URI_x86_64_v2_ghc-cborg-json-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cborg-json-prof-0.2.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cborg-json-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cborg-json-prof}"
SRC_URI[x86_64_v2_ghc-cborg-json-prof.sha256sum] = "a041854c3ea95694576e79ea074e35c8842253d8e460f4dc6a720b6bc3f893fb"

URI_aarch64_ghc-cborg-json = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cborg-json-0.2.6.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-cborg-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cborg-json}"
SRC_URI[aarch64_ghc-cborg-json.sha256sum] = "64da88086b2c58d2864b34906eb7166ad1f8415bdfac652787c17c73d119690b"

URI_aarch64_ghc-cborg-json-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cborg-json-devel-0.2.6.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-cborg-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cborg-json-devel}"
SRC_URI[aarch64_ghc-cborg-json-devel.sha256sum] = "33ec1dec4abd41f745b0fa1c071d2436fdaa78443962446cbe7e3f4331b35863"

URI_aarch64_ghc-cborg-json-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cborg-json-doc-0.2.6.0-1.el10_0.noarch.rpm;name=aarch64_ghc-cborg-json-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cborg-json-doc}"
SRC_URI[aarch64_ghc-cborg-json-doc.sha256sum] = "a16f7f5b016d9efe3c0aef09fc5d5b68ff35ee0c1b59f470382c6c608391fe83"

URI_aarch64_ghc-cborg-json-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cborg-json-prof-0.2.6.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-cborg-json-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cborg-json-prof}"
SRC_URI[aarch64_ghc-cborg-json-prof.sha256sum] = "06851bc33f5d87169ea1ed94795cad685e7e5028d5bf0bc3e3f77b7723b894f6"

RDEPENDS:ghc-cborg-json = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-aeson-pretty \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-cborg \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-half \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cborg-json-devel = " \
 ghc-aeson-devel \
 ghc-aeson-pretty-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-cborg-devel \
 ghc-cborg-json \
 ghc-compiler \
 ghc-scientific-devel \
 ghc-text-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-cborg-json-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cborg-json-prof = " \
 ghc-aeson-pretty-prof \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-cborg-json-devel \
 ghc-cborg-prof \
 ghc-scientific-prof \
 ghc-text-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
