# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slog"
PV = "2.8.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-slog+anyhow-devel \
 rust-slog+default-devel \
 rust-slog+dynamic-keys-devel \
 rust-slog+max_level_debug-devel \
 rust-slog+max_level_error-devel \
 rust-slog+max_level_info-devel \
 rust-slog+max_level_off-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+max_level_warn-devel \
 rust-slog+nested-values-devel \
 rust-slog+nothreads-devel \
 rust-slog+parking_lot_0_12-devel \
 rust-slog+release_max_level_debug-devel \
 rust-slog+release_max_level_error-devel \
 rust-slog+release_max_level_info-devel \
 rust-slog+release_max_level_off-devel \
 rust-slog+release_max_level_trace-devel \
 rust-slog+release_max_level_warn-devel \
 rust-slog+std-devel \
 rust-slog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slog-2.8.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b57218d4fdd64d9a7e1d5f45fc696478c7cd05320355879f38ff29fd78fb30e"

URI_x86_64_v2_rust-slog+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+anyhow-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+anyhow-devel}"
SRC_URI[x86_64_v2_rust-slog+anyhow-devel.sha256sum] = "d172243a7d805272529c06c7a1f1ef669605ffba929dea3191d380c3faf176f6"

URI_x86_64_v2_rust-slog+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+default-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+default-devel}"
SRC_URI[x86_64_v2_rust-slog+default-devel.sha256sum] = "9ae05d8d9770c838239c3c969d465ef472331f6600ff359d15346eea662d9d11"

URI_x86_64_v2_rust-slog+dynamic-keys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+dynamic-keys-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+dynamic-keys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+dynamic-keys-devel}"
SRC_URI[x86_64_v2_rust-slog+dynamic-keys-devel.sha256sum] = "297b63ab29cefdfe302b5622a8a847065bcdf9ad9fa9e4f07b8e50002fa1f558"

URI_x86_64_v2_rust-slog+max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_debug-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_debug-devel.sha256sum] = "d0c43fc9f1d23298deb611d09e23755de3258864f960dd20a95654bf8586e79e"

URI_x86_64_v2_rust-slog+max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_error-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_error-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_error-devel.sha256sum] = "d887c89779b2e1f2d78f7d26526a6af5c84cbde96706715f608b70692106ed92"

URI_x86_64_v2_rust-slog+max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_info-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_info-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_info-devel.sha256sum] = "c716f0371e6ac861eafde0b4f733b591f69926be4df86ab1ca59a9a990492bea"

URI_x86_64_v2_rust-slog+max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_off-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_off-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_off-devel.sha256sum] = "df46febae7b3f8709eba6ce1b4ec7f78d652112d6099e09ad471cdcc47d8286e"

URI_x86_64_v2_rust-slog+max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_trace-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_trace-devel.sha256sum] = "9d520e28296ae4efbb8570fc99e125d0ef2894962ee96bc4b232a535f90b8429"

URI_x86_64_v2_rust-slog+max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+max_level_warn-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-slog+max_level_warn-devel.sha256sum] = "b2b66e4bbf03b2ccba96797c3b02621be75f08c4edda06cfea28bd5e445fcb51"

URI_x86_64_v2_rust-slog+nested-values-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+nested-values-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+nested-values-devel}"
SRC_URI[x86_64_v2_rust-slog+nested-values-devel.sha256sum] = "47689e524e19e7b79ad0364d7757853fca43ff30ab6af99382ba0ffd50974797"

URI_x86_64_v2_rust-slog+nothreads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+nothreads-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+nothreads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+nothreads-devel}"
SRC_URI[x86_64_v2_rust-slog+nothreads-devel.sha256sum] = "9488e364b292838b3004462d98902d9ab7329c2abac48bc2848c1397057aa5bc"

URI_x86_64_v2_rust-slog+parking_lot_0_12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+parking_lot_0_12-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+parking_lot_0_12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+parking_lot_0_12-devel}"
SRC_URI[x86_64_v2_rust-slog+parking_lot_0_12-devel.sha256sum] = "2cf7fad08a08f3c9ba5d16214eb0de50947d6c7a35e1df3916f3dc7934d4665f"

URI_x86_64_v2_rust-slog+release_max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_debug-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_debug-devel.sha256sum] = "064f1d33b48e5613dac818fef971a5df9cc5c68fc94242d1648c5ae41044498c"

URI_x86_64_v2_rust-slog+release_max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_error-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_error-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_error-devel.sha256sum] = "4c9e51bcec38e43db7c50d2c15018aabb01e7eee806a59c60b0c826985a788da"

URI_x86_64_v2_rust-slog+release_max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_info-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_info-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_info-devel.sha256sum] = "cd54fabe8efea6622321abeb923ad788ec0ed44e106fc95e6e329eed9f2b36ba"

URI_x86_64_v2_rust-slog+release_max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_off-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_off-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_off-devel.sha256sum] = "93a9236d0d88d4765b7a3301d39a3389c8a9b75da57abb655d4365f512c25136"

URI_x86_64_v2_rust-slog+release_max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_trace-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_trace-devel.sha256sum] = "4b133feb6c113cc5b5b06381eea19b29cd4ab6d968cbc62389142016ef2a6199"

URI_x86_64_v2_rust-slog+release_max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+release_max_level_warn-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+release_max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-slog+release_max_level_warn-devel.sha256sum] = "7c4640e59f52de2bce9cf7de789fbcfe55eff9f2c472b6e1ee08f1d7c6e2d094"

URI_x86_64_v2_rust-slog+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog+std-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog+std-devel}"
SRC_URI[x86_64_v2_rust-slog+std-devel.sha256sum] = "409886601dcb898f01ac56c2ec8f56fdd8de3f7e33253ca1aa5376aa249e7f2d"

URI_x86_64_v2_rust-slog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-devel-2.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-devel}"
SRC_URI[x86_64_v2_rust-slog-devel.sha256sum] = "0e5b57c4e3cb1be67b35501db7278b4557220e2495523c4e80617b67d9d4e4d2"

URI_aarch64_rust-slog+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+anyhow-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+anyhow-devel}"
SRC_URI[aarch64_rust-slog+anyhow-devel.sha256sum] = "ca8cd5addcef27a928b9a59f3f2ee44359c5e3258f00819fcb0a5eaa50c1f103"

URI_aarch64_rust-slog+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+default-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+default-devel}"
SRC_URI[aarch64_rust-slog+default-devel.sha256sum] = "5af0b8d098e7b30b8b94a84f7ad0f2fb1c513ea9642949f69e6e130d31977983"

URI_aarch64_rust-slog+dynamic-keys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+dynamic-keys-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+dynamic-keys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+dynamic-keys-devel}"
SRC_URI[aarch64_rust-slog+dynamic-keys-devel.sha256sum] = "f2e3587fc2900e0af06acd9186d5d613a18da183e30cf3e502c9266ac21e5268"

URI_aarch64_rust-slog+max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_debug-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_debug-devel}"
SRC_URI[aarch64_rust-slog+max_level_debug-devel.sha256sum] = "116f3f34b34d25b852dbc2a8dbd07dba7ef3cd838e91e6caec69897904e818af"

URI_aarch64_rust-slog+max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_error-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_error-devel}"
SRC_URI[aarch64_rust-slog+max_level_error-devel.sha256sum] = "db452fe0d530b28ef1a0eae2989c14c7dbd2784571c003650a12439c0ed98506"

URI_aarch64_rust-slog+max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_info-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_info-devel}"
SRC_URI[aarch64_rust-slog+max_level_info-devel.sha256sum] = "3abf7121694f7f79f84681eb5d4e00f43544f76a049275932febf35100ddd65d"

URI_aarch64_rust-slog+max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_off-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_off-devel}"
SRC_URI[aarch64_rust-slog+max_level_off-devel.sha256sum] = "7a5c01470dafc17b6f9a95e761258e93e85ea03c886a53eea17451817e1b5cb9"

URI_aarch64_rust-slog+max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_trace-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_trace-devel}"
SRC_URI[aarch64_rust-slog+max_level_trace-devel.sha256sum] = "4afbc7dd8845b875bf8fec9e7ad0867fa8d0a8400e79d2c8e9cdb35496ca7562"

URI_aarch64_rust-slog+max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+max_level_warn-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+max_level_warn-devel}"
SRC_URI[aarch64_rust-slog+max_level_warn-devel.sha256sum] = "16ee2d3221cb583840a86a2c650ca99433bd038d26f1aafac2de4c0194ea48b1"

URI_aarch64_rust-slog+nested-values-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+nested-values-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+nested-values-devel}"
SRC_URI[aarch64_rust-slog+nested-values-devel.sha256sum] = "ab27fcc5304196c831178ad6fededf89d3736c14fc1299558eae2b7713fd80aa"

URI_aarch64_rust-slog+nothreads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+nothreads-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+nothreads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+nothreads-devel}"
SRC_URI[aarch64_rust-slog+nothreads-devel.sha256sum] = "2da79508d81378e57c4eb20f3a531c377609187dbc2ac771eb6a1c9160860426"

URI_aarch64_rust-slog+parking_lot_0_12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+parking_lot_0_12-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+parking_lot_0_12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+parking_lot_0_12-devel}"
SRC_URI[aarch64_rust-slog+parking_lot_0_12-devel.sha256sum] = "781004f7b924109a8343a38f3aab51e6cb982361a4608e8903c0f5e7607163bf"

URI_aarch64_rust-slog+release_max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_debug-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_debug-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_debug-devel.sha256sum] = "d946ede1453aad67e27d93bab3f81854f2546d81327cce709f661f4ca248c0d8"

URI_aarch64_rust-slog+release_max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_error-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_error-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_error-devel.sha256sum] = "fa5c4c6f21238a3c1391bd02f4aab067d7c123c53a56b2db85664db86d07a770"

URI_aarch64_rust-slog+release_max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_info-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_info-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_info-devel.sha256sum] = "d24c664cb6a767249f55bc254998cccd37237325c3dceb5d6cead802afdb296e"

URI_aarch64_rust-slog+release_max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_off-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_off-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_off-devel.sha256sum] = "d11caa7eed226a34540ff5709e3faa39d4a5e132bf3125f93203e4319eb8d869"

URI_aarch64_rust-slog+release_max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_trace-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_trace-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_trace-devel.sha256sum] = "fd648ce0742733fd069c4e7a4610b836347cd3f443de167608f8a1551f3d2792"

URI_aarch64_rust-slog+release_max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+release_max_level_warn-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+release_max_level_warn-devel}"
SRC_URI[aarch64_rust-slog+release_max_level_warn-devel.sha256sum] = "0617c11f9b7c6fe9ee820bf3afb8916fdc54ec118bfdeb3344d4d10491456cea"

URI_aarch64_rust-slog+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog+std-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog+std-devel}"
SRC_URI[aarch64_rust-slog+std-devel.sha256sum] = "7964fc4383f5160ab02193ecfa069dae0f8914976d4f228cd186ee25e9aefed0"

URI_aarch64_rust-slog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-devel-2.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-slog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-devel}"
SRC_URI[aarch64_rust-slog-devel.sha256sum] = "dfe9dfe7d367b2bc241c6b45da7d6514011e1817fa539dc30b3f0c7fca13d168"

RDEPENDS:rust-slog+anyhow-devel = " \
 cargo \
 rust-anyhow-devel \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+default-devel = " \
 cargo \
 rust-slog+nested-values-devel \
 rust-slog+std-devel \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+dynamic-keys-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_debug-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_error-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_info-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_off-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_trace-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+max_level_warn-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+nested-values-devel = " \
 cargo \
 rust-erased-serde0.3+alloc-devel \
 rust-erased-serde0.3-devel \
 rust-serde_core-devel \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+nothreads-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+parking_lot_0_12-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_debug-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_error-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_info-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_off-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_trace-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+release_max_level_warn-devel = " \
 cargo \
 rust-slog-devel \
 "
RDEPENDS:rust-slog+std-devel = " \
 cargo \
 rust-anyhow+std-devel \
 rust-anyhow-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-slog-devel \
 "
RDEPENDS:rust-slog-devel = " \
 cargo \
 rust \
 rust-rustversion+default-devel \
 "
