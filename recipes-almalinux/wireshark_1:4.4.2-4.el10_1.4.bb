# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wireshark"
PE = "1"
PV = "4.4.2"
PR = "4.el10_1.4"
PACKAGES = " \
 wireshark \
 wireshark-cli \
 wireshark-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wireshark-4.4.2-4.el10_1.4.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6b36c3a9adb3531c62464b39b4d491d6fcfbd868f833bd0ce5e084e3b31e39d"

URI_x86_64_v2_wireshark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireshark-4.4.2-4.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_wireshark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireshark}"
SRC_URI[x86_64_v2_wireshark.sha256sum] = "268da3fa46fd8bdeb10e188c67dc8dbf1e8a4e6f77c8289abfe43fe65630a50b"

URI_x86_64_v2_wireshark-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireshark-cli-4.4.2-4.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_wireshark-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireshark-cli}"
SRC_URI[x86_64_v2_wireshark-cli.sha256sum] = "935042d71120bfffd664a7823f78a814cb2899286c35339150b71f4bbbe250fb"

URI_x86_64_v2_wireshark-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/wireshark-devel-4.4.2-4.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_wireshark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireshark-devel}"
SRC_URI[x86_64_v2_wireshark-devel.sha256sum] = "b72ed89ac75e7d85dca4bfb994ea3b001a63d72be188ec4eefac4ded06a24e9a"

URI_aarch64_wireshark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireshark-4.4.2-4.el10_1.4.aarch64.rpm;name=aarch64_wireshark;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireshark}"
SRC_URI[aarch64_wireshark.sha256sum] = "2d75ae8db23bd4352f20a7ab879226ee2dab0534b69691db8fbfbb2ae0601d0b"

URI_aarch64_wireshark-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireshark-cli-4.4.2-4.el10_1.4.aarch64.rpm;name=aarch64_wireshark-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireshark-cli}"
SRC_URI[aarch64_wireshark-cli.sha256sum] = "1fccf94d7f8471c3a5c46d7619c35fff4565753d4d67ccaeaa68c51b9461cb56"

URI_aarch64_wireshark-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/wireshark-devel-4.4.2-4.el10_1.4.aarch64.rpm;name=aarch64_wireshark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireshark-devel}"
SRC_URI[aarch64_wireshark-devel.sha256sum] = "f73ad077157bf5018fbac091c9a51159aa5568d88205ed67096c62032b60b7cf"

RDEPENDS:wireshark = " \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libgcrypt \
 libnl3 \
 libpcap \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 speexdsp \
 wireshark-cli \
 xdg-utils \
 "
RDEPENDS:wireshark-cli = " \
 bash \
 c-ares \
 glib2 \
 glibc \
 gnutls \
 krb5-libs \
 libcap \
 libgcc \
 libgcrypt \
 libnghttp2 \
 libnl3 \
 libpcap \
 libsmi \
 libssh \
 libxml2 \
 libzstd \
 lua-libs \
 pcre2 \
 shadow-utils \
 speexdsp \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:wireshark-devel = " \
 glib2-devel \
 glibc-devel \
 pkgconf-pkg-config \
 wireshark \
 wireshark-cli \
 "
