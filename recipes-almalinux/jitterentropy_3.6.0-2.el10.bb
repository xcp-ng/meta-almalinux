# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jitterentropy"
PV = "3.6.0"
PR = "2.el10"
PACKAGES = " \
 jitterentropy \
 jitterentropy-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/jitterentropy-3.6.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "315c300475fe657c9558c32f90a11b892786d1572b67dc924a2fb61da9969376"

URI_x86_64_v2_jitterentropy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/jitterentropy-3.6.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_jitterentropy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jitterentropy}"
SRC_URI[x86_64_v2_jitterentropy.sha256sum] = "3a068b6c76543d3a51e7aff72eb78918657adf2dc6eb0a87384b4adbfb84c089"

URI_x86_64_v2_jitterentropy-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jitterentropy-devel-3.6.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_jitterentropy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jitterentropy-devel}"
SRC_URI[x86_64_v2_jitterentropy-devel.sha256sum] = "c9d04d17553d8aca47e0f2bb8c5a02bee5d2f41da112b7d36ef9e4a7a4f478ee"

URI_aarch64_jitterentropy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/jitterentropy-3.6.0-2.el10.aarch64.rpm;name=aarch64_jitterentropy;unpack=0"
SRC_URI:append = " ${URI_aarch64_jitterentropy}"
SRC_URI[aarch64_jitterentropy.sha256sum] = "ec161ec1108da68a497048e83f3c73d32132a0eade3e8e3047c938b80062f84a"

URI_aarch64_jitterentropy-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jitterentropy-devel-3.6.0-2.el10.aarch64.rpm;name=aarch64_jitterentropy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jitterentropy-devel}"
SRC_URI[aarch64_jitterentropy-devel.sha256sum] = "293a9f7553631f60ad8a8d5ebb77474f875be1e58a86442f8819b30ad1bf6983"

RDEPENDS:jitterentropy = " \
 glibc \
 "
RDEPENDS:jitterentropy-devel = " \
 jitterentropy \
 "
