# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghostwriter"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ghostwriter \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghostwriter-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "952539bd90aa91dbed423eb61a825f8abe66b0312db0ed21719aeb2fb49fccbf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghostwriter-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghostwriter;unpack=0"
SRC_URI[x86_64_v2_ghostwriter.sha256sum] = "fef852b4131c82b943643f0be466a7ee9e19e4f21f3f0bc3b9dff88e6551f9d5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghostwriter-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ghostwriter;unpack=0"
SRC_URI[aarch64_ghostwriter.sha256sum] = "dad7d07a40a8230bdd996afe98494f2ce106905720a810747e99f4d3f22a22f6"

RDEPENDS:ghostwriter = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
