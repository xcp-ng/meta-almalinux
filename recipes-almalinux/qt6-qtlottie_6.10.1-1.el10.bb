# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtlottie"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtlottie \
 qt6-qtlottie-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtlottie-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ab9946c78ea07a4d9e5b067a9674cf15141758a0a692cd53c89c677cf34a2dc"

URI_x86_64_v2_qt6-qtlottie = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlottie-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlottie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlottie}"
SRC_URI[x86_64_v2_qt6-qtlottie.sha256sum] = "56a1dcb3fb78949390086f9562d0ebce92684d6e1fd2a550d98af7de55df0f7b"

URI_x86_64_v2_qt6-qtlottie-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlottie-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlottie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlottie-devel}"
SRC_URI[x86_64_v2_qt6-qtlottie-devel.sha256sum] = "0ed0e4d8a8efa8d358098c3fb34ee17a9f95d91309c34e30df2cdd2d5ebc3969"

URI_aarch64_qt6-qtlottie = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlottie-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlottie;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlottie}"
SRC_URI[aarch64_qt6-qtlottie.sha256sum] = "b464b5d1ea237519ef14636676eaf144c1f2a7e57a92d0b720b074d11001be8e"

URI_aarch64_qt6-qtlottie-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlottie-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlottie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlottie-devel}"
SRC_URI[aarch64_qt6-qtlottie-devel.sha256sum] = "9bb5989b86701448dda5ac5e528fed9a1e68675f5d51c65f03f239b233e4f8ff"

RDEPENDS:qt6-qtlottie = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtlottie-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlottie \
 "
