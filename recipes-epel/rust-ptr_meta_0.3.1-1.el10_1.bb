# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ptr_meta"
PV = "0.3.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-ptr_meta+default-devel \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta+ptr_meta_derive-devel \
 rust-ptr_meta+std-devel \
 rust-ptr_meta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ptr_meta-0.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8aa7b468c866d43adb470a302dcfc776367bd7cecc058a1ced802aa693bb888"

URI_x86_64_v2_rust-ptr_meta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+default-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+default-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+default-devel.sha256sum] = "0395728881ed8cbdf64fa15b920e5cd79c78d21e58e0ea734539579000979fbc"

URI_x86_64_v2_rust-ptr_meta+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+derive-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+derive-devel.sha256sum] = "b732f8089af13e50f76f5b14d039f1d9df3e879c8726f2ed28b4a55cccf0478c"

URI_x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+ptr_meta_derive-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel.sha256sum] = "1ac6aadd0d4bc31e79a57b24ef39b5362f3fce9432be08626d55e03a928cd924"

URI_x86_64_v2_rust-ptr_meta+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+std-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+std-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+std-devel.sha256sum] = "ed8518a11fccd6f125476c1030027ce60dd1968303ed1478c1b288a10e3326ee"

URI_x86_64_v2_rust-ptr_meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta-devel.sha256sum] = "fc7a8981602bc91bf56bc4ed94d0608dcafff97440f7a17eb5ce7e87a5430fde"

URI_aarch64_rust-ptr_meta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+default-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-ptr_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+default-devel}"
SRC_URI[aarch64_rust-ptr_meta+default-devel.sha256sum] = "2aea190054d7247e769fbdfbe74f3b27f3bcac658cd706dfc4bed7246f672b47"

URI_aarch64_rust-ptr_meta+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+derive-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-ptr_meta+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+derive-devel}"
SRC_URI[aarch64_rust-ptr_meta+derive-devel.sha256sum] = "d93700252a5fae2a00c91d4ea5dfce65e3c1e32a8a60e7cc65e61d2bc1a41e68"

URI_aarch64_rust-ptr_meta+ptr_meta_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+ptr_meta_derive-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-ptr_meta+ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+ptr_meta_derive-devel}"
SRC_URI[aarch64_rust-ptr_meta+ptr_meta_derive-devel.sha256sum] = "37e55ed5b62b82dd1fbc0a5e73d0e15659e290d808084be7a46dc51c716847d8"

URI_aarch64_rust-ptr_meta+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+std-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-ptr_meta+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+std-devel}"
SRC_URI[aarch64_rust-ptr_meta+std-devel.sha256sum] = "53b26d8cf47efb1c4039e90f743af8ad7166e6576f6fc4d641ec89ff667eedc0"

URI_aarch64_rust-ptr_meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-ptr_meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta-devel}"
SRC_URI[aarch64_rust-ptr_meta-devel.sha256sum] = "7480d7e89fbc9e74a3713541afc8f2fe89be1bf2879458b76d7f2b59d70b5804"

RDEPENDS:rust-ptr_meta+default-devel = " \
 cargo \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta+std-devel \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta+derive-devel = " \
 cargo \
 rust-ptr_meta+ptr_meta_derive-devel \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta+ptr_meta_derive-devel = " \
 cargo \
 rust-ptr_meta-devel \
 rust-ptr_meta_derive-devel \
 "
RDEPENDS:rust-ptr_meta+std-devel = " \
 cargo \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta-devel = " \
 cargo \
 rust \
 "
