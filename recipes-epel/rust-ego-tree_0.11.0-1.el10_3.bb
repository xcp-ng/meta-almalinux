# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ego-tree"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-ego-tree+default-devel \
 rust-ego-tree+serde-devel \
 rust-ego-tree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ego-tree-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "282852bec96a3abc371b9e4cdc49ba23685afbc2a2fe71d8ee9b47179044273b"

URI_x86_64_v2_rust-ego-tree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ego-tree+default-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ego-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ego-tree+default-devel}"
SRC_URI[x86_64_v2_rust-ego-tree+default-devel.sha256sum] = "a4a47199d0d25fcff90992775737b88de23754a0cf4e5510b3ef9842fb8d85e6"

URI_x86_64_v2_rust-ego-tree+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ego-tree+serde-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ego-tree+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ego-tree+serde-devel}"
SRC_URI[x86_64_v2_rust-ego-tree+serde-devel.sha256sum] = "2510176e3e90e686540cdefc9edf18f12944d8525684d21648c882da7dade5c9"

URI_x86_64_v2_rust-ego-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ego-tree-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ego-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ego-tree-devel}"
SRC_URI[x86_64_v2_rust-ego-tree-devel.sha256sum] = "1dd05209e3501f8f693f6527f933a9f44016026bf6e9918b262112dc4c4a358c"

URI_aarch64_rust-ego-tree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ego-tree+default-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-ego-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ego-tree+default-devel}"
SRC_URI[aarch64_rust-ego-tree+default-devel.sha256sum] = "8544d08ee9fd4f185d622a7219915bbae42d391840156acd95024746a978a067"

URI_aarch64_rust-ego-tree+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ego-tree+serde-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-ego-tree+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ego-tree+serde-devel}"
SRC_URI[aarch64_rust-ego-tree+serde-devel.sha256sum] = "396152f91cb3e0bda565bb05f9948016d27644b5769ee4c744d4443ca745e926"

URI_aarch64_rust-ego-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ego-tree-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-ego-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ego-tree-devel}"
SRC_URI[aarch64_rust-ego-tree-devel.sha256sum] = "ad93b82865d40a649b42ed6e288af21e26313d2db8ac27f72146de9191b28edb"

RDEPENDS:rust-ego-tree+default-devel = " \
 cargo \
 rust-ego-tree-devel \
 "
RDEPENDS:rust-ego-tree+serde-devel = " \
 cargo \
 rust-ego-tree-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-ego-tree-devel = " \
 cargo \
 "
