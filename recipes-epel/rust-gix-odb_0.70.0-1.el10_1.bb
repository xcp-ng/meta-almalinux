# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-odb"
PV = "0.70.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-odb+default-devel \
 rust-gix-odb+document-features-devel \
 rust-gix-odb+serde-devel \
 rust-gix-odb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-odb-0.70.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08b8a9fe373191b345529fb1e0f74dc8795b48f610efbd404260c5c116df8913"

URI_x86_64_v2_rust-gix-odb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+default-devel-0.70.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+default-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+default-devel.sha256sum] = "f83a60b51ae64c1735a7a9457fa775f5a17817d43a2dc8f914a128713898f05c"

URI_x86_64_v2_rust-gix-odb+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+document-features-devel-0.70.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+document-features-devel.sha256sum] = "ccef0bf953668ac1e949fe3d13ad0c5b713eb08fc966e794d7c728667f489a81"

URI_x86_64_v2_rust-gix-odb+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+serde-devel-0.70.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+serde-devel.sha256sum] = "7219584c822384b8a74e092a11253e255e8131b13811ec223f9e39aff203b341"

URI_x86_64_v2_rust-gix-odb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb-devel-0.70.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb-devel}"
SRC_URI[x86_64_v2_rust-gix-odb-devel.sha256sum] = "26c62a7bb47052c8b12649c864eba83638f50e1bb0e61c4e62981aa590d8650f"

URI_aarch64_rust-gix-odb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+default-devel-0.70.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-odb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+default-devel}"
SRC_URI[aarch64_rust-gix-odb+default-devel.sha256sum] = "d6b00a2d73542e29b24407193e7c3240598d797843eadba151d517361fc2144d"

URI_aarch64_rust-gix-odb+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+document-features-devel-0.70.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-odb+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+document-features-devel}"
SRC_URI[aarch64_rust-gix-odb+document-features-devel.sha256sum] = "13aa6b1e84ae5f0fb6ad78ee2bcca9cd48f353e5e9f91f86c6bafe89c1318b89"

URI_aarch64_rust-gix-odb+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+serde-devel-0.70.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-odb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+serde-devel}"
SRC_URI[aarch64_rust-gix-odb+serde-devel.sha256sum] = "e4db3a3deb697fa25a2ae0cc328f142438d85ad3e55646570138994967ebd6f6"

URI_aarch64_rust-gix-odb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb-devel-0.70.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-odb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb-devel}"
SRC_URI[aarch64_rust-gix-odb-devel.sha256sum] = "4ee45bbb0cb260b0fa69776c3752f4f552ae432fb8326306c1173126a55de96e"

RDEPENDS:rust-gix-odb+default-devel = " \
 cargo \
 rust-gix-odb-devel \
 "
RDEPENDS:rust-gix-odb+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-odb-devel \
 "
RDEPENDS:rust-gix-odb+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-odb-devel \
 rust-gix-pack+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-odb-devel = " \
 cargo \
 rust \
 rust-arc-swap+default-devel \
 rust-gix-date+default-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-features+zlib-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-gix-pack-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-parking_lot+default-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 "
