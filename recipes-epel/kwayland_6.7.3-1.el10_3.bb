# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwayland"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kwayland \
 kwayland-devel \
 kwayland-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwayland-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef6eefa4585e1a29e05ffb51f2733c1116c495312483f97f892dfdf25cb73a05"

URI_x86_64_v2_kwayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland}"
SRC_URI[x86_64_v2_kwayland.sha256sum] = "a305636ae30f9dcbeed092865a476c0f575f8417ecde694b83b19b08c1db822a"

URI_x86_64_v2_kwayland-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland-devel}"
SRC_URI[x86_64_v2_kwayland-devel.sha256sum] = "506ecbd7267f9ae1a0a13cc4a990849633fd5959767db29cb286d9d26131d7d3"

URI_x86_64_v2_kwayland-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-doc-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kwayland-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwayland-doc}"
SRC_URI[x86_64_v2_kwayland-doc.sha256sum] = "01e58ffa08afef0f48ebce1fa6dd7abce06884df1a9266878f6e5a32ec3f6cf0"

URI_aarch64_kwayland = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland}"
SRC_URI[aarch64_kwayland.sha256sum] = "821a040a86b2e80879e6ccbdc6476f787088b0cd3f5eae6c6e56d1d29d6562ab"

URI_aarch64_kwayland-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland-devel}"
SRC_URI[aarch64_kwayland-devel.sha256sum] = "5cc90a863928c7b258e321b07e2f1deab3218164bcbf61c03091f7a9ed1d21ee"

URI_aarch64_kwayland-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kwayland-doc-6.7.3-1.el10_3.noarch.rpm;name=aarch64_kwayland-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwayland-doc}"
SRC_URI[aarch64_kwayland-doc.sha256sum] = "9193d2a790ab2146251c06d7848f1cbf44a7a542c5591a26ada93561e27a6536"

RDEPENDS:kwayland = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kwayland-devel = " \
 cmake-filesystem \
 kwayland \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kwayland-doc = " \
 "
