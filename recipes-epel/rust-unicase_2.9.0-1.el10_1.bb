# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicase"
PV = "2.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-unicase+default-devel \
 rust-unicase+nightly-devel \
 rust-unicase-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicase-2.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "571842cbaa269a02707093552e2fbb4e5483e2a19b392fd0bedbf3868e12ce13"

URI_x86_64_v2_rust-unicase+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicase+default-devel-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicase+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicase+default-devel}"
SRC_URI[x86_64_v2_rust-unicase+default-devel.sha256sum] = "c1514aa4a3242fb936c8e324f51f34e06dfd4c8199d05ed55517e20fee098e29"

URI_x86_64_v2_rust-unicase+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicase+nightly-devel-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicase+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicase+nightly-devel}"
SRC_URI[x86_64_v2_rust-unicase+nightly-devel.sha256sum] = "61608d0dc4a9cd0c93d7c81bbe9f5ba24e4c5c4e3ca4b40e63dc9e28b3bc5155"

URI_x86_64_v2_rust-unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicase-devel-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicase-devel}"
SRC_URI[x86_64_v2_rust-unicase-devel.sha256sum] = "b41849074e03dd90ac58b7df1f3887fd1cd83e9c0153eb4503e284b9278d315a"

URI_aarch64_rust-unicase+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicase+default-devel-2.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-unicase+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicase+default-devel}"
SRC_URI[aarch64_rust-unicase+default-devel.sha256sum] = "7d80c0e7b544dd3caf0b5e75be2089c17c06bb7ede0581cbf80aecbf9497426c"

URI_aarch64_rust-unicase+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicase+nightly-devel-2.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-unicase+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicase+nightly-devel}"
SRC_URI[aarch64_rust-unicase+nightly-devel.sha256sum] = "e3790a50b115646a6f95c2eb0b79ae4909e7f80d40e6cb48743039742ad6ea1b"

URI_aarch64_rust-unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicase-devel-2.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicase-devel}"
SRC_URI[aarch64_rust-unicase-devel.sha256sum] = "dbc0c21391dda9f0df14f52d83129610b3ebe72227002d65a396743a6251bcb2"

RDEPENDS:rust-unicase+default-devel = " \
 cargo \
 rust-unicase-devel \
 "
RDEPENDS:rust-unicase+nightly-devel = " \
 cargo \
 rust-unicase-devel \
 "
RDEPENDS:rust-unicase-devel = " \
 cargo \
 "
