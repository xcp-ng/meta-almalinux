# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plutosvg"
PV = "0.0.8"
PR = "2.el10_2"
PACKAGES = " \
 plutosvg \
 plutosvg-devel \
 plutosvg-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plutosvg-0.0.8-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ea73cfd6ca4b4953c1789c60b3ce2c08202918d705660585d182c8c8d41599a"

URI_x86_64_v2_plutosvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-0.0.8-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg}"
SRC_URI[x86_64_v2_plutosvg.sha256sum] = "83b85bce231bc3b918ae30450f8de4c162de74d560d5ca7c1f2df20ba30d91f7"

URI_x86_64_v2_plutosvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-devel-0.0.8-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg-devel}"
SRC_URI[x86_64_v2_plutosvg-devel.sha256sum] = "3d02288dc36a3baf10e6106c287cb17a723780dc5863f25b205937e13b7258c3"

URI_x86_64_v2_plutosvg-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-samples-0.0.8-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg-samples}"
SRC_URI[x86_64_v2_plutosvg-samples.sha256sum] = "37cdf4a5cc66d34e7e90e0c28e92e80e8b6157d69bfbeb29893b484ff24a95e8"

URI_aarch64_plutosvg = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-0.0.8-2.el10_2.aarch64.rpm;name=aarch64_plutosvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg}"
SRC_URI[aarch64_plutosvg.sha256sum] = "ad271847a3ab64fd1cede406759bf3423e191ff2c1cce9ca1142add7ca29fa6a"

URI_aarch64_plutosvg-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-devel-0.0.8-2.el10_2.aarch64.rpm;name=aarch64_plutosvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg-devel}"
SRC_URI[aarch64_plutosvg-devel.sha256sum] = "52dcf70056ed0d2a2cd8cc3fca770f5b82fee782755122db5aafc1ba71b71c08"

URI_aarch64_plutosvg-samples = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-samples-0.0.8-2.el10_2.aarch64.rpm;name=aarch64_plutosvg-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg-samples}"
SRC_URI[aarch64_plutosvg-samples.sha256sum] = "478dd946d58dad3825598900bd748a02c86927e28e2f620f141ea5426c7a0e69"

RDEPENDS:plutosvg = " \
 freetype \
 glibc \
 plutovg \
 "
RDEPENDS:plutosvg-devel = " \
 cmake-filesystem \
 freetype-devel \
 pkgconf-pkg-config \
 plutosvg \
 plutovg-devel \
 "
RDEPENDS:plutosvg-samples = " \
 freetype \
 glibc \
 plutosvg \
 plutovg \
 "
