# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libproxy"
PV = "0.5.5"
PR = "4.el10"
PACKAGES = " \
 libproxy \
 libproxy-bin \
 libproxy-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libproxy-0.5.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee878151b8a1cceef2f4778eb19eb291f27154755ed29602b51869e9b8ad938b"

URI_x86_64_v2_libproxy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libproxy-0.5.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_libproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libproxy}"
SRC_URI[x86_64_v2_libproxy.sha256sum] = "3dda310efec28f7d658cd87ee44ac1fb3746618ba783e36c3d139d9232d3b888"

URI_x86_64_v2_libproxy-bin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libproxy-bin-0.5.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_libproxy-bin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libproxy-bin}"
SRC_URI[x86_64_v2_libproxy-bin.sha256sum] = "3c20697668ef80a32b541521ac69bb7d3e89e53a6362bc06b8de0506e60a5220"

URI_x86_64_v2_libproxy-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libproxy-devel-0.5.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_libproxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libproxy-devel}"
SRC_URI[x86_64_v2_libproxy-devel.sha256sum] = "631574b9801676cfcb34206b3873ddf375ba2a4e8dd9d7be23cba8d261c27859"

URI_aarch64_libproxy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libproxy-0.5.5-4.el10.aarch64.rpm;name=aarch64_libproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libproxy}"
SRC_URI[aarch64_libproxy.sha256sum] = "7c283d1e99a9b2177c804a2829c7e81b95af74d10ce0122345434302e0985354"

URI_aarch64_libproxy-bin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libproxy-bin-0.5.5-4.el10.aarch64.rpm;name=aarch64_libproxy-bin;unpack=0"
SRC_URI:append = " ${URI_aarch64_libproxy-bin}"
SRC_URI[aarch64_libproxy-bin.sha256sum] = "b752df19dd4a1be5b8107c2b995c4252879891bd51d3bc67d894d0fac0dbd33b"

URI_aarch64_libproxy-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libproxy-devel-0.5.5-4.el10.aarch64.rpm;name=aarch64_libproxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libproxy-devel}"
SRC_URI[aarch64_libproxy-devel.sha256sum] = "8a0917b110ac56bc81b4919b47edd151d5962757585eefc8861bfa4c3ad02374"

RDEPENDS:libproxy = " \
 duktape \
 glib2 \
 glibc \
 libgcc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libproxy-bin = " \
 glibc \
 libproxy \
 "
RDEPENDS:libproxy-devel = " \
 glib2-devel \
 libproxy \
 pkgconf-pkg-config \
 "
