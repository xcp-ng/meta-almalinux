# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tornado"
PV = "6.5.5"
PR = "1.el10_1.1"
PACKAGES = " \
 python3-tornado \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-tornado-6.5.5-1.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "547c01ac17ad69e349ec3b53780401e04745521d23a3d97a99905ad656e25ec8"

URI_x86_64_v2_python3-tornado = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tornado-6.5.5-1.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_python3-tornado;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tornado}"
SRC_URI[x86_64_v2_python3-tornado.sha256sum] = "f6914833b8fbf3d3e3e5921a76872fb48b0bce8c9da88bbfadda838b22c4420e"

URI_aarch64_python3-tornado = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tornado-6.5.5-1.el10_1.1.aarch64.rpm;name=aarch64_python3-tornado;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tornado}"
SRC_URI[aarch64_python3-tornado.sha256sum] = "33ec3856ae68eba38370646ce39fb2404decf7bd4e7e0df08e78d567de372ed8"

RDEPENDS:python3-tornado = " \
 glibc \
 python3 \
 "
