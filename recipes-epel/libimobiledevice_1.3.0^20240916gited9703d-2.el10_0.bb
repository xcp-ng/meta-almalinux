# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libimobiledevice"
PV = "1.3.0^20240916gited9703d"
PR = "2.el10_0"
PACKAGES = " \
 libimobiledevice \
 libimobiledevice-devel \
 libimobiledevice-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libimobiledevice-1.3.0^20240916gited9703d-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "234ee153b0f36a1113c017a81eb59608604e8cfafc75dfe8c90eb4735042b3b0"

URI_x86_64_v2_libimobiledevice = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libimobiledevice-1.3.0^20240916gited9703d-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libimobiledevice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libimobiledevice}"
SRC_URI[x86_64_v2_libimobiledevice.sha256sum] = "3c190fb71fcf9031a22d3f2660f2276b1f3f4f577bdfbb0a257feb3aecb629ba"

URI_x86_64_v2_libimobiledevice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libimobiledevice-devel-1.3.0^20240916gited9703d-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libimobiledevice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libimobiledevice-devel}"
SRC_URI[x86_64_v2_libimobiledevice-devel.sha256sum] = "a59f2cb0fe8c95e39ca63ba0fa9022973b0feee71c06894f523b4723d5eca624"

URI_x86_64_v2_libimobiledevice-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libimobiledevice-utils-1.3.0^20240916gited9703d-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libimobiledevice-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libimobiledevice-utils}"
SRC_URI[x86_64_v2_libimobiledevice-utils.sha256sum] = "0282261a11a3d893875ba56802d6c3303d8ac8d0ced37c5ba7799612ef3dbd0e"

URI_aarch64_libimobiledevice = "${EPEL_MIRROR}/aarch64/Packages/l/libimobiledevice-1.3.0^20240916gited9703d-2.el10_0.aarch64.rpm;name=aarch64_libimobiledevice;unpack=0"
SRC_URI:append = " ${URI_aarch64_libimobiledevice}"
SRC_URI[aarch64_libimobiledevice.sha256sum] = "59805d81d86542be6e8db88820f02a127c595b23ede87869f3e96196c6496bdc"

URI_aarch64_libimobiledevice-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libimobiledevice-devel-1.3.0^20240916gited9703d-2.el10_0.aarch64.rpm;name=aarch64_libimobiledevice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libimobiledevice-devel}"
SRC_URI[aarch64_libimobiledevice-devel.sha256sum] = "262d4e1c8e9dd0b30c9573deb9c2cb5ff81c60e5e980bb8e81727d166e5b2da1"

URI_aarch64_libimobiledevice-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libimobiledevice-utils-1.3.0^20240916gited9703d-2.el10_0.aarch64.rpm;name=aarch64_libimobiledevice-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libimobiledevice-utils}"
SRC_URI[aarch64_libimobiledevice-utils.sha256sum] = "5494e3d867cf3b931e2249b7bdc771f95da463d55e1cbb6e73ada2dbb34d1621"

RDEPENDS:libimobiledevice = " \
 glibc \
 libimobiledevice-glue \
 libplist \
 libusbmuxd \
 openssl-libs \
 "
RDEPENDS:libimobiledevice-devel = " \
 libimobiledevice \
 libimobiledevice-glue-devel \
 libplist-devel \
 libusbmuxd-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libimobiledevice-utils = " \
 glibc \
 libimobiledevice \
 libimobiledevice-glue \
 libplist \
 libtatsu \
 libusbmuxd \
 readline \
 "
