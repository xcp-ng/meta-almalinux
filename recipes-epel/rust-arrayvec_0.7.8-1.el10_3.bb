# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrayvec"
PV = "0.7.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-arrayvec+default-devel \
 rust-arrayvec+serde-devel \
 rust-arrayvec+std-devel \
 rust-arrayvec+zeroize-devel \
 rust-arrayvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrayvec-0.7.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c3b3854e43d9e31142885229eb35c6229e7b0e0f053b7175860f0cf9d55ab1c"

URI_x86_64_v2_rust-arrayvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+default-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+default-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+default-devel.sha256sum] = "34184d8908f9c0d2dc690ebc82de504ff534dda8c1488f573d975f0cb8f450d3"

URI_x86_64_v2_rust-arrayvec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+serde-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+serde-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+serde-devel.sha256sum] = "06fb2057f2557c9e4b7f28605a712da765636b47c69b13a88ed8786e072767fd"

URI_x86_64_v2_rust-arrayvec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+std-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+std-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+std-devel.sha256sum] = "6055836384f73958a4620a065ecd97fc7f5eead0ea35071f9d7bbf9101dc5d97"

URI_x86_64_v2_rust-arrayvec+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+zeroize-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+zeroize-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+zeroize-devel.sha256sum] = "a9527926da8caa9ec567744c624e5641d1a61c1c459a296e734d6a280d990dd9"

URI_x86_64_v2_rust-arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec-devel}"
SRC_URI[x86_64_v2_rust-arrayvec-devel.sha256sum] = "de3370fa4d722209be7267c58447d414757401be805e97dba1a0f0c12e9848e7"

URI_aarch64_rust-arrayvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+default-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-arrayvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+default-devel}"
SRC_URI[aarch64_rust-arrayvec+default-devel.sha256sum] = "97986a5d7d0655181d2cab0e22caa589068d7cc250dcb0423bf32a6e9dc5c19e"

URI_aarch64_rust-arrayvec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+serde-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-arrayvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+serde-devel}"
SRC_URI[aarch64_rust-arrayvec+serde-devel.sha256sum] = "6e08365eeb51389d9311e2a5905b537454ed9dccfed3005241fea7356a0665f1"

URI_aarch64_rust-arrayvec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+std-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-arrayvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+std-devel}"
SRC_URI[aarch64_rust-arrayvec+std-devel.sha256sum] = "3faf47fef29145220176e9dbe252a4a83a04df2032cc7ecd74b73d1dc635577d"

URI_aarch64_rust-arrayvec+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+zeroize-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-arrayvec+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+zeroize-devel}"
SRC_URI[aarch64_rust-arrayvec+zeroize-devel.sha256sum] = "e6abbe73def381929eda4bff5d34526584c62a7d9f13774c240c24ced6b7bf63"

URI_aarch64_rust-arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec-devel}"
SRC_URI[aarch64_rust-arrayvec-devel.sha256sum] = "4a5d326dc5d65075bcf55837a5efa5c94cc558927b50cf5a92ca7b2497cef9af"

RDEPENDS:rust-arrayvec+default-devel = " \
 cargo \
 rust-arrayvec+std-devel \
 rust-arrayvec-devel \
 "
RDEPENDS:rust-arrayvec+serde-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-arrayvec+std-devel = " \
 cargo \
 rust-arrayvec-devel \
 "
RDEPENDS:rust-arrayvec+zeroize-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-arrayvec-devel = " \
 cargo \
 rust \
 "
