# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ravif"
PV = "0.11.20"
PR = "1.el10_1"
PACKAGES = " \
 rust-ravif+asm-devel \
 rust-ravif+default-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ravif-0.11.20-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03c4d0d6174ba718904e16ba8c5627fec20014c9be860da254a76bdb0c57d7ed"

URI_x86_64_v2_rust-ravif+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+asm-devel-0.11.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+asm-devel}"
SRC_URI[x86_64_v2_rust-ravif+asm-devel.sha256sum] = "94f4e6d0ded0f0cd09bfb82e3f140c66af7cd9cee847b0ed65eb990b6ebcc544"

URI_x86_64_v2_rust-ravif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+default-devel-0.11.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+default-devel}"
SRC_URI[x86_64_v2_rust-ravif+default-devel.sha256sum] = "b1e3b40be34fde9a5e1c65266f4038098c832650314f394a6294eab6d81040c3"

URI_x86_64_v2_rust-ravif+threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+threading-devel-0.11.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+threading-devel}"
SRC_URI[x86_64_v2_rust-ravif+threading-devel.sha256sum] = "fc412f5a74425344db1f38f88f7e8e6b34d6d457b694d0da658f0b5882c652c7"

URI_x86_64_v2_rust-ravif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif-devel-0.11.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif-devel}"
SRC_URI[x86_64_v2_rust-ravif-devel.sha256sum] = "e73b9db97b4fd4463873cd134491d3d692cc52df56e41020f273bd10503a862f"

URI_aarch64_rust-ravif+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+asm-devel-0.11.20-1.el10_1.noarch.rpm;name=aarch64_rust-ravif+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+asm-devel}"
SRC_URI[aarch64_rust-ravif+asm-devel.sha256sum] = "ec7a4ae42b7f5f65cfa82abc698799baabbe55169f1bc80a04ac31fe31dda909"

URI_aarch64_rust-ravif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+default-devel-0.11.20-1.el10_1.noarch.rpm;name=aarch64_rust-ravif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+default-devel}"
SRC_URI[aarch64_rust-ravif+default-devel.sha256sum] = "3539bbbac4d165b3d4a1d63490dd59595cb3f54e87e5156451ef7c6bfc4d91b1"

URI_aarch64_rust-ravif+threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+threading-devel-0.11.20-1.el10_1.noarch.rpm;name=aarch64_rust-ravif+threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+threading-devel}"
SRC_URI[aarch64_rust-ravif+threading-devel.sha256sum] = "91f9abf5116255b149797c44d59269e1ea423fffb10d7cc592220966c101ed6f"

URI_aarch64_rust-ravif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif-devel-0.11.20-1.el10_1.noarch.rpm;name=aarch64_rust-ravif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif-devel}"
SRC_URI[aarch64_rust-ravif-devel.sha256sum] = "620ac4c8b4ec181c2d1f7faf929386469f4dd88f92cc410cf4436c0a236c6f77"

RDEPENDS:rust-ravif+asm-devel = " \
 cargo \
 rust-rav1e+asm-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-ravif+default-devel = " \
 cargo \
 rust-ravif+asm-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-ravif+threading-devel = " \
 cargo \
 rust-rav1e+threading-devel \
 rust-ravif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-ravif-devel = " \
 cargo \
 rust \
 rust-avif-serialize+default-devel \
 rust-imgref+default-devel \
 rust-loop9+default-devel \
 rust-quick-error+default-devel \
 rust-rav1e-devel \
 rust-rgb-devel \
 "
