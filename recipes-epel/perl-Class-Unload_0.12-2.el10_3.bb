# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Unload"
PV = "0.12"
PR = "2.el10_3"
PACKAGES = " \
 perl-Class-Unload \
 perl-Class-Unload-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Unload-0.12-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bf6c6a059666db9ac3f846ffe464f84e2276d4f23de5505eddb8a03626a1f01"

URI_x86_64_v2_perl-Class-Unload = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Unload-0.12-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Unload;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Unload}"
SRC_URI[x86_64_v2_perl-Class-Unload.sha256sum] = "07420921cba47bbd6b5ebc2c7bdeba216e5b28374de6e42dc3edd030f9f50bbc"

URI_x86_64_v2_perl-Class-Unload-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Unload-tests-0.12-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Unload-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Unload-tests}"
SRC_URI[x86_64_v2_perl-Class-Unload-tests.sha256sum] = "5ec78778a94a0b182212cec220acac7056d492c9435ee589d02760485a45c944"

URI_aarch64_perl-Class-Unload = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Unload-0.12-2.el10_3.noarch.rpm;name=aarch64_perl-Class-Unload;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Unload}"
SRC_URI[aarch64_perl-Class-Unload.sha256sum] = "d526d2c5991c16f4f6ffe4cf6182a071ecaef9dcd40f235c4ad7ddb266d5eb25"

URI_aarch64_perl-Class-Unload-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Unload-tests-0.12-2.el10_3.noarch.rpm;name=aarch64_perl-Class-Unload-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Unload-tests}"
SRC_URI[aarch64_perl-Class-Unload-tests.sha256sum] = "012954ca92e22afb5ea7d130086c70f57811086cab518eef27b800ae7403bb18"

RDEPENDS:perl-Class-Unload = " \
 perl-Class-Inspector \
 perl-libs \
 "
RDEPENDS:perl-Class-Unload-tests = " \
 bash \
 perl-Class-Inspector \
 perl-Class-Unload \
 perl-Moose \
 perl-Test-Harness \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
