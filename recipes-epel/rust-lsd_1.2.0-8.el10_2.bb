# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lsd"
PV = "1.2.0"
PR = "8.el10_2"
PACKAGES = " \
 lsd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-lsd-1.2.0-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "196bcebca75c0a6db3188fb65c9c0c9bca40edab1d262165ead8a6775de7bd9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsd-1.2.0-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsd;unpack=0"
SRC_URI[x86_64_v2_lsd.sha256sum] = "0dff5d8b6826a4856a05bc3fbc3614bb59553d46c1b3282b8f21e415b3f27251"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lsd-1.2.0-8.el10_2.aarch64.rpm;name=aarch64_lsd;unpack=0"
SRC_URI[aarch64_lsd.sha256sum] = "ff75fdad7e2413e6891111954388da2de329928d8a0e050889359aaa8ebdc5d0"

RDEPENDS:lsd = " \
 glibc \
 libgcc \
 libgit2_1.9 \
 "
