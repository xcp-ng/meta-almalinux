# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xwayland-run"
PV = "0.0.4"
PR = "5.el10"
PACKAGES = " \
 xwayland-run \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xwayland-run-0.0.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a6985c94259e5acdce947462eb6b63c799964e5ff3357316b8da4f24587810d5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xwayland-run-0.0.4-5.el10.noarch.rpm;name=x86_64_v2_xwayland-run;unpack=0"
SRC_URI[x86_64_v2_xwayland-run.sha256sum] = "45bed949ae9bbf0857f7ba98a12c1b31b0df4a321892853feeef31a11c8780f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xwayland-run-0.0.4-5.el10.noarch.rpm;name=aarch64_xwayland-run;unpack=0"
SRC_URI[aarch64_xwayland-run.sha256sum] = "45bed949ae9bbf0857f7ba98a12c1b31b0df4a321892853feeef31a11c8780f0"

RDEPENDS:xwayland-run = " \
 dbus-daemon \
 python3 \
 virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk \
 xorg-x11-server-Xwayland \
 xorg-x11-xauth \
 "
