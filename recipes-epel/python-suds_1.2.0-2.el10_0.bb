# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-suds"
PV = "1.2.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-suds \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-suds-1.2.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64f1a8e6964bd4194ef8d51e3647755865bfb8d8fa9a7c20ecf8b8ac95bbccae"

URI_x86_64_v2_python3-suds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-suds-1.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-suds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-suds}"
SRC_URI[x86_64_v2_python3-suds.sha256sum] = "f9e3a0d2a2aaccce4f7f240ec7759c8363b6163e3a62217085204b0dfe9de628"

URI_aarch64_python3-suds = "${EPEL_MIRROR}/aarch64/Packages/p/python3-suds-1.2.0-2.el10_0.noarch.rpm;name=aarch64_python3-suds;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-suds}"
SRC_URI[aarch64_python3-suds.sha256sum] = "f0f8d9962cd97dd05efd9c8d94acd595b39d8fba1a8ebb39942248a7801ad2d6"

RDEPENDS:python3-suds = " \
 python3 \
 "
