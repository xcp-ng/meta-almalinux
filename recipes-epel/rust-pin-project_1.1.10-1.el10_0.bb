# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project"
PV = "1.1.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-pin-project+default-devel \
 rust-pin-project-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-1.1.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99bb4b34ca8850fb3dfbf5ff2c0533e03bfcdef53a1e5cf1fc95db4a5ecb77ba"

URI_x86_64_v2_rust-pin-project+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project+default-devel-1.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project+default-devel.sha256sum] = "fdaf3c04d5e990a4eb86cd31d95862f67f14f038154f076bb5e831b990723ab8"

URI_x86_64_v2_rust-pin-project-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-devel-1.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-devel}"
SRC_URI[x86_64_v2_rust-pin-project-devel.sha256sum] = "d3731186f4dd129b6eb43ab15829f9460ecb1369ef0cc9cdbdf08bef997dd1c1"

URI_aarch64_rust-pin-project+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project+default-devel-1.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-pin-project+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project+default-devel}"
SRC_URI[aarch64_rust-pin-project+default-devel.sha256sum] = "f2375b776898d304ad287989f387d3dc7e7cdf51b6cc777766c30337635e1e49"

URI_aarch64_rust-pin-project-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-devel-1.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-devel}"
SRC_URI[aarch64_rust-pin-project-devel.sha256sum] = "456b5aaada04d45e3b06e8309a473e540a6f682173f8b61a74fa9f6296752169"

RDEPENDS:rust-pin-project+default-devel = " \
 cargo \
 rust-pin-project-devel \
 "
RDEPENDS:rust-pin-project-devel = " \
 cargo \
 rust \
 rust-pin-project-internal+default-devel \
 "
