# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openbgpd"
PV = "9.1"
PR = "1.el10_1"
PACKAGES = " \
 openbgpd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openbgpd-9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03d6a0a6a71355337ae296294e2ba2fecc17bf3c42e88c7ec77c8e36d59dcf62"

URI_x86_64_v2_openbgpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbgpd-9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbgpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbgpd}"
SRC_URI[x86_64_v2_openbgpd.sha256sum] = "5ba1d796d0ff77179351e785df55d0a454ff61716657a0bd08114338e7583331"

URI_aarch64_openbgpd = "${EPEL_MIRROR}/aarch64/Packages/o/openbgpd-9.1-1.el10_1.aarch64.rpm;name=aarch64_openbgpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbgpd}"
SRC_URI[aarch64_openbgpd.sha256sum] = "1989c00e8e7a18d25b17823822b1923bf0a784d80f28b25da259ed1a0b813aa9"

RDEPENDS:openbgpd = " \
 bash \
 glibc \
 libmnl \
 shadow-utils \
 systemd \
 "
