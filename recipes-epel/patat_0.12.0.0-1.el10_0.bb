# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "patat"
PV = "0.12.0.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-patat \
 ghc-patat-devel \
 ghc-patat-doc \
 ghc-patat-prof \
 patat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/patat-0.12.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caa56b3eed43b597186ee1b099b8d4e1349f8b06bd080d145fd87d2bd2bbf06a"

URI_x86_64_v2_ghc-patat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-patat-0.12.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-patat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-patat}"
SRC_URI[x86_64_v2_ghc-patat.sha256sum] = "abb7322952ea404e87a1acc29c367ffa90be69932c171002f3feff47687eb122"

URI_x86_64_v2_ghc-patat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-patat-devel-0.12.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-patat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-patat-devel}"
SRC_URI[x86_64_v2_ghc-patat-devel.sha256sum] = "c495880bcb0d06338c0e3eeb48b44a231ee344ee937205cc68bcbd3bd07a8b67"

URI_x86_64_v2_ghc-patat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-patat-doc-0.12.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-patat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-patat-doc}"
SRC_URI[x86_64_v2_ghc-patat-doc.sha256sum] = "eafc7d26be3463766b592087f12e4c12db3e403e84936f4720b0b23074808b1f"

URI_x86_64_v2_ghc-patat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-patat-prof-0.12.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-patat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-patat-prof}"
SRC_URI[x86_64_v2_ghc-patat-prof.sha256sum] = "89b1b1ffc45b9e6bcefa2fe191748916bfae1b064c18f8676ae74f9bcd16dbee"

URI_x86_64_v2_patat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/patat-0.12.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_patat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_patat}"
SRC_URI[x86_64_v2_patat.sha256sum] = "282c1e861844ffb1f7dab65e24a43ec5bc31ae29f4c8cc5463778e897ff7e1b2"

URI_aarch64_ghc-patat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-patat-0.12.0.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-patat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-patat}"
SRC_URI[aarch64_ghc-patat.sha256sum] = "4fa6fc5c9e66b0f09aee27bc043a62c096a66393bde49f5dc7875c1607ce963b"

URI_aarch64_ghc-patat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-patat-devel-0.12.0.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-patat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-patat-devel}"
SRC_URI[aarch64_ghc-patat-devel.sha256sum] = "2213b7f20ef8ca7acaeef6e6015629b48017ce427a66b37957d3a2ca7558e213"

URI_aarch64_ghc-patat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-patat-doc-0.12.0.0-1.el10_0.noarch.rpm;name=aarch64_ghc-patat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-patat-doc}"
SRC_URI[aarch64_ghc-patat-doc.sha256sum] = "0325de058ced9003c5907499ee553ea66ce486afa9027f13ab46925108293f80"

URI_aarch64_ghc-patat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-patat-prof-0.12.0.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-patat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-patat-prof}"
SRC_URI[aarch64_ghc-patat-prof.sha256sum] = "d7229c58dca6f1059287d675c40b121bc874a7cbb7762b7036f12d06dc7e336f"

URI_aarch64_patat = "${EPEL_MIRROR}/aarch64/Packages/p/patat-0.12.0.0-1.el10_0.aarch64.rpm;name=aarch64_patat;unpack=0"
SRC_URI:append = " ${URI_aarch64_patat}"
SRC_URI[aarch64_patat.sha256sum] = "e585d20bb5267fe3642cfc4fae685cdaecaf407dd4afc3dd20060441c515c6c2"

RDEPENDS:ghc-patat = " \
 ghc-Glob \
 ghc-JuicyPixels \
 ghc-OneTuple \
 ghc-Only \
 ghc-QuickCheck \
 ghc-SHA \
 ghc-StateVar \
 ghc-aeson \
 ghc-aeson-pretty \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-ansi-wl-pprint \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base16-bytestring \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cassava \
 ghc-cereal \
 ghc-citeproc \
 ghc-colour \
 ghc-commonmark \
 ghc-commonmark-extensions \
 ghc-commonmark-pandoc \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-digest \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-doclayout \
 ghc-doctemplates \
 ghc-emojis \
 ghc-exceptions \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gridtables \
 ghc-haddock-library \
 ghc-hashable \
 ghc-haskell-lexer \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-ipynb \
 ghc-jira-wiki-markup \
 ghc-libyaml \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-optparse-applicative \
 ghc-ordered-containers \
 ghc-os-string \
 ghc-pandoc \
 ghc-pandoc-types \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-pretty-show \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-prettyprinter-compat-ansi-wl-pprint \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-skylighting \
 ghc-skylighting-core \
 ghc-skylighting-format-ansi \
 ghc-skylighting-format-blaze-html \
 ghc-skylighting-format-context \
 ghc-skylighting-format-latex \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-syb \
 ghc-tagged \
 ghc-tagsoup \
 ghc-template-haskell \
 ghc-temporary \
 ghc-terminal-size \
 ghc-texmath \
 ghc-text \
 ghc-text-conversions \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-toml-parser \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-typst \
 ghc-typst-symbols \
 ghc-unicode-collation \
 ghc-unicode-data \
 ghc-unicode-transforms \
 ghc-uniplate \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-wcwidth \
 ghc-witherable \
 ghc-xml \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-yaml \
 ghc-zip-archive \
 ghc-zlib \
 glibc \
 gmp \
 libyaml \
 zlib-ng-compat \
 "
RDEPENDS:ghc-patat-devel = " \
 ghc-aeson-devel \
 ghc-ansi-terminal-devel \
 ghc-ansi-wl-pprint-devel \
 ghc-async-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-bytestring-devel \
 ghc-colour-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-mtl-devel \
 ghc-network-devel \
 ghc-network-uri-devel \
 ghc-optparse-applicative-devel \
 ghc-pandoc-devel \
 ghc-pandoc-types-devel \
 ghc-patat \
 ghc-process-devel \
 ghc-random-devel \
 ghc-skylighting-devel \
 ghc-terminal-size-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 ghc-wcwidth-devel \
 ghc-yaml-devel \
 "
RDEPENDS:ghc-patat-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-patat-prof = " \
 ghc-aeson-prof \
 ghc-ansi-terminal-prof \
 ghc-ansi-wl-pprint-prof \
 ghc-async-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-bytestring-prof \
 ghc-colour-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-mtl-prof \
 ghc-network-prof \
 ghc-network-uri-prof \
 ghc-optparse-applicative-prof \
 ghc-pandoc-prof \
 ghc-pandoc-types-prof \
 ghc-patat-devel \
 ghc-process-prof \
 ghc-random-prof \
 ghc-skylighting-prof \
 ghc-terminal-size-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 ghc-wcwidth-prof \
 ghc-yaml-prof \
 "
RDEPENDS:patat = " \
 glibc \
 gmp \
 libffi \
 libyaml \
 zlib-ng-compat \
 "
