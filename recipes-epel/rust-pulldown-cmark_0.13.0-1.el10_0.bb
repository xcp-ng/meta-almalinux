# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pulldown-cmark"
PV = "0.13.0"
PR = "1.el10_0"
PACKAGES = " \
 pulldown-cmark \
 rust-pulldown-cmark+default-devel \
 rust-pulldown-cmark+gen-tests-devel \
 rust-pulldown-cmark+getopts-devel \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark+pulldown-cmark-escape-devel \
 rust-pulldown-cmark+serde-devel \
 rust-pulldown-cmark+simd-devel \
 rust-pulldown-cmark-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pulldown-cmark-0.13.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cb2d3b1f25521da40e603dfe684a361091783ec4b1cd7b248952b8e78e1e801"

URI_x86_64_v2_pulldown-cmark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulldown-cmark-0.13.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulldown-cmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulldown-cmark}"
SRC_URI[x86_64_v2_pulldown-cmark.sha256sum] = "de36f5b506800a3e0dc9b9c64ab61e2896fbd45da3dedf62da79b908f84a429e"

URI_x86_64_v2_rust-pulldown-cmark+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+default-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+default-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+default-devel.sha256sum] = "3633c841d16cd9e01d66e724ee52a4bd4f84ba520fe3042e17fd7d1e3f191584"

URI_x86_64_v2_rust-pulldown-cmark+gen-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+gen-tests-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+gen-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+gen-tests-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+gen-tests-devel.sha256sum] = "bc93dfca6ee515c6bd2330337206314c15182a2905eba7fee1ed3ddb32fa08d2"

URI_x86_64_v2_rust-pulldown-cmark+getopts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+getopts-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+getopts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+getopts-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+getopts-devel.sha256sum] = "dea6738eefbc44a9f7e1a18040f871e43806534c4df405504f16c65e1ce47e73"

URI_x86_64_v2_rust-pulldown-cmark+html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+html-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+html-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+html-devel.sha256sum] = "12051ca0f239a20a35ad428d5084f199711c516d947397d7284249bd9d4a5e3b"

URI_x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+pulldown-cmark-escape-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel.sha256sum] = "11604ed56ebf5a9cee2942fcd4a7143dc42d80712a988282427a524299b8884d"

URI_x86_64_v2_rust-pulldown-cmark+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+serde-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+serde-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+serde-devel.sha256sum] = "9e827c1d638b87e5ae58c1dbc383e0d05e759f5a2d6cf7c617df0f728fdccc3e"

URI_x86_64_v2_rust-pulldown-cmark+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+simd-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+simd-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+simd-devel.sha256sum] = "a47c1eb1582df8c230dc3f6feb09802a6f9900d62bc948b6f925614fd9d0186b"

URI_x86_64_v2_rust-pulldown-cmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark-devel.sha256sum] = "25e3a75014a7c52a06ca848c9fac8b4717e7d8107e8ac8d3bd84f237566d18b0"

URI_aarch64_pulldown-cmark = "${EPEL_MIRROR}/aarch64/Packages/p/pulldown-cmark-0.13.0-1.el10_0.aarch64.rpm;name=aarch64_pulldown-cmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulldown-cmark}"
SRC_URI[aarch64_pulldown-cmark.sha256sum] = "7bcdad79aedcdfa514bacf823b5e691f321bfd944a3a6053b58039efe8741c83"

URI_aarch64_rust-pulldown-cmark+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+default-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+default-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+default-devel.sha256sum] = "b1184964acba64b5afe8f3419f46ddf25aeaa0f252cf652bb21683093caf911a"

URI_aarch64_rust-pulldown-cmark+gen-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+gen-tests-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark+gen-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+gen-tests-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+gen-tests-devel.sha256sum] = "e143cfabdae7919503c1bc2965acc8226a15af0b00ab6ffad058c196b6b6f712"

URI_aarch64_rust-pulldown-cmark+getopts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+getopts-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark+getopts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+getopts-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+getopts-devel.sha256sum] = "516c9729417c1176676867adfd6c6a0e0996c874f1695db6c4dad59faa5e1e59"

URI_aarch64_rust-pulldown-cmark+html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+html-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark+html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+html-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+html-devel.sha256sum] = "4a3fcefccee3a13aae96eb4d472377d44d94ad51ad8512a52b0419de6a796a2e"

URI_aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+pulldown-cmark-escape-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel.sha256sum] = "ea36f27811f306b7cc829c3e8abaf38a3d39fd6f24cf1ba074dc7918cc891db7"

URI_aarch64_rust-pulldown-cmark+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+serde-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+serde-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+serde-devel.sha256sum] = "7d85e802211d8873589295efc57f9dd7cb96257230a6fd6b580dee6b6f1e84ed"

URI_aarch64_rust-pulldown-cmark+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+simd-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+simd-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+simd-devel.sha256sum] = "af44f94c3ee6da2589d2d58b5d325d089793a5243f20dde3d1129e2982ab59f7"

URI_aarch64_rust-pulldown-cmark-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark-devel}"
SRC_URI[aarch64_rust-pulldown-cmark-devel.sha256sum] = "45c1bc486e05922da35ed90f3c795bfb76a784fc31178598011e77a43e9a8fa2"

RDEPENDS:pulldown-cmark = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-pulldown-cmark+default-devel = " \
 cargo \
 rust-pulldown-cmark+getopts-devel \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+gen-tests-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+getopts-devel = " \
 cargo \
 rust-getopts+default-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+html-devel = " \
 cargo \
 rust-pulldown-cmark+pulldown-cmark-escape-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+pulldown-cmark-escape-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-pulldown-cmark-escape+default-devel \
 "
RDEPENDS:rust-pulldown-cmark+serde-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-pulldown-cmark+simd-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-pulldown-cmark-escape+default-devel \
 rust-pulldown-cmark-escape+simd-devel \
 "
RDEPENDS:rust-pulldown-cmark-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-memchr+default-devel \
 rust-unicase+default-devel \
 "
