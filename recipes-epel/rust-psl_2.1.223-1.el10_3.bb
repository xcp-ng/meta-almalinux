# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psl"
PV = "2.1.223"
PR = "1.el10_3"
PACKAGES = " \
 rust-psl+default-devel \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-psl-2.1.223-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a35d1423737d1a85b28a2321a5ac03be98cff64af3322f5b1f0b69ef6a1168a"

URI_x86_64_v2_rust-psl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+default-devel-2.1.223-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl+default-devel}"
SRC_URI[x86_64_v2_rust-psl+default-devel.sha256sum] = "bfd48a1bc25434f5074e8d99622ab12c73b8e507cfce5279eaf1b9e1a989adad"

URI_x86_64_v2_rust-psl+helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+helpers-devel-2.1.223-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl+helpers-devel}"
SRC_URI[x86_64_v2_rust-psl+helpers-devel.sha256sum] = "34bf601c64e327974b34187b959df780227cced62cdb82c58da5e00cbfe94e6d"

URI_x86_64_v2_rust-psl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl-devel-2.1.223-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl-devel}"
SRC_URI[x86_64_v2_rust-psl-devel.sha256sum] = "c2afb4b833279898ff289c83e6f9fc79ac726203cef5f35920c44a0b6fccc8bf"

URI_aarch64_rust-psl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+default-devel-2.1.223-1.el10_3.noarch.rpm;name=aarch64_rust-psl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl+default-devel}"
SRC_URI[aarch64_rust-psl+default-devel.sha256sum] = "6e2f5d56fd34f23b4a1b38166bb0b13be9c9d36fd591f73bbdeaf47fed2303d4"

URI_aarch64_rust-psl+helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+helpers-devel-2.1.223-1.el10_3.noarch.rpm;name=aarch64_rust-psl+helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl+helpers-devel}"
SRC_URI[aarch64_rust-psl+helpers-devel.sha256sum] = "b53ec142fc96a6a0f3d00a1e6204d84391a8376af7bbfeca8eff7452c85fbbc2"

URI_aarch64_rust-psl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl-devel-2.1.223-1.el10_3.noarch.rpm;name=aarch64_rust-psl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl-devel}"
SRC_URI[aarch64_rust-psl-devel.sha256sum] = "3da6772cfd9f9217cf5df61400167f727cd94a0d35239f12fe4fc1072bcf8e06"

RDEPENDS:rust-psl+default-devel = " \
 cargo \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "
RDEPENDS:rust-psl+helpers-devel = " \
 cargo \
 rust-psl-devel \
 "
RDEPENDS:rust-psl-devel = " \
 cargo \
 rust-psl-types+default-devel \
 "
