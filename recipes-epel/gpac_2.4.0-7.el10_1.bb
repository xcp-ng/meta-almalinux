# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpac"
PV = "2.4.0"
PR = "7.el10_1"
PACKAGES = " \
 gpac \
 gpac-devel \
 gpac-doc \
 gpac-libs \
 gpac-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpac-2.4.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6f562b8ef27c0ec1da6c149ad131acc0782040ad8ac31d832e3002443af26f3"

URI_x86_64_v2_gpac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpac-2.4.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpac}"
SRC_URI[x86_64_v2_gpac.sha256sum] = "e88d3f8a8478918e6751cae905e543e74d2ca4316d314693609963183b25ee2d"

URI_x86_64_v2_gpac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpac-devel-2.4.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpac-devel}"
SRC_URI[x86_64_v2_gpac-devel.sha256sum] = "11d6894c74d03f8f4cd12f7ee4ad32c9788e7446bbaad3961679639af517c2dd"

URI_x86_64_v2_gpac-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpac-doc-2.4.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpac-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpac-doc}"
SRC_URI[x86_64_v2_gpac-doc.sha256sum] = "53af5624365a70e48156cb024492a52f39f022afc8340db24d0238ba0af81865"

URI_x86_64_v2_gpac-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpac-libs-2.4.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpac-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpac-libs}"
SRC_URI[x86_64_v2_gpac-libs.sha256sum] = "5c287b18b4600ee492fd386000ee021df177797ad075c910ff718fd046814f0f"

URI_x86_64_v2_gpac-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpac-static-2.4.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpac-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpac-static}"
SRC_URI[x86_64_v2_gpac-static.sha256sum] = "f8056e1e0fb9f4b2c99de0ceb9872257eda4a21698f298394627b17f608161dc"

URI_aarch64_gpac = "${EPEL_MIRROR}/aarch64/Packages/g/gpac-2.4.0-7.el10_1.aarch64.rpm;name=aarch64_gpac;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpac}"
SRC_URI[aarch64_gpac.sha256sum] = "8156e5b99e84791b752cc199ee4a7fd200ae6d7f4fdac63959e0dea29b9cf161"

URI_aarch64_gpac-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gpac-devel-2.4.0-7.el10_1.aarch64.rpm;name=aarch64_gpac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpac-devel}"
SRC_URI[aarch64_gpac-devel.sha256sum] = "b5bd4d595d72c64a6f586c5cd196afb9900cfd190dc477c9056a365bc9689239"

URI_aarch64_gpac-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gpac-doc-2.4.0-7.el10_1.aarch64.rpm;name=aarch64_gpac-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpac-doc}"
SRC_URI[aarch64_gpac-doc.sha256sum] = "32e43a001912ab6b010b5b920f42400e1b304a12e39b59512d6c376bcfcb1c13"

URI_aarch64_gpac-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gpac-libs-2.4.0-7.el10_1.aarch64.rpm;name=aarch64_gpac-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpac-libs}"
SRC_URI[aarch64_gpac-libs.sha256sum] = "99a9902c587da2a424f9fb5de59d81819c3f2511eeb6f7295f0a80b874e00320"

URI_aarch64_gpac-static = "${EPEL_MIRROR}/aarch64/Packages/g/gpac-static-2.4.0-7.el10_1.aarch64.rpm;name=aarch64_gpac-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpac-static}"
SRC_URI[aarch64_gpac-static.sha256sum] = "13e2ba31364680a36afa6e41a0827fa04c237bf66c9a75fd68cb6d6e9cc614ca"

RDEPENDS:gpac = " \
 glibc \
 gpac-libs \
 "
RDEPENDS:gpac-devel = " \
 gpac-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gpac-doc = " \
 "
RDEPENDS:gpac-libs = " \
 freetype \
 glibc \
 libX11 \
 libXext \
 libXv \
 liba52 \
 libavcodec-free \
 libavdevice-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libglvnd-glx \
 libjpeg-turbo \
 libmad \
 libnghttp2 \
 libogg \
 libpng \
 libswscale-free \
 libtheora \
 libvorbis \
 mesa-libGLU \
 openjpeg2 \
 openssl-libs \
 pipewire-jack-audio-connection-kit-libs \
 pulseaudio-libs \
 virtual/libSDL2-2.0.so.0___64bit_ \
 xvidcore \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:gpac-static = " \
 gpac-devel \
 "
