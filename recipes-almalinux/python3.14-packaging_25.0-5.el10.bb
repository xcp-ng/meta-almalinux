# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-packaging"
PV = "25.0"
PR = "5.el10"
PACKAGES = " \
 python3.14-packaging \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-packaging-25.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "facc0051cb001acfb9d2da097c7a91c70dc64600b3b53c96761b654026f620fd"

URI_x86_64_v2_python3.14-packaging = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-packaging-25.0-5.el10.noarch.rpm;name=x86_64_v2_python3.14-packaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-packaging}"
SRC_URI[x86_64_v2_python3.14-packaging.sha256sum] = "a3860356b23f8190b1d3cc1795294c871ee343cd36b3d901bdbe33de5ea8271f"

URI_aarch64_python3.14-packaging = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-packaging-25.0-5.el10.noarch.rpm;name=aarch64_python3.14-packaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-packaging}"
SRC_URI[aarch64_python3.14-packaging.sha256sum] = "a3860356b23f8190b1d3cc1795294c871ee343cd36b3d901bdbe33de5ea8271f"

RDEPENDS:python3.14-packaging = " \
 python3.14 \
 "
