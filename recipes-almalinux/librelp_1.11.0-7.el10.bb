# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librelp"
PV = "1.11.0"
PR = "7.el10"
PACKAGES = " \
 librelp \
 librelp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/librelp-1.11.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d4adbd92779effbc627e614967bc9e49be742a23585c4013b496d4a893ac09c"

URI_x86_64_v2_librelp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/librelp-1.11.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_librelp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librelp}"
SRC_URI[x86_64_v2_librelp.sha256sum] = "e857a2f96754e524cc2e8c0f20fa47977f535abfcce6e2ac907a1dde1fbc336d"

URI_x86_64_v2_librelp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/librelp-devel-1.11.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_librelp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librelp-devel}"
SRC_URI[x86_64_v2_librelp-devel.sha256sum] = "997c651911648177fdb176faf5b85e764adf5f960a1df9beda830b009b741801"

URI_aarch64_librelp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/librelp-1.11.0-7.el10.aarch64.rpm;name=aarch64_librelp;unpack=0"
SRC_URI:append = " ${URI_aarch64_librelp}"
SRC_URI[aarch64_librelp.sha256sum] = "49a7f542e2ee0d03f6ea74911ddd71f0a513cde74f8240055fa4136c907337d5"

URI_aarch64_librelp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/librelp-devel-1.11.0-7.el10.aarch64.rpm;name=aarch64_librelp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librelp-devel}"
SRC_URI[aarch64_librelp-devel.sha256sum] = "9f67c26b7abe64471716740e8fc266b3cc51c829cc48fea3aa46ef75c14ebbe2"

RDEPENDS:librelp = " \
 glibc \
 gnutls \
 openssl-libs \
 "
RDEPENDS:librelp-devel = " \
 librelp \
 pkgconf-pkg-config \
 "
