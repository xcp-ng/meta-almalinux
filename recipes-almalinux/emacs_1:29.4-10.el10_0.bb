# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "emacs"
PE = "1"
PV = "29.4"
PR = "10.el10_0"
PACKAGES = " \
 emacs \
 emacs-common \
 emacs-filesystem \
 emacs-lucid \
 emacs-nw \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/emacs-29.4-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "773be5a663cf5bdc39156777558e56cc044e05778730fa8c434d5b44419415a1"

URI_x86_64_v2_emacs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/emacs-29.4-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_emacs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs}"
SRC_URI[x86_64_v2_emacs.sha256sum] = "28855ba00f8110334987694ea46e1b00450eef143914dc0973afddfe7dbc9956"
RPROVIDES:emacs:x86_64_v2 = "virtual/emacs_bin__ge_29.4"

URI_x86_64_v2_emacs-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/emacs-common-29.4-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_emacs-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-common}"
SRC_URI[x86_64_v2_emacs-common.sha256sum] = "1a99e61f4aa57ccc7ab9d0083f51bf8e7226ade9c5970069cd7393b92c4d36cd"

URI_x86_64_v2_emacs-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/emacs-filesystem-29.4-10.el10_0.noarch.rpm;name=x86_64_v2_emacs-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-filesystem}"
SRC_URI[x86_64_v2_emacs-filesystem.sha256sum] = "ad151663eebd56c4f7d0f72ffe359e74c5b8129ec50afe582506c3557ce07711"

URI_x86_64_v2_emacs-lucid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/emacs-lucid-29.4-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_emacs-lucid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-lucid}"
SRC_URI[x86_64_v2_emacs-lucid.sha256sum] = "7f19dc365129b8551cb8c0537b8183d9757a66bf63c6768534b40ee3408d0481"
RPROVIDES:emacs-lucid:x86_64_v2 = "virtual/emacs_bin__ge_29.4"

URI_x86_64_v2_emacs-nw = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/emacs-nw-29.4-10.el10_0.x86_64_v2.rpm;name=x86_64_v2_emacs-nw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-nw}"
SRC_URI[x86_64_v2_emacs-nw.sha256sum] = "e62c4da3f0c52b6e892fb813a56a039c96dbc23d6fe88fd60791721a1c498b92"
RPROVIDES:emacs-nw:x86_64_v2 = "virtual/emacs_bin__ge_29.4"

URI_aarch64_emacs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/emacs-29.4-10.el10_0.aarch64.rpm;name=aarch64_emacs;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs}"
SRC_URI[aarch64_emacs.sha256sum] = "572ffef8d6b774cd7c666eeb69ab8fdcc855c14e9d0811a3de614cedabc5b98c"
RPROVIDES:emacs:aarch64 = "virtual/emacs_bin__ge_29.4"

URI_aarch64_emacs-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/emacs-common-29.4-10.el10_0.aarch64.rpm;name=aarch64_emacs-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-common}"
SRC_URI[aarch64_emacs-common.sha256sum] = "53d4f7eae383282e0973c0f4691d54e8eaabf260120fb6c06c1c7a3339bdb012"

URI_aarch64_emacs-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/emacs-filesystem-29.4-10.el10_0.noarch.rpm;name=aarch64_emacs-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-filesystem}"
SRC_URI[aarch64_emacs-filesystem.sha256sum] = "ad151663eebd56c4f7d0f72ffe359e74c5b8129ec50afe582506c3557ce07711"

URI_aarch64_emacs-lucid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/emacs-lucid-29.4-10.el10_0.aarch64.rpm;name=aarch64_emacs-lucid;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-lucid}"
SRC_URI[aarch64_emacs-lucid.sha256sum] = "ddcc177284f792770c879117a93ec57b1c6042d26f3e3d3487a6a6c0f4d0594c"
RPROVIDES:emacs-lucid:aarch64 = "virtual/emacs_bin__ge_29.4"

URI_aarch64_emacs-nw = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/emacs-nw-29.4-10.el10_0.aarch64.rpm;name=aarch64_emacs-nw;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-nw}"
SRC_URI[aarch64_emacs-nw.sha256sum] = "508e959063c45183c82fffb58a477b898a06d7974a283174ccda24bd8867426c"
RPROVIDES:emacs-nw:aarch64 = "virtual/emacs_bin__ge_29.4"

RDEPENDS:emacs = " \
 alsa-lib \
 alternatives \
 bash \
 cairo \
 dbus-libs \
 emacs-common \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 giflib \
 glib2 \
 glibc \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 gtk3 \
 harfbuzz \
 jansson \
 libacl \
 libgcc \
 libjpeg-turbo \
 libotf \
 libpng \
 librsvg2 \
 libselinux \
 libtiff \
 libtree-sitter \
 libwebp \
 libxml2 \
 ncurses-libs \
 pango \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:emacs-common = " \
 alternatives \
 bash \
 emacs-filesystem \
 glibc \
 libgccjit \
 libtree-sitter \
 pkgconf-pkg-config \
 "
RDEPENDS:emacs-filesystem = " \
 "
RDEPENDS:emacs-lucid = " \
 Xaw3d \
 alsa-lib \
 alternatives \
 bash \
 cairo \
 dbus-libs \
 emacs-common \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 giflib \
 glib2 \
 glibc \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 harfbuzz \
 jansson \
 libICE \
 libSM \
 libX11 \
 libXcomposite \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXmu \
 libXpm \
 libXrandr \
 libXrender \
 libXt \
 libacl \
 libgcc \
 libjpeg-turbo \
 libotf \
 libpng \
 librsvg2 \
 libselinux \
 libtiff \
 libtree-sitter \
 libwebp \
 libxml2 \
 m17n-lib \
 ncurses-libs \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:emacs-nw = " \
 alsa-lib \
 alternatives \
 bash \
 dbus-libs \
 emacs-common \
 glibc \
 gnutls \
 jansson \
 libacl \
 libgcc \
 libselinux \
 libtree-sitter \
 libxml2 \
 ncurses-libs \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/emacs_bin__ge_29.4"

PROVIDES:append:aarch64 = " rpm/virtual/emacs_bin__ge_29.4"
