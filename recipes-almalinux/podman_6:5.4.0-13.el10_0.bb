# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman"
PE = "6"
PV = "5.4.0"
PR = "13.el10_0"
PACKAGES = " \
 podman \
 podman-docker \
 podman-remote \
 podman-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/podman-5.4.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bf09fc85643813004796f994940235af6b79d484f1a81d0824c0125f7991251"

URI_x86_64_v2_podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-5.4.0-13.el10_0.x86_64_v2.rpm;name=x86_64_v2_podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman}"
SRC_URI[x86_64_v2_podman.sha256sum] = "26c6c576e89f9091de4b12ef8522dc26c10507de7376a3c05e406f5607b1460d"
RPROVIDES:podman:x86_64_v2 = "virtual/podman_or_/usr/bin/docker"

URI_x86_64_v2_podman-docker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-docker-5.4.0-13.el10_0.noarch.rpm;name=x86_64_v2_podman-docker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-docker}"
SRC_URI[x86_64_v2_podman-docker.sha256sum] = "8abbc5400a991c98ba4d8bee821b158581877b40360242c50dfad6f9a4bb9aad"
RPROVIDES:podman-docker:x86_64_v2 = "virtual/podman_or_/usr/bin/docker"

URI_x86_64_v2_podman-remote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-remote-5.4.0-13.el10_0.x86_64_v2.rpm;name=x86_64_v2_podman-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-remote}"
SRC_URI[x86_64_v2_podman-remote.sha256sum] = "d9b0fb5321d7ff07d053b18a5529c254d57f6f160be00408145f738f15ffa517"

URI_x86_64_v2_podman-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/podman-tests-5.4.0-13.el10_0.x86_64_v2.rpm;name=x86_64_v2_podman-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-tests}"
SRC_URI[x86_64_v2_podman-tests.sha256sum] = "9e138a23559d5f9ee489937810dc0140ed60ede95721bf0a015bf0e589c2c534"

URI_aarch64_podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-5.4.0-13.el10_0.aarch64.rpm;name=aarch64_podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman}"
SRC_URI[aarch64_podman.sha256sum] = "33ef272bf0745d41c7bedd2fa00857a79ed9839a341be9a7f39229855a02c572"
RPROVIDES:podman:aarch64 = "virtual/podman_or_/usr/bin/docker"

URI_aarch64_podman-docker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-docker-5.4.0-13.el10_0.noarch.rpm;name=aarch64_podman-docker;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-docker}"
SRC_URI[aarch64_podman-docker.sha256sum] = "8abbc5400a991c98ba4d8bee821b158581877b40360242c50dfad6f9a4bb9aad"
RPROVIDES:podman-docker:aarch64 = "virtual/podman_or_/usr/bin/docker"

URI_aarch64_podman-remote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-remote-5.4.0-13.el10_0.aarch64.rpm;name=aarch64_podman-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-remote}"
SRC_URI[aarch64_podman-remote.sha256sum] = "2e4512dfc41a70f3336886e4ee6bb6123e4a905d8bded09d634971b5b21e77e6"

URI_aarch64_podman-tests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/podman-tests-5.4.0-13.el10_0.aarch64.rpm;name=aarch64_podman-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-tests}"
SRC_URI[aarch64_podman-tests.sha256sum] = "c09ad5506877a9bf88f1de20264e4a42bd121c4404f5b8d89071052f97f8f569"

RDEPENDS:podman = " \
 catatonit \
 conmon \
 containers-common-extra \
 glibc \
 gpgme \
 libgcc \
 libseccomp \
 shadow-utils-subid \
 "
RDEPENDS:podman-docker = " \
 bash \
 podman \
 "
RDEPENDS:podman-remote = " \
 glibc \
 gpgme \
 libgcc \
 shadow-utils-subid \
 "
RDEPENDS:podman-tests = " \
 attr \
 bash \
 buildah \
 glibc \
 gnupg2 \
 gpgme \
 httpd-tools \
 jq \
 libgcc \
 libseccomp \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 skopeo \
 socat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/podman_or_/usr/bin/docker"

PROVIDES:append:aarch64 = " rpm/virtual/podman_or_/usr/bin/docker"
