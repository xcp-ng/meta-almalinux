# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-collections4"
PV = "4.4"
PR = "22.el10_3"
PACKAGES = " \
 apache-commons-collections4 \
 apache-commons-collections4-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apache-commons-collections4-4.4-22.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "688952b1f9ac97cf810f7953d7c257d81d7a2da46a3198099f1fb5be94af65b8"

URI_x86_64_v2_apache-commons-collections4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apache-commons-collections4-4.4-22.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_apache-commons-collections4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-collections4}"
SRC_URI[x86_64_v2_apache-commons-collections4.sha256sum] = "9489cfe0a89efab864304b87e276c12274d8a4f2718119dc72e8506821626479"

URI_x86_64_v2_apache-commons-collections4-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apache-commons-collections4-javadoc-4.4-22.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_apache-commons-collections4-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-collections4-javadoc}"
SRC_URI[x86_64_v2_apache-commons-collections4-javadoc.sha256sum] = "a7098dc26c2952059390eb4b8e8e9e711d7a659539cbc30d30ccf38e0694b7ec"

URI_aarch64_apache-commons-collections4 = "${EPEL_MIRROR}/aarch64/Packages/a/apache-commons-collections4-4.4-22.el10_3.noarch.rpm;name=aarch64_apache-commons-collections4;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-collections4}"
SRC_URI[aarch64_apache-commons-collections4.sha256sum] = "6aab4eed7747ee05f0e2b4ae1442e25703c5b25c5e60a1f03f96da6b29379f86"

URI_aarch64_apache-commons-collections4-javadoc = "${EPEL_MIRROR}/aarch64/Packages/a/apache-commons-collections4-javadoc-4.4-22.el10_3.noarch.rpm;name=aarch64_apache-commons-collections4-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-collections4-javadoc}"
SRC_URI[aarch64_apache-commons-collections4-javadoc.sha256sum] = "009ebc24a9916c1de56085398e0cfe1dee36cf2df213ce1806b871b3a604ad62"

RDEPENDS:apache-commons-collections4 = " \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-collections4-javadoc = " \
 javapackages-filesystem \
 "
