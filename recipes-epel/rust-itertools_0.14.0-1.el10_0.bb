# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-itertools"
PV = "0.14.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-itertools+default-devel \
 rust-itertools+use_alloc-devel \
 rust-itertools+use_std-devel \
 rust-itertools-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-itertools-0.14.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96269b61d7b26495fe2a4915543d8a1c1c7f639a322ce20b84a0d1a8e0acae2a"

URI_x86_64_v2_rust-itertools+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools+default-devel-0.14.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools+default-devel}"
SRC_URI[x86_64_v2_rust-itertools+default-devel.sha256sum] = "bf0c118698d6ff070b77a883a55ade68aaa9dce3229bdfa09ad49d683524bef6"
RPROVIDES:rust-itertools+default-devel:x86_64_v2 = "virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~"

URI_x86_64_v2_rust-itertools+use_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools+use_alloc-devel-0.14.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools+use_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools+use_alloc-devel}"
SRC_URI[x86_64_v2_rust-itertools+use_alloc-devel.sha256sum] = "f1dbf007ecf831bde9f2927312a6ace2219afabe8b1adb6b33c722657f4c15bf"

URI_x86_64_v2_rust-itertools+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools+use_std-devel-0.14.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools+use_std-devel}"
SRC_URI[x86_64_v2_rust-itertools+use_std-devel.sha256sum] = "375098a3807fb3513ad14cad2ce8b7c46034f17cd19fc4b72d58ecc6afec5f0c"

URI_x86_64_v2_rust-itertools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itertools-devel-0.14.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itertools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itertools-devel}"
SRC_URI[x86_64_v2_rust-itertools-devel.sha256sum] = "8eb8f7695ba782dc8c24d586a9beeaa22bc0189265e6bfd7772b911dc2a5b577"

URI_aarch64_rust-itertools+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools+default-devel-0.14.0-1.el10_0.noarch.rpm;name=aarch64_rust-itertools+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools+default-devel}"
SRC_URI[aarch64_rust-itertools+default-devel.sha256sum] = "dd0d01e5c9284b2ee806ce1f2c5e01dc22a30aab8840f988f3ac2cf31a599fa6"
RPROVIDES:rust-itertools+default-devel:aarch64 = "virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~"

URI_aarch64_rust-itertools+use_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools+use_alloc-devel-0.14.0-1.el10_0.noarch.rpm;name=aarch64_rust-itertools+use_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools+use_alloc-devel}"
SRC_URI[aarch64_rust-itertools+use_alloc-devel.sha256sum] = "03b5f04e498c99a93552c812b19377797aa4abfaf6eaeb6544c2e0222708305a"

URI_aarch64_rust-itertools+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools+use_std-devel-0.14.0-1.el10_0.noarch.rpm;name=aarch64_rust-itertools+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools+use_std-devel}"
SRC_URI[aarch64_rust-itertools+use_std-devel.sha256sum] = "a4140ef689b77fa1398c462cc361f9bce514fba89310b99f4a779c4654775ef0"

URI_aarch64_rust-itertools-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itertools-devel-0.14.0-1.el10_0.noarch.rpm;name=aarch64_rust-itertools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itertools-devel}"
SRC_URI[aarch64_rust-itertools-devel.sha256sum] = "2bf31a5e4fc5137334d6f7ac2254927c39cbaa54ebf0cffa66eaf1c57af2565c"

RDEPENDS:rust-itertools+default-devel = " \
 cargo \
 rust-itertools+use_std-devel \
 rust-itertools-devel \
 "
RDEPENDS:rust-itertools+use_alloc-devel = " \
 cargo \
 rust-itertools-devel \
 "
RDEPENDS:rust-itertools+use_std-devel = " \
 cargo \
 rust-either+use_std-devel \
 rust-itertools+use_alloc-devel \
 rust-itertools-devel \
 "
RDEPENDS:rust-itertools-devel = " \
 cargo \
 rust \
 rust-either-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_itertools/default__ge_0.13.0_with_crate_itertools/default__lt_0.15.0~"
