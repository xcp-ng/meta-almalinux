# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-packager"
PV = "1.1"
PR = "12.el10_3"
PACKAGES = " \
 fedora-packager \
 fedora-packager-kerberos \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fedora-packager-1.1-12.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "95c82d3de7ce46e6fa83cd85152cf052f7d316e29701a9c41468e99e1d66a263"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-packager-1.1-12.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-packager;unpack=0"
SRC_URI[x86_64_v2_fedora-packager.sha256sum] = "a254317e86deb637a3f6e8417a2d9ec002bbc8c6506b4afeffa09226ba160e30"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-packager-kerberos-1.1-12.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-packager-kerberos;unpack=0"
SRC_URI[x86_64_v2_fedora-packager-kerberos.sha256sum] = "463312f3345d4949d7c4f694bde7e84ae56c005d94373f384d6b76638fef10a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fedora-packager-1.1-12.el10_3.noarch.rpm;name=aarch64_fedora-packager;unpack=0"
SRC_URI[aarch64_fedora-packager.sha256sum] = "539fe9ab57c8823ec5112b84b2f63820d5ec055af9efbef0b0558fdc19e7a287"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fedora-packager-kerberos-1.1-12.el10_3.noarch.rpm;name=aarch64_fedora-packager-kerberos;unpack=0"
SRC_URI[aarch64_fedora-packager-kerberos.sha256sum] = "1a04aa5db67164ea1c2c6cade947ec140a977c1821974250150b18fa7ae481f7"

RDEPENDS:fedora-packager = " \
 bash \
 bodhi-client \
 curl \
 fedora-packager-kerberos \
 fedpkg \
 koji \
 mock \
 openssh-clients \
 python3 \
 python3-koji-cli-plugins \
 redhat-rpm-config \
 rpm-build \
 rpmautospec \
 rpmdevtools \
 rpmlint \
 systemd \
 "
RDEPENDS:fedora-packager-kerberos = " \
 bash \
 fedora-packager \
 krb5-pkinit \
 krb5-workstation \
 "
