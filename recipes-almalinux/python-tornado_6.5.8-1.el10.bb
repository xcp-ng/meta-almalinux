# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tornado"
PV = "6.5.8"
PR = "1.el10"
PACKAGES = " \
 python3-tornado \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-tornado-6.5.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "51f4d253f794f7d0fcfce92210dc9ff471cf72592900a3f7e9579845a13781e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tornado-6.5.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tornado;unpack=0"
SRC_URI[x86_64_v2_python3-tornado.sha256sum] = "16e118143862e88ee06911f5deab1e00f2357e5e7d8b7127d6eee221cff3c0b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tornado-6.5.8-1.el10.aarch64.rpm;name=aarch64_python3-tornado;unpack=0"
SRC_URI[aarch64_python3-tornado.sha256sum] = "322e6c8680c7f345c4b80d6bc70c9daf58d5bca5600f8da82771ea70919c3ff8"

RDEPENDS:python3-tornado = " \
 glibc \
 python3 \
 "
