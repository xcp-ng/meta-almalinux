# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-SysRandom-XS"
PV = "0.011"
PR = "3.el10_3"
PACKAGES = " \
 perl-Crypt-SysRandom-XS \
 perl-Crypt-SysRandom-XS-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-SysRandom-XS-0.011-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9aba36922c49ba4835d391e4d7cdcb68d5f8550973d44976a514452e8e9330b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-SysRandom-XS-0.011-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-SysRandom-XS;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-SysRandom-XS.sha256sum] = "dfc1e1230e4031d600e26dd6ebf9ebdd61ab8e03f5e8aa11515d2d543568099c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-SysRandom-XS-tests-0.011-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-SysRandom-XS-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-SysRandom-XS-tests.sha256sum] = "dedd70dd583b435cd5f9ff50248231ba22320aea3966c0efc81909144a9affb8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-SysRandom-XS-0.011-3.el10_3.aarch64.rpm;name=aarch64_perl-Crypt-SysRandom-XS;unpack=0"
SRC_URI[aarch64_perl-Crypt-SysRandom-XS.sha256sum] = "b137e4278e06492f6b51a9cc7f99b50eecf99624cb2fd774eef3ded9ff42eab7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-SysRandom-XS-tests-0.011-3.el10_3.noarch.rpm;name=aarch64_perl-Crypt-SysRandom-XS-tests;unpack=0"
SRC_URI[aarch64_perl-Crypt-SysRandom-XS-tests.sha256sum] = "3cd11426700429a6c35b190016b68dbdeb5e680449faede6d72aa681d9af06bb"

RDEPENDS:perl-Crypt-SysRandom-XS = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Crypt-SysRandom-XS-tests = " \
 bash \
 perl-Crypt-SysRandom-XS \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
