# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim"
PE = "2"
PV = "9.1.083"
PR = "6.el10_1.4"
PACKAGES = " \
 vim-X11 \
 vim-common \
 vim-data \
 vim-enhanced \
 vim-filesystem \
 vim-minimal \
 xxd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/vim-9.1.083-6.el10_1.4.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b726ac08919c1126e3ec1f7494e5cf2819c47ca145fdbe897ca33f402a80375a"

URI_x86_64_v2_vim-X11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-X11-9.1.083-6.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_vim-X11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-X11}"
SRC_URI[x86_64_v2_vim-X11.sha256sum] = "85493c54921b071ef2063050109752355a527fa9774c7a083b265b9e45d20e11"
RPROVIDES:vim-X11:append:x86_64_v2 = " virtual/vim-enhanced_or_vim-X11"

URI_x86_64_v2_vim-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-common-9.1.083-6.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_vim-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-common}"
SRC_URI[x86_64_v2_vim-common.sha256sum] = "62e9cd2fe0657010bd9e572b819f9d3e060d79b129ec75c7f830f745b2f44b8c"

URI_x86_64_v2_vim-data = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-data-9.1.083-6.el10_1.4.noarch.rpm;name=x86_64_v2_vim-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-data}"
SRC_URI[x86_64_v2_vim-data.sha256sum] = "1ef5d7ee05f8e0ef3991ba51537b081c90ac11ef018edc69324a44c46e7d4e1e"

URI_x86_64_v2_vim-enhanced = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-enhanced-9.1.083-6.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_vim-enhanced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-enhanced}"
SRC_URI[x86_64_v2_vim-enhanced.sha256sum] = "a982f0f3d5e715da65ac0a199c8f942fef6e74a1eda072f6fb1b4d55f982be4a"
RPROVIDES:vim-enhanced:append:x86_64_v2 = " virtual/vim-enhanced_or_vim-X11"

URI_x86_64_v2_vim-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-filesystem-9.1.083-6.el10_1.4.noarch.rpm;name=x86_64_v2_vim-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-filesystem}"
SRC_URI[x86_64_v2_vim-filesystem.sha256sum] = "aef525849e463b52ffaacdfaada94a12843215f0cff61d5dcaa4574699e08955"

URI_x86_64_v2_vim-minimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-minimal-9.1.083-6.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_vim-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-minimal}"
SRC_URI[x86_64_v2_vim-minimal.sha256sum] = "d904dfa47a3e5e90333540fdbcba29d653ddbe6cfa3733a56c8700d0977b6f81"

URI_x86_64_v2_xxd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xxd-9.1.083-6.el10_1.4.x86_64_v2.rpm;name=x86_64_v2_xxd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xxd}"
SRC_URI[x86_64_v2_xxd.sha256sum] = "421cda039dc8624211df062fd22d4d98f424aa4ef9deb4b33951f8475a0bc0b8"

URI_aarch64_vim-X11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-X11-9.1.083-6.el10_1.4.aarch64.rpm;name=aarch64_vim-X11;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-X11}"
SRC_URI[aarch64_vim-X11.sha256sum] = "36c38a785ab85d3f9752b34d70146263aa9987560cc910d81be5ee88527217c1"
RPROVIDES:vim-X11:append:aarch64 = " virtual/vim-enhanced_or_vim-X11"

URI_aarch64_vim-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-common-9.1.083-6.el10_1.4.aarch64.rpm;name=aarch64_vim-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-common}"
SRC_URI[aarch64_vim-common.sha256sum] = "8217bf113e15b5e9575db09ea37d6453b12aeace72a1182f2336a2626575ff9b"

URI_aarch64_vim-data = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-data-9.1.083-6.el10_1.4.noarch.rpm;name=aarch64_vim-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-data}"
SRC_URI[aarch64_vim-data.sha256sum] = "1ef5d7ee05f8e0ef3991ba51537b081c90ac11ef018edc69324a44c46e7d4e1e"

URI_aarch64_vim-enhanced = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-enhanced-9.1.083-6.el10_1.4.aarch64.rpm;name=aarch64_vim-enhanced;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-enhanced}"
SRC_URI[aarch64_vim-enhanced.sha256sum] = "3b1d52aeb1152d0de2906603a83f476168cbfa48d994c39ddfffc91e741e2d75"
RPROVIDES:vim-enhanced:append:aarch64 = " virtual/vim-enhanced_or_vim-X11"

URI_aarch64_vim-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-filesystem-9.1.083-6.el10_1.4.noarch.rpm;name=aarch64_vim-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-filesystem}"
SRC_URI[aarch64_vim-filesystem.sha256sum] = "aef525849e463b52ffaacdfaada94a12843215f0cff61d5dcaa4574699e08955"

URI_aarch64_vim-minimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-minimal-9.1.083-6.el10_1.4.aarch64.rpm;name=aarch64_vim-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-minimal}"
SRC_URI[aarch64_vim-minimal.sha256sum] = "06182276a297016fa8038d8785153149219aa2b12ab381b6eeb762dffb8b8e9b"

URI_aarch64_xxd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xxd-9.1.083-6.el10_1.4.aarch64.rpm;name=aarch64_xxd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xxd}"
SRC_URI[aarch64_xxd.sha256sum] = "f119e2217cacdf75cd1c3ded959b08d811b103637a23f62eb03b03db76f1f5c2"

RDEPENDS:vim-X11 = " \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libICE \
 libSM \
 libX11 \
 libXt \
 libacl \
 libattr \
 libcanberra \
 libselinux \
 ncurses-libs \
 pango \
 vim-common \
 "
RDEPENDS:vim-common = " \
 bash \
 vim-data \
 vim-filesystem \
 xxd \
 "
RDEPENDS:vim-data = " \
 "
RDEPENDS:vim-enhanced = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-common \
 which \
 "
RDEPENDS:vim-filesystem = " \
 "
RDEPENDS:vim-minimal = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-data \
 "
RDEPENDS:xxd = " \
 glibc \
 "
