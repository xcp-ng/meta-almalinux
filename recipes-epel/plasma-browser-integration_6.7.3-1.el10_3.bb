# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-browser-integration"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-browser-integration \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-browser-integration-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa3e74f5d7afc84f379523aa85f12200458f9eda57eb3b755699043895fefef2"

URI_x86_64_v2_plasma-browser-integration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-browser-integration-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-browser-integration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-browser-integration}"
SRC_URI[x86_64_v2_plasma-browser-integration.sha256sum] = "6e1150a51b3a1b8ba601f6ffbe39a649db24e9efeeb6ff008424385bf00ed961"

URI_aarch64_plasma-browser-integration = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-browser-integration-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-browser-integration;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-browser-integration}"
SRC_URI[aarch64_plasma-browser-integration.sha256sum] = "4baca1493e84a7efc6a4d2b38cdf7780fc5b0abe9cb82c8ec5466a275c7fb1b2"

RDEPENDS:plasma-browser-integration = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-purpose \
 libstdc++ \
 plasma-activities \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
