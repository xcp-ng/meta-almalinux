# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire-epel"
PV = "1.4.11"
PR = "2.el10_3"
PACKAGES = " \
 pipewire-module-filter-chain-lv2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pipewire-epel-1.4.11-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a878e189be29678e633e8f8faf8a74024377156fbb3455384d731a75777c88b8"

URI_x86_64_v2_pipewire-module-filter-chain-lv2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pipewire-module-filter-chain-lv2-1.4.11-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-filter-chain-lv2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-module-filter-chain-lv2}"
SRC_URI[x86_64_v2_pipewire-module-filter-chain-lv2.sha256sum] = "1056d5fdbd1b1b7c7ff893c3538a308eafc87288457f4f65e0287b4e1c882bfb"

URI_aarch64_pipewire-module-filter-chain-lv2 = "${EPEL_MIRROR}/aarch64/Packages/p/pipewire-module-filter-chain-lv2-1.4.11-2.el10_3.aarch64.rpm;name=aarch64_pipewire-module-filter-chain-lv2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-module-filter-chain-lv2}"
SRC_URI[aarch64_pipewire-module-filter-chain-lv2.sha256sum] = "805a68be3d157375abd90ee47c4fdc69d34751667d884aea604cdcb24ffdf8c5"

RDEPENDS:pipewire-module-filter-chain-lv2 = " \
 glibc \
 lilv-libs \
 pipewire-libs \
 "
