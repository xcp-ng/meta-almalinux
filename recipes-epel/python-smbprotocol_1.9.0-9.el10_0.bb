# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-smbprotocol"
PV = "1.9.0"
PR = "9.el10_0"
PACKAGES = " \
 python3-smbprotocol \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-smbprotocol-1.9.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02533bf50d67afbac8fd7f2a57eb961465ea97eddeb5db3edb636df0215a0971"

URI_x86_64_v2_python3-smbprotocol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-smbprotocol-1.9.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-smbprotocol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-smbprotocol}"
SRC_URI[x86_64_v2_python3-smbprotocol.sha256sum] = "2eee878a65ddfbfd59431cce6fe09c6ad09fe51270538d38bea5137da6bfa604"

URI_aarch64_python3-smbprotocol = "${EPEL_MIRROR}/aarch64/Packages/p/python3-smbprotocol-1.9.0-9.el10_0.noarch.rpm;name=aarch64_python3-smbprotocol;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-smbprotocol}"
SRC_URI[aarch64_python3-smbprotocol.sha256sum] = "1763694415e210a346815c5e06176463927e0c9bb82b0bf29569a1a8090e6155"

RDEPENDS:python3-smbprotocol = " \
 python3 \
 python3-cryptography \
 python3-spnego \
 "
