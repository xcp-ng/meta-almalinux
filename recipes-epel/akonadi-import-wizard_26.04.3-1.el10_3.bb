# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-import-wizard"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-import-wizard \
 akonadi-import-wizard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-import-wizard-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22b811af3779ac33d6bedbfe546fc2322cd4e27e11f593c9f00d4c49df7b252e"

URI_x86_64_v2_akonadi-import-wizard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-import-wizard-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-import-wizard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-import-wizard}"
SRC_URI[x86_64_v2_akonadi-import-wizard.sha256sum] = "eeecc8cd0821e18cdafde6fda587f39b6720f12c7f21870e5ac6807680da4981"

URI_x86_64_v2_akonadi-import-wizard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-import-wizard-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-import-wizard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-import-wizard-devel}"
SRC_URI[x86_64_v2_akonadi-import-wizard-devel.sha256sum] = "9a415761b81ab648bc95d63cea2215df6116c80715aa3848801f4b70a4b385a1"

URI_aarch64_akonadi-import-wizard = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-import-wizard-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-import-wizard;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-import-wizard}"
SRC_URI[aarch64_akonadi-import-wizard.sha256sum] = "3ba7fd417590ed432deae7b3f4cccbc1c4a2a1787c471dc690c69bb7dbb32613"

URI_aarch64_akonadi-import-wizard-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-import-wizard-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-import-wizard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-import-wizard-devel}"
SRC_URI[aarch64_akonadi-import-wizard-devel.sha256sum] = "ca631aae4e36c56ee3bb5ac8665ce687ae4cc0bf72fd0c86fef0963dea87d430"

RDEPENDS:akonadi-import-wizard = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 libgcc \
 libstdc++ \
 mailcommon \
 mailimporter \
 mailimporter-akonadi \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:akonadi-import-wizard-devel = " \
 akonadi-import-wizard \
 cmake-filesystem \
 kmailtransport-devel \
 "
