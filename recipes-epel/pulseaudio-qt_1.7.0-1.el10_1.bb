# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pulseaudio-qt"
PV = "1.7.0"
PR = "1.el10_1"
PACKAGES = " \
 pulseaudio-qt-qt6 \
 pulseaudio-qt-qt6-devel \
 pulseaudio-qt-qt6-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pulseaudio-qt-1.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8a1479e185d455ae6fc1addd619e8cf404d4ebe72bf3eb47b47eccfdab08019"

URI_x86_64_v2_pulseaudio-qt-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-1.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6.sha256sum] = "c760010db74c7ce904139c910703e41f77f1cbfe68c9b5da8a2e7900f6a0f868"

URI_x86_64_v2_pulseaudio-qt-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-devel-1.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6-devel}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6-devel.sha256sum] = "8743e4345c61d671d8c16dc3a5463acaeeebd3046c26df3a6fd5ae8e0c6b0ad0"

URI_x86_64_v2_pulseaudio-qt-qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-doc-1.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6-doc}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6-doc.sha256sum] = "fd57cfd66fe71523ac22a9db248b3a58dacbb6133fb5e783d9e0d51e0b60dc6d"

URI_aarch64_pulseaudio-qt-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-1.7.0-1.el10_1.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6}"
SRC_URI[aarch64_pulseaudio-qt-qt6.sha256sum] = "b462520ff7fe0536b4bb50d3e8929555705b3b97af99031f2c6333d107d8e5db"

URI_aarch64_pulseaudio-qt-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-devel-1.7.0-1.el10_1.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6-devel}"
SRC_URI[aarch64_pulseaudio-qt-qt6-devel.sha256sum] = "d59a6539567585e3b6c579fd66ab6e4e35f8c62e6ebf7e98803f4579af5d1e15"

URI_aarch64_pulseaudio-qt-qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-doc-1.7.0-1.el10_1.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6-doc}"
SRC_URI[aarch64_pulseaudio-qt-qt6-doc.sha256sum] = "7d455af0def1b23fde5b8799fbcf02f24dd9ca9a210e84ae4169d8793c882802"

RDEPENDS:pulseaudio-qt-qt6 = " \
 glibc \
 libstdc++ \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pulseaudio-qt-qt6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pulseaudio-qt-qt6 \
 qt6-qtbase-devel \
 "
RDEPENDS:pulseaudio-qt-qt6-doc = " \
 "
