# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pwgen"
PV = "2.08"
PR = "17.el10_1"
PACKAGES = " \
 pwgen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pwgen-2.08-17.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddb4874fa25ca036b930d0f2ef9e9f898d6ac5c2e58e77642b6156856589f878"

URI_x86_64_v2_pwgen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pwgen-2.08-17.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pwgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pwgen}"
SRC_URI[x86_64_v2_pwgen.sha256sum] = "1419ce5976b0d4c5f4da5f8ee02e888a44baa8d59851f3aef7e4d1e74fbbe6cc"

URI_aarch64_pwgen = "${EPEL_MIRROR}/aarch64/Packages/p/pwgen-2.08-17.el10_1.aarch64.rpm;name=aarch64_pwgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_pwgen}"
SRC_URI[aarch64_pwgen.sha256sum] = "7822d3d81f61f68af43f68bb4da213662e1195c936840bac06caf8076616d515"

RDEPENDS:pwgen = " \
 glibc \
 "
