# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-searcher"
PV = "0.1.17"
PR = "1.el10_3"
PACKAGES = " \
 rust-grep-searcher+default-devel \
 rust-grep-searcher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-searcher-0.1.17-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5e6e5e1a9dd620467095d6697286a3d3a0cab93bbc7160d7b09fb4445435921"

URI_x86_64_v2_rust-grep-searcher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-searcher+default-devel-0.1.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-searcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-searcher+default-devel}"
SRC_URI[x86_64_v2_rust-grep-searcher+default-devel.sha256sum] = "9b9a474a8f0468b64408d05e394fd79d6f5028386540f8ec86f87c79579b76c9"

URI_x86_64_v2_rust-grep-searcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-searcher-devel-0.1.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-searcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-searcher-devel}"
SRC_URI[x86_64_v2_rust-grep-searcher-devel.sha256sum] = "ddd091b140904bce4fc8df9df8660792756e35a78539ad58fbdcbe4483d1f176"

URI_aarch64_rust-grep-searcher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-searcher+default-devel-0.1.17-1.el10_3.noarch.rpm;name=aarch64_rust-grep-searcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-searcher+default-devel}"
SRC_URI[aarch64_rust-grep-searcher+default-devel.sha256sum] = "68389691bf5f1ed4548fc1d3dd7ac6661458d7c774f57a00d27d62fae9588404"

URI_aarch64_rust-grep-searcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-searcher-devel-0.1.17-1.el10_3.noarch.rpm;name=aarch64_rust-grep-searcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-searcher-devel}"
SRC_URI[aarch64_rust-grep-searcher-devel.sha256sum] = "e536281c0a24436fd857d785bd7e4e61c93a5475bc1fed62bbf4d4658e0cf972"

RDEPENDS:rust-grep-searcher+default-devel = " \
 cargo \
 rust-grep-searcher-devel \
 "
RDEPENDS:rust-grep-searcher-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-encoding_rs+default-devel \
 rust-encoding_rs_io+default-devel \
 rust-grep-matcher+default-devel \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-memmap2+default-devel \
 "
