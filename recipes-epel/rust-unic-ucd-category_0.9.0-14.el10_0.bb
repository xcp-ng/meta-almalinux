# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-ucd-category"
PV = "0.9.0"
PR = "14.el10_0"
PACKAGES = " \
 rust-unic-ucd-category+default-devel \
 rust-unic-ucd-category-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-ucd-category-0.9.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81cb3d1d458aa95441bea5f58df857108cc32e39b3f53b7decd50e5043150192"

URI_x86_64_v2_rust-unic-ucd-category+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-category+default-devel-0.9.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-category+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-category+default-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-category+default-devel.sha256sum] = "cc4af9cf919641cd4c26cfeb51eda01ecc22ba2972ba118ecb0c9845176579ef"

URI_x86_64_v2_rust-unic-ucd-category-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-category-devel-0.9.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-category-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-category-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-category-devel.sha256sum] = "f4ecfd24074ec40b8b588f4feb75f0db34f727d34cce203c6af565a16b7a429d"

URI_aarch64_rust-unic-ucd-category+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-category+default-devel-0.9.0-14.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-category+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-category+default-devel}"
SRC_URI[aarch64_rust-unic-ucd-category+default-devel.sha256sum] = "5f87ea2c9d655cb88526298e78876a34fec18217e05aeefdcc05d7565772188b"

URI_aarch64_rust-unic-ucd-category-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-category-devel-0.9.0-14.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-category-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-category-devel}"
SRC_URI[aarch64_rust-unic-ucd-category-devel.sha256sum] = "793a0c689a5b9fcb87b1d3acef435851aaeae87b1fdd1e8d6f955faa6720f67d"

RDEPENDS:rust-unic-ucd-category+default-devel = " \
 cargo \
 rust-unic-ucd-category-devel \
 "
RDEPENDS:rust-unic-ucd-category-devel = " \
 cargo \
 rust-matches+default-devel \
 rust-unic-char-property+default-devel \
 rust-unic-char-range+default-devel \
 rust-unic-ucd-version+default-devel \
 "
