# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fzf"
PV = "0.58.0"
PR = "2.el10_0"
PACKAGES = " \
 fzf \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fzf-0.58.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e5a159baf37f52b37815f85d049eb6746927a1641a72d5c6b8e8e538b8fc23f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fzf-0.58.0-2.el10_0.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_fzf;unpack=0"
SRC_URI[x86_64_v2_fzf.sha256sum] = "8d69752d7768d69f6313edea49422643d7e6aaf4a5307dbb8f512c48221dca84"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fzf-0.58.0-2.el10_0.aarch64.rpm;name=aarch64_fzf;unpack=0"
SRC_URI[aarch64_fzf.sha256sum] = "37a86bbdd9648d4417ab73c062297ecbb370bf31411587ae51e83bbaf802aa78"

RDEPENDS:fzf = " \
 bash \
 glibc \
 "
