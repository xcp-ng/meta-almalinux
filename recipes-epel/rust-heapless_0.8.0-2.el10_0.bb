# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-heapless"
PV = "0.8.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-heapless+default-devel \
 rust-heapless+mpmc_large-devel \
 rust-heapless+portable-atomic-critical-section-devel \
 rust-heapless+portable-atomic-devel \
 rust-heapless+portable-atomic-unsafe-assume-single-core-devel \
 rust-heapless+serde-devel \
 rust-heapless-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-heapless-0.8.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6ff0b731dc171f572b0d62bcbc6e0f20a4aee2cab0d7f242ab26497b2cca136"

URI_x86_64_v2_rust-heapless+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+default-devel-0.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+default-devel}"
SRC_URI[x86_64_v2_rust-heapless+default-devel.sha256sum] = "b06826fba64cc24ff30cce7d26daf9b4ac5b69a3c2d5af3e0e56f0a48af6d37d"
RPROVIDES:rust-heapless+default-devel:append:x86_64_v2 = " virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"

URI_x86_64_v2_rust-heapless+mpmc_large-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+mpmc_large-devel-0.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+mpmc_large-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+mpmc_large-devel}"
SRC_URI[x86_64_v2_rust-heapless+mpmc_large-devel.sha256sum] = "5ab176851e0d8f13b8ac772f6d1c4ffc68b3464b6ba190a6913b16b969b85a1c"

URI_x86_64_v2_rust-heapless+portable-atomic-critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+portable-atomic-critical-section-devel-0.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+portable-atomic-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+portable-atomic-critical-section-devel}"
SRC_URI[x86_64_v2_rust-heapless+portable-atomic-critical-section-devel.sha256sum] = "105a6f1138c7330c42956ce7ab6bb6718169a01803764f66c4752476e2218c4c"

URI_x86_64_v2_rust-heapless+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+portable-atomic-devel-0.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-heapless+portable-atomic-devel.sha256sum] = "ddf95249e916ecb3f61f5929e72db2e4c7bef57e314b18a48c4cff7960c28125"

URI_x86_64_v2_rust-heapless+portable-atomic-unsafe-assume-single-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+portable-atomic-unsafe-assume-single-core-devel-0.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+portable-atomic-unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+portable-atomic-unsafe-assume-single-core-devel}"
SRC_URI[x86_64_v2_rust-heapless+portable-atomic-unsafe-assume-single-core-devel.sha256sum] = "a431090a55a1470d64e08648b537c654e30aa5721f56088806068e09871cfa10"

URI_x86_64_v2_rust-heapless+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless+serde-devel-0.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless+serde-devel}"
SRC_URI[x86_64_v2_rust-heapless+serde-devel.sha256sum] = "8259ddf8875890f977a08a8ce44e51d6fad70bc0b322e6ce1dd23cb8c466d067"

URI_x86_64_v2_rust-heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless-devel-0.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless-devel}"
SRC_URI[x86_64_v2_rust-heapless-devel.sha256sum] = "1733bf5fbd5f03039ab3e188033f90c59ac0d439f28d5e0c0d0272feb7a20da4"

URI_aarch64_rust-heapless+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+default-devel-0.8.0-2.el10_0.noarch.rpm;name=aarch64_rust-heapless+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+default-devel}"
SRC_URI[aarch64_rust-heapless+default-devel.sha256sum] = "0b6eb10e6f2cdde21cfcd7f9482decc534c7872cc4cddc7c73f4f0ef9e2b0e1d"
RPROVIDES:rust-heapless+default-devel:append:aarch64 = " virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"

URI_aarch64_rust-heapless+mpmc_large-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+mpmc_large-devel-0.8.0-2.el10_0.noarch.rpm;name=aarch64_rust-heapless+mpmc_large-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+mpmc_large-devel}"
SRC_URI[aarch64_rust-heapless+mpmc_large-devel.sha256sum] = "72b00878fc9765e8bdeb8725632abbb31db1defd45300ebfd400eacf366ba214"

URI_aarch64_rust-heapless+portable-atomic-critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+portable-atomic-critical-section-devel-0.8.0-2.el10_0.noarch.rpm;name=aarch64_rust-heapless+portable-atomic-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+portable-atomic-critical-section-devel}"
SRC_URI[aarch64_rust-heapless+portable-atomic-critical-section-devel.sha256sum] = "f1b4e3551ab16aad94256acc167b0cc7f6b1798fd5d9a2df9f2f55e67c1b4562"

URI_aarch64_rust-heapless+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+portable-atomic-devel-0.8.0-2.el10_0.noarch.rpm;name=aarch64_rust-heapless+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+portable-atomic-devel}"
SRC_URI[aarch64_rust-heapless+portable-atomic-devel.sha256sum] = "3ff1ce3c21b343b56d20c2a5155c2d01a670c9b7f1d6ba2fbde012a432ab23fc"

URI_aarch64_rust-heapless+portable-atomic-unsafe-assume-single-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+portable-atomic-unsafe-assume-single-core-devel-0.8.0-2.el10_0.noarch.rpm;name=aarch64_rust-heapless+portable-atomic-unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+portable-atomic-unsafe-assume-single-core-devel}"
SRC_URI[aarch64_rust-heapless+portable-atomic-unsafe-assume-single-core-devel.sha256sum] = "41dd8c7ab3d7630a9f7b61b484e80b57f5bfa6d4e53a94cd76ce964fb83131be"

URI_aarch64_rust-heapless+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless+serde-devel-0.8.0-2.el10_0.noarch.rpm;name=aarch64_rust-heapless+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless+serde-devel}"
SRC_URI[aarch64_rust-heapless+serde-devel.sha256sum] = "0de4c79ece5bbdcfad65c94d950149cedf07026d4cddd7c7df440417ed4f8b4a"

URI_aarch64_rust-heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless-devel-0.8.0-2.el10_0.noarch.rpm;name=aarch64_rust-heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless-devel}"
SRC_URI[aarch64_rust-heapless-devel.sha256sum] = "e5333b2edcf61d449e7ea2e590ded85f8edd4dd1de11def5edad924de5ba20ad"

RDEPENDS:rust-heapless+default-devel = " \
 cargo \
 rust-heapless-devel \
 "
RDEPENDS:rust-heapless+mpmc_large-devel = " \
 cargo \
 rust-heapless-devel \
 "
RDEPENDS:rust-heapless+portable-atomic-critical-section-devel = " \
 cargo \
 rust-heapless+portable-atomic-devel \
 rust-heapless-devel \
 rust-portable-atomic+critical-section-devel \
 rust-portable-atomic+default-devel \
 "
RDEPENDS:rust-heapless+portable-atomic-devel = " \
 cargo \
 rust-heapless-devel \
 rust-portable-atomic+default-devel \
 "
RDEPENDS:rust-heapless+portable-atomic-unsafe-assume-single-core-devel = " \
 cargo \
 rust-heapless+portable-atomic-devel \
 rust-heapless-devel \
 rust-portable-atomic+default-devel \
 rust-portable-atomic+unsafe-assume-single-core-devel \
 "
RDEPENDS:rust-heapless+serde-devel = " \
 cargo \
 rust-heapless-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-heapless-devel = " \
 cargo \
 rust-hash32+default-devel \
 rust-stable_deref_trait-devel \
 "
