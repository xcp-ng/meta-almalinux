# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling_core"
PV = "0.20.11"
PR = "1.el10_1"
PACKAGES = " \
 rust-darling_core+default-devel \
 rust-darling_core+diagnostics-devel \
 rust-darling_core+strsim-devel \
 rust-darling_core+suggestions-devel \
 rust-darling_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling_core-0.20.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52bfb49a7d66d6c025ba9664c46219627df310bcf81a25837d8d2d9db0139147"

URI_x86_64_v2_rust-darling_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+default-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+default-devel}"
SRC_URI[x86_64_v2_rust-darling_core+default-devel.sha256sum] = "5bfa471e2b8f45effff3986840c6725d6e0959bfe4dad716caa90f2c4336443d"

URI_x86_64_v2_rust-darling_core+diagnostics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+diagnostics-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+diagnostics-devel}"
SRC_URI[x86_64_v2_rust-darling_core+diagnostics-devel.sha256sum] = "157dd703a467a9efd5fd0ac7a0e550e7ef76563f3cac53bfd32d1bc08640a1c3"

URI_x86_64_v2_rust-darling_core+strsim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+strsim-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+strsim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+strsim-devel}"
SRC_URI[x86_64_v2_rust-darling_core+strsim-devel.sha256sum] = "9ee883eaaeed99447f60979bfdaf456e5556ef3fc6766d7890296559e01fb088"

URI_x86_64_v2_rust-darling_core+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core+suggestions-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core+suggestions-devel}"
SRC_URI[x86_64_v2_rust-darling_core+suggestions-devel.sha256sum] = "b61670055997312ca6268dcc59f97fb102742fe93e28c66684b6104f5dd585ca"

URI_x86_64_v2_rust-darling_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_core-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_core-devel}"
SRC_URI[x86_64_v2_rust-darling_core-devel.sha256sum] = "390c56288c4302d05d982dc31d0cbf3517c109ca5acb1226a7f8020f2c4d8300"

URI_aarch64_rust-darling_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+default-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+default-devel}"
SRC_URI[aarch64_rust-darling_core+default-devel.sha256sum] = "43029b8161f9c87eebb0ae772fcb25391aa170a8b41cb7c588b192f42167d944"

URI_aarch64_rust-darling_core+diagnostics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+diagnostics-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling_core+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+diagnostics-devel}"
SRC_URI[aarch64_rust-darling_core+diagnostics-devel.sha256sum] = "703163d8c5d7bcea548a71851e1df30c7bb1ea865befd9dd9d06a04382a5990c"

URI_aarch64_rust-darling_core+strsim-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+strsim-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling_core+strsim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+strsim-devel}"
SRC_URI[aarch64_rust-darling_core+strsim-devel.sha256sum] = "915eadfefc8a03051ab60dcbcac301faea07ff1aafc6c3b6bb9f6cb5eda0b3ce"

URI_aarch64_rust-darling_core+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core+suggestions-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling_core+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core+suggestions-devel}"
SRC_URI[aarch64_rust-darling_core+suggestions-devel.sha256sum] = "0d00893b3a40ca96013ae88fe199d29769abe7c3c16d1727f0421b518e2efcd3"

URI_aarch64_rust-darling_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_core-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_core-devel}"
SRC_URI[aarch64_rust-darling_core-devel.sha256sum] = "259f446e5800d0a1af594aa686f2ace590fed0005011015f06f8abceb4cc5f42"

RDEPENDS:rust-darling_core+default-devel = " \
 cargo \
 rust-darling_core-devel \
 "
RDEPENDS:rust-darling_core+diagnostics-devel = " \
 cargo \
 rust-darling_core-devel \
 "
RDEPENDS:rust-darling_core+strsim-devel = " \
 cargo \
 rust-darling_core-devel \
 rust-strsim+default-devel \
 "
RDEPENDS:rust-darling_core+suggestions-devel = " \
 cargo \
 rust-darling_core+strsim-devel \
 rust-darling_core-devel \
 "
RDEPENDS:rust-darling_core-devel = " \
 cargo \
 rust \
 rust-fnv+default-devel \
 rust-ident_case+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
