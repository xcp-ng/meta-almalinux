# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kasts"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kasts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kasts-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a1d2b6ada07276f0bf783024277dba413111d18f0da53087f8204103a8f18a9"

URI_x86_64_v2_kasts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kasts-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kasts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kasts}"
SRC_URI[x86_64_v2_kasts.sha256sum] = "9151a7c32242e19c37978e774041dbd45fe4ee0afda8b3ea8e8c896f812ef22b"

URI_aarch64_kasts = "${EPEL_MIRROR}/aarch64/Packages/k/kasts-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kasts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kasts}"
SRC_URI[aarch64_kasts.sha256sum] = "48c40419c656135bb5da73bce5daf7210715cbccd03bc75fcb3a7fe60434a20f"

RDEPENDS:kasts = " \
 glibc \
 kf6-breeze-icons \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kwindowsystem \
 kf6-syndication \
 kf6-threadweaver \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qtkeychain-qt6 \
 taglib \
 vlc-libs \
 "
