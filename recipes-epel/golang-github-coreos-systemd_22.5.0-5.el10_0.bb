# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-coreos-systemd"
PV = "22.5.0"
PR = "5.el10_0"
PACKAGES = " \
 compat-golang-github-coreos-systemd-22-devel \
 golang-github-coreos-systemd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-coreos-systemd-22.5.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36348ecb5e4a1c0790c27f443f3e48ac6b75791c6382f9f272802c1f5f272a26"

URI_x86_64_v2_compat-golang-github-coreos-systemd-22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-coreos-systemd-22-devel-22.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-coreos-systemd-22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-coreos-systemd-22-devel}"
SRC_URI[x86_64_v2_compat-golang-github-coreos-systemd-22-devel.sha256sum] = "089faac02a3e0e92aea7295a3efe11494101e3af78249823f840d32e4ce80e5d"

URI_x86_64_v2_golang-github-coreos-systemd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-coreos-systemd-devel-22.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-coreos-systemd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-coreos-systemd-devel}"
SRC_URI[x86_64_v2_golang-github-coreos-systemd-devel.sha256sum] = "511265c613aaa3e02c5ded2a2cf1d68f90b0ed8419ba9b76632e724dc372e64f"

URI_aarch64_compat-golang-github-coreos-systemd-22-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-coreos-systemd-22-devel-22.5.0-5.el10_0.noarch.rpm;name=aarch64_compat-golang-github-coreos-systemd-22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-coreos-systemd-22-devel}"
SRC_URI[aarch64_compat-golang-github-coreos-systemd-22-devel.sha256sum] = "55552a816e63fee961982dffdfa6d1f4c599fbc50f0f17b2454d220a8a17c7dd"

URI_aarch64_golang-github-coreos-systemd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-coreos-systemd-devel-22.5.0-5.el10_0.noarch.rpm;name=aarch64_golang-github-coreos-systemd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-coreos-systemd-devel}"
SRC_URI[aarch64_golang-github-coreos-systemd-devel.sha256sum] = "9eef0011ca517b03d92ca59b590177dcc684fc374da651bbffea34e1e86347de"

RDEPENDS:compat-golang-github-coreos-systemd-22-devel = " \
 go-filesystem \
 golang-github-coreos-systemd-devel \
 "
RDEPENDS:golang-github-coreos-systemd-devel = " \
 compat-golang-github-godbus-dbus-5-devel \
 go-filesystem \
 "
