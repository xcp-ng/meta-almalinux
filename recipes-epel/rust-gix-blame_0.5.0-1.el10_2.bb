# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-blame"
PV = "0.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-blame+default-devel \
 rust-gix-blame-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-blame-0.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc82e38995eaf769ecf465572ffa8db879952707496b63182565f2d519d53141"

URI_x86_64_v2_rust-gix-blame+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-blame+default-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-blame+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-blame+default-devel}"
SRC_URI[x86_64_v2_rust-gix-blame+default-devel.sha256sum] = "2a66150954c0f3cf8ea683407d3b5ad29208d08196f1002b2abcf7ba4db7b707"

URI_x86_64_v2_rust-gix-blame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-blame-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-blame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-blame-devel}"
SRC_URI[x86_64_v2_rust-gix-blame-devel.sha256sum] = "92ac85143cb1a7258834f5e00ac356dba2b6b838c12ec932de5857f293990afa"

URI_aarch64_rust-gix-blame+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-blame+default-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-blame+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-blame+default-devel}"
SRC_URI[aarch64_rust-gix-blame+default-devel.sha256sum] = "1bb562d444c5c493309db7959bbe0395ab317de1799caa628ce5e9c7e45a08ab"

URI_aarch64_rust-gix-blame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-blame-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-blame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-blame-devel}"
SRC_URI[aarch64_rust-gix-blame-devel.sha256sum] = "64c9fa79b8b9d61a7dd36631eddeffb3e68e683587a3f15858b446374568bc78"

RDEPENDS:rust-gix-blame+default-devel = " \
 cargo \
 rust-gix-blame-devel \
 "
RDEPENDS:rust-gix-blame-devel = " \
 cargo \
 rust \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-diff+blob-devel \
 rust-gix-diff-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
