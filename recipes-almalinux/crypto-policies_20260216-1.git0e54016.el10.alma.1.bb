# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crypto-policies"
PV = "20260216"
PR = "1.git0e54016.el10.alma.1"
PACKAGES = " \
 crypto-policies \
 crypto-policies-scripts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/crypto-policies-20260216-1.git0e54016.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45398c415437578adb65e6a6b0bd4cc7a6fb4cbb2a61109b2cf36701a09ded80"

URI_x86_64_v2_crypto-policies = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-20260216-1.git0e54016.el10.alma.1.noarch.rpm;name=x86_64_v2_crypto-policies;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crypto-policies}"
SRC_URI[x86_64_v2_crypto-policies.sha256sum] = "683a4f3a922dcd240c0663ce6fdd21cd1e03f06731ebde17e0e99f36a3a481e0"

URI_x86_64_v2_crypto-policies-scripts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-scripts-20260216-1.git0e54016.el10.alma.1.noarch.rpm;name=x86_64_v2_crypto-policies-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crypto-policies-scripts}"
SRC_URI[x86_64_v2_crypto-policies-scripts.sha256sum] = "f4a28aa3a742e88602acf42ea8c0ef5ba58e54c763a95e19f15aeb30a00334c8"

URI_aarch64_crypto-policies = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-20260216-1.git0e54016.el10.alma.1.noarch.rpm;name=aarch64_crypto-policies;unpack=0"
SRC_URI:append = " ${URI_aarch64_crypto-policies}"
SRC_URI[aarch64_crypto-policies.sha256sum] = "683a4f3a922dcd240c0663ce6fdd21cd1e03f06731ebde17e0e99f36a3a481e0"

URI_aarch64_crypto-policies-scripts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-scripts-20260216-1.git0e54016.el10.alma.1.noarch.rpm;name=aarch64_crypto-policies-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_crypto-policies-scripts}"
SRC_URI[aarch64_crypto-policies-scripts.sha256sum] = "f4a28aa3a742e88602acf42ea8c0ef5ba58e54c763a95e19f15aeb30a00334c8"

RDEPENDS:crypto-policies = " \
 bash \
 "
RDEPENDS:crypto-policies-scripts = " \
 bash \
 crypto-policies \
 python3 \
 "
