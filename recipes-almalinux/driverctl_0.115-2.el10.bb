# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "driverctl"
PV = "0.115"
PR = "2.el10"
PACKAGES = " \
 driverctl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/driverctl-0.115-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "163d1ae9639a352eaab7ea6ec20d94d07c60d5bbeb63c81bb1b223095ff30d55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/driverctl-0.115-2.el10.noarch.rpm;name=x86_64_v2_driverctl;unpack=0"
SRC_URI[x86_64_v2_driverctl.sha256sum] = "606363c647916b3eac3cbadd44c9027be8f623604085eb2b10419776fbc2210d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/driverctl-0.115-2.el10.noarch.rpm;name=aarch64_driverctl;unpack=0"
SRC_URI[aarch64_driverctl.sha256sum] = "606363c647916b3eac3cbadd44c9027be8f623604085eb2b10419776fbc2210d"

RDEPENDS:driverctl = " \
 bash \
 systemd-udev \
 virtual/coreutils \
 "
