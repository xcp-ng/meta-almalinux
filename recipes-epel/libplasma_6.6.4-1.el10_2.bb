# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libplasma"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 libplasma \
 libplasma-devel \
 libplasma-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libplasma-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d58ede7239aef44e31097845fe961a6725b891c2a340cc9f1d1d5f6f3d89a2f8"

URI_x86_64_v2_libplasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma}"
SRC_URI[x86_64_v2_libplasma.sha256sum] = "c89a803d7e72681e311e1095f951a3daec301df1bf32af0378bb7389edcd24e9"

URI_x86_64_v2_libplasma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplasma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma-devel}"
SRC_URI[x86_64_v2_libplasma-devel.sha256sum] = "7529d7917848d4f5d9a905f38e1bce9d551cafdb688cf658da0a57fe41a4fbeb"

URI_x86_64_v2_libplasma-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-doc-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libplasma-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libplasma-doc}"
SRC_URI[x86_64_v2_libplasma-doc.sha256sum] = "dd8870c2e5933c6bae099650c059c620adc8e2f0e9074e1a13159a0eedb282a7"

URI_aarch64_libplasma = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_libplasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma}"
SRC_URI[aarch64_libplasma.sha256sum] = "7f72ce7d3d346b71a065e2b0f4150ab2da5d758eb0195b7f77f9e6cd477e81da"

URI_aarch64_libplasma-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_libplasma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma-devel}"
SRC_URI[aarch64_libplasma-devel.sha256sum] = "dc414b101fe26d4d9fabda0dae0e8c0fa16b4109f5173dbb66be5d7e58b98406"

URI_aarch64_libplasma-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libplasma-doc-6.6.4-1.el10_2.noarch.rpm;name=aarch64_libplasma-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libplasma-doc}"
SRC_URI[aarch64_libplasma-doc.sha256sum] = "a73f36d2b09447a9d48fb648322b8051eaa7128f3444101f2e776e3dbd0a0529"

RDEPENDS:libplasma = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpackage \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libX11 \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:libplasma-devel = " \
 cmake-filesystem \
 kf6-kirigami-devel \
 kf6-kpackage-devel \
 kf6-kwindowsystem-devel \
 libplasma \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:libplasma-doc = " \
 "
