# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-u-msgpack-python"
PV = "2.8.0"
PR = "6.el10_0"
PACKAGES = " \
 python3-u-msgpack-python \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-u-msgpack-python-2.8.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d546dc9d31c501d1a053508e76a90bf12f5686dfb3f7b06194405dee5419a98e"

URI_x86_64_v2_python3-u-msgpack-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-u-msgpack-python-2.8.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-u-msgpack-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-u-msgpack-python}"
SRC_URI[x86_64_v2_python3-u-msgpack-python.sha256sum] = "568ce56451441c9d9d77b8eb79c2714d1ecd26cdf71393346e861c8fc01f2b0a"

URI_aarch64_python3-u-msgpack-python = "${EPEL_MIRROR}/aarch64/Packages/p/python3-u-msgpack-python-2.8.0-6.el10_0.noarch.rpm;name=aarch64_python3-u-msgpack-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-u-msgpack-python}"
SRC_URI[aarch64_python3-u-msgpack-python.sha256sum] = "ddd773f339c14d3acd43d2d949bd8caa554bde7bfabf2744c9c38b3a9e14462e"

RDEPENDS:python3-u-msgpack-python = " \
 python3 \
 "
