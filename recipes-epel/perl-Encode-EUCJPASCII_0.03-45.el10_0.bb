# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Encode-EUCJPASCII"
PV = "0.03"
PR = "45.el10_0"
PACKAGES = " \
 perl-Encode-EUCJPASCII \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Encode-EUCJPASCII-0.03-45.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e15449e661e34ba771d4d7df6750fcbd245fa48cda0627570051d31c12743687"

URI_x86_64_v2_perl-Encode-EUCJPASCII = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Encode-EUCJPASCII-0.03-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Encode-EUCJPASCII;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Encode-EUCJPASCII}"
SRC_URI[x86_64_v2_perl-Encode-EUCJPASCII.sha256sum] = "d1026613097bc17efebac8b018b797862460b2a4dcd4ee5e07b72cdea2b5fc13"

URI_aarch64_perl-Encode-EUCJPASCII = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Encode-EUCJPASCII-0.03-45.el10_0.aarch64.rpm;name=aarch64_perl-Encode-EUCJPASCII;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Encode-EUCJPASCII}"
SRC_URI[aarch64_perl-Encode-EUCJPASCII.sha256sum] = "289114168ff08f87dd77e35a3468cc8729170dcaa25e3a4f336874f957a26d74"

RDEPENDS:perl-Encode-EUCJPASCII = " \
 glibc \
 perl-Encode \
 perl-base \
 perl-libs \
 "
