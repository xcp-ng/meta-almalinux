# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libplacebo"
PV = "7.349.0"
PR = "4.el10_0"
PACKAGES = " \
 libplacebo \
 libplacebo-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libplacebo-7.349.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e8d9b54c7d63d0a270803a634f17df1472c3d9c7e8d6d025e6f27b635a01b724"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplacebo-7.349.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplacebo;unpack=0"
SRC_URI[x86_64_v2_libplacebo.sha256sum] = "da955e90d700c02f02ee9e011e0691c8bcedab36748b25f5def25d30006b8072"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplacebo-devel-7.349.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplacebo-devel;unpack=0"
SRC_URI[x86_64_v2_libplacebo-devel.sha256sum] = "c1933effbb162af66a226134ab14b22f98267576d92037c4d717e4a19b5bbb24"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libplacebo-7.349.0-4.el10_0.aarch64.rpm;name=aarch64_libplacebo;unpack=0"
SRC_URI[aarch64_libplacebo.sha256sum] = "3bbb044191640424eae656826802659e337e7651429ae1fe493da8ed907b3647"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libplacebo-devel-7.349.0-4.el10_0.aarch64.rpm;name=aarch64_libplacebo-devel;unpack=0"
SRC_URI[aarch64_libplacebo-devel.sha256sum] = "0a9cb8194ffc722a3573f5ad49ba1b2766273fca1529dd0cd6dcb2a745968ba4"

RDEPENDS:libplacebo = " \
 glibc \
 lcms2 \
 libdovi \
 libgcc \
 libshaderc \
 libstdc++ \
 libunwind \
 vulkan-loader \
 "
RDEPENDS:libplacebo-devel = " \
 lcms2-devel \
 libdovi-devel \
 libplacebo \
 libshaderc-devel \
 libunwind-devel \
 pkgconf-pkg-config \
 vulkan-loader-devel \
 "
