# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ed25519-compact"
PV = "2.1.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-ed25519-compact+blind-keys-devel \
 rust-ed25519-compact+ct-codecs-devel \
 rust-ed25519-compact+default-devel \
 rust-ed25519-compact+disable-signatures-devel \
 rust-ed25519-compact+ed25519-devel \
 rust-ed25519-compact+getrandom-devel \
 rust-ed25519-compact+opt_size-devel \
 rust-ed25519-compact+pem-devel \
 rust-ed25519-compact+random-devel \
 rust-ed25519-compact+self-verify-devel \
 rust-ed25519-compact+std-devel \
 rust-ed25519-compact+traits-devel \
 rust-ed25519-compact+x25519-devel \
 rust-ed25519-compact-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ed25519-compact-2.1.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be7d8bf7001e48415776a688544386968da3909f793956bcc40e991b3e14cc0c"

URI_x86_64_v2_rust-ed25519-compact+blind-keys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+blind-keys-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+blind-keys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+blind-keys-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+blind-keys-devel.sha256sum] = "b4a13fbb76645f4db728a08f24a0c758093d9ccdb0a24b5e408e1ef39514196f"

URI_x86_64_v2_rust-ed25519-compact+ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+ct-codecs-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+ct-codecs-devel.sha256sum] = "36ee75f0b398721d0ffe747859ba9fba1a46a981d550b7094db02b606a4e0db2"

URI_x86_64_v2_rust-ed25519-compact+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+default-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+default-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+default-devel.sha256sum] = "b23d162637d4bc2150448430cead421216be74cf269ea5e407dd54cd84f9dd36"

URI_x86_64_v2_rust-ed25519-compact+disable-signatures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+disable-signatures-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+disable-signatures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+disable-signatures-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+disable-signatures-devel.sha256sum] = "7f7dd50ca7c04972b4d98f88f20b575084a19bda236e9d7081c943b43605cc17"

URI_x86_64_v2_rust-ed25519-compact+ed25519-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+ed25519-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+ed25519-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+ed25519-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+ed25519-devel.sha256sum] = "cc9bdb5be4aae81ea7a4f985ff50631661fbaecdb15d57cf7b8463c734ae73c9"

URI_x86_64_v2_rust-ed25519-compact+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+getrandom-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+getrandom-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+getrandom-devel.sha256sum] = "5decd9ed3e77f6df9c9e568d1a304c7f4eaa17bf120ce962c6d5f9a1ea884b03"

URI_x86_64_v2_rust-ed25519-compact+opt_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+opt_size-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+opt_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+opt_size-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+opt_size-devel.sha256sum] = "91beb33f84890ac9c8a99ca47358e35514282c8b4c0321c31b13ea9d787394c8"

URI_x86_64_v2_rust-ed25519-compact+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+pem-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+pem-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+pem-devel.sha256sum] = "21365681846c8a7e3cc5556686471f7cc7293792607ef447e32d3378a3010ea4"

URI_x86_64_v2_rust-ed25519-compact+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+random-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+random-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+random-devel.sha256sum] = "91b9aafb7c54aacd6adf6184130ca9a612ff4d7bf427e2ca604c8bda490fa956"

URI_x86_64_v2_rust-ed25519-compact+self-verify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+self-verify-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+self-verify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+self-verify-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+self-verify-devel.sha256sum] = "139c54e24245136ebc78da72cecda81098349a38679927249b4d9bce651f6df5"

URI_x86_64_v2_rust-ed25519-compact+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+std-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+std-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+std-devel.sha256sum] = "e214b76ae1b681aab69b93720b6f3a75526d4339f345f9811acf8e280cb43e4b"

URI_x86_64_v2_rust-ed25519-compact+traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+traits-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+traits-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+traits-devel.sha256sum] = "e6e110d28f34a6f06981c74d36bab2d330c4324363f1f668a66d33d324d10c5a"

URI_x86_64_v2_rust-ed25519-compact+x25519-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact+x25519-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact+x25519-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact+x25519-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact+x25519-devel.sha256sum] = "ca73789dca172b54a7efed7c3f34ff7de9b0b81e1b921840fbae1303c37c8211"

URI_x86_64_v2_rust-ed25519-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-compact-devel-2.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-compact-devel}"
SRC_URI[x86_64_v2_rust-ed25519-compact-devel.sha256sum] = "41055e6403bbeb0586d4573e9e89b4cbfc7b3d9cbbefe9fd9c5f3b3e367d3de9"

URI_aarch64_rust-ed25519-compact+blind-keys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+blind-keys-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+blind-keys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+blind-keys-devel}"
SRC_URI[aarch64_rust-ed25519-compact+blind-keys-devel.sha256sum] = "880c531d92271ffe7a6d07116c66a640b9d3a0dc147cec3ed07a16a6e338f03d"

URI_aarch64_rust-ed25519-compact+ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+ct-codecs-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+ct-codecs-devel}"
SRC_URI[aarch64_rust-ed25519-compact+ct-codecs-devel.sha256sum] = "98bcbae9b38cfed6637abddc1f8582c30490529c6a83a93d590de40c449bb074"

URI_aarch64_rust-ed25519-compact+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+default-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+default-devel}"
SRC_URI[aarch64_rust-ed25519-compact+default-devel.sha256sum] = "e754f3b9ce0174b787bc359848fe60bb6adea1958cc242f4b839a1a5b1e9791b"

URI_aarch64_rust-ed25519-compact+disable-signatures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+disable-signatures-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+disable-signatures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+disable-signatures-devel}"
SRC_URI[aarch64_rust-ed25519-compact+disable-signatures-devel.sha256sum] = "f7f63242b57b627ac631fb75d09ca1fdd7a3c44bf513fe2e715ebd763bfff66a"

URI_aarch64_rust-ed25519-compact+ed25519-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+ed25519-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+ed25519-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+ed25519-devel}"
SRC_URI[aarch64_rust-ed25519-compact+ed25519-devel.sha256sum] = "2f37bbdbf12f7be1b18f695a5970b38016960c008cd0bc9d9130465fdc5f5778"

URI_aarch64_rust-ed25519-compact+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+getrandom-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+getrandom-devel}"
SRC_URI[aarch64_rust-ed25519-compact+getrandom-devel.sha256sum] = "4a8e23d6c3225b484dbc89a04cbfd8bb6d400d2889f4f39d2b2e88a4d3275a01"

URI_aarch64_rust-ed25519-compact+opt_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+opt_size-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+opt_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+opt_size-devel}"
SRC_URI[aarch64_rust-ed25519-compact+opt_size-devel.sha256sum] = "f9c7f10297b2e79784038435106a5721238a2687ba5f09a76d6bad0ecc86ca91"

URI_aarch64_rust-ed25519-compact+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+pem-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+pem-devel}"
SRC_URI[aarch64_rust-ed25519-compact+pem-devel.sha256sum] = "5e4f8b184de233c77f2137d15cfc7de27186c4652362e22eed3916848737a943"

URI_aarch64_rust-ed25519-compact+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+random-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+random-devel}"
SRC_URI[aarch64_rust-ed25519-compact+random-devel.sha256sum] = "f736608075fa5c0fd8fba2bbfd87f5fd68a43f7104c444ce1a40893ad9a1a838"

URI_aarch64_rust-ed25519-compact+self-verify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+self-verify-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+self-verify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+self-verify-devel}"
SRC_URI[aarch64_rust-ed25519-compact+self-verify-devel.sha256sum] = "96bd58eedf4eb7afc867e77be349e00f542b127044e75660f0ee3c2b633cca1b"

URI_aarch64_rust-ed25519-compact+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+std-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+std-devel}"
SRC_URI[aarch64_rust-ed25519-compact+std-devel.sha256sum] = "7488707b7a974ed98a6c24df9a9ee90277b1bcfa17dc8970d385d437209a67e4"

URI_aarch64_rust-ed25519-compact+traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+traits-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+traits-devel}"
SRC_URI[aarch64_rust-ed25519-compact+traits-devel.sha256sum] = "6e44dabc70bee896d332e65f33380a2e3e86b96f7ec7625038984796e9866dd7"

URI_aarch64_rust-ed25519-compact+x25519-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact+x25519-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact+x25519-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact+x25519-devel}"
SRC_URI[aarch64_rust-ed25519-compact+x25519-devel.sha256sum] = "b2da2ddfb6eaf017270fc1c80d8a6a80cc037705f4123975d8724a91f139964d"

URI_aarch64_rust-ed25519-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-compact-devel-2.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-compact-devel}"
SRC_URI[aarch64_rust-ed25519-compact-devel.sha256sum] = "75db7e53235182175c914d82d0650cf22712d333221f43676099802cb2811277"

RDEPENDS:rust-ed25519-compact+blind-keys-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+ct-codecs-devel = " \
 cargo \
 rust-ct-codecs+default-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+default-devel = " \
 cargo \
 rust-ed25519-compact+pem-devel \
 rust-ed25519-compact+random-devel \
 rust-ed25519-compact+std-devel \
 rust-ed25519-compact+x25519-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+disable-signatures-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+ed25519-devel = " \
 cargo \
 rust-ed25519+default-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+getrandom-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 rust-getrandom0.2+default-devel \
 "
RDEPENDS:rust-ed25519-compact+opt_size-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+pem-devel = " \
 cargo \
 rust-ed25519-compact+ct-codecs-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+random-devel = " \
 cargo \
 rust-ed25519-compact+getrandom-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+self-verify-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+std-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+traits-devel = " \
 cargo \
 rust-ed25519-compact+ed25519-devel \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact+x25519-devel = " \
 cargo \
 rust-ed25519-compact-devel \
 "
RDEPENDS:rust-ed25519-compact-devel = " \
 cargo \
 "
