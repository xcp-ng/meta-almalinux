# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bcder"
PV = "0.7.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-bcder+default-devel \
 rust-bcder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bcder-0.7.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ae60ea014740c9224c207485e99b6a71e4d5d8550cfd0a5ae7051377728a8ca"

URI_x86_64_v2_rust-bcder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcder+default-devel-0.7.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcder+default-devel}"
SRC_URI[x86_64_v2_rust-bcder+default-devel.sha256sum] = "4dd04239bedeba8fe7935c21207be566bc0246675882317fade8ae3758887c62"

URI_x86_64_v2_rust-bcder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcder-devel-0.7.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcder-devel}"
SRC_URI[x86_64_v2_rust-bcder-devel.sha256sum] = "4f4763e9b6ddb053828bacf064f89fed2baff5e8440ccd6972c808518a86d357"

URI_aarch64_rust-bcder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcder+default-devel-0.7.7-1.el10_3.noarch.rpm;name=aarch64_rust-bcder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcder+default-devel}"
SRC_URI[aarch64_rust-bcder+default-devel.sha256sum] = "5392f93dc897379ed4d1047cf5d98b80bfea37d7164e8fdb7182505970b0e803"

URI_aarch64_rust-bcder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcder-devel-0.7.7-1.el10_3.noarch.rpm;name=aarch64_rust-bcder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcder-devel}"
SRC_URI[aarch64_rust-bcder-devel.sha256sum] = "1d4c5748bbb203efe84b6c2273ca362dfce50bfbb3ed6f6b3d5f4d4b72315448"

RDEPENDS:rust-bcder+default-devel = " \
 cargo \
 rust-bcder-devel \
 "
RDEPENDS:rust-bcder-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-smallvec+default-devel \
 "
