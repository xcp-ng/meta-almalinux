# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-raw-window-handle"
PV = "0.6.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-raw-window-handle+alloc-devel \
 rust-raw-window-handle+default-devel \
 rust-raw-window-handle+std-devel \
 rust-raw-window-handle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-raw-window-handle-0.6.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "778ea29eca8b299a4586cd909362aed5b8ca17acda4531b0781fffaa59422007"

URI_x86_64_v2_rust-raw-window-handle+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-window-handle+alloc-devel-0.6.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-window-handle+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-window-handle+alloc-devel}"
SRC_URI[x86_64_v2_rust-raw-window-handle+alloc-devel.sha256sum] = "b59be330e137809d48097223d4cd302af541a001c54344fa5fbe0dea50e4e52e"

URI_x86_64_v2_rust-raw-window-handle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-window-handle+default-devel-0.6.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-window-handle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-window-handle+default-devel}"
SRC_URI[x86_64_v2_rust-raw-window-handle+default-devel.sha256sum] = "3563823d799201a626f0ebf850ad90801aef7ccab09429bb1b44596f4bebc736"

URI_x86_64_v2_rust-raw-window-handle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-window-handle+std-devel-0.6.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-window-handle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-window-handle+std-devel}"
SRC_URI[x86_64_v2_rust-raw-window-handle+std-devel.sha256sum] = "6b735f73379566fc9fe30a0a6865d304f386ac030717d7c7c92decde4a99dfae"

URI_x86_64_v2_rust-raw-window-handle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-window-handle-devel-0.6.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-raw-window-handle-devel}"
SRC_URI[x86_64_v2_rust-raw-window-handle-devel.sha256sum] = "d8661b4ce47e6774601b6e119ce35ca43fd4a4531e5271244ae1f3fce174667e"

URI_aarch64_rust-raw-window-handle+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-window-handle+alloc-devel-0.6.2-2.el10_0.noarch.rpm;name=aarch64_rust-raw-window-handle+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-window-handle+alloc-devel}"
SRC_URI[aarch64_rust-raw-window-handle+alloc-devel.sha256sum] = "e6097792f1c338e3ace7ff4b50ebb14c06d22ecd6b7bf7126b5ffb38c1076c1b"

URI_aarch64_rust-raw-window-handle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-window-handle+default-devel-0.6.2-2.el10_0.noarch.rpm;name=aarch64_rust-raw-window-handle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-window-handle+default-devel}"
SRC_URI[aarch64_rust-raw-window-handle+default-devel.sha256sum] = "3486f00926e4a0c86e485b71b1dd49dec2102c36933773627365326c74f3f51b"

URI_aarch64_rust-raw-window-handle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-window-handle+std-devel-0.6.2-2.el10_0.noarch.rpm;name=aarch64_rust-raw-window-handle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-window-handle+std-devel}"
SRC_URI[aarch64_rust-raw-window-handle+std-devel.sha256sum] = "83e9458f82219a563ba5ae5f85e1493b14ef12322c42cf3abeab4c82081e0662"

URI_aarch64_rust-raw-window-handle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-window-handle-devel-0.6.2-2.el10_0.noarch.rpm;name=aarch64_rust-raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-raw-window-handle-devel}"
SRC_URI[aarch64_rust-raw-window-handle-devel.sha256sum] = "cea7fa565c6800ee40b51721288bb5d97fa244b14c8044a87d3d858866872f62"

RDEPENDS:rust-raw-window-handle+alloc-devel = " \
 cargo \
 rust-raw-window-handle-devel \
 "
RDEPENDS:rust-raw-window-handle+default-devel = " \
 cargo \
 rust-raw-window-handle-devel \
 "
RDEPENDS:rust-raw-window-handle+std-devel = " \
 cargo \
 rust-raw-window-handle+alloc-devel \
 rust-raw-window-handle-devel \
 "
RDEPENDS:rust-raw-window-handle-devel = " \
 cargo \
 rust \
 "
