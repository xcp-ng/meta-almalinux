# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-config"
PV = "0.15.13"
PR = "1.el10_2"
PACKAGES = " \
 rust-config+async-devel \
 rust-config+async-trait-devel \
 rust-config+convert-case-devel \
 rust-config+convert_case-devel \
 rust-config+default-devel \
 rust-config+indexmap-devel \
 rust-config+ini-devel \
 rust-config+json-devel \
 rust-config+json5-devel \
 rust-config+json5_rs-devel \
 rust-config+preserve_order-devel \
 rust-config+ron-devel \
 rust-config+rust-ini-devel \
 rust-config+serde_json-devel \
 rust-config+toml-devel \
 rust-config+yaml-devel \
 rust-config+yaml-rust2-devel \
 rust-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-config-0.15.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "390ab472365fe9531d13023f71657047227773deb2bf6d8c86af34fe4dd34529"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-config+yaml-rust2-devel: (crate(yaml-rust2/default) >= 0.10.0 with crate(yaml-rust2/default) < 0.11.0~)

URI_x86_64_v2_rust-config+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+async-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+async-devel}"
SRC_URI[x86_64_v2_rust-config+async-devel.sha256sum] = "e8a261e39ab433b5614ae3e67dc39f4a3d5c39c69533e3b9c3eb8a7d665a66a5"

URI_x86_64_v2_rust-config+async-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+async-trait-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+async-trait-devel}"
SRC_URI[x86_64_v2_rust-config+async-trait-devel.sha256sum] = "a163f80b4fd2209e437c942d358f058dc4cd4a6b16883a6ef6935f3b9ecc2949"

URI_x86_64_v2_rust-config+convert-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+convert-case-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+convert-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+convert-case-devel}"
SRC_URI[x86_64_v2_rust-config+convert-case-devel.sha256sum] = "e4d5e615c4d9640ae690ee7e5d4ad6be9d871723efc0b7f226be19de426df077"

URI_x86_64_v2_rust-config+convert_case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+convert_case-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+convert_case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+convert_case-devel}"
SRC_URI[x86_64_v2_rust-config+convert_case-devel.sha256sum] = "137e703df4372682b7cad3c0c95fbc441d03648225a856938e3ebf12095cdc6b"

URI_x86_64_v2_rust-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+default-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+default-devel}"
SRC_URI[x86_64_v2_rust-config+default-devel.sha256sum] = "ff7e95a374ed73a6ea1566aee4c74204a87e5638cc91f265e01c35adc16215c2"

URI_x86_64_v2_rust-config+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+indexmap-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+indexmap-devel}"
SRC_URI[x86_64_v2_rust-config+indexmap-devel.sha256sum] = "9b449e047d857932516b2ae347177665ceac6e565c0871dd338cfe176eceaa1d"

URI_x86_64_v2_rust-config+ini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+ini-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+ini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+ini-devel}"
SRC_URI[x86_64_v2_rust-config+ini-devel.sha256sum] = "0b34e3712775b6925f4acc719056542b2533ef7fd4c85991ab16057538aec2d2"

URI_x86_64_v2_rust-config+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+json-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+json-devel}"
SRC_URI[x86_64_v2_rust-config+json-devel.sha256sum] = "e9ca76f12a74b2cbfe4e89907b25b6b1205ef131358783d2719342986c7d2b1c"

URI_x86_64_v2_rust-config+json5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+json5-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+json5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+json5-devel}"
SRC_URI[x86_64_v2_rust-config+json5-devel.sha256sum] = "c78d3fadf3b6332045050d365fff6492fe7e5e3f8f91cbb409c607bd358a80a4"

URI_x86_64_v2_rust-config+json5_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+json5_rs-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+json5_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+json5_rs-devel}"
SRC_URI[x86_64_v2_rust-config+json5_rs-devel.sha256sum] = "b9ceeaa897350f3ca6ec9ff039e8f9f9429ea18cb943d635ced0c3cde762069d"

URI_x86_64_v2_rust-config+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+preserve_order-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-config+preserve_order-devel.sha256sum] = "7f15eb3e0d4da3329c9b406d921de250371c9be3088868141110a89650c37ba0"

URI_x86_64_v2_rust-config+ron-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+ron-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+ron-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+ron-devel}"
SRC_URI[x86_64_v2_rust-config+ron-devel.sha256sum] = "d55103109ee131368bb0d94e02e809cc0e0dbe993d574171d53471f91b3c470d"

URI_x86_64_v2_rust-config+rust-ini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+rust-ini-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+rust-ini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+rust-ini-devel}"
SRC_URI[x86_64_v2_rust-config+rust-ini-devel.sha256sum] = "cf4bf6d3f692bbc31d4a63f671f46c34e3dbbc876d93607acfb42b271ab1da04"

URI_x86_64_v2_rust-config+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+serde_json-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+serde_json-devel}"
SRC_URI[x86_64_v2_rust-config+serde_json-devel.sha256sum] = "ba7dc6c88f3c86432453b41f6bbfde350181cae34f19ad05ee8f2e088c79f4a6"

URI_x86_64_v2_rust-config+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+toml-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+toml-devel}"
SRC_URI[x86_64_v2_rust-config+toml-devel.sha256sum] = "9d1997796123c0b1a8c5ef23269d9ae390b5fb6547825bfe7eacaae9c741550d"

URI_x86_64_v2_rust-config+yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+yaml-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+yaml-devel}"
SRC_URI[x86_64_v2_rust-config+yaml-devel.sha256sum] = "682a9e8e5fc1a5a6e69f0e2f62ee0033526c1832f6f403728528f50c781da072"

URI_x86_64_v2_rust-config+yaml-rust2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config+yaml-rust2-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config+yaml-rust2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config+yaml-rust2-devel}"
SRC_URI[x86_64_v2_rust-config+yaml-rust2-devel.sha256sum] = "cd5e1e3682f7c35f112826a0f85e3b25cc30ac1ae1af6e1842f1385bb9ac86c1"

URI_x86_64_v2_rust-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-config-devel-0.15.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-config-devel}"
SRC_URI[x86_64_v2_rust-config-devel.sha256sum] = "af982cc0783c9a2985b8f94dcfa95258a39fdb1c71d7624514b1b961b42f2216"

URI_aarch64_rust-config+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+async-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+async-devel}"
SRC_URI[aarch64_rust-config+async-devel.sha256sum] = "2a64cb2b94baafb59fa5d1c63fa3cb6ff7af4c7349e160642aa6ffcc396bbd48"

URI_aarch64_rust-config+async-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+async-trait-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+async-trait-devel}"
SRC_URI[aarch64_rust-config+async-trait-devel.sha256sum] = "46fd3cfedf262e5ef32b0652b127b4c77a0d0aaf01598677939a18a82e9f5673"

URI_aarch64_rust-config+convert-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+convert-case-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+convert-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+convert-case-devel}"
SRC_URI[aarch64_rust-config+convert-case-devel.sha256sum] = "02465ac159e810eb3cb706011c9b77527a72af18c7c172b2c8061debfba2216a"

URI_aarch64_rust-config+convert_case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+convert_case-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+convert_case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+convert_case-devel}"
SRC_URI[aarch64_rust-config+convert_case-devel.sha256sum] = "afa1214bf1e6633bfa7453a8e672dba83fee1e1d9f7e12ba050bb4c3049c7fbb"

URI_aarch64_rust-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+default-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+default-devel}"
SRC_URI[aarch64_rust-config+default-devel.sha256sum] = "f9be280f978444c102faf7066fc71dcd718abcf4f8ae0a09fc154b964006a77c"

URI_aarch64_rust-config+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+indexmap-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+indexmap-devel}"
SRC_URI[aarch64_rust-config+indexmap-devel.sha256sum] = "6714af71947c27eea136689831765fdbe6537c19e60136c377d176a7d5dba72d"

URI_aarch64_rust-config+ini-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+ini-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+ini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+ini-devel}"
SRC_URI[aarch64_rust-config+ini-devel.sha256sum] = "872ba82415b2b4f73463e9263fccc47cd10bd1dda45dbf1be9fca298edb1ea96"

URI_aarch64_rust-config+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+json-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+json-devel}"
SRC_URI[aarch64_rust-config+json-devel.sha256sum] = "ad6003d9378e98c0baadcbee563ae0eb0e843241765f07ca29e04699f23461d9"

URI_aarch64_rust-config+json5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+json5-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+json5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+json5-devel}"
SRC_URI[aarch64_rust-config+json5-devel.sha256sum] = "6e451b59047c568d00473ad5af7f5ce0aed631eb2aa033f17484eddfda8671cd"

URI_aarch64_rust-config+json5_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+json5_rs-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+json5_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+json5_rs-devel}"
SRC_URI[aarch64_rust-config+json5_rs-devel.sha256sum] = "7e14079529f44d34b6bfc3875b61fd017352f2d355064c6479f36bbf4be7a1db"

URI_aarch64_rust-config+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+preserve_order-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+preserve_order-devel}"
SRC_URI[aarch64_rust-config+preserve_order-devel.sha256sum] = "21f19c79aa7548a7b9d069478479d4db9f5de7d163b3b3d051839e00e33417ff"

URI_aarch64_rust-config+ron-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+ron-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+ron-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+ron-devel}"
SRC_URI[aarch64_rust-config+ron-devel.sha256sum] = "68a8a536d6d3f9b0bef541a4f37cda1d4ef4b1abbf558d219bace54e483d79ca"

URI_aarch64_rust-config+rust-ini-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+rust-ini-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+rust-ini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+rust-ini-devel}"
SRC_URI[aarch64_rust-config+rust-ini-devel.sha256sum] = "b8ff825fda1a687e34a3ac44b5215ff0920fea14e66b4b2bd1276db3d7ef5a50"

URI_aarch64_rust-config+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+serde_json-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+serde_json-devel}"
SRC_URI[aarch64_rust-config+serde_json-devel.sha256sum] = "8237dc46d81843adc427db00f9d41aab867447d490cb38ceabfc95d1131954a1"

URI_aarch64_rust-config+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+toml-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+toml-devel}"
SRC_URI[aarch64_rust-config+toml-devel.sha256sum] = "49b7dfab7fe9b3cdd34173f40f79c012513f7ce2949ecb30bf659e653ce00345"

URI_aarch64_rust-config+yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+yaml-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+yaml-devel}"
SRC_URI[aarch64_rust-config+yaml-devel.sha256sum] = "975a6be4c966a71f2089863fce9efb4d2d9c9e911e87411e10d33398fbc23952"

URI_aarch64_rust-config+yaml-rust2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config+yaml-rust2-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config+yaml-rust2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config+yaml-rust2-devel}"
SRC_URI[aarch64_rust-config+yaml-rust2-devel.sha256sum] = "b6f0f3e206a6744ff9ef78efa8ae6888ffdb7e6a03b79f3a417d9f5a25724ce9"

URI_aarch64_rust-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-config-devel-0.15.13-1.el10_2.noarch.rpm;name=aarch64_rust-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-config-devel}"
SRC_URI[aarch64_rust-config-devel.sha256sum] = "6b73fb52eb2d61d83bb0bdfa6873b4bf4fb61613055069748f93c965b051f430"

RDEPENDS:rust-config+async-devel = " \
 cargo \
 rust-config+async-trait-devel \
 rust-config-devel \
 "
RDEPENDS:rust-config+async-trait-devel = " \
 cargo \
 rust-async-trait+default-devel \
 rust-config-devel \
 "
RDEPENDS:rust-config+convert-case-devel = " \
 cargo \
 rust-config+convert_case-devel \
 rust-config-devel \
 "
RDEPENDS:rust-config+convert_case-devel = " \
 cargo \
 rust-config-devel \
 rust-convert_case0.6+default-devel \
 "
RDEPENDS:rust-config+default-devel = " \
 cargo \
 rust-config+async-devel \
 rust-config+convert-case-devel \
 rust-config+ini-devel \
 rust-config+json-devel \
 rust-config+json5-devel \
 rust-config+ron-devel \
 rust-config+toml-devel \
 rust-config+yaml-devel \
 rust-config-devel \
 "
RDEPENDS:rust-config+indexmap-devel = " \
 cargo \
 rust-config-devel \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 "
RDEPENDS:rust-config+ini-devel = " \
 cargo \
 rust-config+rust-ini-devel \
 rust-config-devel \
 "
RDEPENDS:rust-config+json-devel = " \
 cargo \
 rust-config+serde_json-devel \
 rust-config-devel \
 "
RDEPENDS:rust-config+json5-devel = " \
 cargo \
 rust-config+json5_rs-devel \
 rust-config-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-config+json5_rs-devel = " \
 cargo \
 rust-config-devel \
 rust-json5+default-devel \
 "
RDEPENDS:rust-config+preserve_order-devel = " \
 cargo \
 rust-config+indexmap-devel \
 rust-config-devel \
 rust-ron0.7+default-devel \
 rust-ron0.7+indexmap-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 rust-toml0.9+parse-devel \
 rust-toml0.9+preserve_order-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9-devel \
 "
RDEPENDS:rust-config+ron-devel = " \
 cargo \
 rust-config-devel \
 rust-ron0.7+default-devel \
 "
RDEPENDS:rust-config+rust-ini-devel = " \
 cargo \
 rust-config-devel \
 rust-rust-ini+default-devel \
 "
RDEPENDS:rust-config+serde_json-devel = " \
 cargo \
 rust-config-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-config+toml-devel = " \
 cargo \
 rust-config-devel \
 rust-toml0.9+parse-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9-devel \
 "
RDEPENDS:rust-config+yaml-devel = " \
 cargo \
 rust-config+yaml-rust2-devel \
 rust-config-devel \
 "
RDEPENDS:rust-config+yaml-rust2-devel:x86_64_v2 = " \
 cargo \
 rust-config-devel \
"
RDEPENDS:rust-config+yaml-rust2-devel:aarch64 = " \
 cargo \
 rust-config-devel \
 rust-yaml-rust2+default-devel \
"
RDEPENDS:rust-config-devel = " \
 cargo \
 rust \
 rust-pathdiff+default-devel \
 rust-serde+default-devel \
 rust-winnow0.7+default-devel \
 "
