# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nickle"
PV = "2.108"
PR = "1.el10_2"
PACKAGES = " \
 nickle \
 nickle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nickle-2.108-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2218ff39055ac95e3cf75148ebefd05771a685a426f32dcc884421ba1dc8297"

URI_x86_64_v2_nickle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nickle-2.108-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nickle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nickle}"
SRC_URI[x86_64_v2_nickle.sha256sum] = "96c39d6371c156c247611feb8bebb0a529407e6712c2b7d213125b7471673689"

URI_x86_64_v2_nickle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nickle-devel-2.108-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nickle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nickle-devel}"
SRC_URI[x86_64_v2_nickle-devel.sha256sum] = "bd68b2aa8e5aa5c7abcec77ca8fa6effd300f7d8fceddb3b76ffef709425f3e6"

URI_aarch64_nickle = "${EPEL_MIRROR}/aarch64/Packages/n/nickle-2.108-1.el10_2.aarch64.rpm;name=aarch64_nickle;unpack=0"
SRC_URI:append = " ${URI_aarch64_nickle}"
SRC_URI[aarch64_nickle.sha256sum] = "4a9cb219db8771f367f03d9769f44ecdff11de300352e7654ca4f773eb4ad5c6"

URI_aarch64_nickle-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nickle-devel-2.108-1.el10_2.aarch64.rpm;name=aarch64_nickle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nickle-devel}"
SRC_URI[aarch64_nickle-devel.sha256sum] = "3e5e52e1be78bf9b768d8f2381595c93a491cd0cd3ac5692b3b92a9b17d77131"

RDEPENDS:nickle = " \
 glibc \
 readline \
 "
RDEPENDS:nickle-devel = " \
 nickle \
 "
