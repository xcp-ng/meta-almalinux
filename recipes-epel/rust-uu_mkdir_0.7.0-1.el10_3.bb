# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_mkdir"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_mkdir+default-devel \
 rust-uu_mkdir+selinux-devel \
 rust-uu_mkdir+smack-devel \
 rust-uu_mkdir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_mkdir-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19b7e4001ac90fee603c1d65f80a1479d82774586091e35ca91ddf76616eb620"

URI_x86_64_v2_rust-uu_mkdir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mkdir+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mkdir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mkdir+default-devel}"
SRC_URI[x86_64_v2_rust-uu_mkdir+default-devel.sha256sum] = "9c5fc19b146c8d012d495affc2dfeb519bcec4b9863d25c49edd9d943c6221c9"

URI_x86_64_v2_rust-uu_mkdir+selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mkdir+selinux-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mkdir+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mkdir+selinux-devel}"
SRC_URI[x86_64_v2_rust-uu_mkdir+selinux-devel.sha256sum] = "3db1f217f3a051ae686bb377dc879e8102cd11f7c4ce969b96f41166b87566ab"

URI_x86_64_v2_rust-uu_mkdir+smack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mkdir+smack-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mkdir+smack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mkdir+smack-devel}"
SRC_URI[x86_64_v2_rust-uu_mkdir+smack-devel.sha256sum] = "613f85812270932a529edadf3e605fb27e065cf0126fdd968bfd4c4bc988ddb1"

URI_x86_64_v2_rust-uu_mkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_mkdir-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_mkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_mkdir-devel}"
SRC_URI[x86_64_v2_rust-uu_mkdir-devel.sha256sum] = "c1838c5df1ee1f1427f9ea5715522033d5c31c40ec3f53b9d4a14297db9da5b6"

URI_aarch64_rust-uu_mkdir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mkdir+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mkdir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mkdir+default-devel}"
SRC_URI[aarch64_rust-uu_mkdir+default-devel.sha256sum] = "0f3cb649f7c62001f2e71fcfed1acc7e54ac79e0418a10efce86fd0ca3494415"

URI_aarch64_rust-uu_mkdir+selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mkdir+selinux-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mkdir+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mkdir+selinux-devel}"
SRC_URI[aarch64_rust-uu_mkdir+selinux-devel.sha256sum] = "ab0e89bc2537460e26fa1e30aa122cc78dba47bd2a65ab3958f2ee1d3f37f257"

URI_aarch64_rust-uu_mkdir+smack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mkdir+smack-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mkdir+smack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mkdir+smack-devel}"
SRC_URI[aarch64_rust-uu_mkdir+smack-devel.sha256sum] = "3e1de68953059ecf5a522be988b5db060d69db2a956b047f8ab9eb776e9f5c45"

URI_aarch64_rust-uu_mkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_mkdir-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_mkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_mkdir-devel}"
SRC_URI[aarch64_rust-uu_mkdir-devel.sha256sum] = "b42615f7fb39ef89c9a5b8bbcf1742dc26870ac9d0460d81c813d343ba7c3028"

RDEPENDS:rust-uu_mkdir+default-devel = " \
 cargo \
 rust-uu_mkdir-devel \
 "
RDEPENDS:rust-uu_mkdir+selinux-devel = " \
 cargo \
 rust-uu_mkdir-devel \
 rust-uucore+selinux-devel \
 "
RDEPENDS:rust-uu_mkdir+smack-devel = " \
 cargo \
 rust-uu_mkdir-devel \
 rust-uucore+smack-devel \
 "
RDEPENDS:rust-uu_mkdir-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 rust-uucore+fsxattr-devel \
 rust-uucore+mode-devel \
 "
