# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx"
PE = "2"
PV = "1.26.3"
PR = "15.el10"
PACKAGES = " \
 nginx \
 nginx-all-modules \
 nginx-core \
 nginx-filesystem \
 nginx-mod-devel \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nginx-1.26.3-15.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "86730b0566732c42204951334742286c6072689099f872de0baf679d65a8a1bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-1.26.3-15.el10.x86_64_v2.rpm;name=x86_64_v2_nginx;unpack=0"
SRC_URI[x86_64_v2_nginx.sha256sum] = "a6c5dee4a6cb47622f7019f5b62076090ae2f06e407ac9b521c51b2e58e0c830"
RPROVIDES:nginx:append:x86_64_v2 = " virtual/httpd_or_nginx virtual/webserver"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-all-modules-1.26.3-15.el10.noarch.rpm;name=x86_64_v2_nginx-all-modules;unpack=0"
SRC_URI[x86_64_v2_nginx-all-modules.sha256sum] = "7780b806e25b2c00ecec5ac4500e41149cf8d81dc8e48f5c489fd8ae2ba9bada"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-core-1.26.3-15.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-core;unpack=0"
SRC_URI[x86_64_v2_nginx-core.sha256sum] = "2044b0ccfcc36e3e6452464014803a6951c52e0cf01cafa89aa76b84b5109c30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-filesystem-1.26.3-15.el10.noarch.rpm;name=x86_64_v2_nginx-filesystem;unpack=0"
SRC_URI[x86_64_v2_nginx-filesystem.sha256sum] = "c990cc09034e00260dabe75a99b67a3f19306809606e34db6a0bfdb042591f8e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nginx-mod-devel-1.26.3-15.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-devel;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-devel.sha256sum] = "67701c150718ab09e33313006a1c27b8b7dbf45a8f80ea5842de668f901a5410"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-image-filter-1.26.3-15.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-image-filter;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-http-image-filter.sha256sum] = "c362a97d5a72203cd7e97c83b15f7a84ed9848563f20f048a32397c1879f4b8c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-perl-1.26.3-15.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-perl;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-http-perl.sha256sum] = "996639e88d2b4b0adc8cf7b5d6875044cb1940a3a21fc36d1745413e70144244"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-http-xslt-filter-1.26.3-15.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-http-xslt-filter.sha256sum] = "19832931bba5fd93c0337b8ab3ef13c69f04c2124af740498ffd9fb5c9da06b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-mail-1.26.3-15.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-mail;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-mail.sha256sum] = "412b1fb84921eb9998dbcfb7c5cbc05cac4023262736390158113023f3443b41"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nginx-mod-stream-1.26.3-15.el10.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-stream;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-stream.sha256sum] = "4d166c14017baf71ed71a6ade32b7fce389ff87fdc6105e4445bcecc11014510"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-1.26.3-15.el10.aarch64.rpm;name=aarch64_nginx;unpack=0"
SRC_URI[aarch64_nginx.sha256sum] = "4929c34581ef3055712f9181ada80210a4059fbc7685637d42b9b022de81df3b"
RPROVIDES:nginx:append:aarch64 = " virtual/httpd_or_nginx virtual/webserver"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-all-modules-1.26.3-15.el10.noarch.rpm;name=aarch64_nginx-all-modules;unpack=0"
SRC_URI[aarch64_nginx-all-modules.sha256sum] = "7780b806e25b2c00ecec5ac4500e41149cf8d81dc8e48f5c489fd8ae2ba9bada"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-core-1.26.3-15.el10.aarch64.rpm;name=aarch64_nginx-core;unpack=0"
SRC_URI[aarch64_nginx-core.sha256sum] = "0b46cc5a5a0460a429cc99ca16ef8811b251fe723323e5aad8c1c782497fe7e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-filesystem-1.26.3-15.el10.noarch.rpm;name=aarch64_nginx-filesystem;unpack=0"
SRC_URI[aarch64_nginx-filesystem.sha256sum] = "c990cc09034e00260dabe75a99b67a3f19306809606e34db6a0bfdb042591f8e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nginx-mod-devel-1.26.3-15.el10.aarch64.rpm;name=aarch64_nginx-mod-devel;unpack=0"
SRC_URI[aarch64_nginx-mod-devel.sha256sum] = "29d82432fb08459997987c6018c7c52bd2aedcdd836ca3cddf3ee516d575ee08"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-image-filter-1.26.3-15.el10.aarch64.rpm;name=aarch64_nginx-mod-http-image-filter;unpack=0"
SRC_URI[aarch64_nginx-mod-http-image-filter.sha256sum] = "8266e2c199c5771af57e198fba2e5f206f704f36e32b5a35b149fb263713499b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-perl-1.26.3-15.el10.aarch64.rpm;name=aarch64_nginx-mod-http-perl;unpack=0"
SRC_URI[aarch64_nginx-mod-http-perl.sha256sum] = "770b6443710844426762530b6520f806cfa77bd053b712efea4ed74fd0bb4ec9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-http-xslt-filter-1.26.3-15.el10.aarch64.rpm;name=aarch64_nginx-mod-http-xslt-filter;unpack=0"
SRC_URI[aarch64_nginx-mod-http-xslt-filter.sha256sum] = "fedc2856c1fd3102231802e56c69333750dce8f9df864fb3de080e5abc166e7a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-mail-1.26.3-15.el10.aarch64.rpm;name=aarch64_nginx-mod-mail;unpack=0"
SRC_URI[aarch64_nginx-mod-mail.sha256sum] = "46ec069a9e7d85aac18e5c945b6267d4eb424201b993fc5adb72a94157080f01"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nginx-mod-stream-1.26.3-15.el10.aarch64.rpm;name=aarch64_nginx-mod-stream;unpack=0"
SRC_URI[aarch64_nginx-mod-stream.sha256sum] = "303a314fcbe76fd887e0f854aa368baa02f6375575aae1e126e2e5f81bf541fb"

RDEPENDS:nginx = " \
 almalinux-logos-httpd \
 bash \
 nginx-core \
 nginx-filesystem \
 systemd \
 "
RDEPENDS:nginx-all-modules = " \
 nginx-mod-http-image-filter \
 nginx-mod-http-perl \
 nginx-mod-http-xslt-filter \
 nginx-mod-mail \
 nginx-mod-stream \
 "
RDEPENDS:nginx-core = " \
 glibc \
 libxcrypt \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:nginx-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:nginx-mod-devel = " \
 bash \
 gcc \
 gd-devel \
 libxslt-devel \
 make \
 nginx \
 openssl-devel \
 pcre2-devel \
 perl-Exporter \
 perl-ExtUtils-Embed \
 perl-constant \
 perl-devel \
 perl-interpreter \
 perl-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:nginx-mod-http-image-filter = " \
 bash \
 gd \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-http-perl = " \
 bash \
 glibc \
 nginx \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
RDEPENDS:nginx-mod-http-xslt-filter = " \
 bash \
 glibc \
 libxml2 \
 libxslt \
 nginx \
 "
RDEPENDS:nginx-mod-mail = " \
 bash \
 glibc \
 nginx \
 "
RDEPENDS:nginx-mod-stream = " \
 bash \
 glibc \
 nginx \
 "
