# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dh-autoreconf"
PV = "20"
PR = "11.el10_0"
PACKAGES = " \
 dh-autoreconf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dh-autoreconf-20-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c35bd05bfab82713a375f01d875f3d7b1b6d32977fae059ad94c164ece55b860"

URI_x86_64_v2_dh-autoreconf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dh-autoreconf-20-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dh-autoreconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dh-autoreconf}"
SRC_URI[x86_64_v2_dh-autoreconf.sha256sum] = "69f6f1407a98d4dc84ed160cfeb727dffbc10c56c5de299c465d4ffddb64a3d2"

URI_aarch64_dh-autoreconf = "${EPEL_MIRROR}/aarch64/Packages/d/dh-autoreconf-20-11.el10_0.noarch.rpm;name=aarch64_dh-autoreconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_dh-autoreconf}"
SRC_URI[aarch64_dh-autoreconf.sha256sum] = "b9537c829c14ebaefdcdc5605f5ebf6c746e2307a27c64ed9420ad9e89f21c5e"

RDEPENDS:dh-autoreconf = " \
 autoconf \
 automake \
 cdbs \
 debhelper \
 gettext-devel \
 libtool \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 "
