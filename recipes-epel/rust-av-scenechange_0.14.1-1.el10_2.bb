# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av-scenechange"
PV = "0.14.1"
PR = "1.el10_2"
PACKAGES = " \
 av-scenechange \
 rust-av-scenechange+asm-devel \
 rust-av-scenechange+binary-devel \
 rust-av-scenechange+cc-devel \
 rust-av-scenechange+clap-devel \
 rust-av-scenechange+console-devel \
 rust-av-scenechange+default-devel \
 rust-av-scenechange+devel-devel \
 rust-av-scenechange+fern-devel \
 rust-av-scenechange+libc-devel \
 rust-av-scenechange+nasm-rs-devel \
 rust-av-scenechange+serde-devel \
 rust-av-scenechange+serde_json-devel \
 rust-av-scenechange+serialize-devel \
 rust-av-scenechange+tracing-chrome-devel \
 rust-av-scenechange+tracing-devel \
 rust-av-scenechange+tracing-subscriber-devel \
 rust-av-scenechange-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av-scenechange-0.14.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1752c01ff1bb37a7e5db583ca5412f1f8850d4d318b4ec35f2c0c44b273832f0"

URI_x86_64_v2_av-scenechange = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/av-scenechange-0.14.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_av-scenechange;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_av-scenechange}"
SRC_URI[x86_64_v2_av-scenechange.sha256sum] = "a26581c69d9c34cf7b66c5ff3fa3bcaeca6b9e4cfbf51d68c4f37297dcadd448"

URI_x86_64_v2_rust-av-scenechange+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+asm-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+asm-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+asm-devel.sha256sum] = "8fa35496668620bb64239eafa0bb2c366970fce64d56a9a7cbfd828f111fa7fb"

URI_x86_64_v2_rust-av-scenechange+binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+binary-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+binary-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+binary-devel.sha256sum] = "9290052c60c715b8524785a5595339bdd302769e7e8f85404b0fd247993db2f7"

URI_x86_64_v2_rust-av-scenechange+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+cc-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+cc-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+cc-devel.sha256sum] = "653f8d3d39e7a1aef8ff3aa9928c0cf4d19b2ae729ea8503c3986239ed05fa1a"

URI_x86_64_v2_rust-av-scenechange+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+clap-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+clap-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+clap-devel.sha256sum] = "4f58f961a863e04336734282ef86b42a898d6d9f018b94335ea1702fa0836f7f"

URI_x86_64_v2_rust-av-scenechange+console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+console-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+console-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+console-devel.sha256sum] = "4404d595a679853eca0c1eecc3c013917cba03a614bc86d10b184dfb4ec86020"

URI_x86_64_v2_rust-av-scenechange+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+default-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+default-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+default-devel.sha256sum] = "e1c58cf3d04400d434a2e9a59ae004a578fd841ae4045b83755e31d3fee0e817"

URI_x86_64_v2_rust-av-scenechange+devel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+devel-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+devel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+devel-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+devel-devel.sha256sum] = "1ec7248ed3a9b482b58a11a6f329294583573f6387c5bf7bafb7dbf550f73bef"

URI_x86_64_v2_rust-av-scenechange+fern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+fern-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+fern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+fern-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+fern-devel.sha256sum] = "f9e8b958f0e82b18136c294c87d13beb7790169101278367de45205e2832c382"

URI_x86_64_v2_rust-av-scenechange+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+libc-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+libc-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+libc-devel.sha256sum] = "2bfa3f058e9e385e035a8118582b7c83f37435a86927dd55be1063170ab1895d"

URI_x86_64_v2_rust-av-scenechange+nasm-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+nasm-rs-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+nasm-rs-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+nasm-rs-devel.sha256sum] = "74a8ec5b2fee876e65a25aa2d2f4441e666e64ff16ba4673eca2c09c1855f936"

URI_x86_64_v2_rust-av-scenechange+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+serde-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+serde-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+serde-devel.sha256sum] = "0bd0263b08e06f0cd32616e2ffff3688baba582e2eabc158a103de38b1e35183"

URI_x86_64_v2_rust-av-scenechange+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+serde_json-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+serde_json-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+serde_json-devel.sha256sum] = "1dca0e6f501385a3e09d43191af49685229b4cb3a861b1cb6d08c39cbcf32cb1"

URI_x86_64_v2_rust-av-scenechange+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+serialize-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+serialize-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+serialize-devel.sha256sum] = "43abedcb79026765c1044e9df7372e5351e26bb9b300d1a158eb2e77abf3b237"

URI_x86_64_v2_rust-av-scenechange+tracing-chrome-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+tracing-chrome-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+tracing-chrome-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+tracing-chrome-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+tracing-chrome-devel.sha256sum] = "bdc0fc07c8c361b6768df9bb43ea0e5293cf5b21c740b4a23c3891b164c3cb2d"

URI_x86_64_v2_rust-av-scenechange+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+tracing-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+tracing-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+tracing-devel.sha256sum] = "c2e2a53da8256358d12fe63909ffaa229cf48dc85e05f2c9265f35b57ecfca36"

URI_x86_64_v2_rust-av-scenechange+tracing-subscriber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+tracing-subscriber-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+tracing-subscriber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+tracing-subscriber-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+tracing-subscriber-devel.sha256sum] = "bf8baa49996483c5c9f7b49fa272598263fc98ce0998716b59d95799771f5144"

URI_x86_64_v2_rust-av-scenechange-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange-devel-0.14.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange-devel.sha256sum] = "9866c9e8985edb5ac6f6721e87aa87837ee94b2c3bb1bef9074c4e1c20dc4ea7"

URI_aarch64_av-scenechange = "${EPEL_MIRROR}/aarch64/Packages/a/av-scenechange-0.14.1-1.el10_2.aarch64.rpm;name=aarch64_av-scenechange;unpack=0"
SRC_URI:append = " ${URI_aarch64_av-scenechange}"
SRC_URI[aarch64_av-scenechange.sha256sum] = "11666828a47e942e813c632284389f8e69ae44d9ce89acb00d1da7acd2d51f38"

URI_aarch64_rust-av-scenechange+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+asm-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+asm-devel}"
SRC_URI[aarch64_rust-av-scenechange+asm-devel.sha256sum] = "b659d7362fb682ee806bf4e5c35e3bfc1ed37b1da68f5bc57b84459d64d22093"

URI_aarch64_rust-av-scenechange+binary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+binary-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+binary-devel}"
SRC_URI[aarch64_rust-av-scenechange+binary-devel.sha256sum] = "7324ce03bfcec2da59d68361b30962025c3ed15fc8800e9fc757eb8ed83b79c7"

URI_aarch64_rust-av-scenechange+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+cc-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+cc-devel}"
SRC_URI[aarch64_rust-av-scenechange+cc-devel.sha256sum] = "d19b22a37b04bbbce25f351e3c3dcc2f687020a3243ae9627db5ab4226abf75f"

URI_aarch64_rust-av-scenechange+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+clap-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+clap-devel}"
SRC_URI[aarch64_rust-av-scenechange+clap-devel.sha256sum] = "7bd68aae13825c3c0145c484777e72ce04e8134afa21762857852adedc7e82fe"

URI_aarch64_rust-av-scenechange+console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+console-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+console-devel}"
SRC_URI[aarch64_rust-av-scenechange+console-devel.sha256sum] = "5261c062d41d31b6097ca21fc42a0fb10d7f925069777053ed496fdbb8c2f364"

URI_aarch64_rust-av-scenechange+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+default-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+default-devel}"
SRC_URI[aarch64_rust-av-scenechange+default-devel.sha256sum] = "4ca7d4d80bd47c5f8b85fbe2da9cd771d909b85c7f07573205b383e31e002a4d"

URI_aarch64_rust-av-scenechange+devel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+devel-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+devel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+devel-devel}"
SRC_URI[aarch64_rust-av-scenechange+devel-devel.sha256sum] = "3518df1e7cb18f1bd22e2637d1a7a2e19f7df55d15dd61acc8a4d14dfa011feb"

URI_aarch64_rust-av-scenechange+fern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+fern-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+fern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+fern-devel}"
SRC_URI[aarch64_rust-av-scenechange+fern-devel.sha256sum] = "9c56e5a9325f8ced8298fa95f42236278f284e81aea0fe35aa1d1aac82fca986"

URI_aarch64_rust-av-scenechange+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+libc-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+libc-devel}"
SRC_URI[aarch64_rust-av-scenechange+libc-devel.sha256sum] = "6be34cbd515e62d59bf673b92c5e9f5785b0c98a5509a350abd6edaffb2537f2"

URI_aarch64_rust-av-scenechange+nasm-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+nasm-rs-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+nasm-rs-devel}"
SRC_URI[aarch64_rust-av-scenechange+nasm-rs-devel.sha256sum] = "011e7da4eabd16c3c62bf20696dbde543b2754bc08ad022454d1ad8439cc8d96"

URI_aarch64_rust-av-scenechange+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+serde-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+serde-devel}"
SRC_URI[aarch64_rust-av-scenechange+serde-devel.sha256sum] = "e92c3d4dd826076dc86b0a37133e4be63480f37fc8912cd9075ccf7fa784cbc1"

URI_aarch64_rust-av-scenechange+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+serde_json-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+serde_json-devel}"
SRC_URI[aarch64_rust-av-scenechange+serde_json-devel.sha256sum] = "3d7883d69b1f573fad4bb502e536c85367b700765ccb415aee9aadd5d74c3f1e"

URI_aarch64_rust-av-scenechange+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+serialize-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+serialize-devel}"
SRC_URI[aarch64_rust-av-scenechange+serialize-devel.sha256sum] = "d58f58a76aca9f643e18d4df46ab7363c62ffe382cc0fc01a15404b61974fa1f"

URI_aarch64_rust-av-scenechange+tracing-chrome-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+tracing-chrome-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+tracing-chrome-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+tracing-chrome-devel}"
SRC_URI[aarch64_rust-av-scenechange+tracing-chrome-devel.sha256sum] = "524e7ca5d9c914e140d20c38c962f5314e5651cf5473e7a4b6291aef1ffad125"

URI_aarch64_rust-av-scenechange+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+tracing-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+tracing-devel}"
SRC_URI[aarch64_rust-av-scenechange+tracing-devel.sha256sum] = "c3bf18248f7e91314602ba69b2009f61b9888445130398c43593c6c868d0921d"

URI_aarch64_rust-av-scenechange+tracing-subscriber-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+tracing-subscriber-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange+tracing-subscriber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+tracing-subscriber-devel}"
SRC_URI[aarch64_rust-av-scenechange+tracing-subscriber-devel.sha256sum] = "2868d71ff9ab5474908fd6776c7920c4c86105cf6c4127ea90b4a87acd30ead2"

URI_aarch64_rust-av-scenechange-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange-devel-0.14.1-1.el10_2.noarch.rpm;name=aarch64_rust-av-scenechange-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange-devel}"
SRC_URI[aarch64_rust-av-scenechange-devel.sha256sum] = "d7ced2ac49f179ae0194adcadc510bc2f824cd368033a6c3cd8038623c180330"

RDEPENDS:av-scenechange = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-av-scenechange+asm-devel = " \
 cargo \
 rust-av-scenechange+cc-devel \
 rust-av-scenechange+libc-devel \
 rust-av-scenechange+nasm-rs-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+binary-devel = " \
 cargo \
 rust-av-scenechange+clap-devel \
 rust-av-scenechange+serialize-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+cc-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 "
RDEPENDS:rust-av-scenechange+clap-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 "
RDEPENDS:rust-av-scenechange+console-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-console+default-devel \
 "
RDEPENDS:rust-av-scenechange+default-devel = " \
 cargo \
 rust-av-scenechange+asm-devel \
 rust-av-scenechange+binary-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+devel-devel = " \
 cargo \
 rust-av-scenechange+console-devel \
 rust-av-scenechange+fern-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+fern-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-fern+default-devel \
 "
RDEPENDS:rust-av-scenechange+libc-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-av-scenechange+nasm-rs-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-nasm-rs+default-devel \
 rust-nasm-rs+parallel-devel \
 "
RDEPENDS:rust-av-scenechange+serde-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-av-scenechange+serde_json-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-av-scenechange+serialize-devel = " \
 cargo \
 rust-av-scenechange+serde-devel \
 rust-av-scenechange+serde_json-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+tracing-chrome-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-tracing-chrome+default-devel \
 "
RDEPENDS:rust-av-scenechange+tracing-devel = " \
 cargo \
 rust-av-scenechange+tracing-chrome-devel \
 rust-av-scenechange+tracing-subscriber-devel \
 rust-av-scenechange-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-av-scenechange+tracing-subscriber-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-tracing-subscriber+default-devel \
 "
RDEPENDS:rust-av-scenechange-devel = " \
 cargo \
 rust \
 rust-aligned+default-devel \
 rust-anyhow+default-devel \
 rust-arg_enum_proc_macro+default-devel \
 rust-arrayvec+default-devel \
 rust-log+default-devel \
 rust-num-rational-devel \
 rust-num-traits+default-devel \
 rust-pastey+default-devel \
 rust-rayon+default-devel \
 rust-thiserror+default-devel \
 rust-v_frame0.3+default-devel \
 rust-y4m+default-devel \
 "
