# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_edit0.22"
PV = "0.22.27"
PR = "1.el10_1"
PACKAGES = " \
 rust-toml_edit0.22+default-devel \
 rust-toml_edit0.22+display-devel \
 rust-toml_edit0.22+parse-devel \
 rust-toml_edit0.22+perf-devel \
 rust-toml_edit0.22+serde-devel \
 rust-toml_edit0.22+unbounded-devel \
 rust-toml_edit0.22+unstable-debug-devel \
 rust-toml_edit0.22-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_edit0.22-0.22.27-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f17f56127f9f34c336f9697631da0913392d312772d49cb99898fc2597c4ca36"

URI_x86_64_v2_rust-toml_edit0.22+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.22+default-devel-0.22.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.22+default-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.22+default-devel.sha256sum] = "490e61070f93f7f64840b61bce4852e4afb94ace055b9b5de89371fc2310f2f6"

URI_x86_64_v2_rust-toml_edit0.22+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.22+display-devel-0.22.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.22+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.22+display-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.22+display-devel.sha256sum] = "74db406227354c6fa3cbac61c53800a5da082e198f523df7f5830547cce810ae"

URI_x86_64_v2_rust-toml_edit0.22+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.22+parse-devel-0.22.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.22+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.22+parse-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.22+parse-devel.sha256sum] = "6f5961a11ea76bef4498c127e8e5acfb6df26ea42a88004eb741214968650212"

URI_x86_64_v2_rust-toml_edit0.22+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.22+perf-devel-0.22.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.22+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.22+perf-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.22+perf-devel.sha256sum] = "f0e399d6fab78b6820352c8b19b4e70a7150e34ea1ea4602d06f67cd295b16a2"

URI_x86_64_v2_rust-toml_edit0.22+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.22+serde-devel-0.22.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.22+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.22+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.22+serde-devel.sha256sum] = "a829ee334b60b899f0b4696ebededea947c5135147776b9654cfdb148df98d23"

URI_x86_64_v2_rust-toml_edit0.22+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.22+unbounded-devel-0.22.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.22+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.22+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.22+unbounded-devel.sha256sum] = "d1a620f4b0ff10f8a726bfb7b4e6f211328e87c423b5daca495766fc40361d17"

URI_x86_64_v2_rust-toml_edit0.22+unstable-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.22+unstable-debug-devel-0.22.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.22+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.22+unstable-debug-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.22+unstable-debug-devel.sha256sum] = "a6110141cfb5a6bb3d6b1eca317e4a4197a392b08c10b01d8952b0e01b605c6b"

URI_x86_64_v2_rust-toml_edit0.22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.22-devel-0.22.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.22-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.22-devel.sha256sum] = "b989c7884ffd159762eec3a22fae308bf2d0725821bc4c134bcba22eaa7c6b11"

URI_aarch64_rust-toml_edit0.22+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.22+default-devel-0.22.27-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.22+default-devel}"
SRC_URI[aarch64_rust-toml_edit0.22+default-devel.sha256sum] = "fb31d1314044a83a3a8888db205cca2aa57d4c5de4498e21a0c2ae23f4037955"

URI_aarch64_rust-toml_edit0.22+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.22+display-devel-0.22.27-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit0.22+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.22+display-devel}"
SRC_URI[aarch64_rust-toml_edit0.22+display-devel.sha256sum] = "70866e0e1ef37ff09527a05ae4b7776c801982c63ce73654afb1baea7cf10711"

URI_aarch64_rust-toml_edit0.22+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.22+parse-devel-0.22.27-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit0.22+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.22+parse-devel}"
SRC_URI[aarch64_rust-toml_edit0.22+parse-devel.sha256sum] = "0797a04c7c938af91e58b553cf6eb1947aa126012badf979321ce622b718e658"

URI_aarch64_rust-toml_edit0.22+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.22+perf-devel-0.22.27-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit0.22+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.22+perf-devel}"
SRC_URI[aarch64_rust-toml_edit0.22+perf-devel.sha256sum] = "37c83a98e20870730f6ff26bdc4ce1f6f88d700c7fb7c345b44c117d382c517b"

URI_aarch64_rust-toml_edit0.22+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.22+serde-devel-0.22.27-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit0.22+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.22+serde-devel}"
SRC_URI[aarch64_rust-toml_edit0.22+serde-devel.sha256sum] = "d8839946b00a472b7a61d98726f15becbb1d248eef645a925e6c490d60d79180"

URI_aarch64_rust-toml_edit0.22+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.22+unbounded-devel-0.22.27-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit0.22+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.22+unbounded-devel}"
SRC_URI[aarch64_rust-toml_edit0.22+unbounded-devel.sha256sum] = "3b9a5c216bbc7437636cea436d5f3b4884bc03f8e69d4c31dd74851877dbbd75"

URI_aarch64_rust-toml_edit0.22+unstable-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.22+unstable-debug-devel-0.22.27-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit0.22+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.22+unstable-debug-devel}"
SRC_URI[aarch64_rust-toml_edit0.22+unstable-debug-devel.sha256sum] = "ef57f960e516446abac719b6cadcffb26232f8819356168ae01a1ca2f70c0553"

URI_aarch64_rust-toml_edit0.22-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.22-devel-0.22.27-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit0.22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.22-devel}"
SRC_URI[aarch64_rust-toml_edit0.22-devel.sha256sum] = "dcab66d3a01bc19e8ac44accda21e7b105a7fdc04ef510f92901cd95066fb608"

RDEPENDS:rust-toml_edit0.22+default-devel = " \
 cargo \
 rust-toml_edit0.22+display-devel \
 rust-toml_edit0.22+parse-devel \
 rust-toml_edit0.22-devel \
 "
RDEPENDS:rust-toml_edit0.22+display-devel = " \
 cargo \
 rust-toml_edit0.22-devel \
 rust-toml_write+default-devel \
 "
RDEPENDS:rust-toml_edit0.22+parse-devel = " \
 cargo \
 rust-toml_edit0.22-devel \
 rust-winnow0.7+default-devel \
 "
RDEPENDS:rust-toml_edit0.22+perf-devel = " \
 cargo \
 rust-kstring+default-devel \
 rust-kstring+max_inline-devel \
 rust-toml_edit0.22-devel \
 "
RDEPENDS:rust-toml_edit0.22+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde_spanned0.6+default-devel \
 rust-serde_spanned0.6+serde-devel \
 rust-toml_datetime0.6+serde-devel \
 rust-toml_edit0.22-devel \
 "
RDEPENDS:rust-toml_edit0.22+unbounded-devel = " \
 cargo \
 rust-toml_edit0.22-devel \
 "
RDEPENDS:rust-toml_edit0.22+unstable-debug-devel = " \
 cargo \
 rust-toml_edit0.22-devel \
 rust-winnow0.7+debug-devel \
 rust-winnow0.7+default-devel \
 "
RDEPENDS:rust-toml_edit0.22-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-toml_datetime0.6+default-devel \
 "
