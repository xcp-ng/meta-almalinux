# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-xmltodict"
PV = "0.13.0"
PR = "5.el10_0"
PACKAGES = " \
 python3-xmltodict \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-xmltodict-0.13.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74119fe5e8ed8029b8d80decbe722cd10545e405ff8f24334d57ad3077db31e2"

URI_x86_64_v2_python3-xmltodict = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xmltodict-0.13.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-xmltodict;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xmltodict}"
SRC_URI[x86_64_v2_python3-xmltodict.sha256sum] = "6626c342deaf640a38dec139bb6c5822e112aad920e8d794758832afcd32889e"

URI_aarch64_python3-xmltodict = "${EPEL_MIRROR}/aarch64/Packages/p/python3-xmltodict-0.13.0-5.el10_0.noarch.rpm;name=aarch64_python3-xmltodict;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xmltodict}"
SRC_URI[aarch64_python3-xmltodict.sha256sum] = "bbe104214c900f08be0fcb48f01612488a21750061eb4fea00ecabf2efa29623"

RDEPENDS:python3-xmltodict = " \
 python3 \
 "
