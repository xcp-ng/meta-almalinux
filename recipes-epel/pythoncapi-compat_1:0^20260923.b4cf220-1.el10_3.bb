# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pythoncapi-compat"
PE = "1"
PV = "0^20260923.b4cf220"
PR = "1.el10_3"
PACKAGES = " \
 pythoncapi-compat-devel \
 pythoncapi-compat-doc \
 pythoncapi-compat-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pythoncapi-compat-0^20260923.b4cf220-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bf68c622314265f90ed3e0b90dc41d44381a6d578335dbe036e54458079e6487"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-devel-0^20260923.b4cf220-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-devel;unpack=0"
SRC_URI[x86_64_v2_pythoncapi-compat-devel.sha256sum] = "a1299b4751384f5d6e97410b6169012ceda09f3fa72ddb38622c62d82d3d5fac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-doc-0^20260923.b4cf220-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-doc;unpack=0"
SRC_URI[x86_64_v2_pythoncapi-compat-doc.sha256sum] = "a9d536c6700ca9bbe9868619fbe46eac5139d3775dd1d75c02f43f5347a8ccc1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-tools-0^20260923.b4cf220-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-tools;unpack=0"
SRC_URI[x86_64_v2_pythoncapi-compat-tools.sha256sum] = "d08ed9a96af8e407f0b52251d9416b454266f17c2fd1beb6d435e8b2c0476d42"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-devel-0^20260923.b4cf220-1.el10_3.noarch.rpm;name=aarch64_pythoncapi-compat-devel;unpack=0"
SRC_URI[aarch64_pythoncapi-compat-devel.sha256sum] = "2f958ee1343098bfc572bb5bf5e5425d5e67bab3f7e5ed48bbb81c0b60134159"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-doc-0^20260923.b4cf220-1.el10_3.noarch.rpm;name=aarch64_pythoncapi-compat-doc;unpack=0"
SRC_URI[aarch64_pythoncapi-compat-doc.sha256sum] = "990cf2a511fdc25f9b4d347f6bb53584dc72a7e15b2cf277c4af2bb63b4c0823"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-tools-0^20260923.b4cf220-1.el10_3.noarch.rpm;name=aarch64_pythoncapi-compat-tools;unpack=0"
SRC_URI[aarch64_pythoncapi-compat-tools.sha256sum] = "475070c264c0d76b280b85011e48d26255a976d1ad4419672dc8f0c30c541671"

RDEPENDS:pythoncapi-compat-devel = " \
 "
RDEPENDS:pythoncapi-compat-doc = " \
 "
RDEPENDS:pythoncapi-compat-tools = " \
 python3 \
 "
