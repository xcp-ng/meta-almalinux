# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-connect"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kde-connect \
 kde-connect-libs \
 kde-connect-nautilus \
 kdeconnectd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-connect-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e4245bc4e324ac8d5b29b328b6295ef84bae6079c00f65e56280f132f9b278a"

URI_x86_64_v2_kde-connect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-connect}"
SRC_URI[x86_64_v2_kde-connect.sha256sum] = "e2023f42ff67a7c81eb93d3df2361e87f7a2348a6c3f41036c8dd70f5d8838ac"

URI_x86_64_v2_kde-connect-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-connect-libs}"
SRC_URI[x86_64_v2_kde-connect-libs.sha256sum] = "3d58b16527b258551c62d443e78da96eb49730ec467034fbd3e3eb96292d4388"

URI_x86_64_v2_kde-connect-nautilus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-nautilus-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect-nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-connect-nautilus}"
SRC_URI[x86_64_v2_kde-connect-nautilus.sha256sum] = "d6148f94848055cef7240e7ecd31b2de077f865baf6433e3ca3e535e1005f739"

URI_x86_64_v2_kdeconnectd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeconnectd-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeconnectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdeconnectd}"
SRC_URI[x86_64_v2_kdeconnectd.sha256sum] = "ec43d40812079ee158ce7bd6dc915e84bcafff05f2c97f1ff7a1496b1d105a32"

URI_aarch64_kde-connect = "${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kde-connect;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-connect}"
SRC_URI[aarch64_kde-connect.sha256sum] = "6bb62a4bb5b4912a794b4c233bc8d83af607bec014ceb0ebd2c775cd6a18b8f2"

URI_aarch64_kde-connect-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kde-connect-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-connect-libs}"
SRC_URI[aarch64_kde-connect-libs.sha256sum] = "8f32dd22dab3bf95cc9dcea0e464cd0ff1aee653c028b1e962e04fa16560ecb5"

URI_aarch64_kde-connect-nautilus = "${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-nautilus-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kde-connect-nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-connect-nautilus}"
SRC_URI[aarch64_kde-connect-nautilus.sha256sum] = "4a0e2a1d50b2c9e33bd51c1236eaa8cef944301a3344f55eb02f98fd643cc798"

URI_aarch64_kdeconnectd = "${EPEL_MIRROR}/aarch64/Packages/k/kdeconnectd-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdeconnectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdeconnectd}"
SRC_URI[aarch64_kdeconnectd.sha256sum] = "fc40068143d1747d80585d0d797de155121932e3b1ad005b37e55949f7ce3049"

RDEPENDS:kde-connect = " \
 fuse-sshfs \
 glibc \
 kde-cli-tools \
 kde-connect-libs \
 kdeconnectd \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpeople \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kf6-qqc2-desktop-style \
 libstdc++ \
 libwayland-client \
 qca-qt6-ossl \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kde-connect-libs = " \
 dbus-libs \
 glibc \
 kde-connect \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-solid \
 libX11 \
 libXtst \
 libei \
 libevdev \
 libfakekey \
 libstdc++ \
 libxkbcommon \
 openssl-libs \
 pulseaudio-qt-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtconnectivity \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:kde-connect-nautilus = " \
 kdeconnectd \
 nautilus-python \
 "
RDEPENDS:kdeconnectd = " \
 glibc \
 kde-connect-libs \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
