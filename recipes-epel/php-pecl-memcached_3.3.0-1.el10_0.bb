# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-memcached"
PV = "3.3.0"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-memcached \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-memcached-3.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eca658af59836ee2f702763ca01b1ffdb68f57a54a68b9bf41b5192401f6d459"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-memcached-3.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-memcached;unpack=0"
SRC_URI[x86_64_v2_php-pecl-memcached.sha256sum] = "31c98a948d3f5caeaa5139177e6efab2097819837341ac4f99768fc19310edeb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-memcached-3.3.0-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-memcached;unpack=0"
SRC_URI[aarch64_php-pecl-memcached.sha256sum] = "1e08f41a17b5c0cd0b732d8f9539574d1a55f4c06e16d763862acd6bc9aea2b8"

RDEPENDS:php-pecl-memcached = " \
 cyrus-sasl-lib \
 fastlz \
 glibc \
 libevent \
 libmemcached-awesome \
 libzstd \
 php-common \
 php-pecl-igbinary \
 php-pecl-msgpack \
 zlib-ng-compat \
 "
