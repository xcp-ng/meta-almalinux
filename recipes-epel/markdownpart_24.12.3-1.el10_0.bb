# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "markdownpart"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 markdownpart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/markdownpart-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7dcf39467bdd3c83133db52e4ddd381bd0725a09883087aa61161cfd74618653"

URI_x86_64_v2_markdownpart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/markdownpart-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_markdownpart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_markdownpart}"
SRC_URI[x86_64_v2_markdownpart.sha256sum] = "4efa6c704b2f8f738fcb013792d46d69362f9c386476029e932dcbf32b9f521b"

URI_aarch64_markdownpart = "${EPEL_MIRROR}/aarch64/Packages/m/markdownpart-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_markdownpart;unpack=0"
SRC_URI:append = " ${URI_aarch64_markdownpart}"
SRC_URI[aarch64_markdownpart.sha256sum] = "f0073821b95c427582295c8003f7aa0dc30418a05ced5b5fb2f06e1e9f6939f4"

RDEPENDS:markdownpart = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kparts \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
