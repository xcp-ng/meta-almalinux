# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lest"
PV = "1.37.0"
PR = "1.el10_0"
PACKAGES = " \
 lest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lest-1.37.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00e0d2b397112648c718cc74b822b25b57058160b16a26e6b600f137971faf8d"

URI_x86_64_v2_lest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lest-devel-1.37.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lest-devel}"
SRC_URI[x86_64_v2_lest-devel.sha256sum] = "cb10110361ba4d2ddfce52f46414bc6f8cb79df62b72f55b44197d7b51bfd0a1"

URI_aarch64_lest-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lest-devel-1.37.0-1.el10_0.noarch.rpm;name=aarch64_lest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lest-devel}"
SRC_URI[aarch64_lest-devel.sha256sum] = "618562a812865d5f176b87686207863ea2a61bf8cc345ec7082a142714178835"

RDEPENDS:lest-devel = " \
 "
