# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-nikic-php-parser5"
PV = "5.9.0"
PR = "1.el10_3"
PACKAGES = " \
 php-nikic-php-parser5 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-nikic-php-parser5-5.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "970fbdf778e110aa52a0c585e880e8332ace34145e9e6afb908323cad8c5df0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-nikic-php-parser5-5.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_php-nikic-php-parser5;unpack=0"
SRC_URI[x86_64_v2_php-nikic-php-parser5.sha256sum] = "79c69e552ce5ac4ba35c204f1b09e3bd550de40a4b9efcecda20f89dcc759bb4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-nikic-php-parser5-5.9.0-1.el10_3.noarch.rpm;name=aarch64_php-nikic-php-parser5;unpack=0"
SRC_URI[aarch64_php-nikic-php-parser5.sha256sum] = "297452cb0e4bf9135b1aff9c6a12cd29df274b8e54ec0c175dc80eb859084380"

RDEPENDS:php-nikic-php-parser5 = " \
 php-fedora-autoloader \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-json \
 virtual/php-tokenizer \
 virtual/php_language__ge_7.4 \
 "
