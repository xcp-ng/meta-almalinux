# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-wire"
PV = "6.2.1"
PR = "5.el10_2"
PACKAGES = " \
 rubygem-cucumber-wire \
 rubygem-cucumber-wire-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-wire-6.2.1-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cc9c3d6ad23e7a52f653c2893b01fc2ebfb4df2c77ad33bf074c2f37a9cfe67"

URI_x86_64_v2_rubygem-cucumber-wire = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-wire-6.2.1-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-wire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-wire}"
SRC_URI[x86_64_v2_rubygem-cucumber-wire.sha256sum] = "1d4840fee49afe3f13a46514c10cbe36602f727dc271d5428dfac5cff5e98015"

URI_x86_64_v2_rubygem-cucumber-wire-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-wire-doc-6.2.1-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-wire-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-wire-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-wire-doc.sha256sum] = "7491d6388b392bd4d54b3023ac2419707a3746e8f0f49656e161a74f18df9f0b"

URI_aarch64_rubygem-cucumber-wire = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-wire-6.2.1-5.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-wire;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-wire}"
SRC_URI[aarch64_rubygem-cucumber-wire.sha256sum] = "ff28c675fadb9f0a47196ba6691938875438038c736c8b6778d31d03001115aa"

URI_aarch64_rubygem-cucumber-wire-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-wire-doc-6.2.1-5.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-wire-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-wire-doc}"
SRC_URI[aarch64_rubygem-cucumber-wire-doc.sha256sum] = "7cd0b9ae40cd02c674e211073dde91f8ab04bdbc678c0866a0d182221de8be92"

RDEPENDS:rubygem-cucumber-wire = " \
 rubygem-cucumber-core \
 rubygem-cucumber-cucumber-expressions \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-wire-doc = " \
 rubygem-cucumber-wire \
 "
