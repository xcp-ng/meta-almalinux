# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvpn"
PV = "2.7.6"
PR = "1.el10_3"
PACKAGES = " \
 openvpn \
 openvpn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openvpn-2.7.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba3126b0edaa37b4e3bd578af2c899084dcee9b99e32fdbd36ced9de390be98a"

URI_x86_64_v2_openvpn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-2.7.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvpn}"
SRC_URI[x86_64_v2_openvpn.sha256sum] = "7fb7cfe2568b61565a35d5dfce3156f351f0a2912955a2b4feb37119b12ae5ac"

URI_x86_64_v2_openvpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-devel-2.7.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvpn-devel}"
SRC_URI[x86_64_v2_openvpn-devel.sha256sum] = "4f40fc45a8bb0c5b9190de878fe8af81678611f06a373d87003e9b04250ad698"

URI_aarch64_openvpn = "${EPEL_MIRROR}/aarch64/Packages/o/openvpn-2.7.6-1.el10_3.aarch64.rpm;name=aarch64_openvpn;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvpn}"
SRC_URI[aarch64_openvpn.sha256sum] = "49f044d1cc261d0c02dc826a921e292dc0717f051f26abaa2d7df214e6d5e40c"

URI_aarch64_openvpn-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openvpn-devel-2.7.6-1.el10_3.aarch64.rpm;name=aarch64_openvpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvpn-devel}"
SRC_URI[aarch64_openvpn-devel.sha256sum] = "21f10220426b1d1eb018dd63e68d92d0a7daec97cb3e7617f7597f5cfd07f42a"

RDEPENDS:openvpn = " \
 bash \
 gawk \
 glibc \
 libcap-ng \
 libnl3 \
 libselinux \
 lz4-libs \
 lzo \
 openssl-libs \
 pam-libs \
 pkcs11-helper \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:openvpn-devel = " \
 "
