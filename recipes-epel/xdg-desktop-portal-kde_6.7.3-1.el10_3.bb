# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal-kde"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 xdg-desktop-portal-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xdg-desktop-portal-kde-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73a5b00dec0806f63c7a76539d503e6535ca1636d4975b717f2a2c35e4da9cb2"

URI_x86_64_v2_xdg-desktop-portal-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xdg-desktop-portal-kde-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal-kde}"
SRC_URI[x86_64_v2_xdg-desktop-portal-kde.sha256sum] = "c488aa4c50218c07267097f9d687371bd5914c2c0148239d8dfd40ad57dc8d6d"

URI_aarch64_xdg-desktop-portal-kde = "${EPEL_MIRROR}/aarch64/Packages/x/xdg-desktop-portal-kde-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_xdg-desktop-portal-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal-kde}"
SRC_URI[aarch64_xdg-desktop-portal-kde.sha256sum] = "c0cdec9e5269ed097d9244f70c53bc84bc1cd85ffec3d1cb2653345109014810"

RDEPENDS:xdg-desktop-portal-kde = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kwayland \
 libstdc++ \
 libwayland-client \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xdg-desktop-portal \
 xdg-desktop-portal-gtk \
 "
