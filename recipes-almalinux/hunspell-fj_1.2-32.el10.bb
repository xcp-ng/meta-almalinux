# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-fj"
PV = "1.2"
PR = "32.el10"
PACKAGES = " \
 hunspell-fj \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-fj-1.2-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "455b3e3bfcba20d4d077bd281c1036189dc2cc0494448ec3c5376670e998971f"

URI_x86_64_v2_hunspell-fj = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-fj-1.2-32.el10.noarch.rpm;name=x86_64_v2_hunspell-fj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-fj}"
SRC_URI[x86_64_v2_hunspell-fj.sha256sum] = "19ec2c3c74f45738ed8ca2912d38e5090512f30134e59d9a456da48c9a5bb560"

URI_aarch64_hunspell-fj = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-fj-1.2-32.el10.noarch.rpm;name=aarch64_hunspell-fj;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-fj}"
SRC_URI[aarch64_hunspell-fj.sha256sum] = "19ec2c3c74f45738ed8ca2912d38e5090512f30134e59d9a456da48c9a5bb560"

RDEPENDS:hunspell-fj = " \
 hunspell-filesystem \
 "
