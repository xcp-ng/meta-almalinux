# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jc"
PV = "1.25.5"
PR = "1.el10_1"
PACKAGES = " \
 jc \
 python3-jc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jc-1.25.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d736ac96fac283a501bcdc34cb5a4989ceb30a81cb939d5109913607efd04e0f"

URI_x86_64_v2_jc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jc-1.25.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_jc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jc}"
SRC_URI[x86_64_v2_jc.sha256sum] = "464fc92170823858cf972e9a9e66d998cb24872d9a2e7fc03ef3db21d7de8bfe"

URI_x86_64_v2_python3-jc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jc-1.25.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jc}"
SRC_URI[x86_64_v2_python3-jc.sha256sum] = "2c7a77f0cfb5733bbe524954ee1f01b7aaed7133671040d3af1bdaf875037c1a"

URI_aarch64_jc = "${EPEL_MIRROR}/aarch64/Packages/j/jc-1.25.5-1.el10_1.noarch.rpm;name=aarch64_jc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jc}"
SRC_URI[aarch64_jc.sha256sum] = "59ecad93642aa7cd5d5172268aa6f6c841dc20b72514f2320ebfba0c7eb2b8f5"

URI_aarch64_python3-jc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jc-1.25.5-1.el10_1.noarch.rpm;name=aarch64_python3-jc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jc}"
SRC_URI[aarch64_python3-jc.sha256sum] = "14fe7245ae449e8f9129e4ba0bfad2248b6839655852051b1d45e06656c34719"

RDEPENDS:jc = " \
 python3 \
 python3-jc \
 "
RDEPENDS:python3-jc = " \
 python3 \
 python3-pygments \
 python3-ruamel-yaml \
 python3-xmltodict \
 "
