# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-brotli"
PV = "8.0.2"
PR = "2.el10_2"
PACKAGES = " \
 rust-brotli+alloc-stdlib-devel \
 rust-brotli+billing-devel \
 rust-brotli+default-devel \
 rust-brotli+disable-timer-devel \
 rust-brotli+disallow_large_window_size-devel \
 rust-brotli+external-literal-probability-devel \
 rust-brotli+ffi-api-devel \
 rust-brotli+float64-devel \
 rust-brotli+floating_point_context_mixing-devel \
 rust-brotli+no-stdlib-ffi-binding-devel \
 rust-brotli+pass-through-ffi-panics-devel \
 rust-brotli+seccomp-devel \
 rust-brotli+sha2-devel \
 rust-brotli+simd-devel \
 rust-brotli+std-devel \
 rust-brotli+validation-devel \
 rust-brotli+vector_scratch_space-devel \
 rust-brotli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-brotli-8.0.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e450509d13914a5d6ebdfcf22f031b754d2435fbb3b0935821762d0d98ae6330"

URI_x86_64_v2_rust-brotli+alloc-stdlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+alloc-stdlib-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+alloc-stdlib-devel}"
SRC_URI[x86_64_v2_rust-brotli+alloc-stdlib-devel.sha256sum] = "ea999aeb2f6049da6e801a88745c03fc6afccc2f166aaaf7c7638090acb8b678"

URI_x86_64_v2_rust-brotli+billing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+billing-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+billing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+billing-devel}"
SRC_URI[x86_64_v2_rust-brotli+billing-devel.sha256sum] = "52b4954fdae4b09e0c00b93b08a720ba1d8bf1429c08b5c10d6e961edb9198d9"

URI_x86_64_v2_rust-brotli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+default-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+default-devel}"
SRC_URI[x86_64_v2_rust-brotli+default-devel.sha256sum] = "ba151d50b84de1f05602ac321ca3779aec1a85e507f64fbf12753b2bd98204e8"

URI_x86_64_v2_rust-brotli+disable-timer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+disable-timer-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+disable-timer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+disable-timer-devel}"
SRC_URI[x86_64_v2_rust-brotli+disable-timer-devel.sha256sum] = "1d75f66c668442af247275de94c50edc2f8a1f440e951790d85d38e669e8a838"

URI_x86_64_v2_rust-brotli+disallow_large_window_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+disallow_large_window_size-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+disallow_large_window_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+disallow_large_window_size-devel}"
SRC_URI[x86_64_v2_rust-brotli+disallow_large_window_size-devel.sha256sum] = "4b7b65883a5fa662c59945275fe32158d1f69a16cc1b57abf0043b36711dc4c3"

URI_x86_64_v2_rust-brotli+external-literal-probability-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+external-literal-probability-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+external-literal-probability-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+external-literal-probability-devel}"
SRC_URI[x86_64_v2_rust-brotli+external-literal-probability-devel.sha256sum] = "9b5fbb7b979e9615c57ecf9fff848c70eabc86c27e0873646db77f483d9dce70"

URI_x86_64_v2_rust-brotli+ffi-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+ffi-api-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+ffi-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+ffi-api-devel}"
SRC_URI[x86_64_v2_rust-brotli+ffi-api-devel.sha256sum] = "41aa154b6cf98ad2035c17681897d0066cbd4820adec78e99162f8668b0b95c7"

URI_x86_64_v2_rust-brotli+float64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+float64-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+float64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+float64-devel}"
SRC_URI[x86_64_v2_rust-brotli+float64-devel.sha256sum] = "a9d84750f894326b7435b1f34a4afb093fe4a668ac88ff0a0c4133c83f11f6dd"

URI_x86_64_v2_rust-brotli+floating_point_context_mixing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+floating_point_context_mixing-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+floating_point_context_mixing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+floating_point_context_mixing-devel}"
SRC_URI[x86_64_v2_rust-brotli+floating_point_context_mixing-devel.sha256sum] = "e2c8702b749727d7aba71e17ba09fa7abf832344caf29a94221db3e4329afe8a"

URI_x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+no-stdlib-ffi-binding-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel}"
SRC_URI[x86_64_v2_rust-brotli+no-stdlib-ffi-binding-devel.sha256sum] = "1135f46b9580e3bcb0d69bd8d25b7d5ee8142e44b07995a56974cc5b95cab9a7"

URI_x86_64_v2_rust-brotli+pass-through-ffi-panics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+pass-through-ffi-panics-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+pass-through-ffi-panics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+pass-through-ffi-panics-devel}"
SRC_URI[x86_64_v2_rust-brotli+pass-through-ffi-panics-devel.sha256sum] = "577a513d274c395018c4939254d7f641eb422e99a9bac3791525563b2f67617a"

URI_x86_64_v2_rust-brotli+seccomp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+seccomp-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+seccomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+seccomp-devel}"
SRC_URI[x86_64_v2_rust-brotli+seccomp-devel.sha256sum] = "0982a2902297ab2dfb6f969bfa36ee3006338574168d13a9772bbefce4ed9ecb"

URI_x86_64_v2_rust-brotli+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+sha2-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+sha2-devel}"
SRC_URI[x86_64_v2_rust-brotli+sha2-devel.sha256sum] = "02479b41121264e771e96bb9daa6d7a92436c6dffc8d670012d6976f871ad2e4"

URI_x86_64_v2_rust-brotli+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+simd-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+simd-devel}"
SRC_URI[x86_64_v2_rust-brotli+simd-devel.sha256sum] = "47722154d023aa7cefc1dcd7a86dd03ffa438762273d2991a1e521895c7b0f65"

URI_x86_64_v2_rust-brotli+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+std-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+std-devel}"
SRC_URI[x86_64_v2_rust-brotli+std-devel.sha256sum] = "9e81ff09b60ed7ce262612b414409dfd3814fff137e602b1e1c4a230f1e956d3"

URI_x86_64_v2_rust-brotli+validation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+validation-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+validation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+validation-devel}"
SRC_URI[x86_64_v2_rust-brotli+validation-devel.sha256sum] = "8d72bc9991d5722e7a8193e5bf1d80b6c0325b8ad6458d59beb9fe63468d9bfe"

URI_x86_64_v2_rust-brotli+vector_scratch_space-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli+vector_scratch_space-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli+vector_scratch_space-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli+vector_scratch_space-devel}"
SRC_URI[x86_64_v2_rust-brotli+vector_scratch_space-devel.sha256sum] = "9328d4b2a1342d90fa3d7005ba15d42d4fbbc9ca2cfc55dc41e6155007a1016f"

URI_x86_64_v2_rust-brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-devel-8.0.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-devel}"
SRC_URI[x86_64_v2_rust-brotli-devel.sha256sum] = "2acb5e2f811d856c9a55bd52f9a51ac2e1572a80a7e73f2b4e2ce3b1335e7316"

URI_aarch64_rust-brotli+alloc-stdlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+alloc-stdlib-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+alloc-stdlib-devel}"
SRC_URI[aarch64_rust-brotli+alloc-stdlib-devel.sha256sum] = "5c953efae840706f57376d8953f048eed27426cc9cb85d319e7e4518f48fb8d6"

URI_aarch64_rust-brotli+billing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+billing-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+billing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+billing-devel}"
SRC_URI[aarch64_rust-brotli+billing-devel.sha256sum] = "b9a9742c7eb5aa0154684e9515bd32b3823c2595fdc4398f10755d2c573e3a0d"

URI_aarch64_rust-brotli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+default-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+default-devel}"
SRC_URI[aarch64_rust-brotli+default-devel.sha256sum] = "eec76569a8c28ba6f2d141a930f52f9c618813f7b253885de4f6375f6ebcf38a"

URI_aarch64_rust-brotli+disable-timer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+disable-timer-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+disable-timer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+disable-timer-devel}"
SRC_URI[aarch64_rust-brotli+disable-timer-devel.sha256sum] = "ace566c71eab6ed9181e00334cc4d40eec28d74b7caa49eb0b1e9c7512ccffbe"

URI_aarch64_rust-brotli+disallow_large_window_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+disallow_large_window_size-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+disallow_large_window_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+disallow_large_window_size-devel}"
SRC_URI[aarch64_rust-brotli+disallow_large_window_size-devel.sha256sum] = "8cd568663eb13ccc0121d46ae7b3787601735d0672d870ce4bdc6d50715b6eb9"

URI_aarch64_rust-brotli+external-literal-probability-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+external-literal-probability-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+external-literal-probability-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+external-literal-probability-devel}"
SRC_URI[aarch64_rust-brotli+external-literal-probability-devel.sha256sum] = "258cc3a308ce1789d6d253075609159a994dcf7154f295e8c03f5716c1adc20f"

URI_aarch64_rust-brotli+ffi-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+ffi-api-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+ffi-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+ffi-api-devel}"
SRC_URI[aarch64_rust-brotli+ffi-api-devel.sha256sum] = "153db9393204945c5b152f38fcbb7025c796056c67726953a159cf78d348d531"

URI_aarch64_rust-brotli+float64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+float64-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+float64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+float64-devel}"
SRC_URI[aarch64_rust-brotli+float64-devel.sha256sum] = "2ec525584fdc261112f97b35236cc7ac51d24f47f6c29e1f78f1596e1dda2056"

URI_aarch64_rust-brotli+floating_point_context_mixing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+floating_point_context_mixing-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+floating_point_context_mixing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+floating_point_context_mixing-devel}"
SRC_URI[aarch64_rust-brotli+floating_point_context_mixing-devel.sha256sum] = "52c510b01b07f59ff2658bd7c1b90c73e2652dec4f29918ae16af73f88e1fc14"

URI_aarch64_rust-brotli+no-stdlib-ffi-binding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+no-stdlib-ffi-binding-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+no-stdlib-ffi-binding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+no-stdlib-ffi-binding-devel}"
SRC_URI[aarch64_rust-brotli+no-stdlib-ffi-binding-devel.sha256sum] = "a4d22a718ea88620a611037188a624a4fdd10d57c9f13e8961e67f3d86963fbd"

URI_aarch64_rust-brotli+pass-through-ffi-panics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+pass-through-ffi-panics-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+pass-through-ffi-panics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+pass-through-ffi-panics-devel}"
SRC_URI[aarch64_rust-brotli+pass-through-ffi-panics-devel.sha256sum] = "2e08cbbd8bd03499fff5eaabad5c587e4e3b929209fd6b3c373046a79b6f6b93"

URI_aarch64_rust-brotli+seccomp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+seccomp-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+seccomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+seccomp-devel}"
SRC_URI[aarch64_rust-brotli+seccomp-devel.sha256sum] = "236cdc453a89d37e92236d2fb5d96138be4ba04f80ff7a798aad8c7e819248b0"

URI_aarch64_rust-brotli+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+sha2-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+sha2-devel}"
SRC_URI[aarch64_rust-brotli+sha2-devel.sha256sum] = "6d00f3ba9441a0632ba930b1629eb19a3824ca1767b45b056b53b04d7e3ee961"

URI_aarch64_rust-brotli+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+simd-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+simd-devel}"
SRC_URI[aarch64_rust-brotli+simd-devel.sha256sum] = "48ffc3a29dd188c0e6a16e8edfa981f046c4489363b3fc9ab6cd9464f6ac6352"

URI_aarch64_rust-brotli+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+std-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+std-devel}"
SRC_URI[aarch64_rust-brotli+std-devel.sha256sum] = "c905522c5a23106605b4a588e530dacc76a03bec9ef65cb93e97ab595d35fbc5"

URI_aarch64_rust-brotli+validation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+validation-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+validation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+validation-devel}"
SRC_URI[aarch64_rust-brotli+validation-devel.sha256sum] = "af4ff3d98c33eb85b2c8faeedd2414ab6c5fb14e79b56a5d52275794d3261ead"

URI_aarch64_rust-brotli+vector_scratch_space-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli+vector_scratch_space-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli+vector_scratch_space-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli+vector_scratch_space-devel}"
SRC_URI[aarch64_rust-brotli+vector_scratch_space-devel.sha256sum] = "8c91edaeb5a58917ac4f0e2039aaf870c20d354306717129388263455619e0ed"

URI_aarch64_rust-brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-devel-8.0.2-2.el10_2.noarch.rpm;name=aarch64_rust-brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-devel}"
SRC_URI[aarch64_rust-brotli-devel.sha256sum] = "2fa52208e200a048a08a6b863cbf01db4c2d869340d6edffcc580169e0d3c91e"

RDEPENDS:rust-brotli+alloc-stdlib-devel = " \
 cargo \
 rust-alloc-stdlib+default-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+billing-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+default-devel = " \
 cargo \
 rust-brotli+std-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+disable-timer-devel = " \
 cargo \
 rust-brotli-decompressor+disable-timer-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+disallow_large_window_size-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+external-literal-probability-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+ffi-api-devel = " \
 cargo \
 rust-brotli-decompressor+ffi-api-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+float64-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+floating_point_context_mixing-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+no-stdlib-ffi-binding-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+pass-through-ffi-panics-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+seccomp-devel = " \
 cargo \
 rust-brotli-decompressor+seccomp-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+sha2-devel = " \
 cargo \
 rust-brotli-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-brotli+simd-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+std-devel = " \
 cargo \
 rust-brotli+alloc-stdlib-devel \
 rust-brotli-decompressor+std-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+validation-devel = " \
 cargo \
 rust-brotli+sha2-devel \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli+vector_scratch_space-devel = " \
 cargo \
 rust-brotli-devel \
 "
RDEPENDS:rust-brotli-devel = " \
 cargo \
 rust \
 rust-alloc-no-stdlib+default-devel \
 rust-brotli-decompressor-devel \
 "
