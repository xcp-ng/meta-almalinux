# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-markbates-safe"
PV = "1.0.1"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-markbates-safe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-markbates-safe-1.0.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27b68bdfd7b37f41b4b42991b1d871c783545b872f7be31e18d2913dc711cd39"

URI_x86_64_v2_golang-github-markbates-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-markbates-safe-devel-1.0.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-markbates-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-markbates-safe-devel}"
SRC_URI[x86_64_v2_golang-github-markbates-safe-devel.sha256sum] = "278efd742937869c826d7bfd645ede44e2ad905e922bec06e646eea572072225"

URI_aarch64_golang-github-markbates-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-markbates-safe-devel-1.0.1-12.el10_0.noarch.rpm;name=aarch64_golang-github-markbates-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-markbates-safe-devel}"
SRC_URI[aarch64_golang-github-markbates-safe-devel.sha256sum] = "c6a0084d20ee4b5644f1506f5a801e6f480e7b7ae8cb8121ecba5ca005115541"

RDEPENDS:golang-github-markbates-safe-devel = " \
 go-filesystem \
 "
