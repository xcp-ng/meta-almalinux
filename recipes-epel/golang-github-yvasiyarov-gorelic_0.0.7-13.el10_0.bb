# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-yvasiyarov-gorelic"
PV = "0.0.7"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-yvasiyarov-gorelic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-yvasiyarov-gorelic-0.0.7-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16ab84d9c37eef132539ee47990e8127d786bf501d1872f59c9f133f04c778c1"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-yvasiyarov-gorelic-devel: golang(github.com/yvasiyarov/go-metrics)
# - golang-github-yvasiyarov-gorelic-devel: golang(github.com/yvasiyarov/newrelic_platform_go)

URI_x86_64_v2_golang-github-yvasiyarov-gorelic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-yvasiyarov-gorelic-devel-0.0.7-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-yvasiyarov-gorelic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-yvasiyarov-gorelic-devel}"
SRC_URI[x86_64_v2_golang-github-yvasiyarov-gorelic-devel.sha256sum] = "808d90ad614dea1f1258b47726a78fe1268e23245cba6c944ac965c6aeafa9d3"

URI_aarch64_golang-github-yvasiyarov-gorelic-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-yvasiyarov-gorelic-devel-0.0.7-13.el10_0.noarch.rpm;name=aarch64_golang-github-yvasiyarov-gorelic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-yvasiyarov-gorelic-devel}"
SRC_URI[aarch64_golang-github-yvasiyarov-gorelic-devel.sha256sum] = "8677f3ce95f14287031e9d7e4e7cf0c3e75ca742c38d68957f293b32f786c28f"

RDEPENDS:golang-github-yvasiyarov-gorelic-devel:x86_64_v2 = " \
 go-filesystem \
"
RDEPENDS:golang-github-yvasiyarov-gorelic-devel:aarch64 = " \
 go-filesystem \
 golang-github-yvasiyarov-metrics-devel \
 golang-github-yvasiyarov-newrelic-platform-devel \
"
