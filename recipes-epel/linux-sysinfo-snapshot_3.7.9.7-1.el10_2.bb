# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linux-sysinfo-snapshot"
PV = "3.7.9.7"
PR = "1.el10_2"
PACKAGES = " \
 linux-sysinfo-snapshot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/linux-sysinfo-snapshot-3.7.9.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ba0c95011cb7dfc683d261527fbdde13746f74a8c0da31253be6db9c4e81427"

URI_x86_64_v2_linux-sysinfo-snapshot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/linux-sysinfo-snapshot-3.7.9.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_linux-sysinfo-snapshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linux-sysinfo-snapshot}"
SRC_URI[x86_64_v2_linux-sysinfo-snapshot.sha256sum] = "997ac5e40d6710f38365c3d66b759d3a96b17db4be8e68d52d2256b82e8790ea"

URI_aarch64_linux-sysinfo-snapshot = "${EPEL_MIRROR}/aarch64/Packages/l/linux-sysinfo-snapshot-3.7.9.7-1.el10_2.noarch.rpm;name=aarch64_linux-sysinfo-snapshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_linux-sysinfo-snapshot}"
SRC_URI[aarch64_linux-sysinfo-snapshot.sha256sum] = "a9e6abd05ead98f7360ceee74dea1acbb1c63f8c51c02086ddd54332e7f5338b"

RDEPENDS:linux-sysinfo-snapshot = " \
 python3 \
 python3-setuptools \
 "
