# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "palapeli"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 palapeli \
 palapeli-devel \
 palapeli-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/palapeli-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "59ddb0125c60831557f611814dae75cf4a7096ff4d6357cc278d299408f8c0bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli;unpack=0"
SRC_URI[x86_64_v2_palapeli.sha256sum] = "d45cfb28ad1593b3bf58fe8775d04fd10f4c69979cbfc3c3f94ccab17219b86f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli-devel;unpack=0"
SRC_URI[x86_64_v2_palapeli-devel.sha256sum] = "1342123e6fb768a511138bc8cd31fe9ee2f8478552617f4bcc24ba442f67b6fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli-libs;unpack=0"
SRC_URI[x86_64_v2_palapeli-libs.sha256sum] = "2475cf79b527a14e49717bcefe9deb57577c1d141bf6bdd36ecfb3c1d9f974c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/palapeli-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_palapeli;unpack=0"
SRC_URI[aarch64_palapeli.sha256sum] = "81f21203fffc80326abd7b3cbc7dace997eb4d7341225c1de3fa8de148a009e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/palapeli-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_palapeli-devel;unpack=0"
SRC_URI[aarch64_palapeli-devel.sha256sum] = "142e4acc57ca0c8efb9a9398c063cc7c1c20ad1e19e0213ebc7f2b26c14458b8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/palapeli-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_palapeli-libs;unpack=0"
SRC_URI[aarch64_palapeli-libs.sha256sum] = "7d9f61ff08483a494c275e108909652e8cf033ade4260ea4b3479e4c9726bc59"

RDEPENDS:palapeli = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 palapeli-libs \
 qhull \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:palapeli-devel = " \
 cmake-filesystem \
 palapeli-libs \
 "
RDEPENDS:palapeli-libs = " \
 glibc \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 libstdc++ \
 palapeli \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
