# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plutovg"
PV = "1.3.3"
PR = "1.el10_3"
PACKAGES = " \
 plutovg \
 plutovg-devel \
 plutovg-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plutovg-1.3.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac75eeef7abab4e87c97737e2964942d39d61900081326a3dc8ac5417536e0f9"

URI_x86_64_v2_plutovg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-1.3.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg}"
SRC_URI[x86_64_v2_plutovg.sha256sum] = "3a351e584313f71970b982a01606c82fbf88a40a32eb3dd21fe1be1ecf8a3e5c"

URI_x86_64_v2_plutovg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-devel-1.3.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg-devel}"
SRC_URI[x86_64_v2_plutovg-devel.sha256sum] = "db1888eef427070e649cccf3ade67f93b165e0d5c35c1b2c9507b419d07f7d5c"

URI_x86_64_v2_plutovg-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-samples-1.3.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg-samples}"
SRC_URI[x86_64_v2_plutovg-samples.sha256sum] = "fd8782ecae08e4ace4cda781a600f0b6c0b76658a2d8a391cb1ec0c7777af7cf"

URI_aarch64_plutovg = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-1.3.3-1.el10_3.aarch64.rpm;name=aarch64_plutovg;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg}"
SRC_URI[aarch64_plutovg.sha256sum] = "6f3af263f752c1dcbbb401fa6d4106f94df052358275041fee54cf7f1a3abf2e"

URI_aarch64_plutovg-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-devel-1.3.3-1.el10_3.aarch64.rpm;name=aarch64_plutovg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg-devel}"
SRC_URI[aarch64_plutovg-devel.sha256sum] = "1103975500b877338aa3d489ae73ddb8f076ed99a4bbc9e3b2294ea7bbd20853"

URI_aarch64_plutovg-samples = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-samples-1.3.3-1.el10_3.aarch64.rpm;name=aarch64_plutovg-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg-samples}"
SRC_URI[aarch64_plutovg-samples.sha256sum] = "2951dd66461776229b1a97eb66a4c9b1f4d9f4c383b6cba794a682584dfb4464"

RDEPENDS:plutovg = " \
 glibc \
 "
RDEPENDS:plutovg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plutovg \
 "
RDEPENDS:plutovg-samples = " \
 glibc \
 plutovg \
 "
