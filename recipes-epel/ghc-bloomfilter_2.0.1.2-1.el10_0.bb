# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-bloomfilter"
PV = "2.0.1.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-bloomfilter \
 ghc-bloomfilter-devel \
 ghc-bloomfilter-doc \
 ghc-bloomfilter-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-bloomfilter-2.0.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf6b4825645f189393f2cbb94c2bdb0b7f45c18e4f700207a6702fe404aaabc1"

URI_x86_64_v2_ghc-bloomfilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bloomfilter-2.0.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bloomfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bloomfilter}"
SRC_URI[x86_64_v2_ghc-bloomfilter.sha256sum] = "0fc8a1b419226cea7f06caa0eb7968d678de87e49a92ec185b1d3599dbf8a254"

URI_x86_64_v2_ghc-bloomfilter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bloomfilter-devel-2.0.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bloomfilter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bloomfilter-devel}"
SRC_URI[x86_64_v2_ghc-bloomfilter-devel.sha256sum] = "9ed00dce1c5cd034c7ee57c88d2c07a921b10a7fa8e70c5b41afffa568b14b29"

URI_x86_64_v2_ghc-bloomfilter-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bloomfilter-doc-2.0.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-bloomfilter-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bloomfilter-doc}"
SRC_URI[x86_64_v2_ghc-bloomfilter-doc.sha256sum] = "307c04eae59c351ad0046fa1e1a04a5fd512fac50aa2dc5d2edda1503b7c84b5"

URI_x86_64_v2_ghc-bloomfilter-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bloomfilter-prof-2.0.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bloomfilter-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bloomfilter-prof}"
SRC_URI[x86_64_v2_ghc-bloomfilter-prof.sha256sum] = "bade04a1ac0e5287dd942cb399dcd734bf251bd5ff02aadc915d01e7d436f10f"

URI_aarch64_ghc-bloomfilter = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bloomfilter-2.0.1.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-bloomfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bloomfilter}"
SRC_URI[aarch64_ghc-bloomfilter.sha256sum] = "cb26b3ba709eeed293ef69f9b75f0a790ac165b401a5fcbe0f29a902ad086f74"

URI_aarch64_ghc-bloomfilter-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bloomfilter-devel-2.0.1.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-bloomfilter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bloomfilter-devel}"
SRC_URI[aarch64_ghc-bloomfilter-devel.sha256sum] = "2390510322da39251a8e0d7bc87cb276e1b8d62e9b18cdc9fe07484de7d33d0c"

URI_aarch64_ghc-bloomfilter-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bloomfilter-doc-2.0.1.2-1.el10_0.noarch.rpm;name=aarch64_ghc-bloomfilter-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bloomfilter-doc}"
SRC_URI[aarch64_ghc-bloomfilter-doc.sha256sum] = "094c2e065fceb3db62868d8f9b689b04d7f79a3326e49bc6572d443a509990b1"

URI_aarch64_ghc-bloomfilter-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bloomfilter-prof-2.0.1.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-bloomfilter-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bloomfilter-prof}"
SRC_URI[aarch64_ghc-bloomfilter-prof.sha256sum] = "4cf3b31d12388e813d99b6aa35d3bf6bc1c94a7b4e3243e74ca9b5d13a4243e3"

RDEPENDS:ghc-bloomfilter = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-bloomfilter-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bloomfilter \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 "
RDEPENDS:ghc-bloomfilter-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-bloomfilter-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bloomfilter-devel \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 "
