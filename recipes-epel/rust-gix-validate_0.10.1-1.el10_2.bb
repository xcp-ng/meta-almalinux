# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-validate"
PV = "0.10.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-validate+default-devel \
 rust-gix-validate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-validate-0.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19a21f9dcb7e27c34f29eddde495737340973293269a4ea8361c25689d1d7196"

URI_x86_64_v2_rust-gix-validate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-validate+default-devel-0.10.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-validate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-validate+default-devel}"
SRC_URI[x86_64_v2_rust-gix-validate+default-devel.sha256sum] = "c8529621a4997d02f81d877f881087e8647c54ba9931f65922c7cdf7ccfd7c10"

URI_x86_64_v2_rust-gix-validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-validate-devel-0.10.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-validate-devel}"
SRC_URI[x86_64_v2_rust-gix-validate-devel.sha256sum] = "5c82920edb975c06982281f75246852e6eb0f4d6456db39d114b2a97ac7fee2e"

URI_aarch64_rust-gix-validate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-validate+default-devel-0.10.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-validate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-validate+default-devel}"
SRC_URI[aarch64_rust-gix-validate+default-devel.sha256sum] = "2a31935e4d5e1a0787a78360481287740d0cab890125872b781213ca92696e80"

URI_aarch64_rust-gix-validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-validate-devel-0.10.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-validate-devel}"
SRC_URI[aarch64_rust-gix-validate-devel.sha256sum] = "eac818400153d72ba1712a0e4d9d3989a19233f5adc9950b645a7c8e7fd59997"

RDEPENDS:rust-gix-validate+default-devel = " \
 cargo \
 rust-gix-validate-devel \
 "
RDEPENDS:rust-gix-validate-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-thiserror+default-devel \
 "
