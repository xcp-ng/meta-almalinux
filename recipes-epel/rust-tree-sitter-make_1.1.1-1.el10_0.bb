# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-make"
PV = "1.1.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-make+default-devel \
 rust-tree-sitter-make-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-make-1.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30104ebf5b700bfe393174765775870a9a9b91817dc8c225267b8ba7207c2a6b"

URI_x86_64_v2_rust-tree-sitter-make+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-make+default-devel-1.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-make+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-make+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-make+default-devel.sha256sum] = "25d5c8c8e4b60210c45fc0a58895c19b1d2d30243adefa0e2394e4eaa798d1e6"

URI_x86_64_v2_rust-tree-sitter-make-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-make-devel-1.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-make-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-make-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-make-devel.sha256sum] = "fbce6caa9987b064a256b9caac7fa9f967e2c20032a1eb05d664deb356b40d05"

URI_aarch64_rust-tree-sitter-make+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-make+default-devel-1.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-make+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-make+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-make+default-devel.sha256sum] = "68e6c76d02fbfe5ac0aff792886abf052280a68b95337aa0fb3af1c6aa15fb31"

URI_aarch64_rust-tree-sitter-make-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-make-devel-1.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-make-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-make-devel}"
SRC_URI[aarch64_rust-tree-sitter-make-devel.sha256sum] = "a62f3f89323a35288d62d457f4fd759d03b2625550249b1b525b52e0d3b10786"

RDEPENDS:rust-tree-sitter-make+default-devel = " \
 cargo \
 rust-tree-sitter-make-devel \
 "
RDEPENDS:rust-tree-sitter-make-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
