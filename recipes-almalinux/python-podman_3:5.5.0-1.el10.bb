# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-podman"
PE = "3"
PV = "5.5.0"
PR = "1.el10"
PACKAGES = " \
 python3-podman \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-podman-5.5.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eec31bedb30c4a2a01a3b7bd9be1c5d3917123080269630ecb28d9be2fc2cbf2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-podman-5.5.0-1.el10.noarch.rpm;name=x86_64_v2_python3-podman;unpack=0"
SRC_URI[x86_64_v2_python3-podman.sha256sum] = "7d5589898c718d4da5c232179d31b8d8ebf6a71c8419c484a57399fd00c7c9b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-podman-5.5.0-1.el10.noarch.rpm;name=aarch64_python3-podman;unpack=0"
SRC_URI[aarch64_python3-podman.sha256sum] = "7d5589898c718d4da5c232179d31b8d8ebf6a71c8419c484a57399fd00c7c9b0"

RDEPENDS:python3-podman = " \
 python3 \
 python3-requests \
 python3-urllib3 \
 "
