# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sub-Install"
PV = "0.929"
PR = "8.el10"
PACKAGES = " \
 perl-Sub-Install \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Sub-Install-0.929-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a63fe870fc1b3f428623eb616035862308489e106bd5a360a1e6fef51f7fa7cf"

URI_x86_64_v2_perl-Sub-Install = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sub-Install-0.929-8.el10.noarch.rpm;name=x86_64_v2_perl-Sub-Install;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sub-Install}"
SRC_URI[x86_64_v2_perl-Sub-Install.sha256sum] = "92cb80f1f0a99a083dfa317fc12b0af726536ae91a0f07a11d4ac62b760d81d7"

URI_aarch64_perl-Sub-Install = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sub-Install-0.929-8.el10.noarch.rpm;name=aarch64_perl-Sub-Install;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sub-Install}"
SRC_URI[aarch64_perl-Sub-Install.sha256sum] = "92cb80f1f0a99a083dfa317fc12b0af726536ae91a0f07a11d4ac62b760d81d7"

RDEPENDS:perl-Sub-Install = " \
 perl-B \
 perl-Carp \
 perl-Scalar-List-Utils \
 perl-libs \
 "
