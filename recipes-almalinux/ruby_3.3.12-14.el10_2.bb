# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby"
PV = "3.3.12"
PR = "14.el10_2"
PACKAGES = " \
 ruby \
 ruby-bundled-gems \
 ruby-default-gems \
 ruby-devel \
 ruby-doc \
 ruby-libs \
 rubygem-bigdecimal \
 rubygem-bundler \
 rubygem-io-console \
 rubygem-irb \
 rubygem-json \
 rubygem-minitest \
 rubygem-power_assert \
 rubygem-psych \
 rubygem-racc \
 rubygem-rake \
 rubygem-rbs \
 rubygem-rdoc \
 rubygem-rexml \
 rubygem-rss \
 rubygem-test-unit \
 rubygem-typeprof \
 rubygems \
 rubygems-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ruby-3.3.12-14.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d7e166133649eb39613e515a5f1abdb895e7362572711304d724eb1ec5780d1"

URI_x86_64_v2_ruby = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-3.3.12-14.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby}"
SRC_URI[x86_64_v2_ruby.sha256sum] = "f85dfdd847953dac5888af46e7792fba7280a0d6dd0921fa699f0df48d350d1c"
RPROVIDES:ruby:x86_64_v2 = "virtual/ruby_runtime_executable_"

URI_x86_64_v2_ruby-bundled-gems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-bundled-gems-3.3.12-14.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby-bundled-gems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-bundled-gems}"
SRC_URI[x86_64_v2_ruby-bundled-gems.sha256sum] = "6e109e206e550dd9ff7807bb3404bf90b537fd5bad8a50998432061508fbd831"

URI_x86_64_v2_ruby-default-gems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-default-gems-3.3.12-14.el10_2.noarch.rpm;name=x86_64_v2_ruby-default-gems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-default-gems}"
SRC_URI[x86_64_v2_ruby-default-gems.sha256sum] = "eee30784ab9187664bab88713a780f0e03173777cb24eeeb2c65f08854146ff3"

URI_x86_64_v2_ruby-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-devel-3.3.12-14.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-devel}"
SRC_URI[x86_64_v2_ruby-devel.sha256sum] = "47980db71852fed638b9cd1515bc6f3fbc8e989462f2f69670a8842fd50719c9"

URI_x86_64_v2_ruby-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ruby-doc-3.3.12-14.el10_2.noarch.rpm;name=x86_64_v2_ruby-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-doc}"
SRC_URI[x86_64_v2_ruby-doc.sha256sum] = "46022b511c83726e5919b500b33fbd6b00f36fe7ff04e742c7028b628cca38ae"

URI_x86_64_v2_ruby-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-libs-3.3.12-14.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-libs}"
SRC_URI[x86_64_v2_ruby-libs.sha256sum] = "2010295485270fd215005d1dddcac95323585facb84bffb4e011f278264835df"
RPROVIDES:ruby-libs:x86_64_v2 = "virtual/ruby_release_"

URI_x86_64_v2_rubygem-bigdecimal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bigdecimal-3.1.5-14.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-bigdecimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-bigdecimal}"
SRC_URI[x86_64_v2_rubygem-bigdecimal.sha256sum] = "6311672a5b9447f4c17c6a5635287551823f1890c15b6905ca54ddb2674ce38c"

URI_x86_64_v2_rubygem-bundler = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bundler-2.5.22-14.el10_2.noarch.rpm;name=x86_64_v2_rubygem-bundler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-bundler}"
SRC_URI[x86_64_v2_rubygem-bundler.sha256sum] = "2351acfc5df3fcc5dde89c2945b1b2c2f82584566adf5020e0254e7f592cfebb"

URI_x86_64_v2_rubygem-io-console = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-io-console-0.7.1-14.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-io-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-io-console}"
SRC_URI[x86_64_v2_rubygem-io-console.sha256sum] = "137fa0a182b1900d33b6c734c5def84270d78f629e40e65d4fb47aa303d4c370"

URI_x86_64_v2_rubygem-irb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-irb-1.13.1-14.el10_2.noarch.rpm;name=x86_64_v2_rubygem-irb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-irb}"
SRC_URI[x86_64_v2_rubygem-irb.sha256sum] = "46613819af1fb9478b0e629651c46aa11e4464bb5c9cffee7e759d6786dec0bc"

URI_x86_64_v2_rubygem-json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-json-2.7.2-14.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-json}"
SRC_URI[x86_64_v2_rubygem-json.sha256sum] = "6c64371376327c01106006211ccb1316b5e79a37160dba2064e963c4a5f39657"

URI_x86_64_v2_rubygem-minitest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-minitest-5.20.0-14.el10_2.noarch.rpm;name=x86_64_v2_rubygem-minitest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-minitest}"
SRC_URI[x86_64_v2_rubygem-minitest.sha256sum] = "21c1889fe2fe8b665fd8d07927f509fe6feeaf78754ab805c15679497e55be47"

URI_x86_64_v2_rubygem-power_assert = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-power_assert-2.0.3-14.el10_2.noarch.rpm;name=x86_64_v2_rubygem-power_assert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-power_assert}"
SRC_URI[x86_64_v2_rubygem-power_assert.sha256sum] = "f635633eb2dfd48b67a65aa9e6a82eadfada6bc616d85081cdf4cc5bf73f08e4"

URI_x86_64_v2_rubygem-psych = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-psych-5.1.2-14.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-psych;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-psych}"
SRC_URI[x86_64_v2_rubygem-psych.sha256sum] = "c6f96228f6ebaa15b283d1f7d99012d7cb3555ea44c0f3909b946edfeb74d124"

URI_x86_64_v2_rubygem-racc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-racc-1.7.3-14.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-racc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-racc}"
SRC_URI[x86_64_v2_rubygem-racc.sha256sum] = "131c232c13a126d1ddbc9ae1d25c53a11ceb7701ce8b066eefe997d5d7f8cb62"

URI_x86_64_v2_rubygem-rake = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rake-13.1.0-14.el10_2.noarch.rpm;name=x86_64_v2_rubygem-rake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rake}"
SRC_URI[x86_64_v2_rubygem-rake.sha256sum] = "c53bb678682a61e82cacd04f0a3d4f33c0e1d8dcad90c1eefd2d5de20caafebf"

URI_x86_64_v2_rubygem-rbs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rbs-3.4.0-14.el10_2.x86_64_v2.rpm;name=x86_64_v2_rubygem-rbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rbs}"
SRC_URI[x86_64_v2_rubygem-rbs.sha256sum] = "eca11b6ecde07dae2684281fa95fff07eb72b65df2376ac6c814c860a5cba783"

URI_x86_64_v2_rubygem-rdoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rdoc-6.6.3.1-14.el10_2.noarch.rpm;name=x86_64_v2_rubygem-rdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rdoc}"
SRC_URI[x86_64_v2_rubygem-rdoc.sha256sum] = "5c00d2550ead68020d3187766315cf476e673c256a3075d89c40e6868434b24e"

URI_x86_64_v2_rubygem-rexml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rexml-3.4.4-14.el10_2.noarch.rpm;name=x86_64_v2_rubygem-rexml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rexml}"
SRC_URI[x86_64_v2_rubygem-rexml.sha256sum] = "797e9b5def067ed1b4a076e585bd427d2faa3fa20db74f61c349ce54a17001bc"

URI_x86_64_v2_rubygem-rss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rss-0.3.1-14.el10_2.noarch.rpm;name=x86_64_v2_rubygem-rss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rss}"
SRC_URI[x86_64_v2_rubygem-rss.sha256sum] = "edcf8a577a06115a59a8a5e4d7f017b389372a4f7da251061524db691c1b5132"

URI_x86_64_v2_rubygem-test-unit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-test-unit-3.6.1-14.el10_2.noarch.rpm;name=x86_64_v2_rubygem-test-unit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-test-unit}"
SRC_URI[x86_64_v2_rubygem-test-unit.sha256sum] = "131dd8cdd912467ba1f8827ee2132e59e97772a0a19a34d30dd7839e793b2109"

URI_x86_64_v2_rubygem-typeprof = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-typeprof-0.21.9-14.el10_2.noarch.rpm;name=x86_64_v2_rubygem-typeprof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-typeprof}"
SRC_URI[x86_64_v2_rubygem-typeprof.sha256sum] = "f76ebecc0e4d4bec6ed47f476de014cea992d3b11812f607afaed01950bc5dc6"

URI_x86_64_v2_rubygems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-3.5.22-14.el10_2.noarch.rpm;name=x86_64_v2_rubygems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygems}"
SRC_URI[x86_64_v2_rubygems.sha256sum] = "e614c319dddb353036831b3163c6c76c806a302b2d1b420f110dc3ac9779a8bd"

URI_x86_64_v2_rubygems-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-devel-3.5.22-14.el10_2.noarch.rpm;name=x86_64_v2_rubygems-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygems-devel}"
SRC_URI[x86_64_v2_rubygems-devel.sha256sum] = "7e994cc7820f22d4c3173560806e49845622523b1b6813aaaf17a3274d4dd035"

URI_aarch64_ruby = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-3.3.12-14.el10_2.aarch64.rpm;name=aarch64_ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby}"
SRC_URI[aarch64_ruby.sha256sum] = "e5742df930b4ad2f82e486d95b22b32d5bf748162fa1346f0a24e65350425a61"
RPROVIDES:ruby:aarch64 = "virtual/ruby_runtime_executable_"

URI_aarch64_ruby-bundled-gems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-bundled-gems-3.3.12-14.el10_2.aarch64.rpm;name=aarch64_ruby-bundled-gems;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-bundled-gems}"
SRC_URI[aarch64_ruby-bundled-gems.sha256sum] = "7a524b905c38fd5a289f8af66b1b0086ede1f57aae4c448daeb0d6306e1baa31"

URI_aarch64_ruby-default-gems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-default-gems-3.3.12-14.el10_2.noarch.rpm;name=aarch64_ruby-default-gems;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-default-gems}"
SRC_URI[aarch64_ruby-default-gems.sha256sum] = "eee30784ab9187664bab88713a780f0e03173777cb24eeeb2c65f08854146ff3"

URI_aarch64_ruby-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-devel-3.3.12-14.el10_2.aarch64.rpm;name=aarch64_ruby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-devel}"
SRC_URI[aarch64_ruby-devel.sha256sum] = "2e8d983d8628bb3decb8643d60a372b9f2da6f852c18474be95e85e31be260ad"

URI_aarch64_ruby-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ruby-doc-3.3.12-14.el10_2.noarch.rpm;name=aarch64_ruby-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-doc}"
SRC_URI[aarch64_ruby-doc.sha256sum] = "46022b511c83726e5919b500b33fbd6b00f36fe7ff04e742c7028b628cca38ae"

URI_aarch64_ruby-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-libs-3.3.12-14.el10_2.aarch64.rpm;name=aarch64_ruby-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-libs}"
SRC_URI[aarch64_ruby-libs.sha256sum] = "5d6f80313b596034e72a04e72c5edac4b4a0fc18041f14bde28395cd941ad07c"
RPROVIDES:ruby-libs:aarch64 = "virtual/ruby_release_"

URI_aarch64_rubygem-bigdecimal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bigdecimal-3.1.5-14.el10_2.aarch64.rpm;name=aarch64_rubygem-bigdecimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-bigdecimal}"
SRC_URI[aarch64_rubygem-bigdecimal.sha256sum] = "cbe8af53c49fb94ac46df121fc179adcac39a786af30fa504845a429ef464f68"

URI_aarch64_rubygem-bundler = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bundler-2.5.22-14.el10_2.noarch.rpm;name=aarch64_rubygem-bundler;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-bundler}"
SRC_URI[aarch64_rubygem-bundler.sha256sum] = "2351acfc5df3fcc5dde89c2945b1b2c2f82584566adf5020e0254e7f592cfebb"

URI_aarch64_rubygem-io-console = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-io-console-0.7.1-14.el10_2.aarch64.rpm;name=aarch64_rubygem-io-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-io-console}"
SRC_URI[aarch64_rubygem-io-console.sha256sum] = "1b2870e1012747ad23e7225b2d5c7967dc664b7b09e6e8c0c19d24a40c0919d9"

URI_aarch64_rubygem-irb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-irb-1.13.1-14.el10_2.noarch.rpm;name=aarch64_rubygem-irb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-irb}"
SRC_URI[aarch64_rubygem-irb.sha256sum] = "46613819af1fb9478b0e629651c46aa11e4464bb5c9cffee7e759d6786dec0bc"

URI_aarch64_rubygem-json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-json-2.7.2-14.el10_2.aarch64.rpm;name=aarch64_rubygem-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-json}"
SRC_URI[aarch64_rubygem-json.sha256sum] = "bc0118992ed9e041f6ba673cf0e2d4d62628bbd7540e18b60574693bf2f9b8eb"

URI_aarch64_rubygem-minitest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-minitest-5.20.0-14.el10_2.noarch.rpm;name=aarch64_rubygem-minitest;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-minitest}"
SRC_URI[aarch64_rubygem-minitest.sha256sum] = "21c1889fe2fe8b665fd8d07927f509fe6feeaf78754ab805c15679497e55be47"

URI_aarch64_rubygem-power_assert = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-power_assert-2.0.3-14.el10_2.noarch.rpm;name=aarch64_rubygem-power_assert;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-power_assert}"
SRC_URI[aarch64_rubygem-power_assert.sha256sum] = "f635633eb2dfd48b67a65aa9e6a82eadfada6bc616d85081cdf4cc5bf73f08e4"

URI_aarch64_rubygem-psych = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-psych-5.1.2-14.el10_2.aarch64.rpm;name=aarch64_rubygem-psych;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-psych}"
SRC_URI[aarch64_rubygem-psych.sha256sum] = "62197da2801406cd61424f7924d5e70c5f7a296d6096f274b640a7aee2b90f58"

URI_aarch64_rubygem-racc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-racc-1.7.3-14.el10_2.aarch64.rpm;name=aarch64_rubygem-racc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-racc}"
SRC_URI[aarch64_rubygem-racc.sha256sum] = "41727182d679ce3b192d2f40e3b114033828f2f3dbf551b6c587608436af7a70"

URI_aarch64_rubygem-rake = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rake-13.1.0-14.el10_2.noarch.rpm;name=aarch64_rubygem-rake;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rake}"
SRC_URI[aarch64_rubygem-rake.sha256sum] = "c53bb678682a61e82cacd04f0a3d4f33c0e1d8dcad90c1eefd2d5de20caafebf"

URI_aarch64_rubygem-rbs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rbs-3.4.0-14.el10_2.aarch64.rpm;name=aarch64_rubygem-rbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rbs}"
SRC_URI[aarch64_rubygem-rbs.sha256sum] = "c196de80a63e0cb4c12c1372f22dcc3d84669865da0a36d6d3297936043fb323"

URI_aarch64_rubygem-rdoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rdoc-6.6.3.1-14.el10_2.noarch.rpm;name=aarch64_rubygem-rdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rdoc}"
SRC_URI[aarch64_rubygem-rdoc.sha256sum] = "5c00d2550ead68020d3187766315cf476e673c256a3075d89c40e6868434b24e"

URI_aarch64_rubygem-rexml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rexml-3.4.4-14.el10_2.noarch.rpm;name=aarch64_rubygem-rexml;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rexml}"
SRC_URI[aarch64_rubygem-rexml.sha256sum] = "797e9b5def067ed1b4a076e585bd427d2faa3fa20db74f61c349ce54a17001bc"

URI_aarch64_rubygem-rss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rss-0.3.1-14.el10_2.noarch.rpm;name=aarch64_rubygem-rss;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rss}"
SRC_URI[aarch64_rubygem-rss.sha256sum] = "edcf8a577a06115a59a8a5e4d7f017b389372a4f7da251061524db691c1b5132"

URI_aarch64_rubygem-test-unit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-test-unit-3.6.1-14.el10_2.noarch.rpm;name=aarch64_rubygem-test-unit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-test-unit}"
SRC_URI[aarch64_rubygem-test-unit.sha256sum] = "131dd8cdd912467ba1f8827ee2132e59e97772a0a19a34d30dd7839e793b2109"

URI_aarch64_rubygem-typeprof = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-typeprof-0.21.9-14.el10_2.noarch.rpm;name=aarch64_rubygem-typeprof;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-typeprof}"
SRC_URI[aarch64_rubygem-typeprof.sha256sum] = "f76ebecc0e4d4bec6ed47f476de014cea992d3b11812f607afaed01950bc5dc6"

URI_aarch64_rubygems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-3.5.22-14.el10_2.noarch.rpm;name=aarch64_rubygems;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygems}"
SRC_URI[aarch64_rubygems.sha256sum] = "e614c319dddb353036831b3163c6c76c806a302b2d1b420f110dc3ac9779a8bd"

URI_aarch64_rubygems-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-devel-3.5.22-14.el10_2.noarch.rpm;name=aarch64_rubygems-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygems-devel}"
SRC_URI[aarch64_rubygems-devel.sha256sum] = "7e994cc7820f22d4c3173560806e49845622523b1b6813aaaf17a3274d4dd035"

RDEPENDS:ruby = " \
 glibc \
 gmp \
 libxcrypt \
 ruby-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby-bundled-gems = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygem-irb \
 rubygems \
 "
RDEPENDS:ruby-default-gems = " \
 ruby \
 ruby-default-gems \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:ruby-devel = " \
 pkgconf-pkg-config \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:ruby-doc = " \
 rubygem-rdoc \
 "
RDEPENDS:ruby-libs = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:rubygem-bigdecimal = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-bundler = " \
 ruby \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:rubygem-io-console = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-irb = " \
 ruby \
 ruby-default-gems \
 rubygem-rdoc \
 rubygems \
 "
RDEPENDS:rubygem-json = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-minitest = " \
 rubygems \
 "
RDEPENDS:rubygem-power_assert = " \
 rubygems \
 "
RDEPENDS:rubygem-psych = " \
 glibc \
 libyaml \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-racc = " \
 glibc \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rake = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-rbs = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rdoc = " \
 ruby \
 rubygem-io-console \
 rubygem-json \
 rubygem-psych \
 rubygems \
 "
RDEPENDS:rubygem-rexml = " \
 rubygems \
 "
RDEPENDS:rubygem-rss = " \
 rubygem-rexml \
 rubygems \
 "
RDEPENDS:rubygem-test-unit = " \
 rubygem-power_assert \
 rubygems \
 "
RDEPENDS:rubygem-typeprof = " \
 ruby \
 rubygem-rbs \
 rubygems \
 "
RDEPENDS:rubygems = " \
 ruby \
 rubygem-psych \
 virtual/ruby_release_ \
 "
RDEPENDS:rubygems-devel = " \
 ruby \
 rubygem-json \
 rubygem-rdoc \
 rubygems \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/ruby_release_ rpm/virtual/ruby_runtime_executable_"

PROVIDES:append:aarch64 = " rpm/virtual/ruby_release_ rpm/virtual/ruby_runtime_executable_"
