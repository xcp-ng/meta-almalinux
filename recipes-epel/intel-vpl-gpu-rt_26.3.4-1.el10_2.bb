# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-vpl-gpu-rt"
PV = "26.3.4"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 intel-vpl-gpu-rt \
 intel-vpl-gpu-rt-devel \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/intel-vpl-gpu-rt-26.3.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f4f2821b274c156f4dace47cd779bf66bef726f3d5808384be1fb96ed0f7a34e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-vpl-gpu-rt-26.3.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-vpl-gpu-rt;unpack=0"
SRC_URI[x86_64_v2_intel-vpl-gpu-rt.sha256sum] = "8c1237388c60f0511f9a3a03b6afcb291c7bb1ca53e55464d55b46a8a14c38a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-vpl-gpu-rt-devel-26.3.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-vpl-gpu-rt-devel;unpack=0"
SRC_URI[x86_64_v2_intel-vpl-gpu-rt-devel.sha256sum] = "0f63f848a3091c0e32a757310d700e2bc016af9fb18cae813725bbf05853a4e1"

RDEPENDS:intel-vpl-gpu-rt = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libva \
 libvpl \
 "
RDEPENDS:intel-vpl-gpu-rt-devel = " \
 intel-vpl-gpu-rt \
 pkgconf-pkg-config \
 "
