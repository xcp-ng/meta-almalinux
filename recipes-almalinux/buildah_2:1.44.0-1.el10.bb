# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "buildah"
PE = "2"
PV = "1.44.0"
PR = "1.el10"
PACKAGES = " \
 buildah \
 buildah-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/buildah-1.44.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d78f7976ab6afb51ef037d9b5677f0a3c39dcaca6208365b034c585b483e402d"

URI_x86_64_v2_buildah = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-1.44.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_buildah;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_buildah}"
SRC_URI[x86_64_v2_buildah.sha256sum] = "3d55f8589bf78dd338bc7dd9a98bb070785a12f1dc072dd6243940745a6c8532"

URI_x86_64_v2_buildah-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/buildah-tests-1.44.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_buildah-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_buildah-tests}"
SRC_URI[x86_64_v2_buildah-tests.sha256sum] = "30b8150f10bbb01365664fb493a015b1f1b2e43dceed2450f34091392bffa82f"

URI_aarch64_buildah = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-1.44.0-1.el10.aarch64.rpm;name=aarch64_buildah;unpack=0"
SRC_URI:append = " ${URI_aarch64_buildah}"
SRC_URI[aarch64_buildah.sha256sum] = "0128b0f15f6a4a7866274830ec6c6d1c02d8830f3674a950645d95578ceadb7e"

URI_aarch64_buildah-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/buildah-tests-1.44.0-1.el10.aarch64.rpm;name=aarch64_buildah-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_buildah-tests}"
SRC_URI[aarch64_buildah-tests.sha256sum] = "73a2c50d593ca732ffaf26e40af6bb08bb0ba3987862fb134d399f770c21cf3e"

RDEPENDS:buildah = " \
 containers-common-extra \
 glibc \
 gpgme \
 libseccomp \
 podman-sequoia \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:buildah-tests = " \
 bash \
 buildah \
 bzip2 \
 git-daemon \
 glibc \
 golang \
 gpgme \
 httpd-tools \
 jq \
 libseccomp \
 libselinux-utils \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 sqlite-libs \
 which \
 xz \
 zstd \
 "
