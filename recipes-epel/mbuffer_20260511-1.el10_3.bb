# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbuffer"
PV = "20260511"
PR = "1.el10_3"
PACKAGES = " \
 mbuffer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mbuffer-20260511-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8df1f3fa8b547c689fb38627c6df272be9be2084cafe7d293bfe3f2e6d866b07"

URI_x86_64_v2_mbuffer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbuffer-20260511-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbuffer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbuffer}"
SRC_URI[x86_64_v2_mbuffer.sha256sum] = "7a1b6dcd38e07cd78862449af27a191204e050bd0497e2b80984b274f291c66e"

URI_aarch64_mbuffer = "${EPEL_MIRROR}/aarch64/Packages/m/mbuffer-20260511-1.el10_3.aarch64.rpm;name=aarch64_mbuffer;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbuffer}"
SRC_URI[aarch64_mbuffer.sha256sum] = "96a593fb1aa7d7d23f44be5d8c6dd1276af855240ede9b6b42dbdde3b25e229d"

RDEPENDS:mbuffer = " \
 glibc \
 libgcc \
 "
