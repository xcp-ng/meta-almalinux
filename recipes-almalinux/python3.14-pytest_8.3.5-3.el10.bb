# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-pytest"
PV = "8.3.5"
PR = "3.el10"
PACKAGES = " \
 python3.14-pytest \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-pytest-8.3.5-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "890d12f11ad075e698e617e39b9a3613054b3d169781310a465fd46f1a1dca59"

URI_x86_64_v2_python3.14-pytest = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-pytest-8.3.5-3.el10.noarch.rpm;name=x86_64_v2_python3.14-pytest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-pytest}"
SRC_URI[x86_64_v2_python3.14-pytest.sha256sum] = "23b3400455748122c332b98ba952e7901a9ae8131a776f38034fe4fb982bd84b"

URI_aarch64_python3.14-pytest = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-pytest-8.3.5-3.el10.noarch.rpm;name=aarch64_python3.14-pytest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-pytest}"
SRC_URI[aarch64_python3.14-pytest.sha256sum] = "23b3400455748122c332b98ba952e7901a9ae8131a776f38034fe4fb982bd84b"

RDEPENDS:python3.14-pytest = " \
 python3.14 \
 python3.14-iniconfig \
 python3.14-packaging \
 python3.14-pluggy \
 "
