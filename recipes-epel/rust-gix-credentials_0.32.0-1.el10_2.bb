# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-credentials"
PV = "0.32.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-credentials+default-devel \
 rust-gix-credentials+document-features-devel \
 rust-gix-credentials+serde-devel \
 rust-gix-credentials-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-credentials-0.32.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "784a352271cd77b6fd2527b98446121eba571ef6ed56d3e7030d82b86accff6c"

URI_x86_64_v2_rust-gix-credentials+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-credentials+default-devel-0.32.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-credentials+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-credentials+default-devel}"
SRC_URI[x86_64_v2_rust-gix-credentials+default-devel.sha256sum] = "64f80b9223948a8f596dd0039ab38b1c4a718089dc6c2f797c248f26c76268c0"

URI_x86_64_v2_rust-gix-credentials+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-credentials+document-features-devel-0.32.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-credentials+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-credentials+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-credentials+document-features-devel.sha256sum] = "75c910585aa54f1e5cba1fbd0e78dcfe44467bad0a7c7858b11bcff2de4d08e8"

URI_x86_64_v2_rust-gix-credentials+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-credentials+serde-devel-0.32.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-credentials+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-credentials+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-credentials+serde-devel.sha256sum] = "54477eaa1dd140540916e8e94ca3bf39ce694c45115c1dc027f19e22c5032d56"

URI_x86_64_v2_rust-gix-credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-credentials-devel-0.32.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-credentials-devel}"
SRC_URI[x86_64_v2_rust-gix-credentials-devel.sha256sum] = "f2ab25382bfdfa16e39f99436e3a99fc88f0deccd145c50d0e3c67e1c9dfe5ea"

URI_aarch64_rust-gix-credentials+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-credentials+default-devel-0.32.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-credentials+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-credentials+default-devel}"
SRC_URI[aarch64_rust-gix-credentials+default-devel.sha256sum] = "d766b739f79ff1305161ebbfac48257ecc06e965d51ece4c9c8f308510d7d63e"

URI_aarch64_rust-gix-credentials+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-credentials+document-features-devel-0.32.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-credentials+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-credentials+document-features-devel}"
SRC_URI[aarch64_rust-gix-credentials+document-features-devel.sha256sum] = "fb2fee0e12c09ae55666667e72fac822416e9335ead929d55202bb242c33d6ec"

URI_aarch64_rust-gix-credentials+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-credentials+serde-devel-0.32.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-credentials+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-credentials+serde-devel}"
SRC_URI[aarch64_rust-gix-credentials+serde-devel.sha256sum] = "88b801b66f3ef7960a4c3748b4183c65c1b76e702375a0ce2d9f641656cb2923"

URI_aarch64_rust-gix-credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-credentials-devel-0.32.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-credentials-devel}"
SRC_URI[aarch64_rust-gix-credentials-devel.sha256sum] = "d48d0e5e1045d1f81da4fc7986c7786e7fca2bfadfe3a677c092e001113eebc3"

RDEPENDS:rust-gix-credentials+default-devel = " \
 cargo \
 rust-gix-credentials-devel \
 "
RDEPENDS:rust-gix-credentials+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-credentials-devel \
 "
RDEPENDS:rust-gix-credentials+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-credentials-devel \
 rust-gix-sec+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-credentials-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-command+default-devel \
 rust-gix-config-value+default-devel \
 rust-gix-date+default-devel \
 rust-gix-path+default-devel \
 rust-gix-prompt+default-devel \
 rust-gix-sec+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-url+default-devel \
 rust-thiserror+default-devel \
 "
