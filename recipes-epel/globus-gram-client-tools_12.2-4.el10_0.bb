# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-client-tools"
PV = "12.2"
PR = "4.el10_0"
PACKAGES = " \
 globus-gram-client-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-client-tools-12.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e517ca02a83b64fa05ae83a749e001e4c945c5bf5d6cd76df25dbc402dc24014"

URI_x86_64_v2_globus-gram-client-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-client-tools-12.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-client-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-client-tools}"
SRC_URI[x86_64_v2_globus-gram-client-tools.sha256sum] = "3272b12b9b85c1c4747b2b431b87bc2a45053a5d4badcdd04a16c8f1ba23d19d"

URI_aarch64_globus-gram-client-tools = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-client-tools-12.2-4.el10_0.aarch64.rpm;name=aarch64_globus-gram-client-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-client-tools}"
SRC_URI[aarch64_globus-gram-client-tools.sha256sum] = "0586a3b4d5a9267504641a3ea1720e5b5d0a6cd3c9d3bd6e1dbfd58d5d8586d5"

RDEPENDS:globus-gram-client-tools = " \
 bash \
 glibc \
 globus-common \
 globus-common-progs \
 globus-gass-server-ez \
 globus-gass-transfer \
 globus-gram-client \
 globus-gram-protocol \
 globus-gss-assist \
 globus-rsl \
 "
