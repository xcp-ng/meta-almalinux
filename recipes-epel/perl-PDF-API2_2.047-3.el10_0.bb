# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PDF-API2"
PV = "2.047"
PR = "3.el10_0"
PACKAGES = " \
 perl-PDF-API2 \
 perl-PDF-API2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-PDF-API2-2.047-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b810e90cfa5811479900ab75d6d437f5696c94573476b058fe9f491d632aa1b9"

URI_x86_64_v2_perl-PDF-API2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PDF-API2-2.047-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PDF-API2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PDF-API2}"
SRC_URI[x86_64_v2_perl-PDF-API2.sha256sum] = "3110bc1f5b7007b1edf52eb5478b2aa870b603ae92fbe5e30533b259a0037b23"

URI_x86_64_v2_perl-PDF-API2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PDF-API2-tests-2.047-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PDF-API2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PDF-API2-tests}"
SRC_URI[x86_64_v2_perl-PDF-API2-tests.sha256sum] = "133eb17061c59fef6d9381013a7dccd47651c886e034a549f6348c04afdac530"

URI_aarch64_perl-PDF-API2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PDF-API2-2.047-3.el10_0.noarch.rpm;name=aarch64_perl-PDF-API2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PDF-API2}"
SRC_URI[aarch64_perl-PDF-API2.sha256sum] = "7443907e800c386f748a22c0f6e559dc7a6f707a4a5f68f763f6c50094c602a8"

URI_aarch64_perl-PDF-API2-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PDF-API2-tests-2.047-3.el10_0.noarch.rpm;name=aarch64_perl-PDF-API2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PDF-API2-tests}"
SRC_URI[aarch64_perl-PDF-API2-tests.sha256sum] = "997e988de49b5b513c8f2d7a5c8481bbf124f1342ae055034a57d9a260521067"

RDEPENDS:perl-PDF-API2 = " \
 dejavu-sans-fonts \
 dejavu-sans-mono-fonts \
 dejavu-serif-fonts \
 perl-Carp \
 perl-Encode \
 perl-English \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Temp \
 perl-FileHandle \
 perl-Font-TTF \
 perl-Graphics-TIFF \
 perl-IO \
 perl-IO-Compress \
 perl-Math-Complex \
 perl-PDF-API2 \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Unicode-UCD \
 perl-base \
 perl-constant \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PDF-API2-tests = " \
 ImageMagick \
 bash \
 libtiff-tools \
 perl-File-Find \
 perl-File-Temp \
 perl-PDF-API2 \
 perl-Scalar-List-Utils \
 perl-Test-Exception \
 perl-Test-Harness \
 perl-Test-Memory-Cycle \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
