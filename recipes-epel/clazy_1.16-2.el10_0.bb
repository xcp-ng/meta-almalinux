# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clazy"
PV = "1.16"
PR = "2.el10_0"
PACKAGES = " \
 clazy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clazy-1.16-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac1faa85860adb90f0600f0b66e2b2babe8b7a283e2bc1282e22b236717ddba9"

URI_x86_64_v2_clazy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clazy-1.16-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clazy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clazy}"
SRC_URI[x86_64_v2_clazy.sha256sum] = "089d7a607f5b36c9b0ab8130c276c6b1fdbf287a92863fe38b6bfb897f21938a"

URI_aarch64_clazy = "${EPEL_MIRROR}/aarch64/Packages/c/clazy-1.16-2.el10_0.aarch64.rpm;name=aarch64_clazy;unpack=0"
SRC_URI:append = " ${URI_aarch64_clazy}"
SRC_URI[aarch64_clazy.sha256sum] = "84a5064fe89a1756790948a703c68dfd65b17c62a9c6b57435c6841d2263fa61"

RDEPENDS:clazy = " \
 bash \
 clang \
 clang-libs \
 clang-tools-extra \
 glibc \
 libstdc++ \
 llvm-libs \
 "
