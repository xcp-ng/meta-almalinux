# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kapidox"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kapidox \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kapidox-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c480052c3c15628e11f5379472a5d2c2ec160bad8eb2a0946c02fdfaaf818f3e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kapidox-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kapidox;unpack=0"
SRC_URI[x86_64_v2_kf6-kapidox.sha256sum] = "c3b4c038516978290a3743916fcece54603010d626ffd7f548c731b4c63e0283"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kapidox-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kapidox;unpack=0"
SRC_URI[aarch64_kf6-kapidox.sha256sum] = "68d4d4b64981f8a8405b60521ac8ba77a8d8d8465e62ad981623f8564b774f77"

RDEPENDS:kf6-kapidox = " \
 bash \
 doxygen \
 kf6-filesystem \
 python3 \
 python3-doxypypy \
 python3-doxyqml \
 python3-jinja2 \
 python3-pyyaml \
 python3-requests \
 qt6-doc-devel \
 "
