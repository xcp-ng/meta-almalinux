# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aml"
PV = "0.3.0"
PR = "5.el10_0"
PACKAGES = " \
 aml \
 aml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aml-0.3.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ee7f859a63565b5696d7b289a95a03861a0ff351faa844f85b1642ff87dc2be"

URI_x86_64_v2_aml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aml-0.3.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aml}"
SRC_URI[x86_64_v2_aml.sha256sum] = "9e18018db6938e1d8c6d92f5dcbbdd0dddf3b9d1b72a03fe426114a0debd401a"

URI_x86_64_v2_aml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aml-devel-0.3.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aml-devel}"
SRC_URI[x86_64_v2_aml-devel.sha256sum] = "23824941bbde16333b378a9c2653d481c54d915c4cdd93dfaca7c83fc24f18fa"

URI_aarch64_aml = "${EPEL_MIRROR}/aarch64/Packages/a/aml-0.3.0-5.el10_0.aarch64.rpm;name=aarch64_aml;unpack=0"
SRC_URI:append = " ${URI_aarch64_aml}"
SRC_URI[aarch64_aml.sha256sum] = "8f7999e7dc42244ea0129921b96674d892a655e9b3cc31bafb86b83b1a7ad155"

URI_aarch64_aml-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aml-devel-0.3.0-5.el10_0.aarch64.rpm;name=aarch64_aml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aml-devel}"
SRC_URI[aarch64_aml-devel.sha256sum] = "02c4c497b13608b17dab7d7227f55abc984923a135ca66583ca8c8d67c26bbcf"

RDEPENDS:aml = " \
 glibc \
 "
RDEPENDS:aml-devel = " \
 aml \
 pkgconf-pkg-config \
 "
