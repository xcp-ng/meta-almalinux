# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-zsh"
PV = "0.5.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-zsh \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-zsh-0.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "35041478f8270607c2e36ea59a43efdb314fc0b6fd876de9b956700266cf96a4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-zsh-0.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-zsh;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-zsh.sha256sum] = "641fded891eddb22aae0f76257e6235db9684ac424b66f49bada5a245c6fe1bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-zsh-0.5.0-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-zsh;unpack=0"
SRC_URI[aarch64_python3-colcon-zsh.sha256sum] = "9a6c8fb8f357f441bff9163aaaf9cb0f3f452b69252ece74af1838734a33a537"

RDEPENDS:python3-colcon-zsh = " \
 python3 \
 python3-colcon-core \
 "
