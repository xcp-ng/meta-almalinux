# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ripgrep"
PV = "14.1.1"
PR = "1.el10_0"
PACKAGES = " \
 ripgrep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ripgrep-14.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14b293516b9f20ce45d39f8ccca088e2bb65b77fa042454d415d0adf25c2a4b1"

URI_x86_64_v2_ripgrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ripgrep-14.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ripgrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ripgrep}"
SRC_URI[x86_64_v2_ripgrep.sha256sum] = "10645c843472a119f8803d4498a5d49afbe02a6fabaa93aa43e0b9324c80595a"

URI_aarch64_ripgrep = "${EPEL_MIRROR}/aarch64/Packages/r/ripgrep-14.1.1-1.el10_0.aarch64.rpm;name=aarch64_ripgrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_ripgrep}"
SRC_URI[aarch64_ripgrep.sha256sum] = "caa39e873bf5a6916718971fa1fdbd37b9f4d611f47102d6a28a57ccb01b07b9"

RDEPENDS:ripgrep = " \
 glibc \
 libgcc \
 pcre2 \
 "
