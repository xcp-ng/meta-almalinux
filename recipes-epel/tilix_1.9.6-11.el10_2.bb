# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tilix"
PV = "1.9.6"
PR = "11.el10_2"
PACKAGES = " \
 tilix \
 tilix-nautilus \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tilix-1.9.6-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1da5dc1850d099c5a4fb92b492f191c41774c7ea066fdfaca311adccfc4c3825"

URI_x86_64_v2_tilix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tilix-1.9.6-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tilix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tilix}"
SRC_URI[x86_64_v2_tilix.sha256sum] = "03db191fb24775aa4c83a3bd2b7d8bf8b3d8acc30bc80799f3bd0710269104f7"

URI_x86_64_v2_tilix-nautilus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tilix-nautilus-1.9.6-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tilix-nautilus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tilix-nautilus}"
SRC_URI[x86_64_v2_tilix-nautilus.sha256sum] = "4515cfb2df0065262d0315b92db71f7fd77ace8c0c9ffcac2c3e6a6e597aabd0"

URI_aarch64_tilix = "${EPEL_MIRROR}/aarch64/Packages/t/tilix-1.9.6-11.el10_2.aarch64.rpm;name=aarch64_tilix;unpack=0"
SRC_URI:append = " ${URI_aarch64_tilix}"
SRC_URI[aarch64_tilix.sha256sum] = "c86c9b2a6a7a9fe866efefd53093c8816648df5e4ae78e054ea9c0c1898a7d19"

URI_aarch64_tilix-nautilus = "${EPEL_MIRROR}/aarch64/Packages/t/tilix-nautilus-1.9.6-11.el10_2.aarch64.rpm;name=aarch64_tilix-nautilus;unpack=0"
SRC_URI:append = " ${URI_aarch64_tilix-nautilus}"
SRC_URI[aarch64_tilix-nautilus.sha256sum] = "92e736d757af5e08accab409d0c41519601199025797b0ca7722bf03d0577959"

RDEPENDS:tilix = " \
 bash \
 dbus \
 glibc \
 gtkd \
 hicolor-icon-theme \
 ldc-libs \
 libX11 \
 libgcc \
 "
RDEPENDS:tilix-nautilus = " \
 nautilus-python \
 tilix \
 "
