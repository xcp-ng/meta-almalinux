# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "minuet"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 minuet \
 minuet-data \
 minuet-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/minuet-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c9f1d56b8f6cab8d07cfa7d6dac84d94d66b7a6734009a9afbc64fc5227d826"

URI_x86_64_v2_minuet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minuet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minuet}"
SRC_URI[x86_64_v2_minuet.sha256sum] = "daa9666d4128b6e48acb4dc0895a9d11972e285c0965a2d1c42b3c0b026bce04"

URI_x86_64_v2_minuet-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-data-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_minuet-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minuet-data}"
SRC_URI[x86_64_v2_minuet-data.sha256sum] = "1507f7e8440d4e6c4b38561b79ce183138f181191ba8fa0ae321607e5cba051b"

URI_x86_64_v2_minuet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minuet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minuet-devel}"
SRC_URI[x86_64_v2_minuet-devel.sha256sum] = "46ba32f74ef02c0d7731de186e61c6d231cd38e62ba34faeb4540f7ca0f6d47b"

URI_aarch64_minuet = "${EPEL_MIRROR}/aarch64/Packages/m/minuet-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_minuet;unpack=0"
SRC_URI:append = " ${URI_aarch64_minuet}"
SRC_URI[aarch64_minuet.sha256sum] = "fb67f706699dacf6e68084c85414e355c7697852994b6df24d49bfd2eb2150a2"

URI_aarch64_minuet-data = "${EPEL_MIRROR}/aarch64/Packages/m/minuet-data-26.04.3-1.el10_3.noarch.rpm;name=aarch64_minuet-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_minuet-data}"
SRC_URI[aarch64_minuet-data.sha256sum] = "996122dbe5b503fdfecdc1fc51d56dfee155bb6db8621fb57f8711dfb037ba4a"

URI_aarch64_minuet-devel = "${EPEL_MIRROR}/aarch64/Packages/m/minuet-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_minuet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_minuet-devel}"
SRC_URI[aarch64_minuet-devel.sha256sum] = "d81ca1ba6b724037ce490a129258c3d434da5fc3b4b0954e60b0c53698389431"

RDEPENDS:minuet = " \
 fluidsynth-libs \
 glibc \
 hicolor-icon-theme \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 minuet-data \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:minuet-data = " \
 minuet \
 "
RDEPENDS:minuet-devel = " \
 minuet \
 "
