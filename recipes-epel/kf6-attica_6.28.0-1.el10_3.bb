# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-attica"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-attica \
 kf6-attica-devel \
 kf6-attica-doc \
 kf6-attica-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-attica-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb5dc6df74135b6f70f35076027667c3832691955ccf6571aa476ef871656461"

URI_x86_64_v2_kf6-attica = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-attica;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica}"
SRC_URI[x86_64_v2_kf6-attica.sha256sum] = "1a163dbfe3f1f5e185a85cc36271e16e016f10df5034a880d9707d6c1e64f65e"

URI_x86_64_v2_kf6-attica-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-attica-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-devel}"
SRC_URI[x86_64_v2_kf6-attica-devel.sha256sum] = "dfa3fc88bd0cff0fd4a41dc602d5c4d4d54fede4ba155326e4163a89d76cdddf"

URI_x86_64_v2_kf6-attica-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-attica-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-doc}"
SRC_URI[x86_64_v2_kf6-attica-doc.sha256sum] = "d9c6d7d0c70b0ce36bb47bccb2445a397d03484cfc1ed5647c3e31775ff31709"

URI_x86_64_v2_kf6-attica-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-attica-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-html}"
SRC_URI[x86_64_v2_kf6-attica-html.sha256sum] = "157ca46402fe9625ab8d4f64a51419e43cb176a0279e158dc5df5ed1b202f4b3"

URI_aarch64_kf6-attica = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-attica;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica}"
SRC_URI[aarch64_kf6-attica.sha256sum] = "b5d7c9ad8fa4cb90a41b0740703de61f803d64626ad3d8eb59e764e34fee4ce2"

URI_aarch64_kf6-attica-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-attica-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-devel}"
SRC_URI[aarch64_kf6-attica-devel.sha256sum] = "4ba2bf6d3b52cfd7ceeb137a6f7ff31e56c319db5cf48f807517daffd28a7122"

URI_aarch64_kf6-attica-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-attica-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-doc}"
SRC_URI[aarch64_kf6-attica-doc.sha256sum] = "5019ab5eb069e936ac75ec1eb0a6cd86f7597f74e0f6e8c79d17feadc789719a"

URI_aarch64_kf6-attica-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-attica-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-html}"
SRC_URI[aarch64_kf6-attica-html.sha256sum] = "e5c93244db6ba3ba59bcf69fdba17d94bba1df849da132b8c559bb62b2b4dcc9"

RDEPENDS:kf6-attica = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-attica-devel = " \
 cmake-filesystem \
 kf6-attica \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-attica-doc = " \
 "
RDEPENDS:kf6-attica-html = " \
 "
