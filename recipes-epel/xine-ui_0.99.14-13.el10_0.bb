# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xine-ui"
PV = "0.99.14"
PR = "13.el10_0"
PACKAGES = " \
 xine-ui \
 xine-ui-aaxine \
 xine-ui-skins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xine-ui-0.99.14-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f97b7158f6633d068272f0ec39d2f8ae5cc6317a5b0bc1acf4b919191df3b004"

URI_x86_64_v2_xine-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xine-ui-0.99.14-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xine-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xine-ui}"
SRC_URI[x86_64_v2_xine-ui.sha256sum] = "ae0491d6b00f6e953bcd07c20b5115dc994bf46a7f9456dae44343763bb2862b"

URI_x86_64_v2_xine-ui-aaxine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xine-ui-aaxine-0.99.14-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xine-ui-aaxine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xine-ui-aaxine}"
SRC_URI[x86_64_v2_xine-ui-aaxine.sha256sum] = "94aec724ecb881f0d337d71960ea9d094b1d9845d7af111fc6abd15bfb5259f6"

URI_x86_64_v2_xine-ui-skins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xine-ui-skins-0.99.14-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xine-ui-skins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xine-ui-skins}"
SRC_URI[x86_64_v2_xine-ui-skins.sha256sum] = "d767f263fa4bc1c00802cef6525ce23562f33c39ac1d1050344a3c1b8469de60"

URI_aarch64_xine-ui = "${EPEL_MIRROR}/aarch64/Packages/x/xine-ui-0.99.14-13.el10_0.aarch64.rpm;name=aarch64_xine-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_xine-ui}"
SRC_URI[aarch64_xine-ui.sha256sum] = "7ae1fb986f870d1ae924910000dd9df992d34b670cba19143080f6cad83d245a"

URI_aarch64_xine-ui-aaxine = "${EPEL_MIRROR}/aarch64/Packages/x/xine-ui-aaxine-0.99.14-13.el10_0.aarch64.rpm;name=aarch64_xine-ui-aaxine;unpack=0"
SRC_URI:append = " ${URI_aarch64_xine-ui-aaxine}"
SRC_URI[aarch64_xine-ui-aaxine.sha256sum] = "afefcd801fff5c1e648ca60fdd9bf5e7546bc959126613dd6f3c3a860b7f8000"

URI_aarch64_xine-ui-skins = "${EPEL_MIRROR}/aarch64/Packages/x/xine-ui-skins-0.99.14-13.el10_0.noarch.rpm;name=aarch64_xine-ui-skins;unpack=0"
SRC_URI:append = " ${URI_aarch64_xine-ui-skins}"
SRC_URI[aarch64_xine-ui-skins.sha256sum] = "c5e1fd1c96905d990d1f73fee07acea586ca0dc8d3bbb558b031f31e3cb139d7"

RDEPENDS:xine-ui = " \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libXext \
 libXft \
 libXinerama \
 libXtst \
 libXv \
 libXxf86vm \
 libjpeg-turbo \
 libpng \
 lirc-libs \
 readline \
 virtual/libcurl.so.4___64bit_ \
 xine-lib \
 xine-lib-extras \
 "
RDEPENDS:xine-ui-aaxine = " \
 aalib-libs \
 glibc \
 libcaca \
 lirc-libs \
 xine-lib \
 xine-lib-extras \
 xine-ui \
 "
RDEPENDS:xine-ui-skins = " \
 bash \
 xine-ui \
 "
