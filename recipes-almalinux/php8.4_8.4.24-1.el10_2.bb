# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4"
PV = "8.4.24"
PR = "1.el10_2"
PACKAGES = " \
 php8.4 \
 php8.4-bcmath \
 php8.4-cli \
 php8.4-common \
 php8.4-dba \
 php8.4-dbg \
 php8.4-devel \
 php8.4-embedded \
 php8.4-enchant \
 php8.4-ffi \
 php8.4-fpm \
 php8.4-gd \
 php8.4-gmp \
 php8.4-intl \
 php8.4-ldap \
 php8.4-mbstring \
 php8.4-mysqlnd \
 php8.4-odbc \
 php8.4-opcache \
 php8.4-pdo \
 php8.4-pgsql \
 php8.4-process \
 php8.4-snmp \
 php8.4-soap \
 php8.4-xml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php8.4-8.4.24-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dabf6cab078914d819c6478ed998203af5b6ad7ce57f0edace7f5550fc2dd4e4"

URI_x86_64_v2_php8.4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4}"
SRC_URI[x86_64_v2_php8.4.sha256sum] = "fb37bae2d17e2d2a19be383501616f6ea73cadf0146414d7063530d7af3e375e"
RPROVIDES:php8.4:x86_64_v2 = "virtual/php"

URI_x86_64_v2_php8.4-bcmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-bcmath-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-bcmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-bcmath}"
SRC_URI[x86_64_v2_php8.4-bcmath.sha256sum] = "0c5fed5cf060c2a304efa99d4b0525e4ecf91f1754eaf8d74b1a25f1c3a5dceb"
RPROVIDES:php8.4-bcmath:x86_64_v2 = "virtual/php-bcmath"

URI_x86_64_v2_php8.4-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-cli-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-cli}"
SRC_URI[x86_64_v2_php8.4-cli.sha256sum] = "761bdcd7846d2a578d0ab0d3219e8647036e1af37ff32fb8b1fb72ef0bd71b9b"
RPROVIDES:php8.4-cli:x86_64_v2 = "virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

URI_x86_64_v2_php8.4-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-common-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-common}"
SRC_URI[x86_64_v2_php8.4-common.sha256sum] = "3623e68bd00fe7acbef5036d268e9cf431972421ef72c3cb8100a5a8bf30920b"
RPROVIDES:php8.4-common:x86_64_v2 = "virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_x86-64_ virtual/php-json virtual/php-json_x86-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_x86-64_ virtual/php-spl virtual/php-spl_x86-64_ virtual/php-tokenizer virtual/php-tokenizer_x86-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

URI_x86_64_v2_php8.4-dba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-dba-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-dba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-dba}"
SRC_URI[x86_64_v2_php8.4-dba.sha256sum] = "4411da8380961b45b61caec3297db939c4c3b04e6a0879c8387c452795037595"

URI_x86_64_v2_php8.4-dbg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-dbg-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-dbg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-dbg}"
SRC_URI[x86_64_v2_php8.4-dbg.sha256sum] = "fb7bb01c0b7075c844ecdf8abfba73ef8497569abb6864c20a5a49d0a41a538d"

URI_x86_64_v2_php8.4-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-devel-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-devel}"
SRC_URI[x86_64_v2_php8.4-devel.sha256sum] = "dc918c21e48724cf2b123a9b32bb56a848b625406489c32114230861a23b5b36"
RPROVIDES:php8.4-devel:x86_64_v2 = "virtual/php-devel_x86-64_ virtual/php-devel_x86-64__ge_5.3.0"

URI_x86_64_v2_php8.4-embedded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-embedded-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-embedded}"
SRC_URI[x86_64_v2_php8.4-embedded.sha256sum] = "988af8e37bf3a84fe1ec94ff99a4b423a9be1784b10f2add9449c032eab77d62"

URI_x86_64_v2_php8.4-enchant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-enchant-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-enchant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-enchant}"
SRC_URI[x86_64_v2_php8.4-enchant.sha256sum] = "ce39f7f476a0ed53eadd020f51da9970f0eb5503940d766a29b0db0b7b90f7ee"

URI_x86_64_v2_php8.4-ffi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-ffi-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-ffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-ffi}"
SRC_URI[x86_64_v2_php8.4-ffi.sha256sum] = "2cff92452c608ff10b0184b530aca6160cba1ab64fac73d981b58dfc04cb4b69"

URI_x86_64_v2_php8.4-fpm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-fpm-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-fpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-fpm}"
SRC_URI[x86_64_v2_php8.4-fpm.sha256sum] = "07008388e2b2e2466e5b5fcb7e4dd4b387cd1ec74671bf776c24490cfd11274f"
RPROVIDES:php8.4-fpm:x86_64_v2 = "virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

URI_x86_64_v2_php8.4-gd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-gd-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-gd}"
SRC_URI[x86_64_v2_php8.4-gd.sha256sum] = "2f3d1234ab221d932769dfc0f32e5dfb838d9ea3d25854abd218a7dafac93a45"
RPROVIDES:php8.4-gd:x86_64_v2 = "virtual/php-gd virtual/php-gd_x86-64_"

URI_x86_64_v2_php8.4-gmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-gmp-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-gmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-gmp}"
SRC_URI[x86_64_v2_php8.4-gmp.sha256sum] = "33296f7af4c8f4c23dda55b21cb0130ba563b9758e20a75ee6183be214263613"
RPROVIDES:php8.4-gmp:x86_64_v2 = "virtual/php-gmp"

URI_x86_64_v2_php8.4-intl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-intl-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-intl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-intl}"
SRC_URI[x86_64_v2_php8.4-intl.sha256sum] = "d2c873d693ad5d61029b3189202ae6eb8ffa83e65adbdc991475cd539521a4c9"
RPROVIDES:php8.4-intl:x86_64_v2 = "virtual/php-intl"

URI_x86_64_v2_php8.4-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-ldap-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-ldap}"
SRC_URI[x86_64_v2_php8.4-ldap.sha256sum] = "622db637f63601d48e1eedfd22c49d456a2bf4e9fd95057c58329d6e6df76ade"
RPROVIDES:php8.4-ldap:x86_64_v2 = "virtual/php-ldap"

URI_x86_64_v2_php8.4-mbstring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-mbstring-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-mbstring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-mbstring}"
SRC_URI[x86_64_v2_php8.4-mbstring.sha256sum] = "4a6a7cfd7d4e975132cdb5711115aff61c05f2b5f9a747b65f945315796c520e"
RPROVIDES:php8.4-mbstring:x86_64_v2 = "virtual/php-mbstring"

URI_x86_64_v2_php8.4-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-mysqlnd-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-mysqlnd}"
SRC_URI[x86_64_v2_php8.4-mysqlnd.sha256sum] = "aa94a7355b5ca7ef4386adb34303d4a9ec6cf5d61d78f22fd34e553848ad20b6"
RPROVIDES:php8.4-mysqlnd:x86_64_v2 = "virtual/php-mysqli virtual/php-mysqlnd"

URI_x86_64_v2_php8.4-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-odbc-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-odbc}"
SRC_URI[x86_64_v2_php8.4-odbc.sha256sum] = "485d09c5b09abb17c82866383130b7d7f7b617e209c9c80967a2305ec472673f"

URI_x86_64_v2_php8.4-opcache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-opcache-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-opcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-opcache}"
SRC_URI[x86_64_v2_php8.4-opcache.sha256sum] = "ca3e4b068a3539b3f2c613886d0b78dc6991c5eaf5b32ce745e5baf88082c339"
RPROVIDES:php8.4-opcache:x86_64_v2 = "virtual/php-opcache"

URI_x86_64_v2_php8.4-pdo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-pdo-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-pdo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pdo}"
SRC_URI[x86_64_v2_php8.4-pdo.sha256sum] = "772cebb1174e81832ab403615d09cdd6ae05fa332331ea59adb0f08103c38042"
RPROVIDES:php8.4-pdo:x86_64_v2 = "virtual/php-pdo virtual/php-sqlite3"

URI_x86_64_v2_php8.4-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-pgsql-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pgsql}"
SRC_URI[x86_64_v2_php8.4-pgsql.sha256sum] = "a75e3a79c5e00d8ddf65b4c040b5e02ac8152f94892916be07ef85fcab9cb6ea"
RPROVIDES:php8.4-pgsql:x86_64_v2 = "virtual/php-pgsql"

URI_x86_64_v2_php8.4-process = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-process-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-process}"
SRC_URI[x86_64_v2_php8.4-process.sha256sum] = "7d22d9263e84c9a61d4e6ffffa81ee251e4d3eebfaba615e487dc0b772c167d5"
RPROVIDES:php8.4-process:x86_64_v2 = "virtual/php-posix virtual/php-process"

URI_x86_64_v2_php8.4-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-snmp-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-snmp}"
SRC_URI[x86_64_v2_php8.4-snmp.sha256sum] = "294d4ff8b93fbba48cbd079fc57f4aa728996d89f142d36e0b47ce8fef636af5"

URI_x86_64_v2_php8.4-soap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-soap-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-soap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-soap}"
SRC_URI[x86_64_v2_php8.4-soap.sha256sum] = "ac08a6456cd28090de2c0e475cb8cda3263f3d9c395b08408f82120674777041"

URI_x86_64_v2_php8.4-xml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-xml-8.4.24-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php8.4-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-xml}"
SRC_URI[x86_64_v2_php8.4-xml.sha256sum] = "d1be0e4c4fcb9a353a5f0523808964a934265a0d370499d5b55a9fea8dc49122"
RPROVIDES:php8.4-xml:x86_64_v2 = "virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

URI_aarch64_php8.4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4}"
SRC_URI[aarch64_php8.4.sha256sum] = "bcabfc18782164cd60513fcc3b1be5e0f162e27dd3ed160d1ac8a88838cbc869"
RPROVIDES:php8.4:aarch64 = "virtual/php"

URI_aarch64_php8.4-bcmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-bcmath-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-bcmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-bcmath}"
SRC_URI[aarch64_php8.4-bcmath.sha256sum] = "9fd5a02fab64da032eb1def74b31d94e1a4acd73bf29ecf6abbaedff83e4c989"
RPROVIDES:php8.4-bcmath:aarch64 = "virtual/php-bcmath"

URI_aarch64_php8.4-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-cli-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-cli}"
SRC_URI[aarch64_php8.4-cli.sha256sum] = "ce9168ee302b590e452242ef437f03cf3e8acab3fa32afbd8c33d1bf9ed09197"
RPROVIDES:php8.4-cli:aarch64 = "virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

URI_aarch64_php8.4-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-common-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-common}"
SRC_URI[aarch64_php8.4-common.sha256sum] = "1b9c87e85cde29419d154a5c10ab3018738475030445e66d694156ade2c6c6ae"
RPROVIDES:php8.4-common:aarch64 = "virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_aarch-64_ virtual/php-json virtual/php-json_aarch-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_aarch-64_ virtual/php-spl virtual/php-spl_aarch-64_ virtual/php-tokenizer virtual/php-tokenizer_aarch-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

URI_aarch64_php8.4-dba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-dba-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-dba;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-dba}"
SRC_URI[aarch64_php8.4-dba.sha256sum] = "07fbdfef17e12846027e0b9beb21e40df3e4e8084f36bf45d0dd7cd93d66d625"

URI_aarch64_php8.4-dbg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-dbg-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-dbg;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-dbg}"
SRC_URI[aarch64_php8.4-dbg.sha256sum] = "4e020a04940b256b3ea3a8d58a996ec5abfcdafeff202681e8138592f6565f11"

URI_aarch64_php8.4-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-devel-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-devel}"
SRC_URI[aarch64_php8.4-devel.sha256sum] = "34ff6b30df9cc5b7ed5cc9606e4e0d09416fd3f51f4286520028334f3e9e779b"
RPROVIDES:php8.4-devel:aarch64 = "virtual/php-devel_aarch-64_ virtual/php-devel_aarch-64__ge_5.3.0"

URI_aarch64_php8.4-embedded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-embedded-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-embedded}"
SRC_URI[aarch64_php8.4-embedded.sha256sum] = "293f3941da59b39b6a781719c4e7bf6745ee1c1d0f712a8e4f6c6a6ef18b542b"

URI_aarch64_php8.4-enchant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-enchant-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-enchant;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-enchant}"
SRC_URI[aarch64_php8.4-enchant.sha256sum] = "70cb3d02657595765bf711ae4c17481686ddd1b987523f6626837a6dd72b32cd"

URI_aarch64_php8.4-ffi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-ffi-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-ffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-ffi}"
SRC_URI[aarch64_php8.4-ffi.sha256sum] = "0366040347103e3710453c8b5566b9ad3c7a827a492b8ff3922011e52d002bf7"

URI_aarch64_php8.4-fpm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-fpm-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-fpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-fpm}"
SRC_URI[aarch64_php8.4-fpm.sha256sum] = "2bb8df2a52ccd484c7c8e627036efe65d438e3f7a85b553e3567f540a1509e5d"
RPROVIDES:php8.4-fpm:aarch64 = "virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

URI_aarch64_php8.4-gd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-gd-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-gd}"
SRC_URI[aarch64_php8.4-gd.sha256sum] = "d11654cba3ebd5f585cef4cacac45dd9596e9bc8b2a27ee8203437f10103ad3f"
RPROVIDES:php8.4-gd:aarch64 = "virtual/php-gd virtual/php-gd_aarch-64_"

URI_aarch64_php8.4-gmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-gmp-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-gmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-gmp}"
SRC_URI[aarch64_php8.4-gmp.sha256sum] = "cfd9a7caef2b4bcab7cd85498823d755cde894ec45a5c11ffd5b871a40fe4680"
RPROVIDES:php8.4-gmp:aarch64 = "virtual/php-gmp"

URI_aarch64_php8.4-intl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-intl-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-intl;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-intl}"
SRC_URI[aarch64_php8.4-intl.sha256sum] = "25de89ca0da6d0ccb1d3c4c2d1456ba07b5c0fdd2c1a2b4aa03e51a8a35e8510"
RPROVIDES:php8.4-intl:aarch64 = "virtual/php-intl"

URI_aarch64_php8.4-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-ldap-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-ldap}"
SRC_URI[aarch64_php8.4-ldap.sha256sum] = "b6e57027d78cd4fdf09087bd191609552fd24a8ceb620b823662b0a3df4fabd7"
RPROVIDES:php8.4-ldap:aarch64 = "virtual/php-ldap"

URI_aarch64_php8.4-mbstring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-mbstring-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-mbstring;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-mbstring}"
SRC_URI[aarch64_php8.4-mbstring.sha256sum] = "32fb092a20891e4b619a2b96bbd26aafe292deecb4e89a606da8e22ce96da75e"
RPROVIDES:php8.4-mbstring:aarch64 = "virtual/php-mbstring"

URI_aarch64_php8.4-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-mysqlnd-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-mysqlnd}"
SRC_URI[aarch64_php8.4-mysqlnd.sha256sum] = "d36b051a55b2cbde7c97d7dbf8c81c7a1589461143c74dac782389429210e9a1"
RPROVIDES:php8.4-mysqlnd:aarch64 = "virtual/php-mysqli virtual/php-mysqlnd"

URI_aarch64_php8.4-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-odbc-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-odbc}"
SRC_URI[aarch64_php8.4-odbc.sha256sum] = "9be67dcd838fce95938c1839d46fe5390b8d916e1f2573ea02d5dd9e5aeaa2b2"

URI_aarch64_php8.4-opcache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-opcache-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-opcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-opcache}"
SRC_URI[aarch64_php8.4-opcache.sha256sum] = "0ec393c87d924b5bde8f4f2b5139736a000edecf6ab1c0abfe52b63c9983cf31"
RPROVIDES:php8.4-opcache:aarch64 = "virtual/php-opcache"

URI_aarch64_php8.4-pdo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-pdo-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-pdo;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pdo}"
SRC_URI[aarch64_php8.4-pdo.sha256sum] = "96e7644604b20a3e7e8a69ed26eda5afaab028b63af5f8aefc294d9998c2def9"
RPROVIDES:php8.4-pdo:aarch64 = "virtual/php-pdo virtual/php-sqlite3"

URI_aarch64_php8.4-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-pgsql-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pgsql}"
SRC_URI[aarch64_php8.4-pgsql.sha256sum] = "8d0d36ac02065c417708634ec3b1ffaec33110ea11ac8741417adbd3e994918e"
RPROVIDES:php8.4-pgsql:aarch64 = "virtual/php-pgsql"

URI_aarch64_php8.4-process = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-process-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-process}"
SRC_URI[aarch64_php8.4-process.sha256sum] = "ca5fef94f9522cacbeb5b48af3ae229657f3d49fa98ef5f6513df87d5e50e6e0"
RPROVIDES:php8.4-process:aarch64 = "virtual/php-posix virtual/php-process"

URI_aarch64_php8.4-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-snmp-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-snmp}"
SRC_URI[aarch64_php8.4-snmp.sha256sum] = "52451262dd77db9516f555f83922c6f7406454cd23f7138e02cdd2257693e5b6"

URI_aarch64_php8.4-soap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-soap-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-soap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-soap}"
SRC_URI[aarch64_php8.4-soap.sha256sum] = "3fb42c889e6b13a46b74ec0292e05b6efdac2dd8be236d902acaf511449dfe7c"

URI_aarch64_php8.4-xml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-xml-8.4.24-1.el10_2.aarch64.rpm;name=aarch64_php8.4-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-xml}"
SRC_URI[aarch64_php8.4-xml.sha256sum] = "11c315bd1048bb8c4a20d1743d85467fcd7ef00649a28fff7a38345881f21a5a"
RPROVIDES:php8.4-xml:aarch64 = "virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

RDEPENDS:php8.4 = " \
 php8.4-common \
 "
RDEPENDS:php8.4-bcmath = " \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-cli = " \
 bash \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php8.4-common \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-common = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 tzdata \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:php8.4-dba = " \
 glibc \
 lmdb-libs \
 php8.4-common \
 tokyocabinet \
 "
RDEPENDS:php8.4-dbg = " \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php8.4-common \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-devel = " \
 autoconf \
 automake \
 bash \
 gcc \
 gcc-c++ \
 krb5-devel \
 libtool \
 libxml2-devel \
 make \
 openssl-devel \
 pcre2-devel \
 php8.4-cli \
 php8.4-common \
 zlib-ng-compat-devel \
 "
RDEPENDS:php8.4-embedded = " \
 glibc \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php8.4-common \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-enchant = " \
 enchant2 \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-ffi = " \
 glibc \
 libffi \
 php8.4-common \
 "
RDEPENDS:php8.4-fpm = " \
 bash \
 glibc \
 httpd-filesystem \
 libacl \
 libselinux \
 libxcrypt \
 libxml2 \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 php8.4-common \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-gd = " \
 gd \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-gmp = " \
 glibc \
 gmp \
 php8.4-common \
 "
RDEPENDS:php8.4-intl = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 php8.4-common \
 "
RDEPENDS:php8.4-ldap = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 php8.4-common \
 "
RDEPENDS:php8.4-mbstring = " \
 glibc \
 oniguruma \
 php8.4-common \
 "
RDEPENDS:php8.4-mysqlnd = " \
 glibc \
 openssl-libs \
 php8.4-common \
 php8.4-pdo \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-odbc = " \
 glibc \
 php8.4-common \
 php8.4-pdo \
 unixODBC \
 "
RDEPENDS:php8.4-opcache:x86_64_v2 = " \
 capstone \
 glibc \
 libgcc \
 php8.4-common \
"
RDEPENDS:php8.4-opcache:aarch64 = " \
 capstone \
 glibc \
 php8.4-common \
"
RDEPENDS:php8.4-pdo = " \
 glibc \
 php8.4-common \
 sqlite-libs \
 "
RDEPENDS:php8.4-pgsql = " \
 glibc \
 libpq \
 php8.4-common \
 php8.4-pdo \
 "
RDEPENDS:php8.4-process = " \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-snmp = " \
 glibc \
 net-snmp \
 net-snmp-libs \
 openssl-libs \
 php8.4-common \
 "
RDEPENDS:php8.4-soap = " \
 glibc \
 libxml2 \
 php8.4-common \
 "
RDEPENDS:php8.4-xml = " \
 glibc \
 libxml2 \
 libxslt \
 php8.4-common \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/php rpm/virtual/php rpm/virtual/php-bcmath rpm/virtual/php-bz2 rpm/virtual/php-cli rpm/virtual/php-ctype rpm/virtual/php-curl rpm/virtual/php-date rpm/virtual/php-devel_x86-64_ rpm/virtual/php-devel_x86-64__ge_5.3.0 rpm/virtual/php-dom rpm/virtual/php-exif rpm/virtual/php-fileinfo rpm/virtual/php-filter rpm/virtual/php-fpm rpm/virtual/php-fpm_ge_8.0 rpm/virtual/php-ftp rpm/virtual/php-gd rpm/virtual/php-gd_x86-64_ rpm/virtual/php-gettext rpm/virtual/php-gmp rpm/virtual/php-hash rpm/virtual/php-iconv rpm/virtual/php-iconv_x86-64_ rpm/virtual/php-intl rpm/virtual/php-json rpm/virtual/php-json_x86-64_ rpm/virtual/php-ldap rpm/virtual/php-libxml rpm/virtual/php-mbstring rpm/virtual/php-mhash rpm/virtual/php-mysqli rpm/virtual/php-mysqlnd rpm/virtual/php-opcache rpm/virtual/php-openssl rpm/virtual/php-pcntl rpm/virtual/php-pcre rpm/virtual/php-pdo rpm/virtual/php-pgsql rpm/virtual/php-phar rpm/virtual/php-posix rpm/virtual/php-process rpm/virtual/php-reflection rpm/virtual/php-session rpm/virtual/php-simplexml rpm/virtual/php-sockets rpm/virtual/php-sockets_x86-64_ rpm/virtual/php-spl rpm/virtual/php-spl_x86-64_ rpm/virtual/php-sqlite3 rpm/virtual/php-tokenizer rpm/virtual/php-tokenizer_x86-64_ rpm/virtual/php-xml rpm/virtual/php-xmlreader rpm/virtual/php-xmlwriter rpm/virtual/php-xsl rpm/virtual/php-zlib rpm/virtual/php_httpd_ rpm/virtual/php_language__ge_5.3.0 rpm/virtual/php_language__ge_5.3.1 rpm/virtual/php_language__ge_5.3.3 rpm/virtual/php_language__ge_7.1 rpm/virtual/php_language__ge_7.2 rpm/virtual/php_language__ge_7.2.5 rpm/virtual/php_language__ge_7.3 rpm/virtual/php_language__ge_7.4 rpm/virtual/php_language__ge_8.1 rpm/virtual/php_language__gt_5.3 rpm/virtual/php_language__gt_5.4"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/php rpm/virtual/php rpm/virtual/php-bcmath rpm/virtual/php-bz2 rpm/virtual/php-cli rpm/virtual/php-ctype rpm/virtual/php-curl rpm/virtual/php-date rpm/virtual/php-devel_aarch-64_ rpm/virtual/php-devel_aarch-64__ge_5.3.0 rpm/virtual/php-dom rpm/virtual/php-exif rpm/virtual/php-fileinfo rpm/virtual/php-filter rpm/virtual/php-fpm rpm/virtual/php-fpm_ge_8.0 rpm/virtual/php-ftp rpm/virtual/php-gd rpm/virtual/php-gd_aarch-64_ rpm/virtual/php-gettext rpm/virtual/php-gmp rpm/virtual/php-hash rpm/virtual/php-iconv rpm/virtual/php-iconv_aarch-64_ rpm/virtual/php-intl rpm/virtual/php-json rpm/virtual/php-json_aarch-64_ rpm/virtual/php-ldap rpm/virtual/php-libxml rpm/virtual/php-mbstring rpm/virtual/php-mhash rpm/virtual/php-mysqli rpm/virtual/php-mysqlnd rpm/virtual/php-opcache rpm/virtual/php-openssl rpm/virtual/php-pcntl rpm/virtual/php-pcre rpm/virtual/php-pdo rpm/virtual/php-pgsql rpm/virtual/php-phar rpm/virtual/php-posix rpm/virtual/php-process rpm/virtual/php-reflection rpm/virtual/php-session rpm/virtual/php-simplexml rpm/virtual/php-sockets rpm/virtual/php-sockets_aarch-64_ rpm/virtual/php-spl rpm/virtual/php-spl_aarch-64_ rpm/virtual/php-sqlite3 rpm/virtual/php-tokenizer rpm/virtual/php-tokenizer_aarch-64_ rpm/virtual/php-xml rpm/virtual/php-xmlreader rpm/virtual/php-xmlwriter rpm/virtual/php-xsl rpm/virtual/php-zlib rpm/virtual/php_httpd_ rpm/virtual/php_language__ge_5.3.0 rpm/virtual/php_language__ge_5.3.1 rpm/virtual/php_language__ge_5.3.3 rpm/virtual/php_language__ge_7.1 rpm/virtual/php_language__ge_7.2 rpm/virtual/php_language__ge_7.2.5 rpm/virtual/php_language__ge_7.3 rpm/virtual/php_language__ge_7.4 rpm/virtual/php_language__ge_8.1 rpm/virtual/php_language__gt_5.3 rpm/virtual/php_language__gt_5.4"
