# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-breeze-icons"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 breeze-icon-theme \
 breeze-icon-theme-rcc \
 kf6-breeze-icons \
 kf6-breeze-icons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-breeze-icons-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3db1c8a1ec0b31229361e4c3100fd306bf8a44f76d03d312239bd4a1b32859f5"

URI_x86_64_v2_breeze-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-icon-theme-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-icon-theme}"
SRC_URI[x86_64_v2_breeze-icon-theme.sha256sum] = "5cb658a74a64907bcf6b13036b8100fb0d3b2c5cd5665247a0aadba8c2bf4125"

URI_x86_64_v2_breeze-icon-theme-rcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-icon-theme-rcc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-icon-theme-rcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-icon-theme-rcc}"
SRC_URI[x86_64_v2_breeze-icon-theme-rcc.sha256sum] = "e5e397894b3b64e39cfd2d68b716190f296ee2e64938f9e623fa075e0c5c1b82"

URI_x86_64_v2_kf6-breeze-icons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-breeze-icons-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-breeze-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-breeze-icons}"
SRC_URI[x86_64_v2_kf6-breeze-icons.sha256sum] = "3b455e65b5cc04a98e523435c08372b85e2f78bda516ccce60e8c5e0dbc53109"

URI_x86_64_v2_kf6-breeze-icons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-breeze-icons-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-breeze-icons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-breeze-icons-devel}"
SRC_URI[x86_64_v2_kf6-breeze-icons-devel.sha256sum] = "8969cc656e6147793fd27540c84877275b61217b6da03ff5323c7f831a16fb46"

URI_aarch64_breeze-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-icon-theme-6.25.0-1.el10_2.noarch.rpm;name=aarch64_breeze-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-icon-theme}"
SRC_URI[aarch64_breeze-icon-theme.sha256sum] = "95c337be1d28493c0e3c5db4d45cad5ad2c3e1b7839a95c3ac12331a64155b52"

URI_aarch64_breeze-icon-theme-rcc = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-icon-theme-rcc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_breeze-icon-theme-rcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-icon-theme-rcc}"
SRC_URI[aarch64_breeze-icon-theme-rcc.sha256sum] = "8c66444e3036cf949bbf9539988a951579d154af1d4075b559d1db6a8fed5848"

URI_aarch64_kf6-breeze-icons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-breeze-icons-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-breeze-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-breeze-icons}"
SRC_URI[aarch64_kf6-breeze-icons.sha256sum] = "c40461b74cfff00c741c12ebb8974e6c8c3687019fc61ec3fc953dbf8e6f1e91"

URI_aarch64_kf6-breeze-icons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-breeze-icons-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-breeze-icons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-breeze-icons-devel}"
SRC_URI[aarch64_kf6-breeze-icons-devel.sha256sum] = "14dde20d52c1d862e5383d16875930f3d64d5ce8e0765e746ea3b95429df5d63"

RDEPENDS:breeze-icon-theme = " \
 almalinux-logos \
 bash \
 hicolor-icon-theme \
 "
RDEPENDS:breeze-icon-theme-rcc = " \
 "
RDEPENDS:kf6-breeze-icons = " \
 breeze-icon-theme \
 glibc \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-breeze-icons-devel = " \
 cmake-filesystem \
 kf6-breeze-icons \
 "
