# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusty_paseto"
PV = "0.8.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-rusty_paseto+aes-devel \
 rust-rusty_paseto+batteries_included-devel \
 rust-rusty_paseto+blake2-devel \
 rust-rusty_paseto+chacha20-devel \
 rust-rusty_paseto+core-devel \
 rust-rusty_paseto+ctr-devel \
 rust-rusty_paseto+default-devel \
 rust-rusty_paseto+ed25519-dalek-devel \
 rust-rusty_paseto+erased-serde-devel \
 rust-rusty_paseto+generic-devel \
 rust-rusty_paseto+hmac-devel \
 rust-rusty_paseto+local-devel \
 rust-rusty_paseto+p384-devel \
 rust-rusty_paseto+public-devel \
 rust-rusty_paseto+serde-devel \
 rust-rusty_paseto+serde_json-devel \
 rust-rusty_paseto+sha2-devel \
 rust-rusty_paseto+v1-devel \
 rust-rusty_paseto+v1_local-devel \
 rust-rusty_paseto+v1_public-devel \
 rust-rusty_paseto+v2-devel \
 rust-rusty_paseto+v2_public-devel \
 rust-rusty_paseto+v3-devel \
 rust-rusty_paseto+v3_local-devel \
 rust-rusty_paseto+v3_public-devel \
 rust-rusty_paseto+v4-devel \
 rust-rusty_paseto+v4_local-devel \
 rust-rusty_paseto+v4_public-devel \
 rust-rusty_paseto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rusty_paseto-0.8.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c58cc9b6cb6abc303277a1363668c3283cabb462ce2f91e54951db0535c300e"

URI_x86_64_v2_rust-rusty_paseto+aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+aes-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+aes-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+aes-devel.sha256sum] = "7401b4614f6d79e28730da04437495a4737c4f2d523e4eaaf8e5e04dded04238"

URI_x86_64_v2_rust-rusty_paseto+batteries_included-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+batteries_included-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+batteries_included-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+batteries_included-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+batteries_included-devel.sha256sum] = "1220c427644b0856da027faeba59a26406c2cbe4b8a3d9c84e984115becaf798"

URI_x86_64_v2_rust-rusty_paseto+blake2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+blake2-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+blake2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+blake2-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+blake2-devel.sha256sum] = "c54ff60a1d83ea490eaf05f81ac88f09cff9c7d2a1c67960598554ce0d1dbd23"

URI_x86_64_v2_rust-rusty_paseto+chacha20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+chacha20-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+chacha20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+chacha20-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+chacha20-devel.sha256sum] = "22ee8f46088adff2ebad4fef0f1630cd6c6b473c4ba977e8dd76f29461978102"

URI_x86_64_v2_rust-rusty_paseto+core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+core-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+core-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+core-devel.sha256sum] = "659c95674d19ab103e7587725017908c36e429eea70310e50be99989da2f736a"

URI_x86_64_v2_rust-rusty_paseto+ctr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+ctr-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+ctr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+ctr-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+ctr-devel.sha256sum] = "df8ddd3b024a3798d3e1a040cefc9b1df9cd81b2484e10fd6d59d2c4edd0a3b5"

URI_x86_64_v2_rust-rusty_paseto+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+default-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+default-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+default-devel.sha256sum] = "abeeab9ef073ba32fcf6c36433bcf81a25c656e560ab2ecc05e2794a7c46cb0a"

URI_x86_64_v2_rust-rusty_paseto+ed25519-dalek-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+ed25519-dalek-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+ed25519-dalek-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+ed25519-dalek-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+ed25519-dalek-devel.sha256sum] = "486424f5c545241e5109942de12c128d4c3cb15140b6a6309ad99fd22f5c3818"

URI_x86_64_v2_rust-rusty_paseto+erased-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+erased-serde-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+erased-serde-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+erased-serde-devel.sha256sum] = "2dbab2ad64c43283be6b93e0fd5e4458d1be3b313e99a5f67454512da66212b6"

URI_x86_64_v2_rust-rusty_paseto+generic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+generic-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+generic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+generic-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+generic-devel.sha256sum] = "75d8fd8325ce9cfd8572ed104093cb20efabe71971e3fb0de9cd5d0c1dc9c5f1"

URI_x86_64_v2_rust-rusty_paseto+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+hmac-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+hmac-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+hmac-devel.sha256sum] = "a723e81f6bfb3eed2842e53a5ea3a384984707df74ca5c5c87f16bb559df3b6c"

URI_x86_64_v2_rust-rusty_paseto+local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+local-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+local-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+local-devel.sha256sum] = "e81d39768c70aa6349212ebbf8f406d2b5dd23031b16b40231bd39de1320c584"

URI_x86_64_v2_rust-rusty_paseto+p384-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+p384-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+p384-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+p384-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+p384-devel.sha256sum] = "51d0226a9c1de1b04b1dd464b9d78ed7b849745647a9fe68269da97d9111d5d2"

URI_x86_64_v2_rust-rusty_paseto+public-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+public-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+public-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+public-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+public-devel.sha256sum] = "db3c4f9f032a5cd1a01186240d7e31f03128268d95ba0b7e0e5d77b82a22f594"

URI_x86_64_v2_rust-rusty_paseto+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+serde-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+serde-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+serde-devel.sha256sum] = "eb4298fdb515c9c772b4c8436368b85058205e323716472a95999c6ae88c51e7"

URI_x86_64_v2_rust-rusty_paseto+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+serde_json-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+serde_json-devel.sha256sum] = "9496a8093221b53757059b591ad6ff63bddd0d2998e570b798458e97decdb587"

URI_x86_64_v2_rust-rusty_paseto+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+sha2-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+sha2-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+sha2-devel.sha256sum] = "88823cf35052f6042bfcc31f1e10134e3c03a6c4b55125323cb0e373c1864887"

URI_x86_64_v2_rust-rusty_paseto+v1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v1-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v1-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v1-devel.sha256sum] = "0e7ee4bd242b456c197bc724dfead7171c850a31d0b1bb6eb58aea1090b37f90"

URI_x86_64_v2_rust-rusty_paseto+v1_local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v1_local-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v1_local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v1_local-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v1_local-devel.sha256sum] = "3803f746ce19012d499b4a633d03d429be3abee9dd79e113cc58c7776d0e2226"

URI_x86_64_v2_rust-rusty_paseto+v1_public-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v1_public-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v1_public-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v1_public-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v1_public-devel.sha256sum] = "d0e5dd3391c780af9d892252925f251626ee7279bf45be1ab7ea9198a9593bbf"

URI_x86_64_v2_rust-rusty_paseto+v2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v2-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v2-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v2-devel.sha256sum] = "dd6e454c5262a0c639c86aeafd6100357e885c9c2449f191bc6a5af3ad3005db"

URI_x86_64_v2_rust-rusty_paseto+v2_public-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v2_public-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v2_public-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v2_public-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v2_public-devel.sha256sum] = "0570433391bb1ce46e738564af19c1d645631801b1576ee146e7c7a0c6420ac8"

URI_x86_64_v2_rust-rusty_paseto+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v3-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v3-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v3-devel.sha256sum] = "1fa1ab247d7cd7b3eb82529bf761414ecafd664710014470114dab7cb210e8f2"

URI_x86_64_v2_rust-rusty_paseto+v3_local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v3_local-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v3_local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v3_local-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v3_local-devel.sha256sum] = "a97f5ae9aa83a7a25682082c789d6672a0075a1a0a829eaaab56affd3f8b35cf"

URI_x86_64_v2_rust-rusty_paseto+v3_public-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v3_public-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v3_public-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v3_public-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v3_public-devel.sha256sum] = "98dac90a21f298830fd337b99cbbfd022ebcf6c6371d90cc95b97ec232b01f6c"

URI_x86_64_v2_rust-rusty_paseto+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v4-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v4-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v4-devel.sha256sum] = "34b618c9e2323f200e68c2fd05da1b431184d3f8970e7652c80134fe96ebd940"

URI_x86_64_v2_rust-rusty_paseto+v4_local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v4_local-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v4_local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v4_local-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v4_local-devel.sha256sum] = "12db0ae9b7aac3d13433dd2aac75c6f3fc7349e4f0688c4e20ae333cd5ca1373"

URI_x86_64_v2_rust-rusty_paseto+v4_public-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto+v4_public-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto+v4_public-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto+v4_public-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto+v4_public-devel.sha256sum] = "2aefc787eaab39bfcd882c0ea5e52a95bbd0201b67dadda9d60a7959ba9bc1fc"

URI_x86_64_v2_rust-rusty_paseto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty_paseto-devel-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty_paseto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty_paseto-devel}"
SRC_URI[x86_64_v2_rust-rusty_paseto-devel.sha256sum] = "08324b65be253d00d73ed1804005164ff8b6bf457992dd354aa8d3ad4192f59e"

URI_aarch64_rust-rusty_paseto+aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+aes-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+aes-devel}"
SRC_URI[aarch64_rust-rusty_paseto+aes-devel.sha256sum] = "f1464a8c0daba2c8281d498feb41aa9c5d8b851a6cb12a9c55f3165f0703882c"

URI_aarch64_rust-rusty_paseto+batteries_included-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+batteries_included-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+batteries_included-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+batteries_included-devel}"
SRC_URI[aarch64_rust-rusty_paseto+batteries_included-devel.sha256sum] = "84860ce28382f41c4bba64467de6271f6c4a2b755bbef4373d3de276e2113be2"

URI_aarch64_rust-rusty_paseto+blake2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+blake2-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+blake2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+blake2-devel}"
SRC_URI[aarch64_rust-rusty_paseto+blake2-devel.sha256sum] = "6c16501ffbe00e9d7fe36b368cbe701592be0e3387a60634be85bb6f80fa0610"

URI_aarch64_rust-rusty_paseto+chacha20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+chacha20-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+chacha20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+chacha20-devel}"
SRC_URI[aarch64_rust-rusty_paseto+chacha20-devel.sha256sum] = "dcc746ac9b492977e281d7c9de267a26d25a197b442d1914fb76c6516c4aeb21"

URI_aarch64_rust-rusty_paseto+core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+core-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+core-devel}"
SRC_URI[aarch64_rust-rusty_paseto+core-devel.sha256sum] = "e6e4e0cbc3c2d545ac2279c41b7495386972acbc8ab12f1f7c4da1b9c4ff8000"

URI_aarch64_rust-rusty_paseto+ctr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+ctr-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+ctr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+ctr-devel}"
SRC_URI[aarch64_rust-rusty_paseto+ctr-devel.sha256sum] = "0d8fc393701605efda3101181ea1d3bdec8d8a280ad67c5fdf752112af974377"

URI_aarch64_rust-rusty_paseto+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+default-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+default-devel}"
SRC_URI[aarch64_rust-rusty_paseto+default-devel.sha256sum] = "b9206c52164dd6dc7e53ed32652a2554af1096c46097971a11a3623b5bb228ed"

URI_aarch64_rust-rusty_paseto+ed25519-dalek-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+ed25519-dalek-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+ed25519-dalek-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+ed25519-dalek-devel}"
SRC_URI[aarch64_rust-rusty_paseto+ed25519-dalek-devel.sha256sum] = "aa5aa8b2fa1111f1f1d52971dacdf4f51eb72a68dafb37288ae84b297b901fe8"

URI_aarch64_rust-rusty_paseto+erased-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+erased-serde-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+erased-serde-devel}"
SRC_URI[aarch64_rust-rusty_paseto+erased-serde-devel.sha256sum] = "6c430eed2b9e9a14e46c32e47d373257a3a8cdc98d4987aa521d33e0f578cb88"

URI_aarch64_rust-rusty_paseto+generic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+generic-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+generic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+generic-devel}"
SRC_URI[aarch64_rust-rusty_paseto+generic-devel.sha256sum] = "53dcdfc61c870faba28ba78aa2ba1f8b944dd698aca1da243ef77babee108028"

URI_aarch64_rust-rusty_paseto+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+hmac-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+hmac-devel}"
SRC_URI[aarch64_rust-rusty_paseto+hmac-devel.sha256sum] = "e173934a80f91e4ad985924a7453faf683027179c5e69d9d690bc87f0db73a60"

URI_aarch64_rust-rusty_paseto+local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+local-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+local-devel}"
SRC_URI[aarch64_rust-rusty_paseto+local-devel.sha256sum] = "2a070671654e11f27cf8698009610640dac313a696a6fab9240a8ee9b493487d"

URI_aarch64_rust-rusty_paseto+p384-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+p384-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+p384-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+p384-devel}"
SRC_URI[aarch64_rust-rusty_paseto+p384-devel.sha256sum] = "121a1ddcc1848b97f0088943810e4e7389075935e3b2d51327535b2d084e3870"

URI_aarch64_rust-rusty_paseto+public-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+public-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+public-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+public-devel}"
SRC_URI[aarch64_rust-rusty_paseto+public-devel.sha256sum] = "2ca8be9d6c1d086c5c68118e9799c9f19abb255ec11afb4a39244ef85e31ee6c"

URI_aarch64_rust-rusty_paseto+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+serde-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+serde-devel}"
SRC_URI[aarch64_rust-rusty_paseto+serde-devel.sha256sum] = "f0e8b83648dfecf339c5ba437b3acb4a4349d772e0974cdf06e09cf037e25a72"

URI_aarch64_rust-rusty_paseto+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+serde_json-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+serde_json-devel}"
SRC_URI[aarch64_rust-rusty_paseto+serde_json-devel.sha256sum] = "b06d099d4e9ea15dc4fa813e5027707f047c167cb116e1fa07eb98986e22c8b1"

URI_aarch64_rust-rusty_paseto+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+sha2-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+sha2-devel}"
SRC_URI[aarch64_rust-rusty_paseto+sha2-devel.sha256sum] = "674fda2d6c7e295eeef4d7b97cc1ec8132153518dafca774db43b9ba2e2a80e5"

URI_aarch64_rust-rusty_paseto+v1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v1-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v1-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v1-devel.sha256sum] = "d5dd097ca098377a556dd0663bb4d0b8aea3beb30eb822c7b644dc497b93529e"

URI_aarch64_rust-rusty_paseto+v1_local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v1_local-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v1_local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v1_local-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v1_local-devel.sha256sum] = "103fd2c6f6f43ba379d8d61d48d933afd3ee725ba95b248ca0cb4b461f9e26bb"

URI_aarch64_rust-rusty_paseto+v1_public-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v1_public-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v1_public-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v1_public-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v1_public-devel.sha256sum] = "0c4afe5106454cd72e70c47378ccfb3a743cffa0e14b76c6895b84f19176ddb2"

URI_aarch64_rust-rusty_paseto+v2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v2-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v2-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v2-devel.sha256sum] = "b611f47fdea962a283280ca6d432906a3ae2cd157d135c6ffe29a74438cbd701"

URI_aarch64_rust-rusty_paseto+v2_public-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v2_public-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v2_public-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v2_public-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v2_public-devel.sha256sum] = "1c749662ac98e64ad3cf31cc060a6b8f231a222db17a55f8fd507b441f35e66f"

URI_aarch64_rust-rusty_paseto+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v3-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v3-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v3-devel.sha256sum] = "ec7ba93b340cc331a96af121008aff34ec00403e8254de0fcf0ea82878865f76"

URI_aarch64_rust-rusty_paseto+v3_local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v3_local-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v3_local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v3_local-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v3_local-devel.sha256sum] = "d530dd8a398a395793cd8d8a74f3a86eb371a7fbe4d62e8d6f1c4596757e000a"

URI_aarch64_rust-rusty_paseto+v3_public-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v3_public-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v3_public-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v3_public-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v3_public-devel.sha256sum] = "6582ef53155a78365218cd9a81cc61006c8dda875b419aec2b94cd0f3eb4a8cd"

URI_aarch64_rust-rusty_paseto+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v4-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v4-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v4-devel.sha256sum] = "2b7c6aad1f256ec949f2fbbd3206a9e61f032a051aa127197274fab733cf2537"

URI_aarch64_rust-rusty_paseto+v4_local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v4_local-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v4_local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v4_local-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v4_local-devel.sha256sum] = "5f3da24905205457b42843f3e5c4fc2656e30dfb5654a8ff5216cc38e72dbc1a"

URI_aarch64_rust-rusty_paseto+v4_public-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto+v4_public-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto+v4_public-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto+v4_public-devel}"
SRC_URI[aarch64_rust-rusty_paseto+v4_public-devel.sha256sum] = "c37d737bf8a211f48bd140f70c194a2e9d0ea9b88567df9e976587b3dc02fcde"

URI_aarch64_rust-rusty_paseto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty_paseto-devel-0.8.0-2.el10_3.noarch.rpm;name=aarch64_rust-rusty_paseto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty_paseto-devel}"
SRC_URI[aarch64_rust-rusty_paseto-devel.sha256sum] = "27f35e414ad9f257f2a92c21f76a79d36adabf2afe8faa9ac229783d9f5a0ce9"

RDEPENDS:rust-rusty_paseto+aes-devel = " \
 cargo \
 rust-aes0.8+default-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+batteries_included-devel = " \
 cargo \
 rust-rusty_paseto+generic-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+blake2-devel = " \
 cargo \
 rust-blake2+default-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+chacha20-devel = " \
 cargo \
 rust-chacha20_0.9+default-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+core-devel = " \
 cargo \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+ctr-devel = " \
 cargo \
 rust-ctr+default-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+default-devel = " \
 cargo \
 rust-rusty_paseto+batteries_included-devel \
 rust-rusty_paseto+v4_local-devel \
 rust-rusty_paseto+v4_public-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+ed25519-dalek-devel = " \
 cargo \
 rust-ed25519-dalek+default-devel \
 rust-ed25519-dalek+zeroize-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+erased-serde-devel = " \
 cargo \
 rust-erased-serde+default-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+generic-devel = " \
 cargo \
 rust-rusty_paseto+core-devel \
 rust-rusty_paseto+erased-serde-devel \
 rust-rusty_paseto+serde-devel \
 rust-rusty_paseto+serde_json-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+hmac-devel = " \
 cargo \
 rust-hmac0.12+default-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+local-devel = " \
 cargo \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+p384-devel = " \
 cargo \
 rust-p384+default-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+public-devel = " \
 cargo \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+serde-devel = " \
 cargo \
 rust-rusty_paseto-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rusty_paseto+serde_json-devel = " \
 cargo \
 rust-rusty_paseto-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rusty_paseto+sha2-devel = " \
 cargo \
 rust-rusty_paseto-devel \
 rust-sha2_0.10+default-devel \
 "
RDEPENDS:rust-rusty_paseto+v1-devel = " \
 cargo \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+v1_local-devel = " \
 cargo \
 rust-rusty_paseto+aes-devel \
 rust-rusty_paseto+blake2-devel \
 rust-rusty_paseto+chacha20-devel \
 rust-rusty_paseto+core-devel \
 rust-rusty_paseto+ctr-devel \
 rust-rusty_paseto+hmac-devel \
 rust-rusty_paseto+local-devel \
 rust-rusty_paseto+sha2-devel \
 rust-rusty_paseto+v1-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+v1_public-devel = " \
 cargo \
 rust-rusty_paseto+core-devel \
 rust-rusty_paseto+public-devel \
 rust-rusty_paseto+v1-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+v2-devel = " \
 cargo \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+v2_public-devel = " \
 cargo \
 rust-ring+std-devel \
 rust-rusty_paseto+core-devel \
 rust-rusty_paseto+ed25519-dalek-devel \
 rust-rusty_paseto+public-devel \
 rust-rusty_paseto+v2-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+v3-devel = " \
 cargo \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+v3_local-devel = " \
 cargo \
 rust-rusty_paseto+aes-devel \
 rust-rusty_paseto+chacha20-devel \
 rust-rusty_paseto+core-devel \
 rust-rusty_paseto+ctr-devel \
 rust-rusty_paseto+hmac-devel \
 rust-rusty_paseto+local-devel \
 rust-rusty_paseto+sha2-devel \
 rust-rusty_paseto+v3-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+v3_public-devel = " \
 cargo \
 rust-rusty_paseto+core-devel \
 rust-rusty_paseto+p384-devel \
 rust-rusty_paseto+public-devel \
 rust-rusty_paseto+sha2-devel \
 rust-rusty_paseto+v3-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+v4-devel = " \
 cargo \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+v4_local-devel = " \
 cargo \
 rust-rusty_paseto+blake2-devel \
 rust-rusty_paseto+chacha20-devel \
 rust-rusty_paseto+core-devel \
 rust-rusty_paseto+local-devel \
 rust-rusty_paseto+v4-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto+v4_public-devel = " \
 cargo \
 rust-ring+std-devel \
 rust-rusty_paseto+core-devel \
 rust-rusty_paseto+ed25519-dalek-devel \
 rust-rusty_paseto+public-devel \
 rust-rusty_paseto+v4-devel \
 rust-rusty_paseto-devel \
 "
RDEPENDS:rust-rusty_paseto-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-digest0.10+default-devel \
 rust-hex+default-devel \
 rust-iso8601+default-devel \
 rust-rand_core0.9+default-devel \
 rust-ring+default-devel \
 rust-ring+std-devel \
 rust-subtle+default-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-zeroize+default-devel \
 rust-zeroize+zeroize_derive-devel \
 "
