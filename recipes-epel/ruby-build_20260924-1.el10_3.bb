# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby-build"
PV = "20260924"
PR = "1.el10_3"
PACKAGES = " \
 ruby-build \
 ruby-build-all \
 ruby-build-core \
 ruby-build-jruby \
 ruby-build-mruby \
 ruby-build-others \
 ruby-build-picoruby \
 ruby-build-rbenv \
 ruby-build-ruby \
 ruby-build-truffleruby \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/ruby-build-20260924-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0282318d4deafac57b74a0ac52cc69b2d467d69c7b9dd82c5217589976e7c521"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-20260924-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build;unpack=0"
SRC_URI[x86_64_v2_ruby-build.sha256sum] = "a7c770b1c4db22133146196d27bfd3c94cff90b20cf788ebe683f0e471c9715f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-all-20260924-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-all;unpack=0"
SRC_URI[x86_64_v2_ruby-build-all.sha256sum] = "33d25c72a306f9879cbf1950e56ae305eea1a79f9eb660072fb994c8755397d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-core-20260924-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-core;unpack=0"
SRC_URI[x86_64_v2_ruby-build-core.sha256sum] = "df1d40ea1052c67cbf06ae245edb28b9b6ec70ac31f1e7c94bd2bda90475724f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-jruby-20260924-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-jruby;unpack=0"
SRC_URI[x86_64_v2_ruby-build-jruby.sha256sum] = "89e35dfdbff98b28b876c2eb1a800eb232c303a29a32b8894c392a9dfdbf30ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-mruby-20260924-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-mruby;unpack=0"
SRC_URI[x86_64_v2_ruby-build-mruby.sha256sum] = "acfad60d9e1a4ccc0d93f7a86e34016ef616a83501b206dae532f0409a8e6bc3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-others-20260924-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-others;unpack=0"
SRC_URI[x86_64_v2_ruby-build-others.sha256sum] = "c03be18b970563d4b52151cf41057e20d188cb6d16bddf945cd5e0dc2a9e0965"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-picoruby-20260924-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-picoruby;unpack=0"
SRC_URI[x86_64_v2_ruby-build-picoruby.sha256sum] = "b3cabc0439aa37284626becfc62f0d82d0c94cdd8c5a118232cb320714493c11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-rbenv-20260924-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-rbenv;unpack=0"
SRC_URI[x86_64_v2_ruby-build-rbenv.sha256sum] = "1618a7984455582dfdb3be12877eab92e6d8505a9056a01521bdbdb644a9a9cb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-ruby-20260924-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-ruby;unpack=0"
SRC_URI[x86_64_v2_ruby-build-ruby.sha256sum] = "c1ab0e3eb051884451699461e322e361cc8375e2029be7ed324ac05354c1e50a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-truffleruby-20260924-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-truffleruby;unpack=0"
SRC_URI[x86_64_v2_ruby-build-truffleruby.sha256sum] = "5b88c0577075c71a8240f21b57e1b2a28a62a37fa8b7531b1d2cd813161d4b28"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-20260924-1.el10_3.noarch.rpm;name=aarch64_ruby-build;unpack=0"
SRC_URI[aarch64_ruby-build.sha256sum] = "1b60454c0bc6d6dbd553df9a5e09ccfee7e54e1af7245579bfb165e10a9892d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-all-20260924-1.el10_3.noarch.rpm;name=aarch64_ruby-build-all;unpack=0"
SRC_URI[aarch64_ruby-build-all.sha256sum] = "2ff9f612e28f23f319bd1d9d7516c67dc83408dd6db6ef4bc9ded8e0e57f2a57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-core-20260924-1.el10_3.noarch.rpm;name=aarch64_ruby-build-core;unpack=0"
SRC_URI[aarch64_ruby-build-core.sha256sum] = "69fa573ff635feadf3b8e5aa61467302e08c4120dcaa76b2aef88763eb564d67"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-jruby-20260924-1.el10_3.noarch.rpm;name=aarch64_ruby-build-jruby;unpack=0"
SRC_URI[aarch64_ruby-build-jruby.sha256sum] = "b8ba709b487d6947bfb048a7fa0b37ce21c527f762fef49bd1d67fa717782c1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-mruby-20260924-1.el10_3.noarch.rpm;name=aarch64_ruby-build-mruby;unpack=0"
SRC_URI[aarch64_ruby-build-mruby.sha256sum] = "cb339ebba8660be7c397527f2d7748c4bd9e7b8c2effa1e25b782908d97a57ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-others-20260924-1.el10_3.noarch.rpm;name=aarch64_ruby-build-others;unpack=0"
SRC_URI[aarch64_ruby-build-others.sha256sum] = "07b97b999b2bc176eba874df720d615dcaae76734c6576c7d3b7180059d246a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-picoruby-20260924-1.el10_3.noarch.rpm;name=aarch64_ruby-build-picoruby;unpack=0"
SRC_URI[aarch64_ruby-build-picoruby.sha256sum] = "73d11f7856901f2865dc9bb48579e681440f1e5872703456027e001a44b3e143"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-rbenv-20260924-1.el10_3.noarch.rpm;name=aarch64_ruby-build-rbenv;unpack=0"
SRC_URI[aarch64_ruby-build-rbenv.sha256sum] = "5ebdeb68b86f717667e47323fdeb360bad8f63db886431d8c04f461d11bcd3db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-ruby-20260924-1.el10_3.noarch.rpm;name=aarch64_ruby-build-ruby;unpack=0"
SRC_URI[aarch64_ruby-build-ruby.sha256sum] = "d50cc818dd959f2d12deed42deda7ff6990451939210d0a1a86e65105b37bbf1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-truffleruby-20260924-1.el10_3.noarch.rpm;name=aarch64_ruby-build-truffleruby;unpack=0"
SRC_URI[aarch64_ruby-build-truffleruby.sha256sum] = "8eea9d5e774df1e046724c5bf4197813a7cf58ce1eb72807ce2e488956ce4430"

RDEPENDS:ruby-build = " \
 ruby-build-core \
 "
RDEPENDS:ruby-build-all = " \
 ruby-build \
 ruby-build-core \
 ruby-build-jruby \
 ruby-build-mruby \
 ruby-build-others \
 ruby-build-picoruby \
 ruby-build-ruby \
 ruby-build-truffleruby \
 "
RDEPENDS:ruby-build-core = " \
 bash \
 "
RDEPENDS:ruby-build-jruby = " \
 gcc-c++ \
 java-latest-openjdk-headless \
 make \
 ruby-build-core \
 "
RDEPENDS:ruby-build-mruby = " \
 ruby \
 ruby-build-core \
 rubygem-rake \
 "
RDEPENDS:ruby-build-others = " \
 ruby-build-core \
 "
RDEPENDS:ruby-build-picoruby = " \
 gcc \
 git-core \
 ruby \
 ruby-build-core \
 rubygem-rake \
 "
RDEPENDS:ruby-build-rbenv = " \
 bash \
 rbenv \
 ruby-build \
 "
RDEPENDS:ruby-build-ruby = " \
 gcc \
 libffi-devel \
 libyaml-devel \
 perl-File-Compare \
 perl-File-Copy \
 perl-FindBin \
 perl-IPC-Cmd \
 perl-Time-Piece \
 perl-interpreter \
 perl-lib \
 ruby-build-core \
 zlib-ng-compat-devel \
 "
RDEPENDS:ruby-build-truffleruby = " \
 gcc \
 libyaml-devel \
 ruby-build-core \
 "
