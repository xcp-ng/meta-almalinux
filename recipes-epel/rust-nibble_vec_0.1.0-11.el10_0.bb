# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nibble_vec"
PV = "0.1.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-nibble_vec+default-devel \
 rust-nibble_vec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nibble_vec-0.1.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27c845f72b05437c1b110b7b25538ad3748f15f3491bed795019488b8f654949"

URI_x86_64_v2_rust-nibble_vec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nibble_vec+default-devel-0.1.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nibble_vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nibble_vec+default-devel}"
SRC_URI[x86_64_v2_rust-nibble_vec+default-devel.sha256sum] = "626279640633b3db6676b713a498d17099477cd8b75a54a188bb40bab229b7ed"

URI_x86_64_v2_rust-nibble_vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nibble_vec-devel-0.1.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nibble_vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nibble_vec-devel}"
SRC_URI[x86_64_v2_rust-nibble_vec-devel.sha256sum] = "d4b9c56cf7a32f3959742ac0ecb28ef1a96adc979fa594f0798ea00ec94e669f"

URI_aarch64_rust-nibble_vec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nibble_vec+default-devel-0.1.0-11.el10_0.noarch.rpm;name=aarch64_rust-nibble_vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nibble_vec+default-devel}"
SRC_URI[aarch64_rust-nibble_vec+default-devel.sha256sum] = "b278653ead620d02894007c80801845b083ae8018143e17243f6047d7217dbc7"

URI_aarch64_rust-nibble_vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nibble_vec-devel-0.1.0-11.el10_0.noarch.rpm;name=aarch64_rust-nibble_vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nibble_vec-devel}"
SRC_URI[aarch64_rust-nibble_vec-devel.sha256sum] = "d2332e4356bf7e81538ad5b181ea6880d8233694f68eba6904cd8810e5959af6"

RDEPENDS:rust-nibble_vec+default-devel = " \
 cargo \
 rust-nibble_vec-devel \
 "
RDEPENDS:rust-nibble_vec-devel = " \
 cargo \
 rust-smallvec+default-devel \
 "
