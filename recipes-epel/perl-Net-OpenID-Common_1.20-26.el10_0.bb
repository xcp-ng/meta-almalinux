# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-OpenID-Common"
PV = "1.20"
PR = "26.el10_0"
PACKAGES = " \
 perl-Net-OpenID-Common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-OpenID-Common-1.20-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0ab85067912126a86d1dcf99fecd21d4767fd9c061c99d9be4f087fb3a99ca5"

URI_x86_64_v2_perl-Net-OpenID-Common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-OpenID-Common-1.20-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-OpenID-Common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-OpenID-Common}"
SRC_URI[x86_64_v2_perl-Net-OpenID-Common.sha256sum] = "6ddaa2a3f157b8638acfb69e2f62e1069a7dddd98a4140f7bb92bfd6d869e7ae"

URI_aarch64_perl-Net-OpenID-Common = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-OpenID-Common-1.20-26.el10_0.noarch.rpm;name=aarch64_perl-Net-OpenID-Common;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-OpenID-Common}"
SRC_URI[aarch64_perl-Net-OpenID-Common.sha256sum] = "a0cb0ca0e4e29fb7ede05e594a2ff577fa702e28dfe138ef96452dca0952a9ad"

RDEPENDS:perl-Net-OpenID-Common = " \
 perl-CGI \
 perl-Carp \
 perl-Crypt-DH-GMP \
 perl-Encode \
 perl-Exporter \
 perl-HTML-Parser \
 perl-HTTP-Message \
 perl-MIME-Base64 \
 perl-Math-BigInt \
 perl-Net-OpenID-Common \
 perl-Storable \
 perl-Time-Local \
 perl-URI \
 perl-XML-Simple \
 perl-base \
 perl-constant \
 perl-fields \
 perl-libs \
 "
