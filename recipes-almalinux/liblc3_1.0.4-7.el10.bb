# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblc3"
PV = "1.0.4"
PR = "7.el10"
PACKAGES = " \
 liblc3 \
 liblc3-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/liblc3-1.0.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3e4848f6b6a1252c39bc0c81a6007a1486e15d7bea22c3e154cac536d3b831b"

URI_x86_64_v2_liblc3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblc3-1.0.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_liblc3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblc3}"
SRC_URI[x86_64_v2_liblc3.sha256sum] = "363fcdd915cdd424f6444bdc943a45cbaa5d4f9d402113ac7fa42060ac88c6d5"

URI_x86_64_v2_liblc3-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/liblc3-devel-1.0.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_liblc3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblc3-devel}"
SRC_URI[x86_64_v2_liblc3-devel.sha256sum] = "b05bed597495f6867943d6d1f890f7c4573658198d0641b50d2babc832bb1959"

URI_aarch64_liblc3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblc3-1.0.4-7.el10.aarch64.rpm;name=aarch64_liblc3;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblc3}"
SRC_URI[aarch64_liblc3.sha256sum] = "63a8611a18e9700b8400cb5618c2a24aaf19f2f802cc0225d029526e3e7b6f0d"

URI_aarch64_liblc3-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/liblc3-devel-1.0.4-7.el10.aarch64.rpm;name=aarch64_liblc3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblc3-devel}"
SRC_URI[aarch64_liblc3-devel.sha256sum] = "3856a20b309ea13f315b09488fd328bd8df6330a71b170705b068ab0abf568c5"

RDEPENDS:liblc3 = " \
 glibc \
 "
RDEPENDS:liblc3-devel = " \
 liblc3 \
 pkgconf-pkg-config \
 "
