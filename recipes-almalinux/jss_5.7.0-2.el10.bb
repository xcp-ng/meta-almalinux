# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jss"
PV = "5.7.0"
PR = "2.el10"
PACKAGES = " \
 idm-jss \
 idm-jss-tomcat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jss-5.7.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e6204f7f59fea88ecb1f69e07115975ee00892e0a2fea6f36382e171965f9eb"

URI_x86_64_v2_idm-jss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-jss-5.7.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_idm-jss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-jss}"
SRC_URI[x86_64_v2_idm-jss.sha256sum] = "779958f94c229e0d252f32b960cb8c37a53315dcf259bbc288d2f980dfe546c9"

URI_x86_64_v2_idm-jss-tomcat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-jss-tomcat-5.7.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_idm-jss-tomcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-jss-tomcat}"
SRC_URI[x86_64_v2_idm-jss-tomcat.sha256sum] = "4bff1da15a8b62b637f84889413fad96e0cdfb01bd54ef282b4e31b013c0e2e5"

URI_aarch64_idm-jss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-jss-5.7.0-2.el10.aarch64.rpm;name=aarch64_idm-jss;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-jss}"
SRC_URI[aarch64_idm-jss.sha256sum] = "193d4a1f4b3f9bb79f61c9283469d6ea79ce9a35582072b339021d646de79843"

URI_aarch64_idm-jss-tomcat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-jss-tomcat-5.7.0-2.el10.aarch64.rpm;name=aarch64_idm-jss-tomcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-jss-tomcat}"
SRC_URI[aarch64_idm-jss-tomcat.sha256sum] = "9962537be46a4b302bf7f17594a640b79f254d59c30c2dac794296ff17c2d9b3"

RDEPENDS:idm-jss = " \
 apache-commons-lang3 \
 glibc \
 java-21-openjdk-headless \
 javapackages-filesystem \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 slf4j \
 slf4j-jdk14 \
 "
RDEPENDS:idm-jss-tomcat = " \
 idm-jss \
 javapackages-filesystem \
 tomcat9 \
 virtual/mvn_org.apache.tomcat_tomcat-catalina_ \
 virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 \
 virtual/mvn_org.apache.tomcat_tomcat-coyote_ \
 virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 \
 virtual/mvn_org.apache.tomcat_tomcat-juli_ \
 virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62 \
 "
