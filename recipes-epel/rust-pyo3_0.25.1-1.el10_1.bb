# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3"
PV = "0.25.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3+abi3-devel \
 rust-pyo3+abi3-py310-devel \
 rust-pyo3+abi3-py311-devel \
 rust-pyo3+abi3-py312-devel \
 rust-pyo3+abi3-py313-devel \
 rust-pyo3+abi3-py314-devel \
 rust-pyo3+abi3-py37-devel \
 rust-pyo3+abi3-py38-devel \
 rust-pyo3+abi3-py39-devel \
 rust-pyo3+anyhow-devel \
 rust-pyo3+arc_lock-devel \
 rust-pyo3+auto-initialize-devel \
 rust-pyo3+bigdecimal-devel \
 rust-pyo3+chrono-devel \
 rust-pyo3+chrono-local-devel \
 rust-pyo3+chrono-tz-devel \
 rust-pyo3+default-devel \
 rust-pyo3+either-devel \
 rust-pyo3+experimental-async-devel \
 rust-pyo3+experimental-inspect-devel \
 rust-pyo3+extension-module-devel \
 rust-pyo3+eyre-devel \
 rust-pyo3+full-devel \
 rust-pyo3+hashbrown-devel \
 rust-pyo3+indexmap-devel \
 rust-pyo3+indoc-devel \
 rust-pyo3+inventory-devel \
 rust-pyo3+jiff-02-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3+macros-devel \
 rust-pyo3+multiple-pymethods-devel \
 rust-pyo3+nightly-devel \
 rust-pyo3+num-bigint-devel \
 rust-pyo3+num-complex-devel \
 rust-pyo3+num-rational-devel \
 rust-pyo3+ordered-float-devel \
 rust-pyo3+parking_lot-devel \
 rust-pyo3+py-clone-devel \
 rust-pyo3+pyo3-macros-devel \
 rust-pyo3+rust_decimal-devel \
 rust-pyo3+serde-devel \
 rust-pyo3+smallvec-devel \
 rust-pyo3+time-devel \
 rust-pyo3+unindent-devel \
 rust-pyo3+uuid-devel \
 rust-pyo3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-0.25.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8f15dbb3df549580f425f1d7b328a7c78f5bc0d6e7954d9a93f859616760614"

URI_x86_64_v2_rust-pyo3+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-devel.sha256sum] = "3cd00e6e4d475d6ccdebccb0dde8ba34f8a77169517b77f8872eda6d24b198b0"

URI_x86_64_v2_rust-pyo3+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py310-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py310-devel.sha256sum] = "4ac440820373eca2995c5044f3c9b69a7eba1a3ff85c13eef2ca0f0af4a8a3e4"

URI_x86_64_v2_rust-pyo3+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py311-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py311-devel.sha256sum] = "a5b1a1ab91e7e7379633631d87e960f379c8cec0096ec1d26ce69738336d576d"

URI_x86_64_v2_rust-pyo3+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py312-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py312-devel.sha256sum] = "bb8b28320d5d24ee37920a8550d42a85e3b751b5f30fec7794575dc2df350e20"

URI_x86_64_v2_rust-pyo3+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py313-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py313-devel.sha256sum] = "81aa43df33c390bd9a2aa3996028f12a0fd8b7d76d1732bd2fe124a444d3126c"

URI_x86_64_v2_rust-pyo3+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py314-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py314-devel.sha256sum] = "9061803828ea9507fff747b47116a981030a62d68424aa2782edd9c546eadc0b"

URI_x86_64_v2_rust-pyo3+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py37-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py37-devel.sha256sum] = "94bf37b750206bd849a179b3450e4d48aeb1e6eec0b6f22ee730d05f783b1b11"

URI_x86_64_v2_rust-pyo3+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py38-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py38-devel.sha256sum] = "90c06395ba4c6f90eedc71f9ec2aeec41cc1ee4609ade222b67a7bf9b3eab23b"

URI_x86_64_v2_rust-pyo3+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py39-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py39-devel.sha256sum] = "cc482e55b44725035c1f01d1f40549ce3b46f2776c8702abf797b4d941075b4d"

URI_x86_64_v2_rust-pyo3+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+anyhow-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+anyhow-devel}"
SRC_URI[x86_64_v2_rust-pyo3+anyhow-devel.sha256sum] = "3d5cb0b2fc06280760c34d9c57fced4f00adbcca171dbf43bbe1c7e18c4c0c12"

URI_x86_64_v2_rust-pyo3+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+arc_lock-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-pyo3+arc_lock-devel.sha256sum] = "b203ec837da7d2737f25027325d24d5d0b1f07f53709b9966a3ebb0c3969c11d"

URI_x86_64_v2_rust-pyo3+auto-initialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+auto-initialize-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+auto-initialize-devel}"
SRC_URI[x86_64_v2_rust-pyo3+auto-initialize-devel.sha256sum] = "7a2f6fc1950e868832345a07b39e6080eeeee83dce96dec666c60f4c33fcfd2e"

URI_x86_64_v2_rust-pyo3+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+bigdecimal-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3+bigdecimal-devel.sha256sum] = "4d2465c11dfeb36049a65f2fffdb812399895422156cd97896b0e870601ee8f1"

URI_x86_64_v2_rust-pyo3+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-devel.sha256sum] = "51f600686225dd7c6615bbbb92c90bcd5481fd865803dbfa8cb55f53087c4653"

URI_x86_64_v2_rust-pyo3+chrono-local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-local-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-local-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-local-devel.sha256sum] = "99de21d71918ef3acc0f73312954811a61116c6355b5ba287c705b941a6aa9ac"

URI_x86_64_v2_rust-pyo3+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-tz-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-tz-devel.sha256sum] = "1d70dc75c33894de8ec812cadbaec7dc48a42ac0c4868a35d2d292bd4b9cafab"

URI_x86_64_v2_rust-pyo3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+default-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3+default-devel.sha256sum] = "42b9d87618fee9454ed47aa9f3550a3aa3657b6f76c5975264eb426a0546e516"

URI_x86_64_v2_rust-pyo3+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+either-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+either-devel}"
SRC_URI[x86_64_v2_rust-pyo3+either-devel.sha256sum] = "55ef7e5d610eef06cee1f1e1456a8de0e811bb09b05962729be322d0f00478bb"

URI_x86_64_v2_rust-pyo3+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+experimental-async-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3+experimental-async-devel.sha256sum] = "8b071379c9205b6dc7a8252f968fdefafb14bcdc6f022227f75a19d99ac770a5"

URI_x86_64_v2_rust-pyo3+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+experimental-inspect-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3+experimental-inspect-devel.sha256sum] = "a3669b259e607a66aaf645c96419c8db9d4b5d95056c3247c6279cfcf29dd586"

URI_x86_64_v2_rust-pyo3+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+extension-module-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3+extension-module-devel.sha256sum] = "5ad08e2dce861e72ca0e624a6401b9a4dccefbf3c302a5397707495345140d1e"

URI_x86_64_v2_rust-pyo3+eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+eyre-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+eyre-devel}"
SRC_URI[x86_64_v2_rust-pyo3+eyre-devel.sha256sum] = "39c0113806c02d813db8bb220c5e34fa47adb02b667802f41b2c50a44fdc534a"

URI_x86_64_v2_rust-pyo3+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+full-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+full-devel}"
SRC_URI[x86_64_v2_rust-pyo3+full-devel.sha256sum] = "7a7b86be80e61645930a8cc1e27c66bf8cfcabdccd188cf586dc6104d64a0837"

URI_x86_64_v2_rust-pyo3+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+hashbrown-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-pyo3+hashbrown-devel.sha256sum] = "f3303cd598c75385f61ca8a1fbfe1ee1bdbe6aac33f109660e9796654f0b890d"

URI_x86_64_v2_rust-pyo3+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+indexmap-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+indexmap-devel}"
SRC_URI[x86_64_v2_rust-pyo3+indexmap-devel.sha256sum] = "0234c80947854097b1783794fa7a5c97a8c3744407411a82a8af985078d6eca6"

URI_x86_64_v2_rust-pyo3+indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+indoc-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+indoc-devel}"
SRC_URI[x86_64_v2_rust-pyo3+indoc-devel.sha256sum] = "d3f9a0053486437722e3305e8063fd410e760b951ea8affaaa441c094f2c8da3"

URI_x86_64_v2_rust-pyo3+inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+inventory-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+inventory-devel}"
SRC_URI[x86_64_v2_rust-pyo3+inventory-devel.sha256sum] = "78d433ce7a496a70b1cee2a9e6f2105302894a943e979fffe828cf0350c0e5df"

URI_x86_64_v2_rust-pyo3+jiff-02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+jiff-02-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+jiff-02-devel}"
SRC_URI[x86_64_v2_rust-pyo3+jiff-02-devel.sha256sum] = "fd1e6ee0ccd3f323324332c75b97caf345f4cff3b5b2073a59fdd2c5ffe04fe5"

URI_x86_64_v2_rust-pyo3+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+lock_api-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+lock_api-devel}"
SRC_URI[x86_64_v2_rust-pyo3+lock_api-devel.sha256sum] = "78d76dabc34c3b3aca614e28850e91f56b45d92b1261d6b7bca3df52db28a311"

URI_x86_64_v2_rust-pyo3+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+macros-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3+macros-devel.sha256sum] = "ed3e6d1a8d71da99810ce4ab3acd949c94ba4801f963571be09cd29381018f79"

URI_x86_64_v2_rust-pyo3+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+multiple-pymethods-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3+multiple-pymethods-devel.sha256sum] = "b0e33f08015b239136f0f2da819b9e385857c6b38a4e081f7bf6027f148b1604"

URI_x86_64_v2_rust-pyo3+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+nightly-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+nightly-devel}"
SRC_URI[x86_64_v2_rust-pyo3+nightly-devel.sha256sum] = "aec53344e43f7e3af0dfad783f0f1f83d6d302592b0495da5887b8c683a5468c"

URI_x86_64_v2_rust-pyo3+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-bigint-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-bigint-devel.sha256sum] = "cc394b69f00a2eea2d7259e88546ffcdf62c34a156e7d1e0b0d10bc7c6b10f87"

URI_x86_64_v2_rust-pyo3+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-complex-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-complex-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-complex-devel.sha256sum] = "f26c5fb527967a9db7b0b45b9185aca73d4a9ba458eff715f06d50ccc1ad4d9c"

URI_x86_64_v2_rust-pyo3+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-rational-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-rational-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-rational-devel.sha256sum] = "84c25d3fea5f4411e85bbf223aab7281753957dee5fec09b7236140f2d04a479"

URI_x86_64_v2_rust-pyo3+ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+ordered-float-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+ordered-float-devel}"
SRC_URI[x86_64_v2_rust-pyo3+ordered-float-devel.sha256sum] = "5a32e5cee37f11ca54772236100113c96b401d3be559bf7ec6c9d721b000e529"

URI_x86_64_v2_rust-pyo3+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+parking_lot-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-pyo3+parking_lot-devel.sha256sum] = "707e6454076aeeab3b43945d4de5391ad6b7027a5af36fbea39f8ff18d5a2579"

URI_x86_64_v2_rust-pyo3+py-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+py-clone-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+py-clone-devel}"
SRC_URI[x86_64_v2_rust-pyo3+py-clone-devel.sha256sum] = "b4dfa207c09dff09d0ab408dc03c95455ed391b184e1830d1ddb546dfb8f12af"

URI_x86_64_v2_rust-pyo3+pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+pyo3-macros-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3+pyo3-macros-devel.sha256sum] = "1e5849bb9a8c17bc8e1a2fdd7879fa9d909ef23e373d00a84925a293e6e8d696"

URI_x86_64_v2_rust-pyo3+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+rust_decimal-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3+rust_decimal-devel.sha256sum] = "357dd4ea442e813c01c10639e984ca2633c867beb1e53aa8c3377c6c4b9d17de"

URI_x86_64_v2_rust-pyo3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+serde-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+serde-devel}"
SRC_URI[x86_64_v2_rust-pyo3+serde-devel.sha256sum] = "5abbfcab11f486142e88ce0438d9a2dcd3c00696b3e0173f7e00c55b760ffb53"

URI_x86_64_v2_rust-pyo3+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+smallvec-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+smallvec-devel}"
SRC_URI[x86_64_v2_rust-pyo3+smallvec-devel.sha256sum] = "bf4048cd66ae1bb269ca87788561782c44f4de227fd2761b93b7558334e170a6"

URI_x86_64_v2_rust-pyo3+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+time-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+time-devel}"
SRC_URI[x86_64_v2_rust-pyo3+time-devel.sha256sum] = "80378a45c7e6e6187b6a38041cf9c7b15c8407ac1213455f1a643302f3016a7f"

URI_x86_64_v2_rust-pyo3+unindent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+unindent-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+unindent-devel}"
SRC_URI[x86_64_v2_rust-pyo3+unindent-devel.sha256sum] = "4f0a26356711f52b17696c3fa1c9a2e465812c5fb1f180aa1634e31de0c10675"

URI_x86_64_v2_rust-pyo3+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+uuid-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+uuid-devel}"
SRC_URI[x86_64_v2_rust-pyo3+uuid-devel.sha256sum] = "a9f47dd6b44f54b3af971ae465f6c3020ca64deec3b2ca1f0b1d5852591f789c"

URI_x86_64_v2_rust-pyo3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-devel.sha256sum] = "507fbc9f2bd7dea176a45dbd79f10fb8421152663dab2f9e6890f225b363b4d7"

URI_aarch64_rust-pyo3+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-devel.sha256sum] = "323d717e838ce1a04d6e5c1afd7d17a3b135276e2d394ebf6fabb2a7d91d7390"

URI_aarch64_rust-pyo3+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py310-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py310-devel.sha256sum] = "332b9f08ab6fd177b31c4882da4384c89cb9bc240de3d637072aa105a304d265"

URI_aarch64_rust-pyo3+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py311-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py311-devel.sha256sum] = "5f22997a217bb5e0e07f9f2579ef74cd86d275dd8373b4925b740f6f93632341"

URI_aarch64_rust-pyo3+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py312-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py312-devel.sha256sum] = "95ee9eb2d88dd2335c54efbb87842a63bc0ae7b7e7faccc09590899caaca0cd5"

URI_aarch64_rust-pyo3+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py313-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py313-devel.sha256sum] = "251e84d216238b86d646e1ac8a452f4a8dab9c1f8f40d51cce7b6e5b0fd62001"

URI_aarch64_rust-pyo3+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py314-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py314-devel.sha256sum] = "020794598b0f71f8b48233f541bc9eb365e7f3c5b9c107b9599c240054834243"

URI_aarch64_rust-pyo3+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py37-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py37-devel.sha256sum] = "f017baa083914c1b06e80d11ef49f8033a5015cda06db3ea188d14c1389395d8"

URI_aarch64_rust-pyo3+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py38-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py38-devel.sha256sum] = "8b8f7fe7de38cd1dbaa3e124ac042d6bdeb7649b9231aeb5e947577bbab99467"

URI_aarch64_rust-pyo3+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py39-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py39-devel.sha256sum] = "29274863f5b82ecc3eb8c3ca98ff889bb2359a54e3e7a211e2d45a775370a12f"

URI_aarch64_rust-pyo3+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+anyhow-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+anyhow-devel}"
SRC_URI[aarch64_rust-pyo3+anyhow-devel.sha256sum] = "a580e374f2b563aa73b8ded5ebdc1a0e17aaefef0a417c2f9077e01362a26ccc"

URI_aarch64_rust-pyo3+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+arc_lock-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+arc_lock-devel}"
SRC_URI[aarch64_rust-pyo3+arc_lock-devel.sha256sum] = "c96d72824b3d7c83239e7996224771713bae77f47a087129ae563b15b29e5364"

URI_aarch64_rust-pyo3+auto-initialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+auto-initialize-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+auto-initialize-devel}"
SRC_URI[aarch64_rust-pyo3+auto-initialize-devel.sha256sum] = "5c0edc092ca6e8f1f79ce788b3e438697631cbbcd7fee03b0bc518213fc4451c"

URI_aarch64_rust-pyo3+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+bigdecimal-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+bigdecimal-devel}"
SRC_URI[aarch64_rust-pyo3+bigdecimal-devel.sha256sum] = "ee54550ac9ef3674bdce1b75748c426c1e28184c3b87efd2534d693f3275d2fd"

URI_aarch64_rust-pyo3+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-devel.sha256sum] = "7ce0ffbaa65929714dafe01cca566591dd3649372e7af87a97a22fa80d10766b"

URI_aarch64_rust-pyo3+chrono-local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-local-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-local-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-local-devel.sha256sum] = "5283573f1c43c8490b4ee66bb4fe6ea7c125878b15d0f9654db019fe9a33c7f3"

URI_aarch64_rust-pyo3+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-tz-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-tz-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-tz-devel.sha256sum] = "3f76b1f1d963fbbc84f9109ad3fd80cdbc46f663cd00c88c8c362512f5da4a6a"

URI_aarch64_rust-pyo3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+default-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+default-devel}"
SRC_URI[aarch64_rust-pyo3+default-devel.sha256sum] = "fcb5c82c9ba843528ab761c11e7007c2eadb2ba73cc00ac006ba4fa76e3de69f"

URI_aarch64_rust-pyo3+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+either-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+either-devel}"
SRC_URI[aarch64_rust-pyo3+either-devel.sha256sum] = "dcc95478eeb59ce1b5a7b462a36764c43583295d0c37617ede1fb3a1d40912e2"

URI_aarch64_rust-pyo3+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+experimental-async-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3+experimental-async-devel.sha256sum] = "5dc5f3b95f55ef7b6fad36b9aa3b4f242c1d676d20be2e0024e518ed570cb20b"

URI_aarch64_rust-pyo3+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+experimental-inspect-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3+experimental-inspect-devel.sha256sum] = "c93b7238e849a1648a14b1e2a929eff5ec56fddc19ff12982188b46151b11ced"

URI_aarch64_rust-pyo3+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+extension-module-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3+extension-module-devel.sha256sum] = "3b1b859d4c0e983eb78f2073fa0146e9dadb5f32148d6a3c2748b29aff407bfc"

URI_aarch64_rust-pyo3+eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+eyre-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+eyre-devel}"
SRC_URI[aarch64_rust-pyo3+eyre-devel.sha256sum] = "2509554e5bca9f77a2f5c2bd0fda1d8d9e54515650821367e7a0a8075c7d1791"

URI_aarch64_rust-pyo3+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+full-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+full-devel}"
SRC_URI[aarch64_rust-pyo3+full-devel.sha256sum] = "7a33f33964d9c00b1d9bcffb96038101943837c109eb02ca9d5c4d5304e5a053"

URI_aarch64_rust-pyo3+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+hashbrown-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+hashbrown-devel}"
SRC_URI[aarch64_rust-pyo3+hashbrown-devel.sha256sum] = "c6c52a3ff7f16b74d2b00be0f69a8fefff1cc2fb6c33d0bd24d7c2c75d1fe19f"

URI_aarch64_rust-pyo3+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+indexmap-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+indexmap-devel}"
SRC_URI[aarch64_rust-pyo3+indexmap-devel.sha256sum] = "6fa447746a03a5fc1675cccbe30203baec2860328a07d36ad9b8f267ac2df32b"

URI_aarch64_rust-pyo3+indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+indoc-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+indoc-devel}"
SRC_URI[aarch64_rust-pyo3+indoc-devel.sha256sum] = "c1e0df56cbc76c823c89ba21ebcf702d15e998a48e142960d40782e9a6a2bb40"

URI_aarch64_rust-pyo3+inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+inventory-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+inventory-devel}"
SRC_URI[aarch64_rust-pyo3+inventory-devel.sha256sum] = "1f228733b78e553bc458a752bb21b506ad1e3141b9a53cf5035b00107695367a"

URI_aarch64_rust-pyo3+jiff-02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+jiff-02-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+jiff-02-devel}"
SRC_URI[aarch64_rust-pyo3+jiff-02-devel.sha256sum] = "6559beed249d4132283bc2af0398d95f1f78fff210338b13de5f1496c55f7762"

URI_aarch64_rust-pyo3+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+lock_api-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+lock_api-devel}"
SRC_URI[aarch64_rust-pyo3+lock_api-devel.sha256sum] = "aefcb1b17b010fa7ca75b0fe946755dc164f33a43477aee761e15367714fe556"

URI_aarch64_rust-pyo3+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+macros-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+macros-devel}"
SRC_URI[aarch64_rust-pyo3+macros-devel.sha256sum] = "14929d62ae8be3eec7e08ee4d898f29ee9b91986dc9463af328c2ad2722a8ad4"

URI_aarch64_rust-pyo3+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+multiple-pymethods-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3+multiple-pymethods-devel.sha256sum] = "62a78331726757763fa51dd3abf64800ae1c3cdc705a221236f8972abf81c2d3"

URI_aarch64_rust-pyo3+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+nightly-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+nightly-devel}"
SRC_URI[aarch64_rust-pyo3+nightly-devel.sha256sum] = "5b177674f4656eea96a7b541d3b5f2a3ee24f27173e6d91af49f6fd7297e5a13"

URI_aarch64_rust-pyo3+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-bigint-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-bigint-devel}"
SRC_URI[aarch64_rust-pyo3+num-bigint-devel.sha256sum] = "64ae7f4ece0b78d4a244d449aaef1ac01e0a1f8d56ccc905356a1fab77ab42ca"

URI_aarch64_rust-pyo3+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-complex-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-complex-devel}"
SRC_URI[aarch64_rust-pyo3+num-complex-devel.sha256sum] = "2378070c4c865f209fc1cf92951ced2901875a56b2bcfcfc0a9d085082954355"

URI_aarch64_rust-pyo3+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-rational-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-rational-devel}"
SRC_URI[aarch64_rust-pyo3+num-rational-devel.sha256sum] = "e9263e01cef398ad157ebb89985a9fc4bb8c78fe47a8ebc984157898fc980759"

URI_aarch64_rust-pyo3+ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+ordered-float-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+ordered-float-devel}"
SRC_URI[aarch64_rust-pyo3+ordered-float-devel.sha256sum] = "7b318cc900b2bbbf3d0088885a05d0aa81ba1db1e6e9e822a5c818eca6368358"

URI_aarch64_rust-pyo3+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+parking_lot-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+parking_lot-devel}"
SRC_URI[aarch64_rust-pyo3+parking_lot-devel.sha256sum] = "4d40025323bcbc5f2b874597887e6d596257e4b9b822a1d23a22dfabd54e10ca"

URI_aarch64_rust-pyo3+py-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+py-clone-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+py-clone-devel}"
SRC_URI[aarch64_rust-pyo3+py-clone-devel.sha256sum] = "9c6159e90450c1414bfc67efdf6345cf1086d13c6148724f0d96aa60bb21f8bd"

URI_aarch64_rust-pyo3+pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+pyo3-macros-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3+pyo3-macros-devel.sha256sum] = "ad3d805955f669dd3870f366b082eab64359a0e207e5090edeeb682bddf16c69"

URI_aarch64_rust-pyo3+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+rust_decimal-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+rust_decimal-devel}"
SRC_URI[aarch64_rust-pyo3+rust_decimal-devel.sha256sum] = "9cd8bb36a5547958e656eb72803d5f644fdd1655c7f90dc37120be18c2bf502b"

URI_aarch64_rust-pyo3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+serde-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+serde-devel}"
SRC_URI[aarch64_rust-pyo3+serde-devel.sha256sum] = "4cc4e2a098debd07986f0c50fd47b45cdc52a624547a609ed117dfa7fb5f71ba"

URI_aarch64_rust-pyo3+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+smallvec-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+smallvec-devel}"
SRC_URI[aarch64_rust-pyo3+smallvec-devel.sha256sum] = "7404d33e1a65a2f4fdeb35877aa4f7944cbf02f8d7bf6859d074fd68f297ca2b"

URI_aarch64_rust-pyo3+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+time-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+time-devel}"
SRC_URI[aarch64_rust-pyo3+time-devel.sha256sum] = "653f886e8212311baf31e303137e8721cbbca5b763908be679668f46a34641e5"

URI_aarch64_rust-pyo3+unindent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+unindent-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+unindent-devel}"
SRC_URI[aarch64_rust-pyo3+unindent-devel.sha256sum] = "3c2971dc9c647ba21f69bf10d546cec7abf861b2bcbe535bb196f76c446465f6"

URI_aarch64_rust-pyo3+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+uuid-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+uuid-devel}"
SRC_URI[aarch64_rust-pyo3+uuid-devel.sha256sum] = "3b209ba8cacc2de2859ec1d0a49107a687d9557f8cdcb433467f189ab7e06615"

URI_aarch64_rust-pyo3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-devel}"
SRC_URI[aarch64_rust-pyo3-devel.sha256sum] = "b3b6d223b269bdc5b36468f586a8e38423b42d28cba7db99dab47b03d6086a7d"

RDEPENDS:rust-pyo3+abi3-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-devel \
 "
RDEPENDS:rust-pyo3+abi3-py310-devel = " \
 cargo \
 rust-pyo3+abi3-py311-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py310-devel \
 "
RDEPENDS:rust-pyo3+abi3-py311-devel = " \
 cargo \
 rust-pyo3+abi3-py312-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py311-devel \
 "
RDEPENDS:rust-pyo3+abi3-py312-devel = " \
 cargo \
 rust-pyo3+abi3-py313-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py312-devel \
 "
RDEPENDS:rust-pyo3+abi3-py313-devel = " \
 cargo \
 rust-pyo3+abi3-py314-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py313-devel \
 "
RDEPENDS:rust-pyo3+abi3-py314-devel = " \
 cargo \
 rust-pyo3+abi3-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py314-devel \
 "
RDEPENDS:rust-pyo3+abi3-py37-devel = " \
 cargo \
 rust-pyo3+abi3-py38-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py37-devel \
 "
RDEPENDS:rust-pyo3+abi3-py38-devel = " \
 cargo \
 rust-pyo3+abi3-py39-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py38-devel \
 "
RDEPENDS:rust-pyo3+abi3-py39-devel = " \
 cargo \
 rust-pyo3+abi3-py310-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py39-devel \
 "
RDEPENDS:rust-pyo3+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+arc_lock-devel = " \
 cargo \
 rust-lock_api+arc_lock-devel \
 rust-lock_api+default-devel \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+default-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+auto-initialize-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-local-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+default-devel = " \
 cargo \
 rust-pyo3+macros-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+experimental-async-devel = " \
 cargo \
 rust-pyo3+macros-devel \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-async-devel \
 "
RDEPENDS:rust-pyo3+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-inspect-devel \
 "
RDEPENDS:rust-pyo3+extension-module-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-ffi+extension-module-devel \
 "
RDEPENDS:rust-pyo3+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+full-devel = " \
 cargo \
 rust-pyo3+anyhow-devel \
 rust-pyo3+arc_lock-devel \
 rust-pyo3+bigdecimal-devel \
 rust-pyo3+chrono-devel \
 rust-pyo3+chrono-local-devel \
 rust-pyo3+chrono-tz-devel \
 rust-pyo3+either-devel \
 rust-pyo3+experimental-async-devel \
 rust-pyo3+experimental-inspect-devel \
 rust-pyo3+eyre-devel \
 rust-pyo3+hashbrown-devel \
 rust-pyo3+indexmap-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3+macros-devel \
 rust-pyo3+num-bigint-devel \
 rust-pyo3+num-complex-devel \
 rust-pyo3+num-rational-devel \
 rust-pyo3+ordered-float-devel \
 rust-pyo3+parking_lot-devel \
 rust-pyo3+py-clone-devel \
 rust-pyo3+rust_decimal-devel \
 rust-pyo3+serde-devel \
 rust-pyo3+smallvec-devel \
 rust-pyo3+uuid-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+hashbrown-devel = " \
 cargo \
 rust-pyo3-devel \
 virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ \
 "
RDEPENDS:rust-pyo3+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+indoc-devel = " \
 cargo \
 rust-indoc+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+lock_api-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+macros-devel = " \
 cargo \
 rust-pyo3+indoc-devel \
 rust-pyo3+pyo3-macros-devel \
 rust-pyo3+unindent-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3+inventory-devel \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+multiple-pymethods-devel \
 "
RDEPENDS:rust-pyo3+nightly-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+ordered-float-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+py-clone-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 "
RDEPENDS:rust-pyo3+rust_decimal-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3+serde-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3+smallvec-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3+time-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-time-devel \
 "
RDEPENDS:rust-pyo3+unindent-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-unindent+default-devel \
 "
RDEPENDS:rust-pyo3+uuid-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-pyo3-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-memoffset+default-devel \
 rust-once_cell+default-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+resolve-config-devel \
 rust-pyo3-ffi+default-devel \
 "
