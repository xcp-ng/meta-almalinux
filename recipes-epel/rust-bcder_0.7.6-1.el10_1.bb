# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bcder"
PV = "0.7.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-bcder+default-devel \
 rust-bcder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bcder-0.7.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13776a686aff710784c01350940cea11e7a4507a31f7aa6306eee9b7f24c1c4b"

URI_x86_64_v2_rust-bcder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcder+default-devel-0.7.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcder+default-devel}"
SRC_URI[x86_64_v2_rust-bcder+default-devel.sha256sum] = "336393d9dc61d25169427d34713d5065b6174aa2bcaeafda6e4d2d3d897157a4"

URI_x86_64_v2_rust-bcder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bcder-devel-0.7.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bcder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bcder-devel}"
SRC_URI[x86_64_v2_rust-bcder-devel.sha256sum] = "8704e31e8a026d05cd36a9f440d06738a896e01d2b8fbf7fe45932c5837dac21"

URI_aarch64_rust-bcder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcder+default-devel-0.7.6-1.el10_1.noarch.rpm;name=aarch64_rust-bcder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcder+default-devel}"
SRC_URI[aarch64_rust-bcder+default-devel.sha256sum] = "9b7072bd0866f3063a0d77bfee3442dee151cee5481cdefab0f8a987b29aa864"

URI_aarch64_rust-bcder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bcder-devel-0.7.6-1.el10_1.noarch.rpm;name=aarch64_rust-bcder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bcder-devel}"
SRC_URI[aarch64_rust-bcder-devel.sha256sum] = "e86cf697ad548368d8136469102bd32de41d5acb6c8d53e2d7e150b0916d42ce"

RDEPENDS:rust-bcder+default-devel = " \
 cargo \
 rust-bcder-devel \
 "
RDEPENDS:rust-bcder-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-smallvec+default-devel \
 "
