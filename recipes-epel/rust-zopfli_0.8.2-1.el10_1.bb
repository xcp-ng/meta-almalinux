# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zopfli"
PV = "0.8.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-zopfli+default-devel \
 rust-zopfli+gzip-devel \
 rust-zopfli+std-devel \
 rust-zopfli+zlib-devel \
 rust-zopfli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zopfli-0.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "863222842f8092aaeb3f7390bb386e3a98add40ab154849972a74988b92c6307"

URI_x86_64_v2_rust-zopfli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+default-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+default-devel}"
SRC_URI[x86_64_v2_rust-zopfli+default-devel.sha256sum] = "c6a69adaaad7c94c04b52789067f863e07987e246fc6f2b5745dc5cb156a1afc"

URI_x86_64_v2_rust-zopfli+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+gzip-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+gzip-devel}"
SRC_URI[x86_64_v2_rust-zopfli+gzip-devel.sha256sum] = "7b61d967814436794a3f7d841a807510ccbcf33ad03a5bce62a416f1b0a9847f"

URI_x86_64_v2_rust-zopfli+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+std-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+std-devel}"
SRC_URI[x86_64_v2_rust-zopfli+std-devel.sha256sum] = "e4f4ce4ccdaa699068abee413afa5404a63b4b37499850cdb7133855ed07b266"

URI_x86_64_v2_rust-zopfli+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+zlib-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+zlib-devel}"
SRC_URI[x86_64_v2_rust-zopfli+zlib-devel.sha256sum] = "e2632c97873c1728eb2c9a9a04afefe28a14d7a1b46a2b16ff2dc08ad32ebfe6"

URI_x86_64_v2_rust-zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli-devel}"
SRC_URI[x86_64_v2_rust-zopfli-devel.sha256sum] = "1a8066de84e603bcfd0a1970f4d439f0f268a6e13792fd5d7834a568166be9d2"

URI_aarch64_rust-zopfli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+default-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zopfli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+default-devel}"
SRC_URI[aarch64_rust-zopfli+default-devel.sha256sum] = "48c1e0ac24bd4c88afd42d243084cc5395d0c744778367e7d51c821840c67ae2"

URI_aarch64_rust-zopfli+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+gzip-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zopfli+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+gzip-devel}"
SRC_URI[aarch64_rust-zopfli+gzip-devel.sha256sum] = "920859cb6bbdcb707addc59fb6fd947d34333bbb77f4732c02d5888f8b221789"

URI_aarch64_rust-zopfli+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+std-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zopfli+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+std-devel}"
SRC_URI[aarch64_rust-zopfli+std-devel.sha256sum] = "f05dcc80e8eb31157f48e82def5596837901b00b2c1ada6732303f6f078db15f"

URI_aarch64_rust-zopfli+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+zlib-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zopfli+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+zlib-devel}"
SRC_URI[aarch64_rust-zopfli+zlib-devel.sha256sum] = "c7bd785b23cdcbbcf8d4e17872f3412c5e23db32bb7be04bbced5b5230c9d4d8"

URI_aarch64_rust-zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli-devel}"
SRC_URI[aarch64_rust-zopfli-devel.sha256sum] = "66da6f54da0866926ee3ea8b8a3c3f27bebe98da311b4f77060f133a3a057a08"

RDEPENDS:rust-zopfli+default-devel = " \
 cargo \
 rust-zopfli+gzip-devel \
 rust-zopfli+std-devel \
 rust-zopfli+zlib-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli+gzip-devel = " \
 cargo \
 rust-crc32fast-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli+std-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 rust-log+default-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli+zlib-devel = " \
 cargo \
 rust-simd-adler32-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli-devel = " \
 cargo \
 rust \
 rust-bumpalo+default-devel \
 "
