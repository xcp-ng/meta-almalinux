# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lzma-rust2"
PV = "0.19.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-lzma-rust2+default-devel \
 rust-lzma-rust2+encoder-devel \
 rust-lzma-rust2+lzip-devel \
 rust-lzma-rust2+optimization-devel \
 rust-lzma-rust2+sha2-devel \
 rust-lzma-rust2+std-devel \
 rust-lzma-rust2+xz-devel \
 rust-lzma-rust2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-lzma-rust2-0.19.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5494c6f48eab3f27d7b81412ec07a52aa6d5b16cf16d8703807607fbb133daf9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+default-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lzma-rust2+default-devel.sha256sum] = "6e8fd5942a18b5f945c8c226f9ba3e4d0b3f311350f45c2d75f15de7c3192fb0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+encoder-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+encoder-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lzma-rust2+encoder-devel.sha256sum] = "6fcdb8ef5bcf3e2c0fd284e96a204a01ebb28308d8dcb223e00a903796342a5b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+lzip-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+lzip-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lzma-rust2+lzip-devel.sha256sum] = "5116da67ac566e4d452e88ad6bf1b79f689d84235e9ac453bee33dcda4f1738b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+optimization-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+optimization-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lzma-rust2+optimization-devel.sha256sum] = "a7e16c6a078f30231f135d334d1a5c7e5998e725c706cedcd3e82835b568d6de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+sha2-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+sha2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lzma-rust2+sha2-devel.sha256sum] = "db8d44f9c1e1e902ce5e5821f316605ba9a963ff8a96c67c4d94c8e03258ee89"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+std-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lzma-rust2+std-devel.sha256sum] = "9ae6045c9ab3a4ef6ad366c202fe3eb859d62f2a31d537f99c6ebdaa63472c28"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2+xz-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2+xz-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lzma-rust2+xz-devel.sha256sum] = "90a7529b9f6c80a8ee170723a30c7d60d9721b7081bfa96fd1acd92a4a0d4aed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lzma-rust2-devel-0.19.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lzma-rust2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lzma-rust2-devel.sha256sum] = "53c7f723b9cf498e05bbabf6b9a53cc8ae3ce75814f948c7137f7938d497f292"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+default-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-lzma-rust2+default-devel;unpack=0"
SRC_URI[aarch64_rust-lzma-rust2+default-devel.sha256sum] = "5eaf62f2292ca0c1b7d78b2d9804d938444368d580882366f366795fbcb90703"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+encoder-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-lzma-rust2+encoder-devel;unpack=0"
SRC_URI[aarch64_rust-lzma-rust2+encoder-devel.sha256sum] = "146d5c161503f709337431ca12844f898a45ef1fe8fea96304e63f0504e4210d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+lzip-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-lzma-rust2+lzip-devel;unpack=0"
SRC_URI[aarch64_rust-lzma-rust2+lzip-devel.sha256sum] = "8e133cdbe7f64f4c52f0653b2c221156456aff284f6364939d58476f8e670b3e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+optimization-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-lzma-rust2+optimization-devel;unpack=0"
SRC_URI[aarch64_rust-lzma-rust2+optimization-devel.sha256sum] = "209442156c80afeb7223c50a7d02dde1732dd5fee0bac43468a810d9c80b5cbb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+sha2-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-lzma-rust2+sha2-devel;unpack=0"
SRC_URI[aarch64_rust-lzma-rust2+sha2-devel.sha256sum] = "489173f3e817a56c774e64b4de13b20d9868b6f074fde703a8dc69b2916d3d6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+std-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-lzma-rust2+std-devel;unpack=0"
SRC_URI[aarch64_rust-lzma-rust2+std-devel.sha256sum] = "8d6c6b7ef9bf1a31f655b9fc3ef03fe5c033b77feabff73eeb69845d7337c9b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2+xz-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-lzma-rust2+xz-devel;unpack=0"
SRC_URI[aarch64_rust-lzma-rust2+xz-devel.sha256sum] = "2a97ea02123d32d815040df2c5b743c3115ac1cf925ef9ea89ab47210cc614b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lzma-rust2-devel-0.19.0-1.el10_3.noarch.rpm;name=aarch64_rust-lzma-rust2-devel;unpack=0"
SRC_URI[aarch64_rust-lzma-rust2-devel.sha256sum] = "f31e568fbc6463f7f675a9f102a39cc5721cdb42f34acb6002055ace362e8198"

RDEPENDS:rust-lzma-rust2+default-devel = " \
 cargo \
 rust-lzma-rust2+encoder-devel \
 rust-lzma-rust2+lzip-devel \
 rust-lzma-rust2+optimization-devel \
 rust-lzma-rust2+std-devel \
 rust-lzma-rust2+xz-devel \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2+encoder-devel = " \
 cargo \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2+lzip-devel = " \
 cargo \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2+optimization-devel = " \
 cargo \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2+sha2-devel = " \
 cargo \
 rust-lzma-rust2-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-lzma-rust2+std-devel = " \
 cargo \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2+xz-devel = " \
 cargo \
 rust-lzma-rust2+sha2-devel \
 rust-lzma-rust2-devel \
 "
RDEPENDS:rust-lzma-rust2-devel = " \
 cargo \
 rust \
 "
