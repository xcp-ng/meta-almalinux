# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libopenraw"
PV = "0.1.3"
PR = "19.el10"
PACKAGES = " \
 libopenraw \
 libopenraw-devel \
 libopenraw-gnome \
 libopenraw-gnome-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libopenraw-0.1.3-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f345a0ab2e7adfd4e9d099a50fd38dc759ae9ab23700122478e6aa4c59792c25"

URI_x86_64_v2_libopenraw = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libopenraw-0.1.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_libopenraw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenraw}"
SRC_URI[x86_64_v2_libopenraw.sha256sum] = "6aed0be1771efa20e54684179862906ec52bc072124b875bda4d0ac1af8500e6"

URI_x86_64_v2_libopenraw-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libopenraw-devel-0.1.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_libopenraw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenraw-devel}"
SRC_URI[x86_64_v2_libopenraw-devel.sha256sum] = "fc1aa9103332ec27feb495ce7c88271cd96384ec6f535e8966882a11721aa826"

URI_x86_64_v2_libopenraw-gnome = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libopenraw-gnome-0.1.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_libopenraw-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenraw-gnome}"
SRC_URI[x86_64_v2_libopenraw-gnome.sha256sum] = "009693141927f791f9c49c88b99648cb7f6a81b4f1d12e4c145a38f742594f03"

URI_x86_64_v2_libopenraw-gnome-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libopenraw-gnome-devel-0.1.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_libopenraw-gnome-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopenraw-gnome-devel}"
SRC_URI[x86_64_v2_libopenraw-gnome-devel.sha256sum] = "7a5011cb242bee9e48aab5e292c26f5839cc3f4250022ebb9aa3f49ab9a0affb"

URI_aarch64_libopenraw = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libopenraw-0.1.3-19.el10.aarch64.rpm;name=aarch64_libopenraw;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenraw}"
SRC_URI[aarch64_libopenraw.sha256sum] = "3e2ffdf9fe0db85ffb8e860c8626e12c865861a465ded3fe80b49e1666fad770"

URI_aarch64_libopenraw-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libopenraw-devel-0.1.3-19.el10.aarch64.rpm;name=aarch64_libopenraw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenraw-devel}"
SRC_URI[aarch64_libopenraw-devel.sha256sum] = "7788f34983896bfe0f9a2933f8ee221ef705fbe9dad452c422dbe30dfb912be0"

URI_aarch64_libopenraw-gnome = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libopenraw-gnome-0.1.3-19.el10.aarch64.rpm;name=aarch64_libopenraw-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenraw-gnome}"
SRC_URI[aarch64_libopenraw-gnome.sha256sum] = "9e3cd94c59898da566da7c188540d35be67c3ab899d618c8c7f8cc32ea034d94"

URI_aarch64_libopenraw-gnome-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libopenraw-gnome-devel-0.1.3-19.el10.aarch64.rpm;name=aarch64_libopenraw-gnome-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopenraw-gnome-devel}"
SRC_URI[aarch64_libopenraw-gnome-devel.sha256sum] = "fc2dc93f7de05329d96ce2990e0b5e19b8d175c0c6fd54303d858550584051b1"

RDEPENDS:libopenraw = " \
 glibc \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 "
RDEPENDS:libopenraw-devel = " \
 libopenraw \
 pkgconf-pkg-config \
 "
RDEPENDS:libopenraw-gnome = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libopenraw \
 "
RDEPENDS:libopenraw-gnome-devel = " \
 libopenraw-devel \
 libopenraw-gnome \
 pkgconf-pkg-config \
 "
