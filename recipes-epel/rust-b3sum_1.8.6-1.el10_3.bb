# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-b3sum"
PV = "1.8.6"
PR = "1.el10_3"
PACKAGES = " \
 b3sum \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-b3sum-1.8.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0b07106bb67812b07d5c34656014515f6f32188d5a4d5c3dd34058c325ac186"

URI_x86_64_v2_b3sum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/b3sum-1.8.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_b3sum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_b3sum}"
SRC_URI[x86_64_v2_b3sum.sha256sum] = "720eafa7ee84427c7bd79233ebd8641639cc87076cf44e7c4a08b1c8ea8901db"

URI_aarch64_b3sum = "${EPEL_MIRROR}/aarch64/Packages/b/b3sum-1.8.6-1.el10_3.aarch64.rpm;name=aarch64_b3sum;unpack=0"
SRC_URI:append = " ${URI_aarch64_b3sum}"
SRC_URI[aarch64_b3sum.sha256sum] = "6eed0b066d05e7c3c99f61a76ee025c00107d7c5d506ff3334d011e07750ccdb"

RDEPENDS:b3sum = " \
 glibc \
 libgcc \
 "
