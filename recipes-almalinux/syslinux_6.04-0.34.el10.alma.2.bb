# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syslinux"
PV = "6.04"
PR = "0.34.el10.alma.2"
PACKAGES:x86_64_v2 = " \
 syslinux \
 syslinux-extlinux \
 syslinux-extlinux-nonlinux \
 syslinux-nonlinux \
 syslinux-tftpboot \
"
PACKAGES:aarch64 = " \
 syslinux-tftpboot \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/syslinux-6.04-0.34.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d1224516d52e87554c72d4a07826ed3002b822615ff98c1ded9a36e6cc12f46"

URI_x86_64_v2_syslinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-6.04-0.34.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_syslinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslinux}"
SRC_URI[x86_64_v2_syslinux.sha256sum] = "0c11c015af04359c8964911e8bc5bb300536c9ffe57bd20abe8e5937871350d8"

URI_x86_64_v2_syslinux-extlinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-extlinux-6.04-0.34.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_syslinux-extlinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslinux-extlinux}"
SRC_URI[x86_64_v2_syslinux-extlinux.sha256sum] = "e57bbb2bbb19f90e40ca24547d6c30cf481e818fb13beda2d93690b9e25bcd3f"

URI_x86_64_v2_syslinux-extlinux-nonlinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-extlinux-nonlinux-6.04-0.34.el10.alma.2.noarch.rpm;name=x86_64_v2_syslinux-extlinux-nonlinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslinux-extlinux-nonlinux}"
SRC_URI[x86_64_v2_syslinux-extlinux-nonlinux.sha256sum] = "8a462149764210c1b49f8283b9dde60ab6e586bc52a9c620c6473be422a66b7d"

URI_x86_64_v2_syslinux-nonlinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-nonlinux-6.04-0.34.el10.alma.2.noarch.rpm;name=x86_64_v2_syslinux-nonlinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslinux-nonlinux}"
SRC_URI[x86_64_v2_syslinux-nonlinux.sha256sum] = "b9f8651cb0411892cd4347497e6ecc0b22fbe96151dac0c32dd6cbce95b53c5a"

URI_x86_64_v2_syslinux-tftpboot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/syslinux-tftpboot-6.04-0.34.el10.alma.2.noarch.rpm;name=x86_64_v2_syslinux-tftpboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslinux-tftpboot}"
SRC_URI[x86_64_v2_syslinux-tftpboot.sha256sum] = "3ed466e1dbf6ff9dc5bb43450c53f26a51ef723b715e5163af27b656895a6d32"

URI_aarch64_syslinux-tftpboot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/syslinux-tftpboot-6.04-0.34.el10.alma.2.noarch.rpm;name=aarch64_syslinux-tftpboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslinux-tftpboot}"
SRC_URI[aarch64_syslinux-tftpboot.sha256sum] = "3ed466e1dbf6ff9dc5bb43450c53f26a51ef723b715e5163af27b656895a6d32"

RDEPENDS:syslinux = " \
 glibc \
 libuuid \
 mtools \
 syslinux-nonlinux \
 "
RDEPENDS:syslinux-extlinux = " \
 bash \
 glibc \
 syslinux \
 syslinux-extlinux-nonlinux \
 "
RDEPENDS:syslinux-extlinux-nonlinux = " \
 glibc \
 syslinux \
 "
RDEPENDS:syslinux-nonlinux = " \
 glibc \
 syslinux \
 "
RDEPENDS:syslinux-tftpboot = " \
 glibc \
 "
