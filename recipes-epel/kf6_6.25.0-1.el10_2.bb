# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-filesystem \
 kf6-rpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02bf13434fe8868b5ce6c6e81b168c7bdf48cb6e373590bb2226c81eb19671a8"

URI_x86_64_v2_kf6-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-filesystem-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-filesystem}"
SRC_URI[x86_64_v2_kf6-filesystem.sha256sum] = "2b5cbcdf7c3fd2ee5451c0f35ee26662d9084c7a56e4304dd1b8bf6f997f36fe"

URI_x86_64_v2_kf6-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-rpm-macros-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-rpm-macros}"
SRC_URI[x86_64_v2_kf6-rpm-macros.sha256sum] = "1369d90e77a4bd1c7811b1a956d05b015694be2b0a2253ba1d69f1db27e15edb"

URI_aarch64_kf6-filesystem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-filesystem-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-filesystem}"
SRC_URI[aarch64_kf6-filesystem.sha256sum] = "4c7266a2925e33cb4f8864dd4436bbdb78668194159000e32ce1a316f9c6f5f6"

URI_aarch64_kf6-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-rpm-macros-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-rpm-macros}"
SRC_URI[aarch64_kf6-rpm-macros.sha256sum] = "c11ef961d8fd3d04fda5101e2f933933d169256a549e71743640d11f2d34877e"

RDEPENDS:kf6-filesystem = " \
 kde-filesystem \
 "
RDEPENDS:kf6-rpm-macros = " \
 cmake \
 doxygen \
 gcc-c++ \
 kde-qdoc-common \
 qt6-doc-devel \
 qt6-qttools-devel \
 qt6-rpm-macros \
 "
