# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "katomic"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 katomic \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/katomic-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f33d35f3fddf7156d9a10ed48f315ea6f5c04522aee1400d61faf1c39048039e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/katomic-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_katomic;unpack=0"
SRC_URI[x86_64_v2_katomic.sha256sum] = "5d8341f42262cbc74869673800bf4699594601618defbffce123f60538dc21b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/katomic-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_katomic;unpack=0"
SRC_URI[aarch64_katomic.sha256sum] = "d99d5fa7c61a7436748d606f076a6f4acf0e162b297949d8fec68ba6a9964107"

RDEPENDS:katomic = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
