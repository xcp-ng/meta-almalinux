# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "easy-rsa"
PV = "3.2.4"
PR = "1.el10_1"
PACKAGES = " \
 easy-rsa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/easy-rsa-3.2.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "718d89095ad2a4e9a86343c6d46813fa2bcb977db3c6f7eb52cc2eabc44c183f"

URI_x86_64_v2_easy-rsa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/easy-rsa-3.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_easy-rsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_easy-rsa}"
SRC_URI[x86_64_v2_easy-rsa.sha256sum] = "8780e25bed0b000941aab760a3c820a14d9269e98eadc9af5e875e1bbbd1114c"

URI_aarch64_easy-rsa = "${EPEL_MIRROR}/aarch64/Packages/e/easy-rsa-3.2.4-1.el10_1.noarch.rpm;name=aarch64_easy-rsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_easy-rsa}"
SRC_URI[aarch64_easy-rsa.sha256sum] = "989a99006faab75a43e1b5c88fb4722f7aae2a52a88fa1afe5900fd882bdca84"

RDEPENDS:easy-rsa = " \
 bash \
 openssl \
 "
