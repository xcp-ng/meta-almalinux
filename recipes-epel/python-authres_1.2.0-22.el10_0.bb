# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-authres"
PV = "1.2.0"
PR = "22.el10_0"
PACKAGES = " \
 python3-authres \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-authres-1.2.0-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37894dcd8fb614cb83228cf164f1c7292a538cba28422ac497a49d55d7ca3aed"

URI_x86_64_v2_python3-authres = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-authres-1.2.0-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-authres;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-authres}"
SRC_URI[x86_64_v2_python3-authres.sha256sum] = "3f59a2e1880b7e38c9c1af2fb82a45985822c14edf1c11a75487e46eddc35ff9"

URI_aarch64_python3-authres = "${EPEL_MIRROR}/aarch64/Packages/p/python3-authres-1.2.0-22.el10_0.noarch.rpm;name=aarch64_python3-authres;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-authres}"
SRC_URI[aarch64_python3-authres.sha256sum] = "687ac38e5e883652afa6cb2e89efe44449a64fbc2ecdf83a1f501d72397af31a"

RDEPENDS:python3-authres = " \
 python3 \
 "
