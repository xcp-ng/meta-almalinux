# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-SQL-Translator"
PV = "1.66"
PR = "5.el10_3"
PACKAGES = " \
 perl-SQL-Translator \
 perl-SQL-Translator-Producer-Diagram \
 perl-SQL-Translator-Producer-GraphViz \
 perl-SQL-Translator-tests \
 sqlt-graph \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-SQL-Translator-1.66-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46e2318f1f76b3056bc73cd7e5629d3179cbc400fa990678bdccdf16c2532619"

URI_x86_64_v2_perl-SQL-Translator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Translator-1.66-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Translator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SQL-Translator}"
SRC_URI[x86_64_v2_perl-SQL-Translator.sha256sum] = "3633044bca23913dd55e23d649a1965191ddb1bedcead23d809d180e8c53d7f2"

URI_x86_64_v2_perl-SQL-Translator-Producer-Diagram = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Translator-Producer-Diagram-1.66-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Translator-Producer-Diagram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SQL-Translator-Producer-Diagram}"
SRC_URI[x86_64_v2_perl-SQL-Translator-Producer-Diagram.sha256sum] = "fcf3ba469f8b5e99bf232630cc3f89ee5f83c6fd0d89137d20f380cbe5b463de"

URI_x86_64_v2_perl-SQL-Translator-Producer-GraphViz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Translator-Producer-GraphViz-1.66-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Translator-Producer-GraphViz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SQL-Translator-Producer-GraphViz}"
SRC_URI[x86_64_v2_perl-SQL-Translator-Producer-GraphViz.sha256sum] = "255c328c5747bb80c7f1f615ae1753e9279aa26f84465df7d071e337610b0859"

URI_x86_64_v2_perl-SQL-Translator-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Translator-tests-1.66-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Translator-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SQL-Translator-tests}"
SRC_URI[x86_64_v2_perl-SQL-Translator-tests.sha256sum] = "fa213915eae0e1fc3cae9a05ae7b7728591aed894a513267a3faaf9bd8605198"

URI_x86_64_v2_sqlt-graph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sqlt-graph-1.66-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sqlt-graph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlt-graph}"
SRC_URI[x86_64_v2_sqlt-graph.sha256sum] = "0d1593f70af1e89747c3a45949ed7cd3022eaf15aa4d8969d954a5a98b175b2d"

URI_aarch64_perl-SQL-Translator = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Translator-1.66-5.el10_3.noarch.rpm;name=aarch64_perl-SQL-Translator;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SQL-Translator}"
SRC_URI[aarch64_perl-SQL-Translator.sha256sum] = "59763f7e32a2bf6655a37e38324045442f5a12616a96adcd617780550d065578"

URI_aarch64_perl-SQL-Translator-Producer-Diagram = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Translator-Producer-Diagram-1.66-5.el10_3.noarch.rpm;name=aarch64_perl-SQL-Translator-Producer-Diagram;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SQL-Translator-Producer-Diagram}"
SRC_URI[aarch64_perl-SQL-Translator-Producer-Diagram.sha256sum] = "a1b568fb11bcbe55e964f538049b9dc1584eeee40ff4c24f352648773ac2c5a2"

URI_aarch64_perl-SQL-Translator-Producer-GraphViz = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Translator-Producer-GraphViz-1.66-5.el10_3.noarch.rpm;name=aarch64_perl-SQL-Translator-Producer-GraphViz;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SQL-Translator-Producer-GraphViz}"
SRC_URI[aarch64_perl-SQL-Translator-Producer-GraphViz.sha256sum] = "1cfaa4c5db12d9561fc760c7a15f705bb1030cfc81372463c3e5eb162ff8a1c6"

URI_aarch64_perl-SQL-Translator-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Translator-tests-1.66-5.el10_3.noarch.rpm;name=aarch64_perl-SQL-Translator-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SQL-Translator-tests}"
SRC_URI[aarch64_perl-SQL-Translator-tests.sha256sum] = "71043f10c337a4a461d32440790b4442935a22b0bf6121fc9b831d259017b0b4"

URI_aarch64_sqlt-graph = "${EPEL_MIRROR}/aarch64/Packages/s/sqlt-graph-1.66-5.el10_3.noarch.rpm;name=aarch64_sqlt-graph;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlt-graph}"
SRC_URI[aarch64_sqlt-graph.sha256sum] = "8984c456bcdc3bb1a76ec4d31ce87269294837b438f3aa0bb5f6f0cd9e4fb8bf"

RDEPENDS:perl-SQL-Translator = " \
 perl-CGI \
 perl-Carp \
 perl-Carp-Clan \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-ShareDir \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Graph \
 perl-IO \
 perl-JSON-MaybeXS \
 perl-Moo \
 perl-Package-Variant \
 perl-Parse-RecDescent \
 perl-PathTools \
 perl-Pod-Usage \
 perl-SQL-Translator \
 perl-Scalar-List-Utils \
 perl-Spreadsheet-ParseExcel \
 perl-Storable \
 perl-Sub-Quote \
 perl-Template-Toolkit \
 perl-Test-Simple \
 perl-Text-ParseWords \
 perl-Text-RecordParser \
 perl-Try-Tiny \
 perl-XML-LibXML \
 perl-XML-Writer \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:perl-SQL-Translator-Producer-Diagram = " \
 perl-Data-Dumper \
 perl-GD \
 perl-SQL-Translator \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-SQL-Translator-Producer-GraphViz = " \
 perl-GraphViz \
 perl-SQL-Translator \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-SQL-Translator-tests = " \
 bash \
 perl-DBD-SQLite \
 perl-Data-Dumper \
 perl-File-Temp \
 perl-FindBin \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-SQL-Translator \
 perl-SQL-Translator-Producer-Diagram \
 perl-SQL-Translator-Producer-GraphViz \
 perl-Storable \
 perl-Symbol \
 perl-Test-Differences \
 perl-Test-Exception \
 perl-Test-Harness \
 perl-Test-PostgreSQL \
 perl-Text-ParseWords \
 perl-XML-Parser \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 sqlt-graph \
 "
RDEPENDS:sqlt-graph = " \
 perl-Data-Dumper \
 perl-Getopt-Long \
 perl-GraphViz \
 perl-Pod-Usage \
 perl-SQL-Translator \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
