# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jaxb-istack-commons"
PV = "4.2.0"
PR = "9.el10"
PACKAGES = " \
 jaxb-istack-commons-maven-plugin \
 jaxb-istack-commons-runtime \
 jaxb-istack-commons-test \
 jaxb-istack-commons-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jaxb-istack-commons-4.2.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dd76af80e1c8e9c46fb550846eff43cfcaec5145c0117fd711cc6d9f988d639"

URI_x86_64_v2_jaxb-istack-commons-maven-plugin = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jaxb-istack-commons-maven-plugin-4.2.0-9.el10.noarch.rpm;name=x86_64_v2_jaxb-istack-commons-maven-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-istack-commons-maven-plugin}"
SRC_URI[x86_64_v2_jaxb-istack-commons-maven-plugin.sha256sum] = "a6953da342df12b384c4c64ac3bdbc7605c7913ccf5e7c13987d9d0926297d6b"

URI_x86_64_v2_jaxb-istack-commons-runtime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-istack-commons-runtime-4.2.0-9.el10.noarch.rpm;name=x86_64_v2_jaxb-istack-commons-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-istack-commons-runtime}"
SRC_URI[x86_64_v2_jaxb-istack-commons-runtime.sha256sum] = "ac4e972f856f2dee129f4f4c1a6d737e326c85a25567a1013f9dc5f1abce9af3"

URI_x86_64_v2_jaxb-istack-commons-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jaxb-istack-commons-test-4.2.0-9.el10.noarch.rpm;name=x86_64_v2_jaxb-istack-commons-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-istack-commons-test}"
SRC_URI[x86_64_v2_jaxb-istack-commons-test.sha256sum] = "ea4d869c8ec475e043e535ac13b22459ec205f91a13ce19572fa8707ee69cbd9"

URI_x86_64_v2_jaxb-istack-commons-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jaxb-istack-commons-tools-4.2.0-9.el10.noarch.rpm;name=x86_64_v2_jaxb-istack-commons-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jaxb-istack-commons-tools}"
SRC_URI[x86_64_v2_jaxb-istack-commons-tools.sha256sum] = "33bd8dc78e552dee1034e91e016b85b7f7f66c14dcafbce44b6c4f1bde1c7651"

URI_aarch64_jaxb-istack-commons-maven-plugin = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jaxb-istack-commons-maven-plugin-4.2.0-9.el10.noarch.rpm;name=aarch64_jaxb-istack-commons-maven-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-istack-commons-maven-plugin}"
SRC_URI[aarch64_jaxb-istack-commons-maven-plugin.sha256sum] = "a6953da342df12b384c4c64ac3bdbc7605c7913ccf5e7c13987d9d0926297d6b"

URI_aarch64_jaxb-istack-commons-runtime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-istack-commons-runtime-4.2.0-9.el10.noarch.rpm;name=aarch64_jaxb-istack-commons-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-istack-commons-runtime}"
SRC_URI[aarch64_jaxb-istack-commons-runtime.sha256sum] = "ac4e972f856f2dee129f4f4c1a6d737e326c85a25567a1013f9dc5f1abce9af3"

URI_aarch64_jaxb-istack-commons-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jaxb-istack-commons-test-4.2.0-9.el10.noarch.rpm;name=aarch64_jaxb-istack-commons-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-istack-commons-test}"
SRC_URI[aarch64_jaxb-istack-commons-test.sha256sum] = "ea4d869c8ec475e043e535ac13b22459ec205f91a13ce19572fa8707ee69cbd9"

URI_aarch64_jaxb-istack-commons-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jaxb-istack-commons-tools-4.2.0-9.el10.noarch.rpm;name=aarch64_jaxb-istack-commons-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_jaxb-istack-commons-tools}"
SRC_URI[aarch64_jaxb-istack-commons-tools.sha256sum] = "33bd8dc78e552dee1034e91e016b85b7f7f66c14dcafbce44b6c4f1bde1c7651"

RDEPENDS:jaxb-istack-commons-maven-plugin = " \
 javapackages-filesystem \
 jaxb-codemodel \
 junit \
 maven-resolver \
 "
RDEPENDS:jaxb-istack-commons-runtime = " \
 javapackages-filesystem \
 "
RDEPENDS:jaxb-istack-commons-test = " \
 javapackages-filesystem \
 junit \
 "
RDEPENDS:jaxb-istack-commons-tools = " \
 javapackages-filesystem \
 "
