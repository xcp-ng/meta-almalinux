# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssl"
PE = "1"
PV = "3.5.8"
PR = "1.el10.alma.1"
PACKAGES = " \
 openssl \
 openssl-devel \
 openssl-fips-provider \
 openssl-libs \
 openssl-perl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssl-3.5.8-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "26f40545b767ab730e00b2f689ea49fb395fac21ad3603b34a0c14b75b86bfbf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-3.5.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl;unpack=0"
SRC_URI[x86_64_v2_openssl.sha256sum] = "fb57ba3194f82fabcd996c218cb97b783cfd58862f72037a9c7b8c6a52d3ed7b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-devel-3.5.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-devel;unpack=0"
SRC_URI[x86_64_v2_openssl-devel.sha256sum] = "4b61bd5d601a80f93564d555fd3839da464bb58b6e4c073fbf2084a0754a87ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-fips-provider-3.5.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-fips-provider;unpack=0"
SRC_URI[x86_64_v2_openssl-fips-provider.sha256sum] = "c0c4839c6ebb367a119e87f1e4266e8b42e0596898d68023263f4e489696a3b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssl-libs-3.5.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-libs;unpack=0"
SRC_URI[x86_64_v2_openssl-libs.sha256sum] = "909344978e6280e3ae6d3ef5e9585c07c94058125a60345872111cdf43367b26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssl-perl-3.5.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssl-perl;unpack=0"
SRC_URI[x86_64_v2_openssl-perl.sha256sum] = "bb0871deee51d84fd0e89dc017f7622202cda8d618c4847be32e3d10d20132f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-3.5.8-1.el10.alma.1.aarch64.rpm;name=aarch64_openssl;unpack=0"
SRC_URI[aarch64_openssl.sha256sum] = "8447ff669a857355f8e11cc4a2e1cf95e519d9da2aff773f6bdd95ddc075c703"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-devel-3.5.8-1.el10.alma.1.aarch64.rpm;name=aarch64_openssl-devel;unpack=0"
SRC_URI[aarch64_openssl-devel.sha256sum] = "ba4dd88e37211bc9b25832c51b7197db470cb52af089c2bc73187843e8f3f196"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-fips-provider-3.5.8-1.el10.alma.1.aarch64.rpm;name=aarch64_openssl-fips-provider;unpack=0"
SRC_URI[aarch64_openssl-fips-provider.sha256sum] = "b7e713abe93bc11973a37eadda67af3b24fb41efcc1484dc0678b2a2645f9b2e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssl-libs-3.5.8-1.el10.alma.1.aarch64.rpm;name=aarch64_openssl-libs;unpack=0"
SRC_URI[aarch64_openssl-libs.sha256sum] = "a025db0788b28fc1b47b3104264b6fca9003425abe2ad2637ca96ff8a2325eb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssl-perl-3.5.8-1.el10.alma.1.aarch64.rpm;name=aarch64_openssl-perl;unpack=0"
SRC_URI[aarch64_openssl-perl.sha256sum] = "e57ae572c06356918c9e78a3e2aa2ebbb1c0625374879ea51aff32914d03dc6e"

RDEPENDS:openssl = " \
 bash \
 glibc \
 openssl-libs \
 virtual/coreutils \
 "
RDEPENDS:openssl-devel = " \
 openssl-devel \
 openssl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openssl-fips-provider = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:openssl-libs = " \
 ca-certificates \
 crypto-policies \
 glibc \
 openssl-fips-provider \
 zlib-ng-compat \
 "
RDEPENDS:openssl-perl = " \
 openssl \
 perl-interpreter \
 "
