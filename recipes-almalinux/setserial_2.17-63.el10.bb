# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setserial"
PV = "2.17"
PR = "63.el10"
PACKAGES = " \
 setserial \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/setserial-2.17-63.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96b46ac8294173652ab95f33d07708937b7e49b0a1c60519dc9332ff65b71b20"

URI_x86_64_v2_setserial = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/setserial-2.17-63.el10.x86_64_v2.rpm;name=x86_64_v2_setserial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setserial}"
SRC_URI[x86_64_v2_setserial.sha256sum] = "d4fd312d432f1ce55d142f0e242fb0f996a963d4b5e75f0f4d0becc7f8d9d3fe"

URI_aarch64_setserial = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/setserial-2.17-63.el10.aarch64.rpm;name=aarch64_setserial;unpack=0"
SRC_URI:append = " ${URI_aarch64_setserial}"
SRC_URI[aarch64_setserial.sha256sum] = "ef40ab3981eb5c15989e90e8b0e6b2d41eb9868e185d22d3338994cbca669a38"

RDEPENDS:setserial = " \
 glibc \
 "
