# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire"
PV = "1.4.11"
PR = "1.el10"
PACKAGES = " \
 pipewire \
 pipewire-alsa \
 pipewire-devel \
 pipewire-gstreamer \
 pipewire-jack-audio-connection-kit \
 pipewire-jack-audio-connection-kit-devel \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pipewire-module-x11 \
 pipewire-plugin-libcamera \
 pipewire-pulseaudio \
 pipewire-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pipewire-1.4.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "211861fd671ccd0d005a9d09e773652850c0c4e7e4ecccd6a46ca5c7f2df4e4d"

URI_x86_64_v2_pipewire = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire}"
SRC_URI[x86_64_v2_pipewire.sha256sum] = "2de15298dec842f5bf88ad22dfd98b3f3f721f8ec17a991448b9b261d7319922"

URI_x86_64_v2_pipewire-alsa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-alsa-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-alsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-alsa}"
SRC_URI[x86_64_v2_pipewire-alsa.sha256sum] = "cd7c5159f815e9c6bb75833f2f3870abc867bf6e3cdd1b41a03b82bcb51f3b87"

URI_x86_64_v2_pipewire-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-devel-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-devel}"
SRC_URI[x86_64_v2_pipewire-devel.sha256sum] = "ef304b9f2d7a7df970b3879cab22a1973e3fb861ad025a81a84c1ae623335b6f"

URI_x86_64_v2_pipewire-gstreamer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-gstreamer-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-gstreamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-gstreamer}"
SRC_URI[x86_64_v2_pipewire-gstreamer.sha256sum] = "5b541e86cdbeef99953e83c3464d86cacdd0e188a7de40a96230e2d4591dde0b"

URI_x86_64_v2_pipewire-jack-audio-connection-kit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit.sha256sum] = "ca13f8021ee366a54b7c10e95f70058da7a0b92701f0d50140726748833d22a0"

URI_x86_64_v2_pipewire-jack-audio-connection-kit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-devel-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit-devel}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-devel.sha256sum] = "c4a00bfdeb7c1a83b346d67cbbdc8f8d907dcc6981a0b5c486c9e7b72dd17ff2"

URI_x86_64_v2_pipewire-jack-audio-connection-kit-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-libs-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-jack-audio-connection-kit-libs}"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-libs.sha256sum] = "1aaea7f9e9ddc95eb723c4ae961e29cb64af7ba449a0d08344c4214d58b4747c"

URI_x86_64_v2_pipewire-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-libs-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-libs}"
SRC_URI[x86_64_v2_pipewire-libs.sha256sum] = "1af807b16e30108232ab01f6654006b3dca0bf127efe2903dce090f25f33c42e"

URI_x86_64_v2_pipewire-module-x11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-module-x11-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-module-x11}"
SRC_URI[x86_64_v2_pipewire-module-x11.sha256sum] = "48f869996a37d0ffe8a8c3283386cddf358e73db820c7b1017cfa44ca690733d"

URI_x86_64_v2_pipewire-plugin-libcamera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-plugin-libcamera-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-plugin-libcamera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-plugin-libcamera}"
SRC_URI[x86_64_v2_pipewire-plugin-libcamera.sha256sum] = "87c69dfd84e51002c52daf152aee57b07364b22ae76a910e5365f29bdc79da7b"

URI_x86_64_v2_pipewire-pulseaudio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-pulseaudio-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-pulseaudio}"
SRC_URI[x86_64_v2_pipewire-pulseaudio.sha256sum] = "5f55ef1da5d89198e69dd7b5f47f357013a22ffbf655891ae6c855aaa1f857fc"

URI_x86_64_v2_pipewire-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-utils-1.4.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipewire-utils}"
SRC_URI[x86_64_v2_pipewire-utils.sha256sum] = "e4e3291d7ea6e89e4562b153355f284cb5fb6be0b63576b99a98aadfd8b22ba5"

URI_aarch64_pipewire = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire}"
SRC_URI[aarch64_pipewire.sha256sum] = "26051133783d8252177d75eee0e0594980de5029d6c510c9467afb2d0243788f"

URI_aarch64_pipewire-alsa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-alsa-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-alsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-alsa}"
SRC_URI[aarch64_pipewire-alsa.sha256sum] = "5c77d1464bdef8c7672105f328644cfc04fd7439ad91e28d693444f28c12290f"

URI_aarch64_pipewire-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-devel-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-devel}"
SRC_URI[aarch64_pipewire-devel.sha256sum] = "256ddc28a6afc88f5f385c6df632fb15a32cde64ccdfc198464d18be326e5cc8"

URI_aarch64_pipewire-gstreamer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-gstreamer-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-gstreamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-gstreamer}"
SRC_URI[aarch64_pipewire-gstreamer.sha256sum] = "de63369d6e787050672d2d355f240eadd1a2e716652bea420273478c3ad36bd3"

URI_aarch64_pipewire-jack-audio-connection-kit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit.sha256sum] = "8c23e1a178fba6f250b6081b12cddb5242dd75cd536b298b3f8c203da760e28c"

URI_aarch64_pipewire-jack-audio-connection-kit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-devel-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit-devel}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-devel.sha256sum] = "5060f16f143be72fdd980b36b7978d4bcceb46b6426ab024b54691f602202169"

URI_aarch64_pipewire-jack-audio-connection-kit-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-libs-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-jack-audio-connection-kit-libs}"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-libs.sha256sum] = "15c12f466977e761ac051efaad26263f6fe2073b848d2828ebea5c57d48d422d"

URI_aarch64_pipewire-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-libs-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-libs}"
SRC_URI[aarch64_pipewire-libs.sha256sum] = "b1123e9ea80b8489af87039ab9a3a775a0e36ea05498ca603d171eae19bc3002"

URI_aarch64_pipewire-module-x11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-module-x11-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-module-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-module-x11}"
SRC_URI[aarch64_pipewire-module-x11.sha256sum] = "77ea67cfbded557bb66d3d3ede152454dc7df68995291521db413ee2032f9fb4"

URI_aarch64_pipewire-plugin-libcamera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-plugin-libcamera-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-plugin-libcamera;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-plugin-libcamera}"
SRC_URI[aarch64_pipewire-plugin-libcamera.sha256sum] = "a1c27b0297af0b0cb6c073be72215a19e60bcc2eab07b6abdd19f83574096555"

URI_aarch64_pipewire-pulseaudio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-pulseaudio-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-pulseaudio}"
SRC_URI[aarch64_pipewire-pulseaudio.sha256sum] = "f2555ab3b1d24638a4df627b4a4e6f01ec373ec0e195fb6d203438db3a1c4569"

URI_aarch64_pipewire-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-utils-1.4.11-1.el10.aarch64.rpm;name=aarch64_pipewire-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipewire-utils}"
SRC_URI[aarch64_pipewire-utils.sha256sum] = "93681a3e3cfa45016cfed52a942c7bcba1d9052ef68d54aeefbaeb5d8e1d3965"

RDEPENDS:pipewire = " \
 bash \
 glibc \
 pipewire-libs \
 rtkit \
 systemd \
 wireplumber \
 "
RDEPENDS:pipewire-alsa = " \
 alsa-lib \
 glibc \
 pipewire-libs \
 "
RDEPENDS:pipewire-devel = " \
 pipewire-devel \
 pipewire-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 pipewire-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit = " \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-devel = " \
 pipewire-jack-audio-connection-kit-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-libs = " \
 bash \
 glibc \
 pipewire-jack-audio-connection-kit \
 pipewire-libs \
 "
RDEPENDS:pipewire-libs = " \
 alsa-lib \
 avahi-libs \
 bluez-libs \
 dbus-libs \
 fdk-aac-free \
 fftw-libs-single \
 glib2 \
 glibc \
 libgcc \
 liblc3 \
 libldac \
 libsbc \
 libselinux \
 libsndfile \
 libstdc++ \
 libusb1 \
 openssl-libs \
 opus \
 pulseaudio-libs \
 systemd-libs \
 webrtc-audio-processing \
 "
RDEPENDS:pipewire-module-x11 = " \
 glibc \
 libX11 \
 libXfixes \
 libcanberra \
 pipewire-libs \
 "
RDEPENDS:pipewire-plugin-libcamera = " \
 glibc \
 libcamera \
 libdrm \
 libgcc \
 libstdc++ \
 pipewire-libs \
 "
RDEPENDS:pipewire-pulseaudio = " \
 avahi-libs \
 bash \
 dbus-libs \
 glib2 \
 glibc \
 libgcc \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:pipewire-utils = " \
 alsa-lib \
 dbus-libs \
 glibc \
 libgcc \
 libsndfile \
 ncurses-libs \
 pipewire \
 pipewire-libs \
 readline \
 "
