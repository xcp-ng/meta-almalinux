# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-modernc-sqlite"
PV = "1.30.0"
PR = "3.el10_0"
PACKAGES = " \
 golang-modernc-sqlite \
 golang-modernc-sqlite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-modernc-sqlite-1.30.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c64399af26da13cf9179651dc8bd46020167cd7979537fda0dfb7e02959ab44f"

URI_x86_64_v2_golang-modernc-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-modernc-sqlite-1.30.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-modernc-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-modernc-sqlite}"
SRC_URI[x86_64_v2_golang-modernc-sqlite.sha256sum] = "606a4e62e8466451dd5bb4a14e608f4b5d1db9c785f61d0291342331ec7e5705"

URI_x86_64_v2_golang-modernc-sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-modernc-sqlite-devel-1.30.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-modernc-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-modernc-sqlite-devel}"
SRC_URI[x86_64_v2_golang-modernc-sqlite-devel.sha256sum] = "73be693f3d5850b0c4c524e0950fd9354dba0a8b45b6de35f0dd76c32ee5f30e"

URI_aarch64_golang-modernc-sqlite = "${EPEL_MIRROR}/aarch64/Packages/g/golang-modernc-sqlite-1.30.0-3.el10_0.aarch64.rpm;name=aarch64_golang-modernc-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-modernc-sqlite}"
SRC_URI[aarch64_golang-modernc-sqlite.sha256sum] = "c8644e13e31d9eafa25553772e2b58af5b10a4c4f671b34bf8eb4d2edc21aace"

URI_aarch64_golang-modernc-sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-modernc-sqlite-devel-1.30.0-3.el10_0.noarch.rpm;name=aarch64_golang-modernc-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-modernc-sqlite-devel}"
SRC_URI[aarch64_golang-modernc-sqlite-devel.sha256sum] = "2735e34b5ede78bd34eef9002df0e8e922486741f6f316cca640ee2b96d08cec"

RDEPENDS:golang-modernc-sqlite = " \
 "
RDEPENDS:golang-modernc-sqlite-devel = " \
 go-filesystem \
 golang-modernc-libc-devel \
 golang-x-sys-devel \
 "
