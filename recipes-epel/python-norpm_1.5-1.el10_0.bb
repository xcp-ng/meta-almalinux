# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-norpm"
PV = "1.5"
PR = "1.el10_0"
PACKAGES = " \
 python3-norpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-norpm-1.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bf8c87b358e9be53afff482d3b37f2c6cb6dec84e53688f2f02fbb504a4fc0c"

URI_x86_64_v2_python3-norpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-norpm-1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-norpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-norpm}"
SRC_URI[x86_64_v2_python3-norpm.sha256sum] = "e1ed184e0ed38a07e4fb3acd4b6595b474865c43a3adff0079dfa203198606fe"

URI_aarch64_python3-norpm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-norpm-1.5-1.el10_0.noarch.rpm;name=aarch64_python3-norpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-norpm}"
SRC_URI[aarch64_python3-norpm.sha256sum] = "134f64fabb5b7d7284bc3d00b868a88819d007dad5ab63363e70a47b68077778"

RDEPENDS:python3-norpm = " \
 python3 \
 python3-ply \
 "
