# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ethtool"
PE = "2"
PV = "6.19"
PR = "1.el10"
PACKAGES = " \
 ethtool \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ethtool-6.19-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8093402bf63683e54c72ab1d410e6cadb415e2a7ab7bde79ea797a8f5b3f239c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ethtool-6.19-1.el10.x86_64_v2.rpm;name=x86_64_v2_ethtool;unpack=0"
SRC_URI[x86_64_v2_ethtool.sha256sum] = "8127d28b1974553b3832b56c8cdd065229c24bd9cd71b7ea1748cdfa85e78e17"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ethtool-6.19-1.el10.aarch64.rpm;name=aarch64_ethtool;unpack=0"
SRC_URI[aarch64_ethtool.sha256sum] = "f4830aef2d6b1f3534f0ebb8055c3a77e649225bc1a4ed16eb441bc7e0def82e"

RDEPENDS:ethtool = " \
 glibc \
 libmnl \
 "
