# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-git-lfs"
PV = "1.2.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-git-lfs \
 ghc-git-lfs-devel \
 ghc-git-lfs-doc \
 ghc-git-lfs-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-git-lfs-1.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d0a7f070a3630ae3bb5de034ad4df4b3c51358bfc8aa005c58cb806f039c8ca"

URI_x86_64_v2_ghc-git-lfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-git-lfs-1.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-git-lfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-git-lfs}"
SRC_URI[x86_64_v2_ghc-git-lfs.sha256sum] = "f2e4065602680d1ca97ab68350513218cf5439a5b1a06512828bac3c712c139d"

URI_x86_64_v2_ghc-git-lfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-git-lfs-devel-1.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-git-lfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-git-lfs-devel}"
SRC_URI[x86_64_v2_ghc-git-lfs-devel.sha256sum] = "3d74b3abc64c9f6ea0115f009a1199ce0bc58e91d6ea01261fc94db29e354c50"

URI_x86_64_v2_ghc-git-lfs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-git-lfs-doc-1.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-git-lfs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-git-lfs-doc}"
SRC_URI[x86_64_v2_ghc-git-lfs-doc.sha256sum] = "7e6b7bbd9ab2f8bf6d0813dcdbf4c0e61249272b1b14791e141f5a6bc5799a85"

URI_x86_64_v2_ghc-git-lfs-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-git-lfs-prof-1.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-git-lfs-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-git-lfs-prof}"
SRC_URI[x86_64_v2_ghc-git-lfs-prof.sha256sum] = "33bd6117a49d77ef4ad7c9fc087105f7f79b890366c3c31c8446ad172df3c4ee"

URI_aarch64_ghc-git-lfs = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-git-lfs-1.2.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-git-lfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-git-lfs}"
SRC_URI[aarch64_ghc-git-lfs.sha256sum] = "d042e1051b1a006319e1f05a2aab125ddce428ea8739f8226bc64cc068e8fc7b"

URI_aarch64_ghc-git-lfs-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-git-lfs-devel-1.2.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-git-lfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-git-lfs-devel}"
SRC_URI[aarch64_ghc-git-lfs-devel.sha256sum] = "ffc6643004b1206bcf249c3e21325bb0989567c3d4f4db4cd20f22076e946a4f"

URI_aarch64_ghc-git-lfs-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-git-lfs-doc-1.2.2-1.el10_0.noarch.rpm;name=aarch64_ghc-git-lfs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-git-lfs-doc}"
SRC_URI[aarch64_ghc-git-lfs-doc.sha256sum] = "c8d94ce0c30ed25993583cbada44a7f283063109b93b83bada42ad1e49dc9600"

URI_aarch64_ghc-git-lfs-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-git-lfs-prof-1.2.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-git-lfs-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-git-lfs-prof}"
SRC_URI[aarch64_ghc-git-lfs-prof.sha256sum] = "003914f9f7f43c200910ca8b5dd76fd8cea45c6a7c47c88a326c3d6824275b2b"

RDEPENDS:ghc-git-lfs = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-client \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-mime-types \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-git-lfs-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-git-lfs \
 ghc-http-client-devel \
 ghc-http-types-devel \
 ghc-network-uri-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-git-lfs-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-git-lfs-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-containers-prof \
 ghc-git-lfs-devel \
 ghc-http-client-prof \
 ghc-http-types-prof \
 ghc-network-uri-prof \
 ghc-text-prof \
 "
