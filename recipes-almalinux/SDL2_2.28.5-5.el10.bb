# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SDL2"
PV = "2.28.5"
PR = "5.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/SDL2-2.28.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62fad36f40b223b40314f4be328f14ddf9880496136772b1ea08780b4f146712"

