# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-test-result"
PV = "0.3.8"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-test-result \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-test-result-0.3.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7926ef66aea5479845d90c36db37e1c59f9c72aaee2b4685759e811f40249378"

URI_x86_64_v2_python3-colcon-test-result = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-test-result-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-test-result;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-test-result}"
SRC_URI[x86_64_v2_python3-colcon-test-result.sha256sum] = "68124ee49a2cdf812ca4ba3d8dd1d39a217a02b1e802c97587379d8915a6b1a5"

URI_aarch64_python3-colcon-test-result = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-test-result-0.3.8-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-test-result;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-test-result}"
SRC_URI[aarch64_python3-colcon-test-result.sha256sum] = "21b52ae71a7c7de3ef94270e1824d9bda93ad89142cb145105e5aba86685b46f"

RDEPENDS:python3-colcon-test-result = " \
 python3 \
 python3-colcon-core \
 "
