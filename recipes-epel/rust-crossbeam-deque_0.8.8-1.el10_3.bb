# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-deque"
PV = "0.8.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam-deque+default-devel \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-deque-0.8.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e864f44a994079aa2a53b998906d712b81d42711bc5e03a316bd83c5397f5467"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque+default-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-deque+default-devel.sha256sum] = "81b96042cbebbb4d4bcc200cbdb50975d42ac75136d8386d5eeab8d973fbc326"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque+std-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-deque+std-devel.sha256sum] = "fe74849c3578d1095a2969918d3b5ab9de4e0612aa408ac4598a6904106f15c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque-devel-0.8.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-deque-devel.sha256sum] = "a3301c3c05dbab6ce38f6dbab84b271a243569bf5c1c82e4934e292d170ab6bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque+default-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-deque+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-deque+default-devel.sha256sum] = "42706a53f969716e2d5650a53696a45cb346132a0d954a1b2f1b1e23a173c34f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque+std-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-deque+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-deque+std-devel.sha256sum] = "b4533d88d052f9a15d0ddfae3a428e23219a76dff43adb653ad085f585b874e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque-devel-0.8.8-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-deque-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-deque-devel.sha256sum] = "711ed05fb9de0dced1499524bad46ac0a0d021b6e99cbe76846445e365e7773b"

RDEPENDS:rust-crossbeam-deque+default-devel = " \
 cargo \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 "
RDEPENDS:rust-crossbeam-deque+std-devel = " \
 cargo \
 rust-crossbeam-deque-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-deque-devel = " \
 cargo \
 rust \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils-devel \
 "
