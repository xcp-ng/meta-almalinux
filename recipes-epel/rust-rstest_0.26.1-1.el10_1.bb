# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rstest"
PV = "0.26.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-rstest+async-timeout-devel \
 rust-rstest+crate-name-devel \
 rust-rstest+default-devel \
 rust-rstest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rstest-0.26.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c4c4f1ec6777bca9a58959491eb42f1b57a4d7ea7c016957129af1a3247165b"

URI_x86_64_v2_rust-rstest+async-timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest+async-timeout-devel-0.26.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest+async-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest+async-timeout-devel}"
SRC_URI[x86_64_v2_rust-rstest+async-timeout-devel.sha256sum] = "9c0931b78b656f2bc5a2cf5153d33f53a2ac8bb180cffb51d866573a877c4f05"

URI_x86_64_v2_rust-rstest+crate-name-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest+crate-name-devel-0.26.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest+crate-name-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest+crate-name-devel}"
SRC_URI[x86_64_v2_rust-rstest+crate-name-devel.sha256sum] = "231e18fed668490741a891454d531a2812fd1deb7142e339d0eefd8e45c23464"

URI_x86_64_v2_rust-rstest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest+default-devel-0.26.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest+default-devel}"
SRC_URI[x86_64_v2_rust-rstest+default-devel.sha256sum] = "d599e07ff1f39bb0d1961e58fead7838f03a2637adc8d6317627d7ad084c7893"

URI_x86_64_v2_rust-rstest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest-devel-0.26.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest-devel}"
SRC_URI[x86_64_v2_rust-rstest-devel.sha256sum] = "fdff6b18e57b72c09fb7c281bac22c7f5292966eb3e55aea848815d8c799cefb"

URI_aarch64_rust-rstest+async-timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest+async-timeout-devel-0.26.1-1.el10_1.noarch.rpm;name=aarch64_rust-rstest+async-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest+async-timeout-devel}"
SRC_URI[aarch64_rust-rstest+async-timeout-devel.sha256sum] = "46c8f542d0971d97b85e06a114c132f120bd617235d89365993940bcc4153563"

URI_aarch64_rust-rstest+crate-name-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest+crate-name-devel-0.26.1-1.el10_1.noarch.rpm;name=aarch64_rust-rstest+crate-name-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest+crate-name-devel}"
SRC_URI[aarch64_rust-rstest+crate-name-devel.sha256sum] = "161a7c52191138433e5d96c2e41bebf60b75e3c2fce8b030eae4953bec6c5133"

URI_aarch64_rust-rstest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest+default-devel-0.26.1-1.el10_1.noarch.rpm;name=aarch64_rust-rstest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest+default-devel}"
SRC_URI[aarch64_rust-rstest+default-devel.sha256sum] = "6c5d7f897a640b87897e048f03a165f19cf4b1e152bef86c637d2d9be233d81e"

URI_aarch64_rust-rstest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest-devel-0.26.1-1.el10_1.noarch.rpm;name=aarch64_rust-rstest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest-devel}"
SRC_URI[aarch64_rust-rstest-devel.sha256sum] = "e5c064cbe7cc81604297b4fe998ff803e6df0e7f668b4130c99e34ae43ea5440"

RDEPENDS:rust-rstest+async-timeout-devel = " \
 cargo \
 rust-futures-timer+default-devel \
 rust-futures-util+default-devel \
 rust-rstest-devel \
 rust-rstest_macros+async-timeout-devel \
 "
RDEPENDS:rust-rstest+crate-name-devel = " \
 cargo \
 rust-rstest-devel \
 rust-rstest_macros+crate-name-devel \
 "
RDEPENDS:rust-rstest+default-devel = " \
 cargo \
 rust-rstest+async-timeout-devel \
 rust-rstest+crate-name-devel \
 rust-rstest-devel \
 "
RDEPENDS:rust-rstest-devel = " \
 cargo \
 rust \
 rust-rstest_macros-devel \
 "
