# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-apparentlymart-textseg-15"
PV = "15.0.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-apparentlymart-textseg-15-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-apparentlymart-textseg-15-15.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "758d8a6c248d3e6cde3895abfb1e024974f03f6b594241a88e0f4a90bc4c1d84"

URI_x86_64_v2_golang-github-apparentlymart-textseg-15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-apparentlymart-textseg-15-devel-15.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-apparentlymart-textseg-15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-apparentlymart-textseg-15-devel}"
SRC_URI[x86_64_v2_golang-github-apparentlymart-textseg-15-devel.sha256sum] = "0ad0513ffa4b8479f3a8b9a34b9e7a643e5b488e85ae568e385f28919468db60"

URI_aarch64_golang-github-apparentlymart-textseg-15-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-apparentlymart-textseg-15-devel-15.0.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-apparentlymart-textseg-15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-apparentlymart-textseg-15-devel}"
SRC_URI[aarch64_golang-github-apparentlymart-textseg-15-devel.sha256sum] = "ec4d1bf1244be4273bf79f34fab823d897e13c7234f232041cf5f08524f6cc81"

RDEPENDS:golang-github-apparentlymart-textseg-15-devel = " \
 go-filesystem \
 "
