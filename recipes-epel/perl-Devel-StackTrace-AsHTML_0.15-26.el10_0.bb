# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-StackTrace-AsHTML"
PV = "0.15"
PR = "26.el10_0"
PACKAGES = " \
 perl-Devel-StackTrace-AsHTML \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-StackTrace-AsHTML-0.15-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c8a115530cb1b88abce1e5c183fe0ba6669b4a28744c0ec2c396b41a5536f4b"

URI_x86_64_v2_perl-Devel-StackTrace-AsHTML = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-StackTrace-AsHTML-0.15-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-StackTrace-AsHTML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-StackTrace-AsHTML}"
SRC_URI[x86_64_v2_perl-Devel-StackTrace-AsHTML.sha256sum] = "2b7a8d60b9685ea286187918440204ac22a19232e442332b108aa4e0b5f74691"

URI_aarch64_perl-Devel-StackTrace-AsHTML = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-StackTrace-AsHTML-0.15-26.el10_0.noarch.rpm;name=aarch64_perl-Devel-StackTrace-AsHTML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-StackTrace-AsHTML}"
SRC_URI[aarch64_perl-Devel-StackTrace-AsHTML.sha256sum] = "85c0e09a8bae32b3030a00665c84b262c39a8b4253777cfd5dc271facfa4ba34"

RDEPENDS:perl-Devel-StackTrace-AsHTML = " \
 perl-Data-Dumper \
 perl-Devel-StackTrace \
 perl-Scalar-List-Utils \
 perl-libs \
 "
