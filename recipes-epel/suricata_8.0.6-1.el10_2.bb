# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "suricata"
PV = "8.0.6"
PR = "1.el10_2"
PACKAGES = " \
 suricata \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/suricata-8.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2bc7e0dd3e79c0d849c7553bcc4c7f978294683432fdd16b8c1f0b215adcb1af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suricata-8.0.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suricata;unpack=0"
SRC_URI[x86_64_v2_suricata.sha256sum] = "fe4f55058bf1a391b21c0b76f8f8f6e2c926f676ba8860582602a37e7695e4dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suricata-8.0.6-1.el10_2.aarch64.rpm;name=aarch64_suricata;unpack=0"
SRC_URI[aarch64_suricata.sha256sum] = "576eef3a7719be492510ae78af146da38bd520217a9de2f2b188c9843d100ead"

RDEPENDS:suricata:x86_64_v2 = " \
 bash \
 file-libs \
 glibc \
 hiredis \
 jansson \
 libcap-ng \
 libevent \
 libgcc \
 libmaxminddb \
 libnet \
 libnetfilter_queue \
 libnfnetlink \
 libpcap \
 libyaml \
 lz4-libs \
 pcre2 \
 python3 \
 python3-pyyaml \
 shadow-utils \
 systemd \
 vectorscan \
 zlib-ng-compat \
"
RDEPENDS:suricata:aarch64 = " \
 bash \
 file-libs \
 glibc \
 hiredis \
 jansson \
 libcap-ng \
 libevent \
 libgcc \
 libmaxminddb \
 libnet \
 libnetfilter_queue \
 libnfnetlink \
 libpcap \
 libyaml \
 lz4-libs \
 pcre2 \
 python3 \
 python3-pyyaml \
 shadow-utils \
 systemd \
 zlib-ng-compat \
"
