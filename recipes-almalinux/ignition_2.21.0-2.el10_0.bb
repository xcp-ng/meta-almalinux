# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ignition"
PV = "2.21.0"
PR = "2.el10_0"
PACKAGES = " \
 ignition \
 ignition-edge \
 ignition-grub \
 ignition-validate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ignition-2.21.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14fcb3958a217eff1ba18267843af036a6284d867f8495372a7f5d1e387ddc57"

URI_x86_64_v2_ignition = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-2.21.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_ignition;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition}"
SRC_URI[x86_64_v2_ignition.sha256sum] = "2d18440e7de1520f9c9b26fb250c37accbacd4171111da6b733a225bbd31386e"

URI_x86_64_v2_ignition-edge = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-edge-2.21.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_ignition-edge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-edge}"
SRC_URI[x86_64_v2_ignition-edge.sha256sum] = "337b43880a91e67fb1f407b00b57fff2dbc1175ae6b7d0ee9922a6961b9cd760"

URI_x86_64_v2_ignition-grub = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-grub-2.21.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_ignition-grub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-grub}"
SRC_URI[x86_64_v2_ignition-grub.sha256sum] = "c8d793545c570112900c8873b058cc82b0a640a59792154043d0c55c6e49da11"

URI_x86_64_v2_ignition-validate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ignition-validate-2.21.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_ignition-validate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ignition-validate}"
SRC_URI[x86_64_v2_ignition-validate.sha256sum] = "bcb05442ea2a6d857a75e85154a95277844f6e0d79e693fd36344a246e7c8f99"

URI_aarch64_ignition = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-2.21.0-2.el10_0.aarch64.rpm;name=aarch64_ignition;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition}"
SRC_URI[aarch64_ignition.sha256sum] = "d960b841834efc5ee894e2070fd13667f6757cda82d4f318f03c1dcc27be6d03"

URI_aarch64_ignition-edge = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-edge-2.21.0-2.el10_0.aarch64.rpm;name=aarch64_ignition-edge;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-edge}"
SRC_URI[aarch64_ignition-edge.sha256sum] = "a606f16c7b73a8134439a6b5e66267a348cc9f72a3eea9a54e718d39eeb64de6"

URI_aarch64_ignition-grub = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-grub-2.21.0-2.el10_0.aarch64.rpm;name=aarch64_ignition-grub;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-grub}"
SRC_URI[aarch64_ignition-grub.sha256sum] = "cc5a88679f19de40b5d0f8304d2b01cafe4ea23cbb668a10dc8ba6347a6e3533"

URI_aarch64_ignition-validate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ignition-validate-2.21.0-2.el10_0.aarch64.rpm;name=aarch64_ignition-validate;unpack=0"
SRC_URI:append = " ${URI_aarch64_ignition-validate}"
SRC_URI[aarch64_ignition-validate.sha256sum] = "7ec93b0c4e7687c1f2f1bf5a165577e7b18a616a12339e21e6cf503d2313a1dd"

RDEPENDS:ignition = " \
 bash \
 dosfstools \
 dracut \
 dracut-network \
 glibc \
 libblkid \
 libgcc \
 libstdc++ \
 libuuid \
 popt \
 "
RDEPENDS:ignition-edge = " \
 bash \
 "
RDEPENDS:ignition-grub = " \
 "
RDEPENDS:ignition-validate = " \
 glibc \
 "
