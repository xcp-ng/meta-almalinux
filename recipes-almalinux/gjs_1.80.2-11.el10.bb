# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gjs"
PV = "1.80.2"
PR = "11.el10"
PACKAGES = " \
 gjs \
 gjs-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gjs-1.80.2-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13ca3c1591e921e12d42205a46d5242a656c7693c21f548c311448e0076a0d20"

URI_x86_64_v2_gjs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gjs-1.80.2-11.el10.x86_64_v2.rpm;name=x86_64_v2_gjs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gjs}"
SRC_URI[x86_64_v2_gjs.sha256sum] = "b27ad26c9d8235534b663a6aaa9fbe4c990ac7d64cbd8e86d06f615f4812e4ac"

URI_x86_64_v2_gjs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gjs-devel-1.80.2-11.el10.x86_64_v2.rpm;name=x86_64_v2_gjs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gjs-devel}"
SRC_URI[x86_64_v2_gjs-devel.sha256sum] = "be59e9cd9a12d486ff42213e73fc037d9486f80e1b118d62f5c39fd6220105a8"

URI_aarch64_gjs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gjs-1.80.2-11.el10.aarch64.rpm;name=aarch64_gjs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gjs}"
SRC_URI[aarch64_gjs.sha256sum] = "8bf219ba40219fe540af6bb896578d9a89a67528cfe0d21743275dbdc85dfcb4"

URI_aarch64_gjs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gjs-devel-1.80.2-11.el10.aarch64.rpm;name=aarch64_gjs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gjs-devel}"
SRC_URI[aarch64_gjs-devel.sha256sum] = "f1d2a0a31dcb53971daef7b3bfc8e73adbd89eaa1a8689e7187ae5b61c6304e9"

RDEPENDS:gjs = " \
 cairo \
 cairo-gobject \
 glib2 \
 glibc \
 gobject-introspection \
 libX11 \
 libffi \
 libgcc \
 libicu \
 libstdc++ \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:gjs-devel = " \
 cairo-devel \
 cairo-gobject-devel \
 gjs \
 glib2-devel \
 gobject-introspection-devel \
 libffi-devel \
 pkgconf-pkg-config \
 "
