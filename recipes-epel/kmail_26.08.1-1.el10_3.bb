# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmail"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmail \
 kmail-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmail-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3a72292befa4066a27f6f6b0a17475204093afd07a7b6e9589a5775ea77e1986"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail;unpack=0"
SRC_URI[x86_64_v2_kmail.sha256sum] = "c713f48c13a1a29288f1386f71881fcdd94628cc0b6abcd0e2c6b7d0579cc931"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail-libs;unpack=0"
SRC_URI[x86_64_v2_kmail-libs.sha256sum] = "e8cb1a0007c1205f8677f264a7bd0dffc98f51c2dac77d67125e02d3eaef87d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmail-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmail;unpack=0"
SRC_URI[aarch64_kmail.sha256sum] = "b7ca2c2773d4eeeb438455b97dcc663865c4df15050c8e9218e82cc57e37b4bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmail-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmail-libs;unpack=0"
SRC_URI[aarch64_kmail-libs.sha256sum] = "035f41fcae3644df15bf388cd3095daa83940972a454bf9bea543e8b0c924650"

RDEPENDS:kmail = " \
 akonadi-import-wizard \
 akonadi-mime \
 akonadi-server \
 glibc \
 grantlee-editor \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kmime \
 kf6-knotifications \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmail-account-wizard \
 kmail-libs \
 kmailtransport \
 kontactinterface \
 ktnef \
 libgcc \
 libstdc++ \
 mailcommon \
 messagelib \
 pim-data-exporter \
 pim-sieve-editor \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:kmail-libs = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgme2pp \
 kcalutils \
 kf6-kbookmarks \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kmime \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 kidentitymanagement \
 kldap \
 kmail \
 kmailtransport \
 kontactinterface \
 kpimtextedit \
 ktextaddons-qt6 \
 libgcc \
 libgpg-error \
 libgravatar \
 libkdepim \
 libkleo \
 libksieve \
 libstdc++ \
 mailcommon \
 messagelib \
 pimcommon \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
