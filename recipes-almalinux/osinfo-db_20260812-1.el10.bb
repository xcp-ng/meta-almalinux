# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osinfo-db"
PV = "20260812"
PR = "1.el10"
PACKAGES = " \
 osinfo-db \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osinfo-db-20260812-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "37267e7a0945d91f023956cc1173afec9c7c2ee22fdab3c0a96c041bcd04b026"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osinfo-db-20260812-1.el10.noarch.rpm;name=x86_64_v2_osinfo-db;unpack=0"
SRC_URI[x86_64_v2_osinfo-db.sha256sum] = "3b5f035dd9ac4283dbb9b511aa5d5ae8c458be5bdcf4ac7a231ea9ff3136e865"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osinfo-db-20260812-1.el10.noarch.rpm;name=aarch64_osinfo-db;unpack=0"
SRC_URI[aarch64_osinfo-db.sha256sum] = "3b5f035dd9ac4283dbb9b511aa5d5ae8c458be5bdcf4ac7a231ea9ff3136e865"

RDEPENDS:osinfo-db = " \
 hwdata \
 "
