# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "esmi_ib_library"
PV = "4.3"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 e_smi_tool \
 esmi_ib_library \
 esmi_ib_library-devel \
 esmi_ib_library-doc \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/e/esmi_ib_library-4.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68dcbbbbf79ba30f23c241805debc3cd7be5e6f54c4acfa3239f13c4fa6a1f74"

URI_x86_64_v2_e_smi_tool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/e_smi_tool-4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_e_smi_tool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e_smi_tool}"
SRC_URI[x86_64_v2_e_smi_tool.sha256sum] = "e1be5628c4068878b9748c23d40af3c7d01f560bc663175284916b413b39b310"

URI_x86_64_v2_esmi_ib_library = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/esmi_ib_library-4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_esmi_ib_library;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_esmi_ib_library}"
SRC_URI[x86_64_v2_esmi_ib_library.sha256sum] = "b1f5b1d0f54b199684a75302c424fc2583a69ac11a025f0235064b2b96c0e1c1"

URI_x86_64_v2_esmi_ib_library-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/esmi_ib_library-devel-4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_esmi_ib_library-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_esmi_ib_library-devel}"
SRC_URI[x86_64_v2_esmi_ib_library-devel.sha256sum] = "d5241f732f2bb75bcc3789a9beb60966f217cba8f44b1d849bf35ed37b3530a7"

URI_x86_64_v2_esmi_ib_library-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/esmi_ib_library-doc-4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_esmi_ib_library-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_esmi_ib_library-doc}"
SRC_URI[x86_64_v2_esmi_ib_library-doc.sha256sum] = "d53710b261644faf9880831bd94c6ba21c9fb328ab14f3dc9a6ddfb1815867bb"

RDEPENDS:e_smi_tool = " \
 esmi_ib_library \
 glibc \
 "
RDEPENDS:esmi_ib_library = " \
 glibc \
 "
RDEPENDS:esmi_ib_library-devel = " \
 esmi_ib_library \
 "
RDEPENDS:esmi_ib_library-doc = " \
 "
