# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Algorithm-Diff"
PV = "1.2010"
PR = "14.el10"
PACKAGES = " \
 perl-Algorithm-Diff \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Algorithm-Diff-1.2010-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1edd0cae95931ee58d503fbb31b7905cb4db1e78e98c2557c742c787ca2d8c85"

URI_x86_64_v2_perl-Algorithm-Diff = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Algorithm-Diff-1.2010-14.el10.noarch.rpm;name=x86_64_v2_perl-Algorithm-Diff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Algorithm-Diff}"
SRC_URI[x86_64_v2_perl-Algorithm-Diff.sha256sum] = "cee8d71f19e1436d8474f3b018a3f4acb73b6c68a72f9d72ae8dfe3d351f99de"

URI_aarch64_perl-Algorithm-Diff = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Algorithm-Diff-1.2010-14.el10.noarch.rpm;name=aarch64_perl-Algorithm-Diff;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Algorithm-Diff}"
SRC_URI[aarch64_perl-Algorithm-Diff.sha256sum] = "cee8d71f19e1436d8474f3b018a3f4acb73b6c68a72f9d72ae8dfe3d351f99de"

RDEPENDS:perl-Algorithm-Diff = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
