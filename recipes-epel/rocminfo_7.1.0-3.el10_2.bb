# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocminfo"
PV = "7.1.0"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 rocminfo \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocminfo-7.1.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed423186b247e24bdd82827b12becdb26af71fbc9a9fc94837f29cd3f348326f"

URI_x86_64_v2_rocminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocminfo-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocminfo}"
SRC_URI[x86_64_v2_rocminfo.sha256sum] = "3566106ea8437ea6d2c582a1b13a08c39833d85f1a7bf995214ce286ec5b4adb"

RDEPENDS:rocminfo = " \
 glibc \
 kmod \
 libgcc \
 libstdc++ \
 python3 \
 rocm-runtime \
 "
