# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "forgejo"
PV = "12.0.1"
PR = "1.el10_1"
PACKAGES = " \
 forgejo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/forgejo-12.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdb852373b0b053ecd9082cc68a2a7fa91eb969d71f3ff9391afd11cac226d4d"

URI_x86_64_v2_forgejo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/forgejo-12.0.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_forgejo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_forgejo}"
SRC_URI[x86_64_v2_forgejo.sha256sum] = "e023fd598a1bf0f90fbb287217b5e28a62201e52fa7acfa8dc0ae01e316b5566"

URI_aarch64_forgejo = "${EPEL_MIRROR}/aarch64/Packages/f/forgejo-12.0.1-1.el10_1.aarch64.rpm;name=aarch64_forgejo;unpack=0"
SRC_URI:append = " ${URI_aarch64_forgejo}"
SRC_URI[aarch64_forgejo.sha256sum] = "2b69c5bb5d73f646c47868089a22c110bf416547b7ac4cbac660fc6538999b24"

RDEPENDS:forgejo = " \
 bash \
 git-core \
 git-lfs \
 glibc \
 sed \
 shadow-utils \
 virtual/coreutils \
 "
