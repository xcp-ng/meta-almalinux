# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quote"
PV = "1.0.45"
PR = "1.el10_1"
PACKAGES = " \
 rust-quote+default-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quote-1.0.45-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c381193bd8477d8ad1723c3dfae2172acb47b50aa264c588bad1cb98538685d"

URI_x86_64_v2_rust-quote+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote+default-devel-1.0.45-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote+default-devel}"
SRC_URI[x86_64_v2_rust-quote+default-devel.sha256sum] = "e364732eab2f599dc7759b34114925869af1825e096bb6509e8618f4f16362a8"

URI_x86_64_v2_rust-quote+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote+proc-macro-devel-1.0.45-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-quote+proc-macro-devel.sha256sum] = "1df11476ba2d565a98f7199efb2a1e50e6eb1b7713392e1d1d9fc598858875c8"

URI_x86_64_v2_rust-quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote-devel-1.0.45-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote-devel}"
SRC_URI[x86_64_v2_rust-quote-devel.sha256sum] = "7bd2a49f311f8968837a0b80b94bffd25575a67c57a8003394ff081412e90688"

URI_aarch64_rust-quote+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote+default-devel-1.0.45-1.el10_1.noarch.rpm;name=aarch64_rust-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote+default-devel}"
SRC_URI[aarch64_rust-quote+default-devel.sha256sum] = "b16075933521e7290fc141680481f6318015a52e22e03635bab5047556797390"

URI_aarch64_rust-quote+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote+proc-macro-devel-1.0.45-1.el10_1.noarch.rpm;name=aarch64_rust-quote+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote+proc-macro-devel}"
SRC_URI[aarch64_rust-quote+proc-macro-devel.sha256sum] = "883937f1a327fa9c0200579b50a6f21337ad3e6afb5ce73651b43196ab317135"

URI_aarch64_rust-quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote-devel-1.0.45-1.el10_1.noarch.rpm;name=aarch64_rust-quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote-devel}"
SRC_URI[aarch64_rust-quote-devel.sha256sum] = "6dcc2c27b8337e7db1d8ff124c3bf0d9bae2a0d3141f4cc7cba0d6b1953328ae"

RDEPENDS:rust-quote+default-devel = " \
 cargo \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 "
RDEPENDS:rust-quote+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote-devel \
 "
RDEPENDS:rust-quote-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 "
