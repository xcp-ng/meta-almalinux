# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch-manifest"
PV = "2.27.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-onefetch-manifest+default-devel \
 rust-onefetch-manifest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-manifest-2.27.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fa0dd6abcb657d44f30d109b516775024534b583f04d91dd41a17285b79e22a"

URI_x86_64_v2_rust-onefetch-manifest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-manifest+default-devel-2.27.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-manifest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-manifest+default-devel}"
SRC_URI[x86_64_v2_rust-onefetch-manifest+default-devel.sha256sum] = "c553d2e36f58e1c0b653ca5331ecce4b72e27f0d7a0223d8f93498aae278031e"

URI_x86_64_v2_rust-onefetch-manifest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-manifest-devel-2.27.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-manifest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-manifest-devel}"
SRC_URI[x86_64_v2_rust-onefetch-manifest-devel.sha256sum] = "4bc38aed25288850480505db3fa5a69074c50624ddd7e5de00b47637696b8599"

URI_aarch64_rust-onefetch-manifest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-manifest+default-devel-2.27.1-2.el10_2.noarch.rpm;name=aarch64_rust-onefetch-manifest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-manifest+default-devel}"
SRC_URI[aarch64_rust-onefetch-manifest+default-devel.sha256sum] = "859c0c3a000ac8ed7c51c44b6b755c12e84f08131c5b7ac3c2d721a7e0dbd2ce"

URI_aarch64_rust-onefetch-manifest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-manifest-devel-2.27.1-2.el10_2.noarch.rpm;name=aarch64_rust-onefetch-manifest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-manifest-devel}"
SRC_URI[aarch64_rust-onefetch-manifest-devel.sha256sum] = "85c884fa72299e463bc398c275280f75859c79182aeb549a835706fd7c822ac2"

RDEPENDS:rust-onefetch-manifest+default-devel = " \
 cargo \
 rust-onefetch-manifest-devel \
 "
RDEPENDS:rust-onefetch-manifest-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-cargo_toml+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 "
