# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-deque"
PV = "0.8.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-crossbeam-deque+default-devel \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-deque-0.8.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b046628e7f21f47ef4a222ff046583d5f40e96cb8c17e200105186f8fcc8a1ba"

URI_x86_64_v2_rust-crossbeam-deque+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque+default-devel-0.8.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-deque+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-deque+default-devel.sha256sum] = "7ca65cf694c98239d8ddef5c5f6a59fdf8a2e8cb03794f148d374b6f4a7b7a9b"

URI_x86_64_v2_rust-crossbeam-deque+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque+std-devel-0.8.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-deque+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-deque+std-devel.sha256sum] = "12b32986707e0fa89b8f4922bf5e427a7e41b06aeddb925aac735c0616230d6f"

URI_x86_64_v2_rust-crossbeam-deque-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque-devel-0.8.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-deque-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-deque-devel.sha256sum] = "24654487d0d2a7f3a7d08732d44cbf6f82dcfa3e0f1930a024d05e638db8e4d6"

URI_aarch64_rust-crossbeam-deque+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque+default-devel-0.8.6-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-deque+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-deque+default-devel}"
SRC_URI[aarch64_rust-crossbeam-deque+default-devel.sha256sum] = "d57a8034f598d07db71e2a19e39789d938328f73b0489fc94ce79e1e894cdb77"

URI_aarch64_rust-crossbeam-deque+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque+std-devel-0.8.6-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-deque+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-deque+std-devel}"
SRC_URI[aarch64_rust-crossbeam-deque+std-devel.sha256sum] = "46c06aaee15068751e1a3cdd6e9d7da85e7241bef827d4f6c8e9a8120e2cffa9"

URI_aarch64_rust-crossbeam-deque-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque-devel-0.8.6-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-deque-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-deque-devel}"
SRC_URI[aarch64_rust-crossbeam-deque-devel.sha256sum] = "aa360216e64f4e9e5f4267c6f2cc4697bc1f8f1fd8cfc01d887e7e2419988636"

RDEPENDS:rust-crossbeam-deque+default-devel = " \
 cargo \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 "
RDEPENDS:rust-crossbeam-deque+std-devel = " \
 cargo \
 rust-crossbeam-deque-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-deque-devel = " \
 cargo \
 rust \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils-devel \
 "
