# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is_executable"
PV = "1.0.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-is_executable+default-devel \
 rust-is_executable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is_executable-1.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27bb5920a2ff86c534044574bae1a889729424a462cf7a9a6850fab42b811ffe"

URI_x86_64_v2_rust-is_executable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is_executable+default-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is_executable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is_executable+default-devel}"
SRC_URI[x86_64_v2_rust-is_executable+default-devel.sha256sum] = "931d2a1f2dc0fa0f339d04c09298642954103f7355da655093520ad12b9c11c7"

URI_x86_64_v2_rust-is_executable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is_executable-devel-1.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is_executable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is_executable-devel}"
SRC_URI[x86_64_v2_rust-is_executable-devel.sha256sum] = "4cfa50e4c0281635dc43466ed6c5b24f973756e62d7caedbdffbef50c836a98d"

URI_aarch64_rust-is_executable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is_executable+default-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-is_executable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is_executable+default-devel}"
SRC_URI[aarch64_rust-is_executable+default-devel.sha256sum] = "4f27a826d3cc620fb022fa4a21e778a475fb632a1a9e5f19b1027669a61db46d"

URI_aarch64_rust-is_executable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is_executable-devel-1.0.6-1.el10_3.noarch.rpm;name=aarch64_rust-is_executable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is_executable-devel}"
SRC_URI[aarch64_rust-is_executable-devel.sha256sum] = "31f687d5d208656e6389e4cb727e153c1264ad9f668f1f0f643e1ee47413b7a1"

RDEPENDS:rust-is_executable+default-devel = " \
 cargo \
 rust-is_executable-devel \
 "
RDEPENDS:rust-is_executable-devel = " \
 cargo \
 "
