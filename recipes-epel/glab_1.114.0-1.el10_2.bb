# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glab"
PV = "1.114.0"
PR = "1.el10_2"
PACKAGES = " \
 glab \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/glab-1.114.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "27f001ea3fce6dd645202685e06e6d18f1b20f29b59ff76857251f283ee6635e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glab-1.114.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glab;unpack=0"
SRC_URI[x86_64_v2_glab.sha256sum] = "b46949cf5bb49171ddab41f1712d5d553cacb73ad46a416b30944c5913fb5c4c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/glab-1.114.0-1.el10_2.aarch64.rpm;name=aarch64_glab;unpack=0"
SRC_URI[aarch64_glab.sha256sum] = "1f384f572cf5208f965f26bdd1ccdf0c253d8fe6194fe7502d451045107bc295"

RDEPENDS:glab = " \
 git-core \
 glibc \
 "
