# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdivide"
PV = "5.3.0"
PR = "1.el10_1"
PACKAGES = " \
 libdivide-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdivide-5.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f8988236c7e66c516eb11d9893c6ad71c07145ab53260e4ddc0d014764eade0"

URI_x86_64_v2_libdivide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdivide-devel-5.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdivide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdivide-devel}"
SRC_URI[x86_64_v2_libdivide-devel.sha256sum] = "ebfc8b466295f17381ea5b8ade6d8797d4722c4829fbc1fa3da8a69fdc3d4a89"

URI_aarch64_libdivide-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdivide-devel-5.3.0-1.el10_1.aarch64.rpm;name=aarch64_libdivide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdivide-devel}"
SRC_URI[aarch64_libdivide-devel.sha256sum] = "3af8711f29cc5307261ad8ab33577c1e17f8700dd3b7b927960152622dc198f5"

RDEPENDS:libdivide-devel = " \
 cmake-filesystem \
 "
