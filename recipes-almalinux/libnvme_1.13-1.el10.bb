# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnvme"
PV = "1.13"
PR = "1.el10"
PACKAGES = " \
 libnvme \
 libnvme-devel \
 python3-libnvme \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libnvme-1.13-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9d54bab7ac5165bf4826a21ba6028aefe5c9244e3e3a32fef196bd4622bfe68"

URI_x86_64_v2_libnvme = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnvme-1.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnvme}"
SRC_URI[x86_64_v2_libnvme.sha256sum] = "5ccc8e8909509d685d3d5aa21d87005e7148f0c4ab916091951e6cce96f987c8"

URI_x86_64_v2_libnvme-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnvme-devel-1.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnvme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnvme-devel}"
SRC_URI[x86_64_v2_libnvme-devel.sha256sum] = "58b724f0de69b95c6a7226f1e0be289cf1414a7154292d535ad8faeb0a4c85bd"

URI_x86_64_v2_python3-libnvme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnvme-1.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libnvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnvme}"
SRC_URI[x86_64_v2_python3-libnvme.sha256sum] = "8681ed2a359dfd859b4b56c6d07b0d3f315c97dae675c38bed002dc6a87025db"

URI_aarch64_libnvme = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnvme-1.13-1.el10.aarch64.rpm;name=aarch64_libnvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnvme}"
SRC_URI[aarch64_libnvme.sha256sum] = "f38600f874a05f84151173068efbd765d7f03d2d218e2c35978390dc70dc38f1"

URI_aarch64_libnvme-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnvme-devel-1.13-1.el10.aarch64.rpm;name=aarch64_libnvme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnvme-devel}"
SRC_URI[aarch64_libnvme-devel.sha256sum] = "d2ee1c9b61432b7655e7363c2cfbbde3a35e53f636b97b061856fcab1e800245"

URI_aarch64_python3-libnvme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnvme-1.13-1.el10.aarch64.rpm;name=aarch64_python3-libnvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnvme}"
SRC_URI[aarch64_python3-libnvme.sha256sum] = "a032c2456571e1ad2c9e3563cac2e097dcb616c625cc601683c1fb6ab88cad4f"

RDEPENDS:libnvme = " \
 dbus-libs \
 glibc \
 json-c \
 keyutils-libs \
 libgcc \
 openssl-libs \
 "
RDEPENDS:libnvme-devel = " \
 dbus-devel \
 json-c-devel \
 keyutils-libs-devel \
 libnvme \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libnvme = " \
 glibc \
 libnvme \
 python3 \
 "
