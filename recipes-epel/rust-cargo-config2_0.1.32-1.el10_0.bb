# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-config2"
PV = "0.1.32"
PR = "1.el10_0"
PACKAGES = " \
 rust-cargo-config2+default-devel \
 rust-cargo-config2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-config2-0.1.32-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec07e2f17c10f7c8eaa3e8b8171aacf50d14ed39e94c90bc16fc90c624cb8620"

URI_x86_64_v2_rust-cargo-config2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-config2+default-devel-0.1.32-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-config2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-config2+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-config2+default-devel.sha256sum] = "249067966788da3e4d0f961b8e06607b65ae57976a395fb8d5812e15c5cf7031"

URI_x86_64_v2_rust-cargo-config2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-config2-devel-0.1.32-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-config2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-config2-devel}"
SRC_URI[x86_64_v2_rust-cargo-config2-devel.sha256sum] = "aa15780e4e2b4a45ad00d16f9c88eed9ddbef4cb6a72600b418487feb8009740"

URI_aarch64_rust-cargo-config2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-config2+default-devel-0.1.32-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-config2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-config2+default-devel}"
SRC_URI[aarch64_rust-cargo-config2+default-devel.sha256sum] = "c30318af31dfc5609a75614ebecce6e0c9e0e97bc6f829dbe6ec18ddfd793129"

URI_aarch64_rust-cargo-config2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-config2-devel-0.1.32-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-config2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-config2-devel}"
SRC_URI[aarch64_rust-cargo-config2-devel.sha256sum] = "afa839767e80663262d5969820c0442027647c93f5a2809375ff2cf80c09fbcf"

RDEPENDS:rust-cargo-config2+default-devel = " \
 cargo \
 rust-cargo-config2-devel \
 "
RDEPENDS:rust-cargo-config2-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit+serde-devel \
 rust-toml_edit-devel \
 "
