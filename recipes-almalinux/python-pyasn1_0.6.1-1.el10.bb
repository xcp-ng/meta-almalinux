# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyasn1"
PV = "0.6.1"
PR = "1.el10"
PACKAGES = " \
 python3-pyasn1 \
 python3-pyasn1-modules \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pyasn1-0.6.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5adaebf3319ac4a6159f31d4b9c4e176f694a4a4b7fbbca0848a4aed3fe8f079"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyasn1-0.6.1-1.el10.noarch.rpm;name=x86_64_v2_python3-pyasn1;unpack=0"
SRC_URI[x86_64_v2_python3-pyasn1.sha256sum] = "029b123cc167ed555185dd42ec510938f3e4919ed29a8b3022c4d1b447120d5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyasn1-modules-0.6.1-1.el10.noarch.rpm;name=x86_64_v2_python3-pyasn1-modules;unpack=0"
SRC_URI[x86_64_v2_python3-pyasn1-modules.sha256sum] = "d90ae265ba089382244d19ec831c6529d99052844febc618fc2c229efe696369"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyasn1-0.6.1-1.el10.noarch.rpm;name=aarch64_python3-pyasn1;unpack=0"
SRC_URI[aarch64_python3-pyasn1.sha256sum] = "029b123cc167ed555185dd42ec510938f3e4919ed29a8b3022c4d1b447120d5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyasn1-modules-0.6.1-1.el10.noarch.rpm;name=aarch64_python3-pyasn1-modules;unpack=0"
SRC_URI[aarch64_python3-pyasn1-modules.sha256sum] = "d90ae265ba089382244d19ec831c6529d99052844febc618fc2c229efe696369"

RDEPENDS:python3-pyasn1 = " \
 python3 \
 "
RDEPENDS:python3-pyasn1-modules = " \
 python3 \
 python3-pyasn1 \
 "
