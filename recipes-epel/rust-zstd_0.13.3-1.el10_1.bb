# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zstd"
PV = "0.13.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-zstd+arrays-devel \
 rust-zstd+bindgen-devel \
 rust-zstd+debug-devel \
 rust-zstd+default-devel \
 rust-zstd+doc-cfg-devel \
 rust-zstd+experimental-devel \
 rust-zstd+fat-lto-devel \
 rust-zstd+legacy-devel \
 rust-zstd+no_asm-devel \
 rust-zstd+pkg-config-devel \
 rust-zstd+thin-devel \
 rust-zstd+thin-lto-devel \
 rust-zstd+wasm-devel \
 rust-zstd+zdict_builder-devel \
 rust-zstd+zstdmt-devel \
 rust-zstd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zstd-0.13.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "092cadf219b375be56508de6e3f53f319aee68ef0e1a0bbf15d022527b4a703f"

URI_x86_64_v2_rust-zstd+arrays-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+arrays-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+arrays-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+arrays-devel}"
SRC_URI[x86_64_v2_rust-zstd+arrays-devel.sha256sum] = "d132b74bade410be3f7905fc17b8599f47bad0be6e31086f82a280f76d47ef86"

URI_x86_64_v2_rust-zstd+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+bindgen-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+bindgen-devel}"
SRC_URI[x86_64_v2_rust-zstd+bindgen-devel.sha256sum] = "58acf7b6486749b2a9098a02a3a5d962618076bfee343579de9c5055081538c3"

URI_x86_64_v2_rust-zstd+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+debug-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+debug-devel}"
SRC_URI[x86_64_v2_rust-zstd+debug-devel.sha256sum] = "39b73a24d5f4fb09e72b1bd65ff1a6db9eb642d5d6040970d6b10d9d136baa40"

URI_x86_64_v2_rust-zstd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+default-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+default-devel}"
SRC_URI[x86_64_v2_rust-zstd+default-devel.sha256sum] = "d4af248827a191f8058419c5b3585f1b115653c7b1eef5f5fd98c81a6cbe1151"

URI_x86_64_v2_rust-zstd+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+doc-cfg-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-zstd+doc-cfg-devel.sha256sum] = "a22a44a934e4ad65d4cd9ffddf5e6aae33ebbdc428c59767ebb6c2255fe90a4e"

URI_x86_64_v2_rust-zstd+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+experimental-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+experimental-devel}"
SRC_URI[x86_64_v2_rust-zstd+experimental-devel.sha256sum] = "df89aba96429488139659b057394e46278646e213866f76be95346212843e121"

URI_x86_64_v2_rust-zstd+fat-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+fat-lto-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+fat-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd+fat-lto-devel.sha256sum] = "b8613934168f050547f75b048fe6f065dbf1ab9c732a8596bde260cace424e93"

URI_x86_64_v2_rust-zstd+legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+legacy-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+legacy-devel}"
SRC_URI[x86_64_v2_rust-zstd+legacy-devel.sha256sum] = "9be7ea9e89a00095f2816c3e1797eb7321b8b9a4fd52e2cd1fd62fcb56b7e513"

URI_x86_64_v2_rust-zstd+no_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+no_asm-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+no_asm-devel}"
SRC_URI[x86_64_v2_rust-zstd+no_asm-devel.sha256sum] = "de70f6cc4f2c789174e676cfbfb8e556ec9b19582247127da176b7898e874df3"

URI_x86_64_v2_rust-zstd+pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+pkg-config-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+pkg-config-devel}"
SRC_URI[x86_64_v2_rust-zstd+pkg-config-devel.sha256sum] = "1ae8743d892cd3b9bddff469412e1c9ec25c552ea52cb748fd654779f7c4738a"

URI_x86_64_v2_rust-zstd+thin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+thin-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+thin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+thin-devel}"
SRC_URI[x86_64_v2_rust-zstd+thin-devel.sha256sum] = "f209b32a19fa4efde2a1845658a33d22aa2962cf722329edcf6a06850ec5967c"

URI_x86_64_v2_rust-zstd+thin-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+thin-lto-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+thin-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd+thin-lto-devel.sha256sum] = "7f3b200ddb839a9ef1226e826d4ad6d3c8188efb57d77c026c8f2ddd8c999a7f"

URI_x86_64_v2_rust-zstd+wasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+wasm-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+wasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+wasm-devel}"
SRC_URI[x86_64_v2_rust-zstd+wasm-devel.sha256sum] = "58dd63cc690ce9c7d839e3a6dc15843514ab7cbeb657c91cfe15175c3e181df3"

URI_x86_64_v2_rust-zstd+zdict_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+zdict_builder-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+zdict_builder-devel}"
SRC_URI[x86_64_v2_rust-zstd+zdict_builder-devel.sha256sum] = "0cfee56f9c86a74bbb4ebf4c4b09ea7d931ae875674deea5ecd5a699d2873a8f"

URI_x86_64_v2_rust-zstd+zstdmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd+zstdmt-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd+zstdmt-devel}"
SRC_URI[x86_64_v2_rust-zstd+zstdmt-devel.sha256sum] = "16082ee2f98e45eb981e8b883b5199692cd608949a3a52e15a4a56b46c174293"

URI_x86_64_v2_rust-zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-devel-0.13.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-devel}"
SRC_URI[x86_64_v2_rust-zstd-devel.sha256sum] = "a2b4cddbdd0444f10d26b24a4d528d70daf475eafe0d7c76b5f744c5ab9edde4"

URI_aarch64_rust-zstd+arrays-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+arrays-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+arrays-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+arrays-devel}"
SRC_URI[aarch64_rust-zstd+arrays-devel.sha256sum] = "faf055ec063f39aac01249e61f79d83190ed991c3adbe254734e088c6ed25c08"

URI_aarch64_rust-zstd+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+bindgen-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+bindgen-devel}"
SRC_URI[aarch64_rust-zstd+bindgen-devel.sha256sum] = "d1b9c2a7fd27515582785f26443e51b31bea71108a714b9431dbc05f155b1610"

URI_aarch64_rust-zstd+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+debug-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+debug-devel}"
SRC_URI[aarch64_rust-zstd+debug-devel.sha256sum] = "88b2ee6a2d477ed7056669d41846db1a71dac00ad5a22d45ba01c74004c7262e"

URI_aarch64_rust-zstd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+default-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+default-devel}"
SRC_URI[aarch64_rust-zstd+default-devel.sha256sum] = "d224e60042675fa1ecb574a70ec82c87edcbbf0fd1ce2c76c961a39545bad83d"

URI_aarch64_rust-zstd+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+doc-cfg-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+doc-cfg-devel}"
SRC_URI[aarch64_rust-zstd+doc-cfg-devel.sha256sum] = "6eaa3cce1126562fba8216a9d24be6095b1a2f92f966c2a0d141c35f339a00ce"

URI_aarch64_rust-zstd+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+experimental-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+experimental-devel}"
SRC_URI[aarch64_rust-zstd+experimental-devel.sha256sum] = "1bed4a66e03c639a8f2c718a859799ec9cf70fbecd73488a7dd85390dd90da3d"

URI_aarch64_rust-zstd+fat-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+fat-lto-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+fat-lto-devel}"
SRC_URI[aarch64_rust-zstd+fat-lto-devel.sha256sum] = "f3f77cf28d9e02c5b9b726f3b86be77708cb289c5a2f975e46cd50cd313b8f9d"

URI_aarch64_rust-zstd+legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+legacy-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+legacy-devel}"
SRC_URI[aarch64_rust-zstd+legacy-devel.sha256sum] = "29299de66127ef7dda43355407f06a9ffc005f5cc26122be5df39310b2a65a82"

URI_aarch64_rust-zstd+no_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+no_asm-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+no_asm-devel}"
SRC_URI[aarch64_rust-zstd+no_asm-devel.sha256sum] = "7afd2b8cf8ea7fcc24c7fe907f8f06cc94a2c5a7268935375fec2ddbf7dbd98c"

URI_aarch64_rust-zstd+pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+pkg-config-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+pkg-config-devel}"
SRC_URI[aarch64_rust-zstd+pkg-config-devel.sha256sum] = "1819d207dc9cfac630a1bc522cb2cef27e1fa632dfc341b3b207dd68f6d49283"

URI_aarch64_rust-zstd+thin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+thin-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+thin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+thin-devel}"
SRC_URI[aarch64_rust-zstd+thin-devel.sha256sum] = "aa43e75dcfe32d9fbca7568a0802f9c25048036da4d758dac3c20cdc90a01bb0"

URI_aarch64_rust-zstd+thin-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+thin-lto-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+thin-lto-devel}"
SRC_URI[aarch64_rust-zstd+thin-lto-devel.sha256sum] = "aa1ae6d7b6bcb5bd0123b8d6bd947e57bd421802fdeeb40c3a90c47ba06bfac0"

URI_aarch64_rust-zstd+wasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+wasm-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+wasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+wasm-devel}"
SRC_URI[aarch64_rust-zstd+wasm-devel.sha256sum] = "2eac4fc53737890cd5d58afda8a2cc2f057b9dcae55930a998f835e981d407eb"

URI_aarch64_rust-zstd+zdict_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+zdict_builder-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+zdict_builder-devel}"
SRC_URI[aarch64_rust-zstd+zdict_builder-devel.sha256sum] = "a8131bddb4932716ef36881a12fd105b327457ad018af6706003d8e50e237c92"

URI_aarch64_rust-zstd+zstdmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd+zstdmt-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd+zstdmt-devel}"
SRC_URI[aarch64_rust-zstd+zstdmt-devel.sha256sum] = "6ff79548324a016afe37da7dc07d190bc58fe656f459cb3e85cc3bbcc9cb95cf"

URI_aarch64_rust-zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-devel-0.13.3-1.el10_1.noarch.rpm;name=aarch64_rust-zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-devel}"
SRC_URI[aarch64_rust-zstd-devel.sha256sum] = "f76b90bc83ff4e5edcf7a30324a44e28fbaa3f075d05ed92e956d681727761d8"

RDEPENDS:rust-zstd+arrays-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+arrays-devel \
 "
RDEPENDS:rust-zstd+bindgen-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+bindgen-devel \
 "
RDEPENDS:rust-zstd+debug-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+debug-devel \
 "
RDEPENDS:rust-zstd+default-devel = " \
 cargo \
 rust-zstd+arrays-devel \
 rust-zstd+legacy-devel \
 rust-zstd+zdict_builder-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-zstd+doc-cfg-devel = " \
 cargo \
 rust-zstd-devel \
 "
RDEPENDS:rust-zstd+experimental-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+experimental-devel \
 "
RDEPENDS:rust-zstd+fat-lto-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+fat-lto-devel \
 "
RDEPENDS:rust-zstd+legacy-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+legacy-devel \
 "
RDEPENDS:rust-zstd+no_asm-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+no_asm-devel \
 "
RDEPENDS:rust-zstd+pkg-config-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+pkg-config-devel \
 "
RDEPENDS:rust-zstd+thin-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+thin-devel \
 "
RDEPENDS:rust-zstd+thin-lto-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+thin-lto-devel \
 "
RDEPENDS:rust-zstd+wasm-devel = " \
 cargo \
 rust-zstd-devel \
 "
RDEPENDS:rust-zstd+zdict_builder-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+zdict_builder-devel \
 "
RDEPENDS:rust-zstd+zstdmt-devel = " \
 cargo \
 rust-zstd-devel \
 rust-zstd-safe+zstdmt-devel \
 "
RDEPENDS:rust-zstd-devel = " \
 cargo \
 rust \
 rust-zstd-safe+std-devel \
 rust-zstd-safe-devel \
 "
