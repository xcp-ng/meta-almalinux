# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-vsimd"
PV = "0.8.0"
PR = "6.el10_3"
PACKAGES = " \
 rust-vsimd+alloc-devel \
 rust-vsimd+default-devel \
 rust-vsimd+detect-devel \
 rust-vsimd+std-devel \
 rust-vsimd+unstable-devel \
 rust-vsimd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-vsimd-0.8.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "719bc2091230a0b9be76eabe34bec4f360ceb1981e94ad662b02c86798f9a473"

URI_x86_64_v2_rust-vsimd+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsimd+alloc-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsimd+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsimd+alloc-devel}"
SRC_URI[x86_64_v2_rust-vsimd+alloc-devel.sha256sum] = "08b36b90544d232f03e089a3e073ddcd8ef81ff94f2789c83df9d553ed7a466c"

URI_x86_64_v2_rust-vsimd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsimd+default-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsimd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsimd+default-devel}"
SRC_URI[x86_64_v2_rust-vsimd+default-devel.sha256sum] = "0f5b4bbc3b932809d427b2e02e44f7e91b4a8223e7c2dc87634bdb42178d7723"

URI_x86_64_v2_rust-vsimd+detect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsimd+detect-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsimd+detect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsimd+detect-devel}"
SRC_URI[x86_64_v2_rust-vsimd+detect-devel.sha256sum] = "39841e6f17bacd582c2e26bcb53f20fbc5329655559724da3594629d99008cc3"

URI_x86_64_v2_rust-vsimd+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsimd+std-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsimd+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsimd+std-devel}"
SRC_URI[x86_64_v2_rust-vsimd+std-devel.sha256sum] = "59d6d3b74dc2560606d47c4239a8197fd93ad1cc9b962dd59367b191c9f7f986"

URI_x86_64_v2_rust-vsimd+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsimd+unstable-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsimd+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsimd+unstable-devel}"
SRC_URI[x86_64_v2_rust-vsimd+unstable-devel.sha256sum] = "cb473c492c7fa7875860efbda265894b4b69577999814eaf43edf5e4e412cbd9"

URI_x86_64_v2_rust-vsimd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vsimd-devel-0.8.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vsimd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vsimd-devel}"
SRC_URI[x86_64_v2_rust-vsimd-devel.sha256sum] = "0c9eb7cb3039b9f356cf2a04b4631a240951c4a2c4f5ecfd28680f86d1db1d26"

URI_aarch64_rust-vsimd+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsimd+alloc-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-vsimd+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsimd+alloc-devel}"
SRC_URI[aarch64_rust-vsimd+alloc-devel.sha256sum] = "d68137eab50d244505677f414b81e5e57bb11b9c62266640303a4b4ed3199b49"

URI_aarch64_rust-vsimd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsimd+default-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-vsimd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsimd+default-devel}"
SRC_URI[aarch64_rust-vsimd+default-devel.sha256sum] = "9c2c3a5c7ec0bf2ab90762e03ef85aa06c3af8b6c341d93bf91b36e1d20d79d3"

URI_aarch64_rust-vsimd+detect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsimd+detect-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-vsimd+detect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsimd+detect-devel}"
SRC_URI[aarch64_rust-vsimd+detect-devel.sha256sum] = "b9a5c44898ee2ca306c7668013d56bdd6dae900de43053f0d22e9ef7c340a9ba"

URI_aarch64_rust-vsimd+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsimd+std-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-vsimd+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsimd+std-devel}"
SRC_URI[aarch64_rust-vsimd+std-devel.sha256sum] = "ecf2bf70b0d52d2423346b8348fe41003705fd62280693aba76b7a1a0a952f30"

URI_aarch64_rust-vsimd+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsimd+unstable-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-vsimd+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsimd+unstable-devel}"
SRC_URI[aarch64_rust-vsimd+unstable-devel.sha256sum] = "916d1b9432ae448133157de8bfbaf44e0f9cfeda8dc5581ca6a42f39d7ff96b8"

URI_aarch64_rust-vsimd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vsimd-devel-0.8.0-6.el10_3.noarch.rpm;name=aarch64_rust-vsimd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vsimd-devel}"
SRC_URI[aarch64_rust-vsimd-devel.sha256sum] = "9c88e55fd156ec16c67781113ab166fda692011f390fa9508747b0995b3f9ffc"

RDEPENDS:rust-vsimd+alloc-devel = " \
 cargo \
 rust-vsimd-devel \
 "
RDEPENDS:rust-vsimd+default-devel = " \
 cargo \
 rust-vsimd-devel \
 "
RDEPENDS:rust-vsimd+detect-devel = " \
 cargo \
 rust-vsimd+std-devel \
 rust-vsimd-devel \
 "
RDEPENDS:rust-vsimd+std-devel = " \
 cargo \
 rust-vsimd+alloc-devel \
 rust-vsimd-devel \
 "
RDEPENDS:rust-vsimd+unstable-devel = " \
 cargo \
 rust-vsimd-devel \
 "
RDEPENDS:rust-vsimd-devel = " \
 cargo \
 rust \
 "
