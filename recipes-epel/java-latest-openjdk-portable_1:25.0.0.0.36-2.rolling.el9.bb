# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk-portable"
PE = "1"
PV = "25.0.0.0.36"
PR = "2.rolling.el9"
PACKAGES = " \
 java-latest-openjdk-portable \
 java-latest-openjdk-portable-devel \
 java-latest-openjdk-portable-devel-fastdebug \
 java-latest-openjdk-portable-devel-slowdebug \
 java-latest-openjdk-portable-docs \
 java-latest-openjdk-portable-fastdebug \
 java-latest-openjdk-portable-misc \
 java-latest-openjdk-portable-slowdebug \
 java-latest-openjdk-portable-sources \
 java-latest-openjdk-portable-static-libs \
 java-latest-openjdk-portable-static-libs-fastdebug \
 java-latest-openjdk-portable-static-libs-slowdebug \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-portable-25.0.0.0.36-2.rolling.el9.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fb602a8c8aef156ca2de71244cfd526e7d2911c7d9c6b5a3a0bb79b9eae5419"

URI_x86_64_v2_java-latest-openjdk-portable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable.sha256sum] = "3ed22c38df32445e2dc3e2bbae76e9964b54debc9433b1e8faed21fc9ff0d45a"

URI_x86_64_v2_java-latest-openjdk-portable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-devel}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel.sha256sum] = "d7b015992479f80fca93e00dd5826fe9ae2005ce2f0fa63c8294e0d4bdcb555d"

URI_x86_64_v2_java-latest-openjdk-portable-devel-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-fastdebug-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-devel-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel-fastdebug.sha256sum] = "cdd54f346974eea8af0b2a277715ff34f0ce588a12447e4fe76f1b38e92684cd"

URI_x86_64_v2_java-latest-openjdk-portable-devel-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-slowdebug-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-devel-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel-slowdebug.sha256sum] = "60ad5d495cc60700df3ee81b42e11705b50e9eaa9633c9e7b5533c608f5c8492"

URI_x86_64_v2_java-latest-openjdk-portable-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-docs-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-docs}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-docs.sha256sum] = "ce08f007eea794561a9dad8c0173671fe3a5356f5a4159034f17a457cd326052"

URI_x86_64_v2_java-latest-openjdk-portable-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-fastdebug-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-fastdebug.sha256sum] = "af1ea2f55dc80328e0814b2b21ad83f78db88bdef24d167d496db71fd4d09573"

URI_x86_64_v2_java-latest-openjdk-portable-misc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-misc-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-misc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-misc}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-misc.sha256sum] = "b41f7ead34386f4f35afdd27d024595b388b293e4593aa45a1cef884be668448"

URI_x86_64_v2_java-latest-openjdk-portable-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-slowdebug-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-slowdebug.sha256sum] = "dc3701a3758a6cb23c00ed5cd3a263f5bd84b9e4e5eb8194f5ad6bd73d292427"

URI_x86_64_v2_java-latest-openjdk-portable-sources = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-sources-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-sources;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-sources}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-sources.sha256sum] = "676c78d66e3fbf11e188815d631d9164cfb2a5b83d62bc663ce0422da2117545"

URI_x86_64_v2_java-latest-openjdk-portable-static-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-static-libs}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs.sha256sum] = "1eacbe8cc6fe8afbb7bcb2064d3e96677a0b738ebb06f9a527066f66781758b3"

URI_x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-fastdebug-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug.sha256sum] = "6fd1109e7a9124bb851d6ebc3cb116e2d95913c0f74626d6329855035b2a15a4"

URI_x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-slowdebug-25.0.0.0.36-2.rolling.el9.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug.sha256sum] = "2ebfefb1144170f1c7766f60e5df177e44a9bd8fe20bf328bc6eef8997f86190"

URI_aarch64_java-latest-openjdk-portable = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable}"
SRC_URI[aarch64_java-latest-openjdk-portable.sha256sum] = "d6dca43ba08210db41030ce577c1cdfd394a12260ea66114b60b33b98cc20496"

URI_aarch64_java-latest-openjdk-portable-devel = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel.sha256sum] = "d98a81dcc3b5d3a70dcc92c7fd9ab666bf0daccbd6640ea382ad8e6640c7dba7"

URI_aarch64_java-latest-openjdk-portable-devel-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-fastdebug-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel-fastdebug.sha256sum] = "da7a1eb66ae6086d1fa33eacc488e724c7d8a7ead5783824f063226a0f43482d"

URI_aarch64_java-latest-openjdk-portable-devel-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-slowdebug-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel-slowdebug.sha256sum] = "e33050c78be1f8fa2d63df45977da089959eaa319b7870daffd55b6c76a6c86c"

URI_aarch64_java-latest-openjdk-portable-docs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-docs-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-docs}"
SRC_URI[aarch64_java-latest-openjdk-portable-docs.sha256sum] = "ff314b28abcde8fc9ad9f56834094228c96dfc7f2571342097e7a6c6a57f1fa5"

URI_aarch64_java-latest-openjdk-portable-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-fastdebug-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-fastdebug.sha256sum] = "4ecaeb55c258868a283a4b0b3ab94917dd0699e1ba5b4c0f647dc431dd37158f"

URI_aarch64_java-latest-openjdk-portable-misc = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-misc-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-misc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-misc}"
SRC_URI[aarch64_java-latest-openjdk-portable-misc.sha256sum] = "5d785fa748d0b6f3e46aaeb4a104c1075dbf1d262f3f30ea12d256147c51e40c"

URI_aarch64_java-latest-openjdk-portable-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-slowdebug-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-slowdebug.sha256sum] = "8e6eb61f23bcbce67496c0b79d4b8d6b37a7e5682bdd679a1213a0b196b09cc0"

URI_aarch64_java-latest-openjdk-portable-sources = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-sources-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-sources;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-sources}"
SRC_URI[aarch64_java-latest-openjdk-portable-sources.sha256sum] = "910964ed3c787a4f20ec249284851e3820972a393cdb200db1cc22ed149a692a"

URI_aarch64_java-latest-openjdk-portable-static-libs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs.sha256sum] = "6d4c296219055835643e45550488032580ebd917d19c0c0e8ef7f4400f253c12"

URI_aarch64_java-latest-openjdk-portable-static-libs-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-fastdebug-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs-fastdebug.sha256sum] = "e0e01c81bb0ee862e55ad3e90810e4aebf3898692687fd835b0d13526759c8c6"

URI_aarch64_java-latest-openjdk-portable-static-libs-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-slowdebug-25.0.0.0.36-2.rolling.el9.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs-slowdebug.sha256sum] = "ec7bcd586d39aeda491b9bd1fae8c7b1ecea156c376835d12e49ea4b2984933b"

RDEPENDS:java-latest-openjdk-portable = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-docs = " \
 "
RDEPENDS:java-latest-openjdk-portable-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-misc = " \
 "
RDEPENDS:java-latest-openjdk-portable-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-sources = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs-slowdebug = " \
 "
