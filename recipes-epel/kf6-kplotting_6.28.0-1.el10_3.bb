# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kplotting"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kplotting \
 kf6-kplotting-devel \
 kf6-kplotting-doc \
 kf6-kplotting-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kplotting-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b220cd73c1e24a6d87970c475125d677d02bd95343666e8c25e2088e82aaf92"

URI_x86_64_v2_kf6-kplotting = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kplotting;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting}"
SRC_URI[x86_64_v2_kf6-kplotting.sha256sum] = "0b803ef6ff6e88aa88c910d7250b52be60b0f0cf23c3ec523413cddde1398c50"

URI_x86_64_v2_kf6-kplotting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kplotting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-devel}"
SRC_URI[x86_64_v2_kf6-kplotting-devel.sha256sum] = "6a60a53b08e9e46d114cb28d41480312d5fba5dfa66477d76a9b0d1453df242d"

URI_x86_64_v2_kf6-kplotting-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kplotting-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-doc}"
SRC_URI[x86_64_v2_kf6-kplotting-doc.sha256sum] = "15436000d4ebd21b32ddda5aba69218ce020a7cb66a29db729d713361a2a29b6"

URI_x86_64_v2_kf6-kplotting-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kplotting-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-html}"
SRC_URI[x86_64_v2_kf6-kplotting-html.sha256sum] = "0c33e9e965afea4cb9ba6802472f367548c5497f32f0d41502e028c65565486d"

URI_aarch64_kf6-kplotting = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kplotting;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting}"
SRC_URI[aarch64_kf6-kplotting.sha256sum] = "123ff1902ef839d37ce672088e750358ad69664732391634334df14cf2fd6cc3"

URI_aarch64_kf6-kplotting-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kplotting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-devel}"
SRC_URI[aarch64_kf6-kplotting-devel.sha256sum] = "579c9a03237274f9ba9836149f5b9fdad5426c5790a1966725eff47a71eced7b"

URI_aarch64_kf6-kplotting-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kplotting-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-doc}"
SRC_URI[aarch64_kf6-kplotting-doc.sha256sum] = "9fc9db223b8e50ab1587b841e9ccfd3158fca9fe2bd6566d5a6a444e87f90ce1"

URI_aarch64_kf6-kplotting-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kplotting-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-html}"
SRC_URI[aarch64_kf6-kplotting-html.sha256sum] = "194b999ccbbdda7440363d3ef6b2c6f487eccb54550bdb4dfde2cc0fcd0d7154"

RDEPENDS:kf6-kplotting = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kplotting-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kplotting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kplotting-doc = " \
 "
RDEPENDS:kf6-kplotting-html = " \
 "
