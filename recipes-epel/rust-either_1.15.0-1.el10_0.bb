# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-either"
PV = "1.15.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-either+default-devel \
 rust-either+serde-devel \
 rust-either+std-devel \
 rust-either+use_std-devel \
 rust-either-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-either-1.15.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8316b98d043b356cbb4b255f51626d9eba476b0b368be74b891664bd05a8a8a"

URI_x86_64_v2_rust-either+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+default-devel-1.15.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+default-devel}"
SRC_URI[x86_64_v2_rust-either+default-devel.sha256sum] = "eecbb56bd370c4d35d4737a067b7f7a8da9930e879f9f25341a9a7880cebbb3b"

URI_x86_64_v2_rust-either+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+serde-devel-1.15.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+serde-devel}"
SRC_URI[x86_64_v2_rust-either+serde-devel.sha256sum] = "b820fe775c0421d174446b27f605089298464972220200d08f7307329fd63391"

URI_x86_64_v2_rust-either+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+std-devel-1.15.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+std-devel}"
SRC_URI[x86_64_v2_rust-either+std-devel.sha256sum] = "32ab11673012ef28c71dd2b715be82e6d10ddebcba22548036fda4a5a9a29bcf"

URI_x86_64_v2_rust-either+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+use_std-devel-1.15.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+use_std-devel}"
SRC_URI[x86_64_v2_rust-either+use_std-devel.sha256sum] = "c87b5c746de3e1b5c374602f82a8cf6db8235d27cfe2b0258deec74ebe4c3d4c"

URI_x86_64_v2_rust-either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either-devel-1.15.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either-devel}"
SRC_URI[x86_64_v2_rust-either-devel.sha256sum] = "18135bec0371edadb659289dce0a1bf829122fac035046416efb126403554aab"

URI_aarch64_rust-either+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+default-devel-1.15.0-1.el10_0.noarch.rpm;name=aarch64_rust-either+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+default-devel}"
SRC_URI[aarch64_rust-either+default-devel.sha256sum] = "88bda2a76fe854217689c392a081c39aa85348f315764a7089dedf1a0473584d"

URI_aarch64_rust-either+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+serde-devel-1.15.0-1.el10_0.noarch.rpm;name=aarch64_rust-either+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+serde-devel}"
SRC_URI[aarch64_rust-either+serde-devel.sha256sum] = "b1d111d279ebd6c76ef1b3c430ca4bb64f40152dea2cd54a30885009adcae098"

URI_aarch64_rust-either+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+std-devel-1.15.0-1.el10_0.noarch.rpm;name=aarch64_rust-either+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+std-devel}"
SRC_URI[aarch64_rust-either+std-devel.sha256sum] = "189ee0b483621488ced791d1f2bf2262f54727d3c830dc35fec5b5c9884b8699"

URI_aarch64_rust-either+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+use_std-devel-1.15.0-1.el10_0.noarch.rpm;name=aarch64_rust-either+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+use_std-devel}"
SRC_URI[aarch64_rust-either+use_std-devel.sha256sum] = "c6785353fa9e99a53a97899c9c7c304f64264d68b28d963bfecf8e473046724c"

URI_aarch64_rust-either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either-devel-1.15.0-1.el10_0.noarch.rpm;name=aarch64_rust-either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either-devel}"
SRC_URI[aarch64_rust-either-devel.sha256sum] = "5d4e6f6c20c948ef89137e6e15ad4eec4730c13130e1685e60a12110fc13d5b7"

RDEPENDS:rust-either+default-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either+serde-devel = " \
 cargo \
 rust-either-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-either+std-devel = " \
 cargo \
 rust-either-devel \
 "
RDEPENDS:rust-either+use_std-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either-devel = " \
 cargo \
 rust \
 "
