# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-ttacon-chalk"
PV = "0.1"
PR = "16.20190306git22c06c8.el10_0"
PACKAGES = " \
 golang-github-ttacon-chalk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-ttacon-chalk-0.1-16.20190306git22c06c8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7899418b0f0b0be2c0f20e86153e5a4100e685610bd2edf3e1feade68b85a90"

URI_aarch64_golang-github-ttacon-chalk-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-ttacon-chalk-devel-0.1-16.20190306git22c06c8.el10_0.noarch.rpm;name=aarch64_golang-github-ttacon-chalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-ttacon-chalk-devel}"
SRC_URI[aarch64_golang-github-ttacon-chalk-devel.sha256sum] = "357d816fa3220050513b17d94bc5b4ceda6e821d50327806fd6e45d430545649"

RDEPENDS:golang-github-ttacon-chalk-devel = " \
 go-filesystem \
 "
