# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-data-default-instances-dlist"
PV = "0.0.1"
PR = "31.el10_0"
PACKAGES = " \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-dlist-devel \
 ghc-data-default-instances-dlist-doc \
 ghc-data-default-instances-dlist-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-data-default-instances-dlist-0.0.1-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da68db2146f7821e3c5ac61f23e4c788871cbcc3dc99df7db9dddabeccfb8462"

URI_x86_64_v2_ghc-data-default-instances-dlist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-dlist-0.0.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-instances-dlist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-dlist}"
SRC_URI[x86_64_v2_ghc-data-default-instances-dlist.sha256sum] = "c9fd3f84a77cbb71eddf7d7d7863d215564c704dd7b70ed2dceb01f39b9c27b2"

URI_x86_64_v2_ghc-data-default-instances-dlist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-dlist-devel-0.0.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-instances-dlist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-dlist-devel}"
SRC_URI[x86_64_v2_ghc-data-default-instances-dlist-devel.sha256sum] = "9d1e08ad459940159abb1e7477a664db9e6979f41c08953dd88cbace9a25c078"

URI_x86_64_v2_ghc-data-default-instances-dlist-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-dlist-doc-0.0.1-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-data-default-instances-dlist-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-dlist-doc}"
SRC_URI[x86_64_v2_ghc-data-default-instances-dlist-doc.sha256sum] = "05d5b6589f42a74a09a485d096c95234a47aafe1ef7e39d1054c89c3e2194732"

URI_x86_64_v2_ghc-data-default-instances-dlist-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-default-instances-dlist-prof-0.0.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-default-instances-dlist-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-default-instances-dlist-prof}"
SRC_URI[x86_64_v2_ghc-data-default-instances-dlist-prof.sha256sum] = "53c6163a53849108754a8b7d03ead01421620cd08c266b64a0009224a9546fc4"

URI_aarch64_ghc-data-default-instances-dlist = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-dlist-0.0.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-instances-dlist;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-dlist}"
SRC_URI[aarch64_ghc-data-default-instances-dlist.sha256sum] = "3987ed4b324f49d330a1345dffbda5f63f42cc376daa707dafcc1a26faf84357"

URI_aarch64_ghc-data-default-instances-dlist-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-dlist-devel-0.0.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-instances-dlist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-dlist-devel}"
SRC_URI[aarch64_ghc-data-default-instances-dlist-devel.sha256sum] = "a48c7e713d545b5ac9c3a77089989b2f16c4ff3d574d404ffde019deab748e7b"

URI_aarch64_ghc-data-default-instances-dlist-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-dlist-doc-0.0.1-31.el10_0.noarch.rpm;name=aarch64_ghc-data-default-instances-dlist-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-dlist-doc}"
SRC_URI[aarch64_ghc-data-default-instances-dlist-doc.sha256sum] = "bdfa92705f4ec7ec3c8399068c9529aca223d446677b1d56d83240e58d22609d"

URI_aarch64_ghc-data-default-instances-dlist-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-default-instances-dlist-prof-0.0.1-31.el10_0.aarch64.rpm;name=aarch64_ghc-data-default-instances-dlist-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-default-instances-dlist-prof}"
SRC_URI[aarch64_ghc-data-default-instances-dlist-prof.sha256sum] = "006bd47ab1d9aaf0e6a2b091ebab77d37b392e9ae2180cb6a8fcc8e7da665858"

RDEPENDS:ghc-data-default-instances-dlist = " \
 ghc-array \
 ghc-base \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-dlist \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-data-default-instances-dlist-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-data-default-class-devel \
 ghc-data-default-instances-dlist \
 ghc-dlist-devel \
 "
RDEPENDS:ghc-data-default-instances-dlist-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-data-default-instances-dlist-prof = " \
 ghc-base-prof \
 ghc-data-default-class-prof \
 ghc-data-default-instances-dlist-devel \
 ghc-dlist-prof \
 "
