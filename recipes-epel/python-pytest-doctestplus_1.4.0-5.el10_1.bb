# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-doctestplus"
PV = "1.4.0"
PR = "5.el10_1"
PACKAGES = " \
 python3-pytest-doctestplus \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-doctestplus-1.4.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b562a78dc95f0f1fc010e341e22290cb114003a50860b845c5a8d175fc65af1c"

URI_x86_64_v2_python3-pytest-doctestplus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-doctestplus-1.4.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-doctestplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-doctestplus}"
SRC_URI[x86_64_v2_python3-pytest-doctestplus.sha256sum] = "0002877052e2d671db1a45a58115329e7829673f5f80be29eb8374ba89bed430"

URI_aarch64_python3-pytest-doctestplus = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-doctestplus-1.4.0-5.el10_1.noarch.rpm;name=aarch64_python3-pytest-doctestplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-doctestplus}"
SRC_URI[aarch64_python3-pytest-doctestplus.sha256sum] = "b4818196d09946b5453069db9f6a0d4aa4d9b723e0e2090c72d4c2bac20b3ade"

RDEPENDS:python3-pytest-doctestplus = " \
 python3 \
 python3-packaging \
 python3-pytest \
 "
