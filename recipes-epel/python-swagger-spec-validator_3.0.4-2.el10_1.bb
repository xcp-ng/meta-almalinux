# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-swagger-spec-validator"
PV = "3.0.4"
PR = "2.el10_1"
PACKAGES = " \
 python3-swagger-spec-validator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-swagger-spec-validator-3.0.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a366abe36e055b1473d2d9d69b79be089256010ab066e8bccd0b9e4e83a7f60c"

URI_x86_64_v2_python3-swagger-spec-validator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-swagger-spec-validator-3.0.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-swagger-spec-validator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-swagger-spec-validator}"
SRC_URI[x86_64_v2_python3-swagger-spec-validator.sha256sum] = "27d724cc49e76a9fc3d531e47e2e6776f370974c411d43682c989d4bcc209565"

URI_aarch64_python3-swagger-spec-validator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-swagger-spec-validator-3.0.4-2.el10_1.noarch.rpm;name=aarch64_python3-swagger-spec-validator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-swagger-spec-validator}"
SRC_URI[aarch64_python3-swagger-spec-validator.sha256sum] = "c43146c85ea57bd5ef7f60ee5f392a46a2782f4098c8f2b0fd5a098ddd6dbae5"

RDEPENDS:python3-swagger-spec-validator = " \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
 python3-typing-extensions \
 "
