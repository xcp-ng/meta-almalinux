# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdevelop"
PE = "9"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdevelop \
 kdevelop-devel \
 kdevelop-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdevelop-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fe292ed4a69fda4b4fdbafa7f8043c063cb285d206071c397f7611f88e14d59"

URI_x86_64_v2_kdevelop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdevelop}"
SRC_URI[x86_64_v2_kdevelop.sha256sum] = "c76da3d8bab13e7af3ee72571453ff4ae87fb3f4988e3bef39c375c62e60db23"

URI_x86_64_v2_kdevelop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdevelop-devel}"
SRC_URI[x86_64_v2_kdevelop-devel.sha256sum] = "ac3c696666ecaf7d9bb2dd927a4118d0205a8b7052524c710eedfff2410056ef"

URI_x86_64_v2_kdevelop-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdevelop-libs}"
SRC_URI[x86_64_v2_kdevelop-libs.sha256sum] = "6acb9d47a1a48018a15e6d67539edaf91b18fc8ce58b8bc20894b7e9db0f3f55"

URI_aarch64_kdevelop = "${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdevelop;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdevelop}"
SRC_URI[aarch64_kdevelop.sha256sum] = "3a990dd6a201aa95dd6b9d34be7290bc280a5343f74313846af26c97ad80ae34"

URI_aarch64_kdevelop-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdevelop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdevelop-devel}"
SRC_URI[aarch64_kdevelop-devel.sha256sum] = "f5a23f20229572bd99b859b799a2ba2cc03aedb021be5e35d1916eb082676eb4"

URI_aarch64_kdevelop-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdevelop-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdevelop-libs}"
SRC_URI[aarch64_kdevelop-libs.sha256sum] = "8f15ee0505f7fd69cc13b072129d3009a26b67fae1be5a37a471cbf26e414924"

RDEPENDS:kdevelop = " \
 astyle \
 bash \
 cmake \
 cppcheck \
 git \
 glibc \
 kdevelop-libs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 konsole-part \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kdevelop-devel = " \
 cmake-filesystem \
 kdevelop-libs \
 kf6-ktexteditor-devel \
 kf6-threadweaver-devel \
 qt6-qt5compat-devel \
 qt6-qtbase-devel \
 qt6-qtwebengine-devel \
 "
RDEPENDS:kdevelop-libs = " \
 apr \
 apr-util \
 astyle \
 clang-libs \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-krunner \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-purpose \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kf6-threadweaver \
 libgcc \
 libkomparediff2 \
 libksysguard \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-help \
 qt6-qtwebengine \
 subversion-libs \
 "
