# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-segment"
PV = "0.9.0"
PR = "18.el10_0"
PACKAGES = " \
 rust-unic-segment+default-devel \
 rust-unic-segment-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-segment-0.9.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db298bee5f96f35faae065bede4d5ba4372c3464e29806b04b971a50b9af1180"

URI_x86_64_v2_rust-unic-segment+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-segment+default-devel-0.9.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-segment+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-segment+default-devel}"
SRC_URI[x86_64_v2_rust-unic-segment+default-devel.sha256sum] = "2d7cebbba469cc0d59f498e2e013d648b2a7fbedbdc34228d147659c3234d28b"

URI_x86_64_v2_rust-unic-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-segment-devel-0.9.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-segment-devel}"
SRC_URI[x86_64_v2_rust-unic-segment-devel.sha256sum] = "5ca537b1024e0ff0cfeb241bc4551c3e9b35e7d66c1a5136112b3e1313c7d7df"

URI_aarch64_rust-unic-segment+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-segment+default-devel-0.9.0-18.el10_0.noarch.rpm;name=aarch64_rust-unic-segment+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-segment+default-devel}"
SRC_URI[aarch64_rust-unic-segment+default-devel.sha256sum] = "d3a995c8904267704dcc4daa675c52a0b226615f1d157d23d074ff0935f9bc84"

URI_aarch64_rust-unic-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-segment-devel-0.9.0-18.el10_0.noarch.rpm;name=aarch64_rust-unic-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-segment-devel}"
SRC_URI[aarch64_rust-unic-segment-devel.sha256sum] = "48542a79f61ae14f209146fde44e56db2f4feb6b6ccdd40a77839a3434d2e871"

RDEPENDS:rust-unic-segment+default-devel = " \
 cargo \
 rust-unic-segment-devel \
 "
RDEPENDS:rust-unic-segment-devel = " \
 cargo \
 rust-unic-ucd-segment+default-devel \
 "
