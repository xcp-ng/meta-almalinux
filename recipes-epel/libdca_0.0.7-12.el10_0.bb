# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdca"
PV = "0.0.7"
PR = "12.el10_0"
PACKAGES = " \
 libdca \
 libdca-devel \
 libdca-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdca-0.0.7-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3186f06266e95404847f7a51a1a09e17832a6b4c043c3ba01337bcce84b16c0a"

URI_x86_64_v2_libdca = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdca-0.0.7-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdca}"
SRC_URI[x86_64_v2_libdca.sha256sum] = "1b281228e3f397aae8247c4d94435a21d49a07648a79a890410cbe5d39ac981d"

URI_x86_64_v2_libdca-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdca-devel-0.0.7-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdca-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdca-devel}"
SRC_URI[x86_64_v2_libdca-devel.sha256sum] = "f337c478d045335c9c835d26bb94c11e12a142ca1c2a9cd9f5a2fdf2a49d01d1"

URI_x86_64_v2_libdca-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdca-tools-0.0.7-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdca-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdca-tools}"
SRC_URI[x86_64_v2_libdca-tools.sha256sum] = "1d500cd2cca5a11f152c2834d3af47f2cdf8877ddede2f1cb059d9be30b1f6a5"

URI_aarch64_libdca = "${EPEL_MIRROR}/aarch64/Packages/l/libdca-0.0.7-12.el10_0.aarch64.rpm;name=aarch64_libdca;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdca}"
SRC_URI[aarch64_libdca.sha256sum] = "9d2107b55b13e08cacf776b69e07a216fefa9f108d7702b2438047193938644f"

URI_aarch64_libdca-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdca-devel-0.0.7-12.el10_0.aarch64.rpm;name=aarch64_libdca-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdca-devel}"
SRC_URI[aarch64_libdca-devel.sha256sum] = "5e0321177ff939ecee3be0a95f4ea4d31ea955d69fe919afa67f615c5d1f0757"

URI_aarch64_libdca-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libdca-tools-0.0.7-12.el10_0.aarch64.rpm;name=aarch64_libdca-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdca-tools}"
SRC_URI[aarch64_libdca-tools.sha256sum] = "019a6e33d5bba83499b9927a4ab54bb083f30184717457dd29cf5432e9c5763d"

RDEPENDS:libdca = " \
 glibc \
 "
RDEPENDS:libdca-devel = " \
 libdca \
 pkgconf-pkg-config \
 "
RDEPENDS:libdca-tools = " \
 bash \
 glibc \
 libdca \
 "
