# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mold"
PV = "2.40.4"
PR = "1.el10_1"
PACKAGES = " \
 mold \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mold-2.40.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0112dd14b92d0cefacfdad65f8b433b0a5ae3dbc62f664b4c69edb21159bbda"

URI_x86_64_v2_mold = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mold-2.40.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mold}"
SRC_URI[x86_64_v2_mold.sha256sum] = "0b740c4080d34615acf99dae32d1554e816ddc0741cfa349b44dba6f63c72b53"

URI_aarch64_mold = "${EPEL_MIRROR}/aarch64/Packages/m/mold-2.40.4-1.el10_1.aarch64.rpm;name=aarch64_mold;unpack=0"
SRC_URI:append = " ${URI_aarch64_mold}"
SRC_URI[aarch64_mold.sha256sum] = "753cf0c2fb83e8487b86808be99b24925c682f9d37f33d2bf66e9d6a24152d86"

RDEPENDS:mold = " \
 alternatives \
 bash \
 blake3 \
 glibc \
 libstdc++ \
 libzstd \
 mimalloc \
 tbb \
 zlib-ng-compat \
 "
