# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-es"
PE = "1"
PV = "2.8"
PR = "5.el10"
PACKAGES = " \
 hunspell-es \
 hunspell-es-AR \
 hunspell-es-BO \
 hunspell-es-CL \
 hunspell-es-CO \
 hunspell-es-CR \
 hunspell-es-CU \
 hunspell-es-DO \
 hunspell-es-EC \
 hunspell-es-ES \
 hunspell-es-GQ \
 hunspell-es-GT \
 hunspell-es-HN \
 hunspell-es-MX \
 hunspell-es-NI \
 hunspell-es-PA \
 hunspell-es-PE \
 hunspell-es-PR \
 hunspell-es-PY \
 hunspell-es-SV \
 hunspell-es-US \
 hunspell-es-UY \
 hunspell-es-VE \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-es-2.8-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b9745ab14a740f80fdeb4572adc34dff64094840b8d8b5515759cbd02831575"

URI_x86_64_v2_hunspell-es = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es}"
SRC_URI[x86_64_v2_hunspell-es.sha256sum] = "dcebb58b93ac71db81bd66a193b98ac0609a22471a7144f1760b339095e540bf"

URI_x86_64_v2_hunspell-es-AR = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-AR-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-AR;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-AR}"
SRC_URI[x86_64_v2_hunspell-es-AR.sha256sum] = "a0480bb844bc8d5bc44e7809080596938cd7942cfa915d24f3613461fb975207"

URI_x86_64_v2_hunspell-es-BO = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-BO-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-BO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-BO}"
SRC_URI[x86_64_v2_hunspell-es-BO.sha256sum] = "bde1fe17313357ea6c08feb64dd81fc5667cebe94612fdd8d215c15ee0005d08"

URI_x86_64_v2_hunspell-es-CL = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-CL-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-CL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-CL}"
SRC_URI[x86_64_v2_hunspell-es-CL.sha256sum] = "15571b3ef2af02aa267457eec77f55abc3d235e75d0ac8a5e7c482f672dabf2e"

URI_x86_64_v2_hunspell-es-CO = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-CO-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-CO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-CO}"
SRC_URI[x86_64_v2_hunspell-es-CO.sha256sum] = "22491f7c3c4cd2f5287996d8689818693c2cef23a2fdeff232d004f94f466a8c"

URI_x86_64_v2_hunspell-es-CR = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-CR-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-CR;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-CR}"
SRC_URI[x86_64_v2_hunspell-es-CR.sha256sum] = "4a4f67911e25bd5df6a65eb86c1818be2d442c31830f3d8e08f22a3c724a5f48"

URI_x86_64_v2_hunspell-es-CU = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-CU-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-CU;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-CU}"
SRC_URI[x86_64_v2_hunspell-es-CU.sha256sum] = "e6453d9dbebe498e944d39b54d66772fefadb6483cbfbf5be8734c297b1aeb13"

URI_x86_64_v2_hunspell-es-DO = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-DO-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-DO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-DO}"
SRC_URI[x86_64_v2_hunspell-es-DO.sha256sum] = "342b1fe46a21cbd55eb80813668d80c42c26e1b6daa9cbe75d8af89b74f1bb19"

URI_x86_64_v2_hunspell-es-EC = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-EC-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-EC;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-EC}"
SRC_URI[x86_64_v2_hunspell-es-EC.sha256sum] = "eb56b3e385fdc94aa9cda02c2b75efab255c4d5d2af1627eed955b2a92b7e2ba"

URI_x86_64_v2_hunspell-es-ES = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-ES-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-ES;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-ES}"
SRC_URI[x86_64_v2_hunspell-es-ES.sha256sum] = "d69fc9fe1857b2f18793fb54fb9d7587abc68f32b9d13e86e2309491fc95b628"

URI_x86_64_v2_hunspell-es-GQ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-GQ-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-GQ;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-GQ}"
SRC_URI[x86_64_v2_hunspell-es-GQ.sha256sum] = "923a6e23f616528daa2090d72cacb013db99cc48aa41fb8892350f823845cfe9"

URI_x86_64_v2_hunspell-es-GT = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-GT-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-GT;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-GT}"
SRC_URI[x86_64_v2_hunspell-es-GT.sha256sum] = "6e9b198f0f89bc96957f6471fa5ce56c9410a9cd597b790d3aa1a90616c98600"

URI_x86_64_v2_hunspell-es-HN = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-HN-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-HN;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-HN}"
SRC_URI[x86_64_v2_hunspell-es-HN.sha256sum] = "9c5c32400a3358b333721611fd34748879807887d6909449931aa2850009bd69"

URI_x86_64_v2_hunspell-es-MX = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-MX-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-MX;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-MX}"
SRC_URI[x86_64_v2_hunspell-es-MX.sha256sum] = "619fed73ebc27dffe96ef3b19a415f78c962c47ab4ebfd6b58bb291ead6c462a"

URI_x86_64_v2_hunspell-es-NI = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-NI-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-NI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-NI}"
SRC_URI[x86_64_v2_hunspell-es-NI.sha256sum] = "d7b7295e3f316961699ef3598cb2f89fcaba2ae3015b42d8b2ef39ddc0c5015b"

URI_x86_64_v2_hunspell-es-PA = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-PA-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-PA;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-PA}"
SRC_URI[x86_64_v2_hunspell-es-PA.sha256sum] = "4cb7cd41e882a1faa9447fed64ca131c5c4269db8533ec1fb48c0534ad23c9b9"

URI_x86_64_v2_hunspell-es-PE = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-PE-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-PE;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-PE}"
SRC_URI[x86_64_v2_hunspell-es-PE.sha256sum] = "1b049b1c896168dd1b979db0d8d7446c5122f8174437942c8bddb7b7f9ecc122"

URI_x86_64_v2_hunspell-es-PR = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-PR-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-PR;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-PR}"
SRC_URI[x86_64_v2_hunspell-es-PR.sha256sum] = "9e13b1cf7dd1f728fb6f2132aec5179fd35fccbaa4f85b116682b53e08aa376e"

URI_x86_64_v2_hunspell-es-PY = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-PY-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-PY;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-PY}"
SRC_URI[x86_64_v2_hunspell-es-PY.sha256sum] = "7a2c7b77ee9b272084ff1fcfd815d4c6ccabb2e54319245fcf17b61fb00d8656"

URI_x86_64_v2_hunspell-es-SV = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-SV-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-SV;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-SV}"
SRC_URI[x86_64_v2_hunspell-es-SV.sha256sum] = "5e2b90d7cbf965f79b0b5681a1dc388c24a0aa9bcf8f4a0402c9e7a653312dbb"

URI_x86_64_v2_hunspell-es-US = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-US-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-US;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-US}"
SRC_URI[x86_64_v2_hunspell-es-US.sha256sum] = "348842d982077264dd20be4d03606f2e858828b1461cda15e8d9c393b4ecdd3d"

URI_x86_64_v2_hunspell-es-UY = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-UY-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-UY;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-UY}"
SRC_URI[x86_64_v2_hunspell-es-UY.sha256sum] = "fd40cd63fbd539aa447e50186aa81bd35675173fce26cad66d4b76cfaf44be87"

URI_x86_64_v2_hunspell-es-VE = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-es-VE-2.8-5.el10.noarch.rpm;name=x86_64_v2_hunspell-es-VE;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-es-VE}"
SRC_URI[x86_64_v2_hunspell-es-VE.sha256sum] = "4db74706e7e7fc915e95bcd85a6caf733874e6f962dcebce963b58524762531b"

URI_aarch64_hunspell-es = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es}"
SRC_URI[aarch64_hunspell-es.sha256sum] = "dcebb58b93ac71db81bd66a193b98ac0609a22471a7144f1760b339095e540bf"

URI_aarch64_hunspell-es-AR = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-AR-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-AR;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-AR}"
SRC_URI[aarch64_hunspell-es-AR.sha256sum] = "a0480bb844bc8d5bc44e7809080596938cd7942cfa915d24f3613461fb975207"

URI_aarch64_hunspell-es-BO = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-BO-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-BO;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-BO}"
SRC_URI[aarch64_hunspell-es-BO.sha256sum] = "bde1fe17313357ea6c08feb64dd81fc5667cebe94612fdd8d215c15ee0005d08"

URI_aarch64_hunspell-es-CL = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-CL-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-CL;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-CL}"
SRC_URI[aarch64_hunspell-es-CL.sha256sum] = "15571b3ef2af02aa267457eec77f55abc3d235e75d0ac8a5e7c482f672dabf2e"

URI_aarch64_hunspell-es-CO = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-CO-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-CO;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-CO}"
SRC_URI[aarch64_hunspell-es-CO.sha256sum] = "22491f7c3c4cd2f5287996d8689818693c2cef23a2fdeff232d004f94f466a8c"

URI_aarch64_hunspell-es-CR = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-CR-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-CR;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-CR}"
SRC_URI[aarch64_hunspell-es-CR.sha256sum] = "4a4f67911e25bd5df6a65eb86c1818be2d442c31830f3d8e08f22a3c724a5f48"

URI_aarch64_hunspell-es-CU = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-CU-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-CU;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-CU}"
SRC_URI[aarch64_hunspell-es-CU.sha256sum] = "e6453d9dbebe498e944d39b54d66772fefadb6483cbfbf5be8734c297b1aeb13"

URI_aarch64_hunspell-es-DO = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-DO-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-DO;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-DO}"
SRC_URI[aarch64_hunspell-es-DO.sha256sum] = "342b1fe46a21cbd55eb80813668d80c42c26e1b6daa9cbe75d8af89b74f1bb19"

URI_aarch64_hunspell-es-EC = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-EC-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-EC;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-EC}"
SRC_URI[aarch64_hunspell-es-EC.sha256sum] = "eb56b3e385fdc94aa9cda02c2b75efab255c4d5d2af1627eed955b2a92b7e2ba"

URI_aarch64_hunspell-es-ES = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-ES-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-ES;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-ES}"
SRC_URI[aarch64_hunspell-es-ES.sha256sum] = "d69fc9fe1857b2f18793fb54fb9d7587abc68f32b9d13e86e2309491fc95b628"

URI_aarch64_hunspell-es-GQ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-GQ-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-GQ;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-GQ}"
SRC_URI[aarch64_hunspell-es-GQ.sha256sum] = "923a6e23f616528daa2090d72cacb013db99cc48aa41fb8892350f823845cfe9"

URI_aarch64_hunspell-es-GT = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-GT-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-GT;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-GT}"
SRC_URI[aarch64_hunspell-es-GT.sha256sum] = "6e9b198f0f89bc96957f6471fa5ce56c9410a9cd597b790d3aa1a90616c98600"

URI_aarch64_hunspell-es-HN = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-HN-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-HN;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-HN}"
SRC_URI[aarch64_hunspell-es-HN.sha256sum] = "9c5c32400a3358b333721611fd34748879807887d6909449931aa2850009bd69"

URI_aarch64_hunspell-es-MX = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-MX-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-MX;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-MX}"
SRC_URI[aarch64_hunspell-es-MX.sha256sum] = "619fed73ebc27dffe96ef3b19a415f78c962c47ab4ebfd6b58bb291ead6c462a"

URI_aarch64_hunspell-es-NI = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-NI-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-NI;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-NI}"
SRC_URI[aarch64_hunspell-es-NI.sha256sum] = "d7b7295e3f316961699ef3598cb2f89fcaba2ae3015b42d8b2ef39ddc0c5015b"

URI_aarch64_hunspell-es-PA = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-PA-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-PA;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-PA}"
SRC_URI[aarch64_hunspell-es-PA.sha256sum] = "4cb7cd41e882a1faa9447fed64ca131c5c4269db8533ec1fb48c0534ad23c9b9"

URI_aarch64_hunspell-es-PE = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-PE-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-PE;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-PE}"
SRC_URI[aarch64_hunspell-es-PE.sha256sum] = "1b049b1c896168dd1b979db0d8d7446c5122f8174437942c8bddb7b7f9ecc122"

URI_aarch64_hunspell-es-PR = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-PR-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-PR;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-PR}"
SRC_URI[aarch64_hunspell-es-PR.sha256sum] = "9e13b1cf7dd1f728fb6f2132aec5179fd35fccbaa4f85b116682b53e08aa376e"

URI_aarch64_hunspell-es-PY = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-PY-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-PY;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-PY}"
SRC_URI[aarch64_hunspell-es-PY.sha256sum] = "7a2c7b77ee9b272084ff1fcfd815d4c6ccabb2e54319245fcf17b61fb00d8656"

URI_aarch64_hunspell-es-SV = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-SV-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-SV;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-SV}"
SRC_URI[aarch64_hunspell-es-SV.sha256sum] = "5e2b90d7cbf965f79b0b5681a1dc388c24a0aa9bcf8f4a0402c9e7a653312dbb"

URI_aarch64_hunspell-es-US = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-US-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-US;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-US}"
SRC_URI[aarch64_hunspell-es-US.sha256sum] = "348842d982077264dd20be4d03606f2e858828b1461cda15e8d9c393b4ecdd3d"

URI_aarch64_hunspell-es-UY = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-UY-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-UY;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-UY}"
SRC_URI[aarch64_hunspell-es-UY.sha256sum] = "fd40cd63fbd539aa447e50186aa81bd35675173fce26cad66d4b76cfaf44be87"

URI_aarch64_hunspell-es-VE = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-es-VE-2.8-5.el10.noarch.rpm;name=aarch64_hunspell-es-VE;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-es-VE}"
SRC_URI[aarch64_hunspell-es-VE.sha256sum] = "4db74706e7e7fc915e95bcd85a6caf733874e6f962dcebce963b58524762531b"

RDEPENDS:hunspell-es = " \
 hunspell-es-AR \
 hunspell-es-BO \
 hunspell-es-CL \
 hunspell-es-CO \
 hunspell-es-CR \
 hunspell-es-CU \
 hunspell-es-DO \
 hunspell-es-EC \
 hunspell-es-ES \
 hunspell-es-GQ \
 hunspell-es-GT \
 hunspell-es-HN \
 hunspell-es-MX \
 hunspell-es-NI \
 hunspell-es-PA \
 hunspell-es-PE \
 hunspell-es-PR \
 hunspell-es-PY \
 hunspell-es-SV \
 hunspell-es-US \
 hunspell-es-UY \
 hunspell-es-VE \
 hunspell-filesystem \
 "
RDEPENDS:hunspell-es-AR = " \
 hunspell \
 "
RDEPENDS:hunspell-es-BO = " \
 hunspell \
 "
RDEPENDS:hunspell-es-CL = " \
 hunspell \
 "
RDEPENDS:hunspell-es-CO = " \
 hunspell \
 "
RDEPENDS:hunspell-es-CR = " \
 hunspell \
 "
RDEPENDS:hunspell-es-CU = " \
 hunspell \
 "
RDEPENDS:hunspell-es-DO = " \
 hunspell \
 "
RDEPENDS:hunspell-es-EC = " \
 hunspell \
 "
RDEPENDS:hunspell-es-ES = " \
 hunspell \
 "
RDEPENDS:hunspell-es-GQ = " \
 hunspell \
 "
RDEPENDS:hunspell-es-GT = " \
 hunspell \
 "
RDEPENDS:hunspell-es-HN = " \
 hunspell \
 "
RDEPENDS:hunspell-es-MX = " \
 hunspell \
 "
RDEPENDS:hunspell-es-NI = " \
 hunspell \
 "
RDEPENDS:hunspell-es-PA = " \
 hunspell \
 "
RDEPENDS:hunspell-es-PE = " \
 hunspell \
 "
RDEPENDS:hunspell-es-PR = " \
 hunspell \
 "
RDEPENDS:hunspell-es-PY = " \
 hunspell \
 "
RDEPENDS:hunspell-es-SV = " \
 hunspell \
 "
RDEPENDS:hunspell-es-US = " \
 hunspell \
 "
RDEPENDS:hunspell-es-UY = " \
 hunspell \
 "
RDEPENDS:hunspell-es-VE = " \
 hunspell \
 "
