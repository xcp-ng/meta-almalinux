# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-paramiko"
PV = "3.5.0"
PR = "1.el10_0"
PACKAGES = " \
 python-paramiko-doc \
 python3-paramiko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-paramiko-3.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b5c28ee9b53f7cf2683cf1c0bff4a29c2cf8accfff43e0729f54c37af64f1de"

URI_x86_64_v2_python-paramiko-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-paramiko-doc-3.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-paramiko-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-paramiko-doc}"
SRC_URI[x86_64_v2_python-paramiko-doc.sha256sum] = "6b47beb5c264d1386c683b584b9804e9420aa5254d2407dad03b6dcf9928df6f"

URI_x86_64_v2_python3-paramiko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-paramiko-3.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-paramiko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-paramiko}"
SRC_URI[x86_64_v2_python3-paramiko.sha256sum] = "0a252f36118e377d15946411e2b2e8ddd78766be1b3fbe067528d1b6cd1b7d99"

URI_aarch64_python-paramiko-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-paramiko-doc-3.5.0-1.el10_0.noarch.rpm;name=aarch64_python-paramiko-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-paramiko-doc}"
SRC_URI[aarch64_python-paramiko-doc.sha256sum] = "170ed731b5e8f28561dbac99e21480b224f0f219a3287220fd3ce9c758478964"

URI_aarch64_python3-paramiko = "${EPEL_MIRROR}/aarch64/Packages/p/python3-paramiko-3.5.0-1.el10_0.noarch.rpm;name=aarch64_python3-paramiko;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-paramiko}"
SRC_URI[aarch64_python3-paramiko.sha256sum] = "513f651f2ccd903a5cc2e91b193cda4f91994991d6492a2cec5e8bea79f9116b"

RDEPENDS:python-paramiko-doc = " \
 python3-paramiko \
 "
RDEPENDS:python3-paramiko = " \
 python3 \
 python3-bcrypt \
 python3-cryptography \
 python3-pynacl \
 "
