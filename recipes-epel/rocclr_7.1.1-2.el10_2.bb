# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocclr"
PV = "7.1.1"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 rocm-hip \
 rocm-hip-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocclr-7.1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc24c5e71a05b2403aa6f68fcb4afb454c127ed81682daaae0e19dd7876b249c"

URI_x86_64_v2_rocm-hip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-hip-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-hip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-hip}"
SRC_URI[x86_64_v2_rocm-hip.sha256sum] = "34008c4f78575070b52bbdde44fe17a3cbecad4ea3141f92b8c9c2c292da9722"

URI_x86_64_v2_rocm-hip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-hip-devel-7.1.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-hip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-hip-devel}"
SRC_URI[x86_64_v2_rocm-hip-devel.sha256sum] = "0181a6a5def035f8bd044252f6fba5e2aad0f0ddf2da9155111e673e90408022"

RDEPENDS:rocm-hip = " \
 glibc \
 hipcc \
 libgcc \
 libstdc++ \
 numactl-libs \
 rocm-comgr \
 rocm-runtime \
 "
RDEPENDS:rocm-hip-devel = " \
 bash \
 binutils \
 cmake-filesystem \
 gawk \
 perl-interpreter \
 rocm-comgr-devel \
 rocm-hip \
 rocm-runtime-devel \
 "
