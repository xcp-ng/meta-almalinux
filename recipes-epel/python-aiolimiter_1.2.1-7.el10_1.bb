# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiolimiter"
PV = "1.2.1"
PR = "7.el10_1"
PACKAGES = " \
 python3-aiolimiter \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-aiolimiter-1.2.1-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b5a9f1b0313cb7c4bd27c55a030ea01a341cd2b0af310fc1c16349fe340e4d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiolimiter-1.2.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiolimiter;unpack=0"
SRC_URI[x86_64_v2_python3-aiolimiter.sha256sum] = "779ecb7f12a3e1d6374309532a7ba5c7fc66b672a0428685012d9170138decaf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-aiolimiter-1.2.1-7.el10_1.noarch.rpm;name=aarch64_python3-aiolimiter;unpack=0"
SRC_URI[aarch64_python3-aiolimiter.sha256sum] = "4bd56b018fdf20edf18892c6575d2bee2bb51e4e4404a10186b3834609315b62"

RDEPENDS:python3-aiolimiter = " \
 python3 \
 "
