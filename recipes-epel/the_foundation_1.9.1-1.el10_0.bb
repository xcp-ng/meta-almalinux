# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "the_foundation"
PV = "1.9.1"
PR = "1.el10_0"
PACKAGES = " \
 the_foundation \
 the_foundation-devel \
 the_foundation-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/the_foundation-1.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33334b1e4d60d4aa64942a8f43fdc5344225e19eb242086035dc2bdcdd2eeec9"

URI_x86_64_v2_the_foundation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/the_foundation-1.9.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_the_foundation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_the_foundation}"
SRC_URI[x86_64_v2_the_foundation.sha256sum] = "edeb52f76ac2cd2b0cf41254739d7c636f657018c97aef7e6c48fbecf8f12ffa"

URI_x86_64_v2_the_foundation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/the_foundation-devel-1.9.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_the_foundation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_the_foundation-devel}"
SRC_URI[x86_64_v2_the_foundation-devel.sha256sum] = "5a04335afd056b6c38ead7bceaf8c3819e099b208cae21584ccbf2cb95c70d32"

URI_x86_64_v2_the_foundation-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/the_foundation-doc-1.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_the_foundation-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_the_foundation-doc}"
SRC_URI[x86_64_v2_the_foundation-doc.sha256sum] = "be093e5a08d803e2242e0810a6ed6f3edaa8315c413a44f72b144eba370261a4"

URI_aarch64_the_foundation = "${EPEL_MIRROR}/aarch64/Packages/t/the_foundation-1.9.1-1.el10_0.aarch64.rpm;name=aarch64_the_foundation;unpack=0"
SRC_URI:append = " ${URI_aarch64_the_foundation}"
SRC_URI[aarch64_the_foundation.sha256sum] = "2785f24e4d8c84b3d9148ed2379b8a8b465b6095f9dca40177c14063cd810468"

URI_aarch64_the_foundation-devel = "${EPEL_MIRROR}/aarch64/Packages/t/the_foundation-devel-1.9.1-1.el10_0.aarch64.rpm;name=aarch64_the_foundation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_the_foundation-devel}"
SRC_URI[aarch64_the_foundation-devel.sha256sum] = "bbc9255840d4e319793a82c692c5f8c5e0f949a1d039a754530df81ee13bd7c0"

URI_aarch64_the_foundation-doc = "${EPEL_MIRROR}/aarch64/Packages/t/the_foundation-doc-1.9.1-1.el10_0.noarch.rpm;name=aarch64_the_foundation-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_the_foundation-doc}"
SRC_URI[aarch64_the_foundation-doc.sha256sum] = "0b9260129116bd882888163c49354e35bc0843cb4ba5b31380f06b73c0555bdc"

RDEPENDS:the_foundation = " \
 glibc \
 libunistring \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:the_foundation-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 the_foundation \
 "
RDEPENDS:the_foundation-doc = " \
 "
