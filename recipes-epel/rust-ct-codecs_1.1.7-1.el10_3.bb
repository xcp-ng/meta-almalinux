# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ct-codecs"
PV = "1.1.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-ct-codecs+default-devel \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ct-codecs-1.1.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c167ed9d7cbda58febaea3d44079ae0d7cb8fd86b116717de6bb0c56b4ebf84"

URI_x86_64_v2_rust-ct-codecs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+default-devel-1.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs+default-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs+default-devel.sha256sum] = "4588e584b0a3c296b48be754051581993cd8397c9e4f00c02a7a3689cbbbeab9"

URI_x86_64_v2_rust-ct-codecs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+std-devel-1.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs+std-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs+std-devel.sha256sum] = "086600311d0268d3d46eeef71ad8fcb9b75c84859c5ff7489aed208079cf1244"

URI_x86_64_v2_rust-ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs-devel-1.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs-devel.sha256sum] = "6fdfd6d9332813a591beb6b0854f0588256e43c383275a2f833daf78214066b6"

URI_aarch64_rust-ct-codecs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+default-devel-1.1.7-1.el10_3.noarch.rpm;name=aarch64_rust-ct-codecs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs+default-devel}"
SRC_URI[aarch64_rust-ct-codecs+default-devel.sha256sum] = "ae19629f842d5541ba94a93956dd6ead40b38cc171de877c76c6c4ac6aaeeaaf"

URI_aarch64_rust-ct-codecs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+std-devel-1.1.7-1.el10_3.noarch.rpm;name=aarch64_rust-ct-codecs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs+std-devel}"
SRC_URI[aarch64_rust-ct-codecs+std-devel.sha256sum] = "97eae9056e9cbdb63c94a802cfc153194d50b5dd2c1dedd24f4687a66f3a4e8b"

URI_aarch64_rust-ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs-devel-1.1.7-1.el10_3.noarch.rpm;name=aarch64_rust-ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs-devel}"
SRC_URI[aarch64_rust-ct-codecs-devel.sha256sum] = "dbfaeb3dab83e9449f39fa143a4fbff2d33f1c691c83daa5f967cd6a72bc68b8"

RDEPENDS:rust-ct-codecs+default-devel = " \
 cargo \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs+std-devel = " \
 cargo \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs-devel = " \
 cargo \
 "
