# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet9.0"
PV = "9.0.111"
PR = "1.el10_0"
PACKAGES = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-runtime-dbg-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-host \
 dotnet-hostfxr-9.0 \
 dotnet-runtime-9.0 \
 dotnet-runtime-dbg-9.0 \
 dotnet-sdk-9.0 \
 dotnet-sdk-9.0-source-built-artifacts \
 dotnet-sdk-aot-9.0 \
 dotnet-sdk-dbg-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 netstandard-targeting-pack-2.1 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet9.0-9.0.111-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9091c41e20e8086db2a846496661e35e3ec1837859369b92d75bd71c6de97f63"

URI_x86_64_v2_aspnetcore-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-9.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-9.0.sha256sum] = "d59b137543b3cce5fe666bcfc578c83aca81d7df56a92b8dca06e7b6e605e8ff"

URI_x86_64_v2_aspnetcore-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-9.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-9.0.sha256sum] = "eda6e751db5d580e494e480710efd3e1f8ad876430770eeef176101930306c5c"

URI_x86_64_v2_aspnetcore-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-9.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-9.0.sha256sum] = "d878190308e20fc670729a253498598658d599d8dd18574ec1c6100c249a4259"

URI_x86_64_v2_dotnet-apphost-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-9.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-9.0.sha256sum] = "dbcfd4fae4635d7002f9947f4adb32ec85cda619c031b34adcf25ba14b66ed40"

URI_x86_64_v2_dotnet-host = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-host-9.0.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-host;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-host}"
SRC_URI[x86_64_v2_dotnet-host.sha256sum] = "4c3d5e4ac9913094b1161bc80059e885bd6da6bf1f47eccc8e447e71e5e89e6f"

URI_x86_64_v2_dotnet-hostfxr-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-9.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-9.0.sha256sum] = "312a05527d92b8984fa28783683ce0e6b171f09a5b8baba79d7cfb01f71dad57"

URI_x86_64_v2_dotnet-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-9.0}"
SRC_URI[x86_64_v2_dotnet-runtime-9.0.sha256sum] = "81cd259137780fd874401b61817aebfe927b1981841fffb1ee5c309f74623eb8"

URI_x86_64_v2_dotnet-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-9.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-9.0.sha256sum] = "f0e64424da9eae465d5b80b087e321d3adf6f4670b63f34b5867749c9a242031"

URI_x86_64_v2_dotnet-sdk-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-9.0-9.0.111-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-9.0.sha256sum] = "d56d1f63a787f1c6cca83d1ca84db55f41b950758a6bd06c7720be30935d8c3d"

URI_x86_64_v2_dotnet-sdk-9.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.111-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-9.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "36b042f22fe6847866cffc226b7456aea2ab2d03607b392c4a0ad60b57b0b09d"

URI_x86_64_v2_dotnet-sdk-aot-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-9.0-9.0.111-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-aot-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-aot-9.0.sha256sum] = "c0d60e9dc7ed870e743402c56038886b25e0cb5b84936dd512a30e1e91b56833"

URI_x86_64_v2_dotnet-sdk-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-9.0-9.0.111-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-9.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-9.0.sha256sum] = "e74cb160278c0347ea02c4bdd36b10ef5fe5b283bbdaa762e5e97c13f3566e0d"

URI_x86_64_v2_dotnet-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-9.0-9.0.10-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-9.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-9.0.sha256sum] = "6a79430034c66e99da505457202fb6853d3c6889874b6b703e2560ebd1aae598"

URI_x86_64_v2_dotnet-templates-9.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-9.0-9.0.111-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-9.0}"
SRC_URI[x86_64_v2_dotnet-templates-9.0.sha256sum] = "51feb8f97509950e0186dd548e2e4263ca666f5a5e8da6f8ea23cecfe5ca60d6"

URI_x86_64_v2_netstandard-targeting-pack-2.1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netstandard-targeting-pack-2.1-9.0.111-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netstandard-targeting-pack-2.1}"
SRC_URI[x86_64_v2_netstandard-targeting-pack-2.1.sha256sum] = "3d381ff271db36c64c72676a2a95b6d224ca379900466b9579cd4556814bdeb7"

URI_aarch64_aspnetcore-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-9.0-9.0.10-1.el10_0.aarch64.rpm;name=aarch64_aspnetcore-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-9.0}"
SRC_URI[aarch64_aspnetcore-runtime-9.0.sha256sum] = "2445f4c2ee3589a7bdbd58af1f03fd1b008443e7c88e0f596033f4854da74f85"

URI_aarch64_aspnetcore-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-9.0-9.0.10-1.el10_0.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-9.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-9.0.sha256sum] = "4e5e9d8801d86e98a080346b533016d276e6039af1d3ba5d437b2fabe798948c"

URI_aarch64_aspnetcore-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-9.0-9.0.10-1.el10_0.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-9.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-9.0.sha256sum] = "d9aa2897498f5deaa1c3cdb8b6ea34ed7a998526830429ba2a6543143b0cdd3a"

URI_aarch64_dotnet-apphost-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-9.0-9.0.10-1.el10_0.aarch64.rpm;name=aarch64_dotnet-apphost-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-9.0}"
SRC_URI[aarch64_dotnet-apphost-pack-9.0.sha256sum] = "715ecd35bf7013cdae1963f1e443ad7192005cf0427564c85109f2c70d5155e5"

URI_aarch64_dotnet-host = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-host-9.0.10-1.el10_0.aarch64.rpm;name=aarch64_dotnet-host;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-host}"
SRC_URI[aarch64_dotnet-host.sha256sum] = "b124acd6e0a0679bd08eda2a1be312dc0f3237598c17cccb2c85aba2cdc7e670"

URI_aarch64_dotnet-hostfxr-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-9.0-9.0.10-1.el10_0.aarch64.rpm;name=aarch64_dotnet-hostfxr-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-9.0}"
SRC_URI[aarch64_dotnet-hostfxr-9.0.sha256sum] = "ac4163248ef05b16439baef520a4b566fd6afa68f407bd0862355c76f46fac66"

URI_aarch64_dotnet-runtime-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-9.0-9.0.10-1.el10_0.aarch64.rpm;name=aarch64_dotnet-runtime-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-9.0}"
SRC_URI[aarch64_dotnet-runtime-9.0.sha256sum] = "fabed763cc84a7eed7dff1540eeb14570177c40d53a7186a8595e8c0719b83d0"

URI_aarch64_dotnet-runtime-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-9.0-9.0.10-1.el10_0.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-9.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-9.0.sha256sum] = "4f5012c0a4e9aa158fc0fa3efaa889f521beb4ee201518b8c2e57fcda032b398"

URI_aarch64_dotnet-sdk-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-9.0-9.0.111-1.el10_0.aarch64.rpm;name=aarch64_dotnet-sdk-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-9.0}"
SRC_URI[aarch64_dotnet-sdk-9.0.sha256sum] = "73947c9f0f11976f6416c7753a9c1ac0b982e6fece7aca251e3246795db47e60"

URI_aarch64_dotnet-sdk-9.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-9.0-source-built-artifacts-9.0.111-1.el10_0.aarch64.rpm;name=aarch64_dotnet-sdk-9.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-9.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-9.0-source-built-artifacts.sha256sum] = "db6feba8872c7423295eff0be809bab12a81f327a87563ca3e44daed3753ef20"

URI_aarch64_dotnet-sdk-aot-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-9.0-9.0.111-1.el10_0.aarch64.rpm;name=aarch64_dotnet-sdk-aot-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-aot-9.0}"
SRC_URI[aarch64_dotnet-sdk-aot-9.0.sha256sum] = "e4270e14880e6c2b2dc48b566f1a6a9ab9e81b9e7716aa0ec9454025926a098b"

URI_aarch64_dotnet-sdk-dbg-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-9.0-9.0.111-1.el10_0.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-9.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-9.0.sha256sum] = "aa4efa5bc026e358df84a23741b5c04650db3d66b545f84bc4c58019107962e9"

URI_aarch64_dotnet-targeting-pack-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-9.0-9.0.10-1.el10_0.aarch64.rpm;name=aarch64_dotnet-targeting-pack-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-9.0}"
SRC_URI[aarch64_dotnet-targeting-pack-9.0.sha256sum] = "a6217a280c2c026aefea6d7ac3ba9c6323a39192f8c82cd5154efc17c1a857e5"

URI_aarch64_dotnet-templates-9.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-9.0-9.0.111-1.el10_0.aarch64.rpm;name=aarch64_dotnet-templates-9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-9.0}"
SRC_URI[aarch64_dotnet-templates-9.0.sha256sum] = "8e988754dc2395a0dacc981e295af4f6c8ae81fbbf3c78a2323e75046ee8a992"

URI_aarch64_netstandard-targeting-pack-2.1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netstandard-targeting-pack-2.1-9.0.111-1.el10_0.aarch64.rpm;name=aarch64_netstandard-targeting-pack-2.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_netstandard-targeting-pack-2.1}"
SRC_URI[aarch64_netstandard-targeting-pack-2.1.sha256sum] = "70abe2fc1978101cf8393b428478664701560d2c1329eaf2d8c8e41b5e470575"

RDEPENDS:aspnetcore-runtime-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-9.0 = " \
 aspnetcore-runtime-9.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-9.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-host = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-hostfxr-9.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-9.0 = " \
 dotnet-hostfxr-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-9.0 = " \
 dotnet-runtime-9.0 \
 "
RDEPENDS:dotnet-sdk-9.0 = " \
 aspnetcore-runtime-9.0 \
 aspnetcore-targeting-pack-9.0 \
 dotnet-apphost-pack-9.0 \
 dotnet-runtime-9.0 \
 dotnet-targeting-pack-9.0 \
 dotnet-templates-9.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-9.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-9.0 = " \
 bash \
 brotli-devel \
 clang \
 dotnet-sdk-9.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-9.0 = " \
 dotnet-sdk-9.0 \
 "
RDEPENDS:dotnet-targeting-pack-9.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-9.0 = " \
 dotnet-host \
 "
RDEPENDS:netstandard-targeting-pack-2.1 = " \
 dotnet-host \
 "
