# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "greenboot"
PV = "0.15.9"
PR = "1.el10"
PACKAGES = " \
 greenboot \
 greenboot-default-health-checks \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/greenboot-0.15.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b6d49de3e313cb9cb9f1c76907cca4c63671ef1e020948b332ccb7f75285252"

URI_x86_64_v2_greenboot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/greenboot-0.15.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_greenboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_greenboot}"
SRC_URI[x86_64_v2_greenboot.sha256sum] = "340ef4878256e1cc6d719d7a37fb61d2edd72b8ea2ff4efcea8d253c0aa7e2d9"

URI_x86_64_v2_greenboot-default-health-checks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/greenboot-default-health-checks-0.15.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_greenboot-default-health-checks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_greenboot-default-health-checks}"
SRC_URI[x86_64_v2_greenboot-default-health-checks.sha256sum] = "0687c5cd616578c7396dd16f8e89b7ff2ca75a8bcbb61d8bd5cddbcb93ebc4b0"

URI_aarch64_greenboot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/greenboot-0.15.9-1.el10.aarch64.rpm;name=aarch64_greenboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_greenboot}"
SRC_URI[aarch64_greenboot.sha256sum] = "df6f98cfd349824ce486e1932c4d4364943df6613f114f782027d6888c498828"

URI_aarch64_greenboot-default-health-checks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/greenboot-default-health-checks-0.15.9-1.el10.aarch64.rpm;name=aarch64_greenboot-default-health-checks;unpack=0"
SRC_URI:append = " ${URI_aarch64_greenboot-default-health-checks}"
SRC_URI[aarch64_greenboot-default-health-checks.sha256sum] = "6ad2fb16860287cdb28abcac08704dabccfbacd222a4ac9f9e0790f002f07aab"

RDEPENDS:greenboot = " \
 bash \
 grub2-tools-minimal \
 pam \
 rpm-ostree \
 systemd \
 "
RDEPENDS:greenboot-default-health-checks = " \
 bash \
 greenboot \
 jq \
 util-linux \
 "
