# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-pybind11"
PV = "2.13.6"
PR = "4.el10"
PACKAGES = " \
 python3.14-pybind11 \
 python3.14-pybind11-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-pybind11-2.13.6-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d2fb96c12dde0652528536a5bab1a214758e4c64c5e4ce1f76a69d9bb88cbf2"

URI_x86_64_v2_python3.14-pybind11 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-pybind11-2.13.6-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-pybind11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-pybind11}"
SRC_URI[x86_64_v2_python3.14-pybind11.sha256sum] = "bba9dbaabca2305df227c1e8419c608c4faefb04cf792daa0bbfc5203880421c"

URI_x86_64_v2_python3.14-pybind11-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-pybind11-devel-2.13.6-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-pybind11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-pybind11-devel}"
SRC_URI[x86_64_v2_python3.14-pybind11-devel.sha256sum] = "82461793744e688a3e829c402131d2a6104ff0b1caa466ef2381eba93001307b"

URI_aarch64_python3.14-pybind11 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-pybind11-2.13.6-4.el10.aarch64.rpm;name=aarch64_python3.14-pybind11;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-pybind11}"
SRC_URI[aarch64_python3.14-pybind11.sha256sum] = "86778a376bdb5246b733c6c0a1d45be843f268620239ca4f8db847de89670a97"

URI_aarch64_python3.14-pybind11-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-pybind11-devel-2.13.6-4.el10.aarch64.rpm;name=aarch64_python3.14-pybind11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-pybind11-devel}"
SRC_URI[aarch64_python3.14-pybind11-devel.sha256sum] = "611ee5acbd6edaf528f474d1f0dc54d7f35ab6a091193cb4d2f51d6b3185dd2d"

RDEPENDS:python3.14-pybind11 = " \
 python3.14 \
 python3.14-pybind11-devel \
 "
RDEPENDS:python3.14-pybind11-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 python3.14 \
 "
