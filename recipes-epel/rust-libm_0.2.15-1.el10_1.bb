# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libm"
PV = "0.2.15"
PR = "1.el10_1"
PACKAGES = " \
 rust-libm+arch-devel \
 rust-libm+default-devel \
 rust-libm+force-soft-floats-devel \
 rust-libm+unstable-devel \
 rust-libm+unstable-float-devel \
 rust-libm+unstable-intrinsics-devel \
 rust-libm+unstable-public-internals-devel \
 rust-libm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libm-0.2.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32a8e06c961c81367037ce425eba7230020bf9e18ff8c35fe1781b62267f1d78"

URI_x86_64_v2_rust-libm+arch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+arch-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+arch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+arch-devel}"
SRC_URI[x86_64_v2_rust-libm+arch-devel.sha256sum] = "3f32117336cb166734a497041d1ee52da94ab72f6f40263209be6bdba8c1cf43"

URI_x86_64_v2_rust-libm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+default-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+default-devel}"
SRC_URI[x86_64_v2_rust-libm+default-devel.sha256sum] = "4b71f302fe89edc7895765830a40d8460b6a03232daced06a5854c090d8e6d31"

URI_x86_64_v2_rust-libm+force-soft-floats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+force-soft-floats-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+force-soft-floats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+force-soft-floats-devel}"
SRC_URI[x86_64_v2_rust-libm+force-soft-floats-devel.sha256sum] = "f55aa0b02540dd55a4edab10cf498adcbdd2ead327921af7b296998856522209"

URI_x86_64_v2_rust-libm+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+unstable-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+unstable-devel}"
SRC_URI[x86_64_v2_rust-libm+unstable-devel.sha256sum] = "14e9d3b6560861befbcbb105d60b64a6d6bffab1b71e7234964cafb93a03f669"

URI_x86_64_v2_rust-libm+unstable-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+unstable-float-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+unstable-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+unstable-float-devel}"
SRC_URI[x86_64_v2_rust-libm+unstable-float-devel.sha256sum] = "4419afb155ea669a4e7597710eeb9d8ae866193b177acf25ac315a66bbae0baf"

URI_x86_64_v2_rust-libm+unstable-intrinsics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+unstable-intrinsics-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+unstable-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+unstable-intrinsics-devel}"
SRC_URI[x86_64_v2_rust-libm+unstable-intrinsics-devel.sha256sum] = "1cc75cd0aa99e5fb0de41e6cad69158e90ff59a39c24b2fe8e115113030268b3"

URI_x86_64_v2_rust-libm+unstable-public-internals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm+unstable-public-internals-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm+unstable-public-internals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm+unstable-public-internals-devel}"
SRC_URI[x86_64_v2_rust-libm+unstable-public-internals-devel.sha256sum] = "c157f47976f5e2f65ece930eeb65e3462393602e9a4095e6250b356f986c19b6"

URI_x86_64_v2_rust-libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libm-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libm-devel}"
SRC_URI[x86_64_v2_rust-libm-devel.sha256sum] = "df35125fdaa18b5e24486ebee9b2e1055564af2f90c093882dd53929898318b4"

URI_aarch64_rust-libm+arch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+arch-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-libm+arch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+arch-devel}"
SRC_URI[aarch64_rust-libm+arch-devel.sha256sum] = "c7130ce708ed2364d1777a6f25784acdddea9bb28afb15b5c441b568247f37ce"

URI_aarch64_rust-libm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+default-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-libm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+default-devel}"
SRC_URI[aarch64_rust-libm+default-devel.sha256sum] = "5178fd2f9ef28ae3e0e1f05c08797ff24820c5ba72343baa045445cf09244d61"

URI_aarch64_rust-libm+force-soft-floats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+force-soft-floats-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-libm+force-soft-floats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+force-soft-floats-devel}"
SRC_URI[aarch64_rust-libm+force-soft-floats-devel.sha256sum] = "7d2d079e15054246d1d913c6f469ed3926b80040c7842f3e933918e3e756c959"

URI_aarch64_rust-libm+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+unstable-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-libm+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+unstable-devel}"
SRC_URI[aarch64_rust-libm+unstable-devel.sha256sum] = "ae64f35b4b4512ffa102700bc525591ac95582513d6d0e7569de4a4e45a1c35b"

URI_aarch64_rust-libm+unstable-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+unstable-float-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-libm+unstable-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+unstable-float-devel}"
SRC_URI[aarch64_rust-libm+unstable-float-devel.sha256sum] = "c30c05cf265e4fc6afcbc28eab88faaadd4a7c52c13441bc969b14e92ff160d8"

URI_aarch64_rust-libm+unstable-intrinsics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+unstable-intrinsics-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-libm+unstable-intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+unstable-intrinsics-devel}"
SRC_URI[aarch64_rust-libm+unstable-intrinsics-devel.sha256sum] = "c290dded338a5a5e57e23b7d0d7946988aecc7827cf39557b823f276adbf22db"

URI_aarch64_rust-libm+unstable-public-internals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm+unstable-public-internals-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-libm+unstable-public-internals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm+unstable-public-internals-devel}"
SRC_URI[aarch64_rust-libm+unstable-public-internals-devel.sha256sum] = "87b35f2fa12ac3a12291220cef7741a6283c2b0d68f244a04b824cdbe067709c"

URI_aarch64_rust-libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libm-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libm-devel}"
SRC_URI[aarch64_rust-libm-devel.sha256sum] = "4c636dcd67fc2b159eadca4db2dcc78a5cef464b9d4bd431b3143d6f052cd968"

RDEPENDS:rust-libm+arch-devel = " \
 cargo \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+default-devel = " \
 cargo \
 rust-libm+arch-devel \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+force-soft-floats-devel = " \
 cargo \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+unstable-devel = " \
 cargo \
 rust-libm+unstable-float-devel \
 rust-libm+unstable-intrinsics-devel \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+unstable-float-devel = " \
 cargo \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+unstable-intrinsics-devel = " \
 cargo \
 rust-libm-devel \
 "
RDEPENDS:rust-libm+unstable-public-internals-devel = " \
 cargo \
 rust-libm-devel \
 "
RDEPENDS:rust-libm-devel = " \
 cargo \
 rust \
 "
