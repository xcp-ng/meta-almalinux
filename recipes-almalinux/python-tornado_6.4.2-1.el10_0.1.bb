# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tornado"
PV = "6.4.2"
PR = "1.el10_0.1"
PACKAGES = " \
 python3-tornado \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-tornado-6.4.2-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "241c0155d3962c18cd526c44667ae2480ebd6b4ac778f0ba459b13258bbadfc2"

URI_x86_64_v2_python3-tornado = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tornado-6.4.2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_python3-tornado;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tornado}"
SRC_URI[x86_64_v2_python3-tornado.sha256sum] = "df0492da9b931d50eda26e2266c25f50429749da024ca95f39a14fb1160cb69d"

URI_aarch64_python3-tornado = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tornado-6.4.2-1.el10_0.1.aarch64.rpm;name=aarch64_python3-tornado;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tornado}"
SRC_URI[aarch64_python3-tornado.sha256sum] = "a7afce88a8b12836b939f9ffb9e4613dcba312c4e417fe33b48bcccd3582438f"

RDEPENDS:python3-tornado = " \
 glibc \
 python3 \
 "
