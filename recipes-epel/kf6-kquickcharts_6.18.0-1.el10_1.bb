# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kquickcharts"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kquickcharts \
 kf6-kquickcharts-devel \
 kf6-kquickcharts-doc \
 kf6-kquickcharts-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kquickcharts-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7150df40b45eaaf21aed9d187bba38ea10e0e3f0879aa5235b25493323b58ff1"

URI_x86_64_v2_kf6-kquickcharts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kquickcharts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts}"
SRC_URI[x86_64_v2_kf6-kquickcharts.sha256sum] = "f953fda03d77d077529c3b426bba8d520c60d69f436b71c564ef1877d3bfb8f4"

URI_x86_64_v2_kf6-kquickcharts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kquickcharts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts-devel}"
SRC_URI[x86_64_v2_kf6-kquickcharts-devel.sha256sum] = "b96f361a1097629a8a5d914bde88cbbe941f266d7e76e5b0da460d182f0c84aa"

URI_x86_64_v2_kf6-kquickcharts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kquickcharts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts-doc}"
SRC_URI[x86_64_v2_kf6-kquickcharts-doc.sha256sum] = "6c8436ce3fc4526e364bd5d0b17aa0b6dc9c8c559b088e4f1a052103cb9f10f8"

URI_x86_64_v2_kf6-kquickcharts-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kquickcharts-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kquickcharts-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kquickcharts-html}"
SRC_URI[x86_64_v2_kf6-kquickcharts-html.sha256sum] = "ee6ef1a2622694a30a5fb3c25797e195c3c54e509fa323223cf7760ae0359f3f"

URI_aarch64_kf6-kquickcharts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kquickcharts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts}"
SRC_URI[aarch64_kf6-kquickcharts.sha256sum] = "cd7c3f69b017dc44df01aa0c423049ee10c7bc28d14e237842538fd403638281"

URI_aarch64_kf6-kquickcharts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kquickcharts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts-devel}"
SRC_URI[aarch64_kf6-kquickcharts-devel.sha256sum] = "e8c9592940334f146e757e85a9fddc857c09c046078cb189f8f05538ec6eca5e"

URI_aarch64_kf6-kquickcharts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kquickcharts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts-doc}"
SRC_URI[aarch64_kf6-kquickcharts-doc.sha256sum] = "c56717b298feafaecbf06b2695f254d88a3eb25660a24bd81a73afefb3ab90ee"

URI_aarch64_kf6-kquickcharts-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kquickcharts-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kquickcharts-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kquickcharts-html}"
SRC_URI[aarch64_kf6-kquickcharts-html.sha256sum] = "8e10e6cf82525dd9873e42656491428a7ce9a9db797062896ca1fe466e720680"

RDEPENDS:kf6-kquickcharts = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kquickcharts-devel = " \
 cmake-filesystem \
 kf6-kquickcharts \
 "
RDEPENDS:kf6-kquickcharts-doc = " \
 "
RDEPENDS:kf6-kquickcharts-html = " \
 "
