# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-atomic-polyfill"
PV = "1.0.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-atomic-polyfill+default-devel \
 rust-atomic-polyfill-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-atomic-polyfill-1.0.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f0601be08e1f97260f533e2b02538647e51ac8cd8f402dee066632a8751f8bd"

URI_x86_64_v2_rust-atomic-polyfill+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic-polyfill+default-devel-1.0.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic-polyfill+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic-polyfill+default-devel}"
SRC_URI[x86_64_v2_rust-atomic-polyfill+default-devel.sha256sum] = "ecc9346050c34f0b43bafbb7541c0b1a9d7bec48d5fc32d87caa6344494a59ab"

URI_x86_64_v2_rust-atomic-polyfill-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic-polyfill-devel-1.0.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic-polyfill-devel}"
SRC_URI[x86_64_v2_rust-atomic-polyfill-devel.sha256sum] = "560ca1dfe22e585a2a204aedf539b429b3aa1d106b2b3728a4606d92deba894a"

URI_aarch64_rust-atomic-polyfill+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic-polyfill+default-devel-1.0.3-4.el10_0.noarch.rpm;name=aarch64_rust-atomic-polyfill+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic-polyfill+default-devel}"
SRC_URI[aarch64_rust-atomic-polyfill+default-devel.sha256sum] = "375287977ae4f2a3ed031e45646a3736bec1992db3842c9e811b12906d575618"

URI_aarch64_rust-atomic-polyfill-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic-polyfill-devel-1.0.3-4.el10_0.noarch.rpm;name=aarch64_rust-atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic-polyfill-devel}"
SRC_URI[aarch64_rust-atomic-polyfill-devel.sha256sum] = "9956749222444d01c55ca09c4da470d46d0dc4852de4c3e3e80ec63c08ad8269"

RDEPENDS:rust-atomic-polyfill+default-devel = " \
 cargo \
 rust-atomic-polyfill-devel \
 "
RDEPENDS:rust-atomic-polyfill-devel = " \
 bash \
 cargo \
 rust-critical-section+default-devel \
 "
