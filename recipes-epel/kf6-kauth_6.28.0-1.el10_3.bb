# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kauth"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kauth \
 kf6-kauth-devel \
 kf6-kauth-doc \
 kf6-kauth-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kauth-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea22b65f21262518e9b353e65f995125adb96c72192265f063144148ab9140e8"

URI_x86_64_v2_kf6-kauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth}"
SRC_URI[x86_64_v2_kf6-kauth.sha256sum] = "002c093ba605ec68cf281f872d10ddcc934c60b16139e7420151d4273b4d2cdb"

URI_x86_64_v2_kf6-kauth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-devel}"
SRC_URI[x86_64_v2_kf6-kauth-devel.sha256sum] = "dea95a44454f4b13801dc6466b04bf848957f404348aa06e094b44e3e029eb0d"

URI_x86_64_v2_kf6-kauth-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kauth-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-doc}"
SRC_URI[x86_64_v2_kf6-kauth-doc.sha256sum] = "b4eb06ca3dbeaab19a2d9b1d1cf7f0c17b3685b90bf0d2a64941444125ef7453"

URI_x86_64_v2_kf6-kauth-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kauth-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-html}"
SRC_URI[x86_64_v2_kf6-kauth-html.sha256sum] = "f6416ee6ce18b1c30de2446359c52d5484b09da1ae78ec069fe3cc404927abcb"

URI_aarch64_kf6-kauth = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth}"
SRC_URI[aarch64_kf6-kauth.sha256sum] = "c5c79c63be66cf352c569b519dcf0d6ca8af43ec7750f83ad121c91946f5cc61"

URI_aarch64_kf6-kauth-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-devel}"
SRC_URI[aarch64_kf6-kauth-devel.sha256sum] = "b09aafdd142282b83cec82f22910bb144cb2bb0567af2eb00912c3480834b612"

URI_aarch64_kf6-kauth-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kauth-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-doc}"
SRC_URI[aarch64_kf6-kauth-doc.sha256sum] = "47df075d1b2ada2b78b1caaa5f80d8945afa9ff263a1f01d87adfed35ffb5570"

URI_aarch64_kf6-kauth-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kauth-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-html}"
SRC_URI[aarch64_kf6-kauth-html.sha256sum] = "f1daf1833096425ac3db07d5df3a36c2aefa41ec6e89d991d1b77f73e13dad26"

RDEPENDS:kf6-kauth = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-kwindowsystem \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kauth-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons-devel \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kauth-doc = " \
 "
RDEPENDS:kf6-kauth-html = " \
 "
