# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-crc32c"
PV = "2.8"
PR = "2.el10_2"
PACKAGES = " \
 python3-crc32c \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-crc32c-2.8-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1739f986442304e4b597526f1de945a0d99482c0acac97ebb41728d31007afb"

URI_x86_64_v2_python3-crc32c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-crc32c-2.8-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-crc32c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-crc32c}"
SRC_URI[x86_64_v2_python3-crc32c.sha256sum] = "fa95bb6475c6d1008174a30ed079c4010d22cdf47d6ce4d2b50d22ab14c6415d"

URI_aarch64_python3-crc32c = "${EPEL_MIRROR}/aarch64/Packages/p/python3-crc32c-2.8-2.el10_2.aarch64.rpm;name=aarch64_python3-crc32c;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-crc32c}"
SRC_URI[aarch64_python3-crc32c.sha256sum] = "924dca64ea6a6eada9c701f8e945366fecf8e4990ef4ffc25310710efb3e3bde"

RDEPENDS:python3-crc32c = " \
 glibc \
 python3 \
 "
