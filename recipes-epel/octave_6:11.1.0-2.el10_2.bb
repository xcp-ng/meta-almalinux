# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "octave"
PE = "6"
PV = "11.1.0"
PR = "2.el10_2"
PACKAGES = " \
 octave \
 octave-devel \
 octave-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/octave-11.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cc94e73ff4a71f8c0e0d3770b81dadd9f1900e41e57adc1cf5ee0f46053a50f"

URI_x86_64_v2_octave = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/octave-11.1.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_octave;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_octave}"
SRC_URI[x86_64_v2_octave.sha256sum] = "fa627fa59ec25d8daefbe639b9a93592535f077a240257e94b713608e6f39d17"

URI_x86_64_v2_octave-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/octave-devel-11.1.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_octave-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_octave-devel}"
SRC_URI[x86_64_v2_octave-devel.sha256sum] = "e4b51428e8593a63a62f4c1f36bb55fa5fd4946c3e1b5bd53ba223de95f58818"

URI_x86_64_v2_octave-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/octave-doc-11.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_octave-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_octave-doc}"
SRC_URI[x86_64_v2_octave-doc.sha256sum] = "0fc47d98f025d543bba4e28309ae8ab0fb6d47c0f9fdd68926a831ddcafaee26"

URI_aarch64_octave = "${EPEL_MIRROR}/aarch64/Packages/o/octave-11.1.0-2.el10_2.aarch64.rpm;name=aarch64_octave;unpack=0"
SRC_URI:append = " ${URI_aarch64_octave}"
SRC_URI[aarch64_octave.sha256sum] = "be627398c565a1a034ed9d4dbc879a192ced4530ee61066f3eae7fc7ade93c8f"

URI_aarch64_octave-devel = "${EPEL_MIRROR}/aarch64/Packages/o/octave-devel-11.1.0-2.el10_2.aarch64.rpm;name=aarch64_octave-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_octave-devel}"
SRC_URI[aarch64_octave-devel.sha256sum] = "cd5c0aaa129adaf4de4e77a2471c647d8c9cac1aeb5b30d385e14a69bbbd8bd7"

URI_aarch64_octave-doc = "${EPEL_MIRROR}/aarch64/Packages/o/octave-doc-11.1.0-2.el10_2.noarch.rpm;name=aarch64_octave-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_octave-doc}"
SRC_URI[aarch64_octave-doc.sha256sum] = "0646a16d74980364a1c464b246f4623815dc47f1a43e9d467ccec6ffcbf7f9e3"

RDEPENDS:octave:x86_64_v2 = " \
 GraphicsMagick \
 GraphicsMagick-c++ \
 alsa-lib \
 arpack \
 bash \
 bzip2-libs \
 epstool \
 fftw-libs-double \
 fftw-libs-single \
 flexiblas-netlib \
 fltk \
 fontconfig \
 freetype \
 gl2ps \
 glibc \
 glpk \
 gnuplot-common \
 hdf5 \
 hicolor-icon-theme \
 info \
 java-25-openjdk-headless \
 less \
 libX11 \
 libgcc \
 libgfortran \
 libglvnd-glx \
 libgomp \
 libqhull_r \
 libquadmath \
 libsndfile \
 libstdc++ \
 libwayland-client \
 mesa-libGLU \
 pcre2 \
 portaudio \
 qrupdate \
 qscintilla-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-help \
 readline \
 suitesparse \
 sundials \
 texinfo \
 texlive-amsfonts \
 texlive-geometry \
 texlive-graphics \
 texlive-hyperref \
 texlive-listings \
 texlive-lm \
 texlive-mathtools \
 texlive-titlesec \
 texlive-xcolor \
 virtual/gnuplot \
 virtual/libcurl.so.4___64bit_ \
 virtual/tex_fontenc.sty_ \
 virtual/tex_inputenc.sty_ \
 zlib-ng-compat \
"
RDEPENDS:octave:aarch64 = " \
 GraphicsMagick \
 GraphicsMagick-c++ \
 alsa-lib \
 arpack \
 bash \
 bzip2-libs \
 epstool \
 fftw-libs-double \
 fftw-libs-single \
 flexiblas-netlib \
 fltk \
 fontconfig \
 freetype \
 gl2ps \
 glibc \
 glpk \
 gnuplot-common \
 hdf5 \
 hicolor-icon-theme \
 info \
 java-25-openjdk-headless \
 less \
 libX11 \
 libgcc \
 libgfortran \
 libglvnd-glx \
 libgomp \
 libqhull_r \
 libsndfile \
 libstdc++ \
 libwayland-client \
 mesa-libGLU \
 pcre2 \
 portaudio \
 qrupdate \
 qscintilla-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-help \
 readline \
 suitesparse \
 sundials \
 texinfo \
 texlive-amsfonts \
 texlive-geometry \
 texlive-graphics \
 texlive-hyperref \
 texlive-listings \
 texlive-lm \
 texlive-mathtools \
 texlive-titlesec \
 texlive-xcolor \
 virtual/gnuplot \
 virtual/libcurl.so.4___64bit_ \
 virtual/tex_fontenc.sty_ \
 virtual/tex_inputenc.sty_ \
 zlib-ng-compat \
"
RDEPENDS:octave-devel = " \
 bash \
 fftw-devel \
 flexiblas-devel \
 gcc-c++ \
 gcc-gfortran \
 hdf5-devel \
 libappstream-glib \
 octave \
 octave-devel \
 pkgconf-pkg-config \
 readline-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:octave-doc = " \
 "
