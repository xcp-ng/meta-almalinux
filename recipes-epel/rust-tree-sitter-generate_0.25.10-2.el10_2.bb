# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-generate"
PV = "0.25.10"
PR = "2.el10_2"
PACKAGES = " \
 rust-tree-sitter-generate+default-devel \
 rust-tree-sitter-generate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-generate-0.25.10-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fac0d637a31c4fcb7eb5b13ea35527438a1c2aa12f2d59a0c32cacac3bcdd73d"

URI_x86_64_v2_rust-tree-sitter-generate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-generate+default-devel-0.25.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-generate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-generate+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-generate+default-devel.sha256sum] = "7b509cebdc6efeed7a138f656319b05a8c2839c64a26a154a8a980ffc14387e9"

URI_x86_64_v2_rust-tree-sitter-generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-generate-devel-0.25.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-generate-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-generate-devel.sha256sum] = "a0c93d067b1f78f3fb3d08d6c01081fbba2833efb3ffd500b87ef1b043dc5deb"

URI_aarch64_rust-tree-sitter-generate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-generate+default-devel-0.25.10-2.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-generate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-generate+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-generate+default-devel.sha256sum] = "5ac3dcc6fabff2ec2d23ce3cd682404b5c506b0c26bd0726761bd0458cfe8682"

URI_aarch64_rust-tree-sitter-generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-generate-devel-0.25.10-2.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-generate-devel}"
SRC_URI[aarch64_rust-tree-sitter-generate-devel.sha256sum] = "4b159150b87f74bd500819d88bb63ea67543b4df92b60adec284027c966eada3"

RDEPENDS:rust-tree-sitter-generate+default-devel = " \
 cargo \
 rust-tree-sitter-generate-devel \
 "
RDEPENDS:rust-tree-sitter-generate-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-heck+default-devel \
 rust-indexmap+default-devel \
 rust-indoc+default-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 rust-regex+default-devel \
 rust-regex-syntax+default-devel \
 rust-rustc-hash+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 rust-smallbitvec+default-devel \
 rust-thiserror+default-devel \
 rust-topological-sort+default-devel \
 rust-tree-sitter0.25+default-devel \
 "
