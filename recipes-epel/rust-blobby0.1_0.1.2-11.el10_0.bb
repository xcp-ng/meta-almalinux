# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blobby0.1"
PV = "0.1.2"
PR = "11.el10_0"
PACKAGES = " \
 rust-blobby0.1+default-devel \
 rust-blobby0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blobby0.1-0.1.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd35a75f8e951f05bc554b691722cc359cf71dd74714b886913922d02c080885"

URI_x86_64_v2_rust-blobby0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blobby0.1+default-devel-0.1.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blobby0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blobby0.1+default-devel}"
SRC_URI[x86_64_v2_rust-blobby0.1+default-devel.sha256sum] = "eaf26032e43d6465b71d296a1e478190590638c75471b06f817ed964909bf07b"

URI_x86_64_v2_rust-blobby0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blobby0.1-devel-0.1.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blobby0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blobby0.1-devel}"
SRC_URI[x86_64_v2_rust-blobby0.1-devel.sha256sum] = "47f484e5b89591eb3cef424ba326d6995c3fee083d9f4a93ece8532503477161"

URI_aarch64_rust-blobby0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blobby0.1+default-devel-0.1.2-11.el10_0.noarch.rpm;name=aarch64_rust-blobby0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blobby0.1+default-devel}"
SRC_URI[aarch64_rust-blobby0.1+default-devel.sha256sum] = "6117afcf971868e6342d1612c312d0403bb8b34359b5b75b1f22283a045ce344"

URI_aarch64_rust-blobby0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blobby0.1-devel-0.1.2-11.el10_0.noarch.rpm;name=aarch64_rust-blobby0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blobby0.1-devel}"
SRC_URI[aarch64_rust-blobby0.1-devel.sha256sum] = "83d1d298ca3a93ba59ad3b2d11bb493644ab8371987f88ef86cbf7880caf57a2"

RDEPENDS:rust-blobby0.1+default-devel = " \
 cargo \
 rust-blobby0.1-devel \
 "
RDEPENDS:rust-blobby0.1-devel = " \
 cargo \
 rust-byteorder-devel \
 "
