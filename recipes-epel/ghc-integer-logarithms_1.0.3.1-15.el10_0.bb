# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-integer-logarithms"
PV = "1.0.3.1"
PR = "15.el10_0"
PACKAGES = " \
 ghc-integer-logarithms \
 ghc-integer-logarithms-devel \
 ghc-integer-logarithms-doc \
 ghc-integer-logarithms-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-integer-logarithms-1.0.3.1-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "103002c70f46ad6ed0e3ce90a70c8b7f2c2b217cf5018b9179175a11a710175f"

URI_x86_64_v2_ghc-integer-logarithms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-integer-logarithms-1.0.3.1-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-integer-logarithms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-integer-logarithms}"
SRC_URI[x86_64_v2_ghc-integer-logarithms.sha256sum] = "f84518596973bd8a7c4d5e156f3e0aec6a7b48a9e7315583d4bf01655b6ccd8d"

URI_x86_64_v2_ghc-integer-logarithms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-integer-logarithms-devel-1.0.3.1-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-integer-logarithms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-integer-logarithms-devel}"
SRC_URI[x86_64_v2_ghc-integer-logarithms-devel.sha256sum] = "cb65bd850aefe09469eeca681f373978e0796cbe61b0da13142c58235b21a275"

URI_x86_64_v2_ghc-integer-logarithms-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-integer-logarithms-doc-1.0.3.1-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-integer-logarithms-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-integer-logarithms-doc}"
SRC_URI[x86_64_v2_ghc-integer-logarithms-doc.sha256sum] = "b8a006b29d3d703ec19266a1c4e85335c7ac63715911308f7bd9d235527c9463"

URI_x86_64_v2_ghc-integer-logarithms-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-integer-logarithms-prof-1.0.3.1-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-integer-logarithms-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-integer-logarithms-prof}"
SRC_URI[x86_64_v2_ghc-integer-logarithms-prof.sha256sum] = "393e8ec90706cc67162742d80eb37948a89b5c399f27e95bc393dd66a3973999"

URI_aarch64_ghc-integer-logarithms = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-integer-logarithms-1.0.3.1-15.el10_0.aarch64.rpm;name=aarch64_ghc-integer-logarithms;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-integer-logarithms}"
SRC_URI[aarch64_ghc-integer-logarithms.sha256sum] = "46e5398d876137503830a8702891b12c82138fe8f79ba9484f2a03b0d463a037"

URI_aarch64_ghc-integer-logarithms-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-integer-logarithms-devel-1.0.3.1-15.el10_0.aarch64.rpm;name=aarch64_ghc-integer-logarithms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-integer-logarithms-devel}"
SRC_URI[aarch64_ghc-integer-logarithms-devel.sha256sum] = "7889740ce347b4f02c74edaf6fc2be1a3ba8cc9e9f17da7573950cc0bfc85e8a"

URI_aarch64_ghc-integer-logarithms-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-integer-logarithms-doc-1.0.3.1-15.el10_0.noarch.rpm;name=aarch64_ghc-integer-logarithms-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-integer-logarithms-doc}"
SRC_URI[aarch64_ghc-integer-logarithms-doc.sha256sum] = "61821541a76df3cedf4b993ede61587fb4c14c6c8cedef3a85bfe3af62fe0119"

URI_aarch64_ghc-integer-logarithms-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-integer-logarithms-prof-1.0.3.1-15.el10_0.aarch64.rpm;name=aarch64_ghc-integer-logarithms-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-integer-logarithms-prof}"
SRC_URI[aarch64_ghc-integer-logarithms-prof.sha256sum] = "a7826560eb74eb56db2d85cb1c2d2c3894e82ca9a7cd48a887e97bcec7777e34"

RDEPENDS:ghc-integer-logarithms = " \
 ghc-array \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-integer-logarithms-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-ghc-bignum-devel \
 ghc-integer-logarithms \
 "
RDEPENDS:ghc-integer-logarithms-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-integer-logarithms-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-ghc-bignum-prof \
 ghc-integer-logarithms-devel \
 "
