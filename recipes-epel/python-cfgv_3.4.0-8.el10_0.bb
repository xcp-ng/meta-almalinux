# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cfgv"
PV = "3.4.0"
PR = "8.el10_0"
PACKAGES = " \
 python3-cfgv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cfgv-3.4.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f797fcfec9207a635df45c1ac5524b14c82067c8428ae239a0280517dedca556"

URI_x86_64_v2_python3-cfgv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cfgv-3.4.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cfgv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cfgv}"
SRC_URI[x86_64_v2_python3-cfgv.sha256sum] = "7a9b2be99df4fdc25b530d8cf2f546e0be866527a66165995612f0f14fb6ca30"

URI_aarch64_python3-cfgv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cfgv-3.4.0-8.el10_0.noarch.rpm;name=aarch64_python3-cfgv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cfgv}"
SRC_URI[aarch64_python3-cfgv.sha256sum] = "a8a5184dfd45a7718637548bf921d03152902817a232d56bd8099aef1e5844b5"

RDEPENDS:python3-cfgv = " \
 python3 \
 "
