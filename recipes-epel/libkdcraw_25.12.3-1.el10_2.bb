# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdcraw"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libkdcraw \
 libkdcraw-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdcraw-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd3d18a2e0bf2d917a5eb0f44bede626d4fdb3b5b9529d52010ced486a5490a3"

URI_x86_64_v2_libkdcraw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdcraw-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdcraw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdcraw}"
SRC_URI[x86_64_v2_libkdcraw.sha256sum] = "5c72ac64c8e881860eaf0116b55fb94a425123b0714d30aa7302ed4035b9e074"

URI_x86_64_v2_libkdcraw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdcraw-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdcraw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdcraw-devel}"
SRC_URI[x86_64_v2_libkdcraw-devel.sha256sum] = "6dd5e93952b1a19265dbf1ad1822541f2669eae161387a19bcd486bdf4c3987a"

URI_aarch64_libkdcraw = "${EPEL_MIRROR}/aarch64/Packages/l/libkdcraw-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkdcraw;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdcraw}"
SRC_URI[aarch64_libkdcraw.sha256sum] = "6982423b82792a43d5936b82f9576ea7eb13f9e334319bfccb254ca595e2aa62"

URI_aarch64_libkdcraw-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdcraw-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkdcraw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdcraw-devel}"
SRC_URI[aarch64_libkdcraw-devel.sha256sum] = "765e306adbf64489f542ca85c0f428a666a259bb85739087835c4ce65ee223ab"

RDEPENDS:libkdcraw = " \
 LibRaw \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdcraw-devel = " \
 cmake-filesystem \
 libkdcraw \
 qt6-qtbase-devel \
 "
