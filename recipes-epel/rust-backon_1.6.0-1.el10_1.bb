# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-backon"
PV = "1.6.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-backon+default-devel \
 rust-backon+futures-timer-devel \
 rust-backon+futures-timer-sleep-devel \
 rust-backon+std-blocking-sleep-devel \
 rust-backon+std-devel \
 rust-backon+tokio-devel \
 rust-backon+tokio-sleep-devel \
 rust-backon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-backon-1.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b592d8df5efc0dd0d959163dd0366903df902158d0f7dc0f124013524e043dc"

URI_x86_64_v2_rust-backon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+default-devel-1.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+default-devel}"
SRC_URI[x86_64_v2_rust-backon+default-devel.sha256sum] = "969fb618c4e60f7a0a1d65054a9ee36c905f5687fc7bf993c7d2278481d3568f"

URI_x86_64_v2_rust-backon+futures-timer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+futures-timer-devel-1.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+futures-timer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+futures-timer-devel}"
SRC_URI[x86_64_v2_rust-backon+futures-timer-devel.sha256sum] = "1014f1e918649881a128fad84376a83f4e293ef0ce70c403d6cecb2d971818e6"

URI_x86_64_v2_rust-backon+futures-timer-sleep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+futures-timer-sleep-devel-1.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+futures-timer-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+futures-timer-sleep-devel}"
SRC_URI[x86_64_v2_rust-backon+futures-timer-sleep-devel.sha256sum] = "10e05100f0fdf971cf73b05a5fd6cb1c5f568f3e632a81e844a4f3392e4b8e64"

URI_x86_64_v2_rust-backon+std-blocking-sleep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+std-blocking-sleep-devel-1.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+std-blocking-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+std-blocking-sleep-devel}"
SRC_URI[x86_64_v2_rust-backon+std-blocking-sleep-devel.sha256sum] = "abfbc1d61591691b97599009c3300901a6d0a69adba6b5cf8a23fe132fe76752"

URI_x86_64_v2_rust-backon+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+std-devel-1.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+std-devel}"
SRC_URI[x86_64_v2_rust-backon+std-devel.sha256sum] = "07196769fbb483fa2c3a7b60054896db6239f7004bc3a351de7c1ad2e7394cee"

URI_x86_64_v2_rust-backon+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+tokio-devel-1.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+tokio-devel}"
SRC_URI[x86_64_v2_rust-backon+tokio-devel.sha256sum] = "085cf3ce473738d4cf671e71c7a8c6cb837889db4d7de301a0ae862a885b21ce"

URI_x86_64_v2_rust-backon+tokio-sleep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon+tokio-sleep-devel-1.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon+tokio-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon+tokio-sleep-devel}"
SRC_URI[x86_64_v2_rust-backon+tokio-sleep-devel.sha256sum] = "031df23236f8981cb4aaff557e7a01f001c0c09b22c6732e6473ab30599ed003"

URI_x86_64_v2_rust-backon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backon-devel-1.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backon-devel}"
SRC_URI[x86_64_v2_rust-backon-devel.sha256sum] = "1556875df367dd7c2327b0101ddd78657e9c71ad627c0337d6284939f7c11cc5"

URI_aarch64_rust-backon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+default-devel-1.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-backon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+default-devel}"
SRC_URI[aarch64_rust-backon+default-devel.sha256sum] = "4e8232c5c91f7eb5cf0adfe87aae7dc22752c4cbe874c405526a4e8f65252181"

URI_aarch64_rust-backon+futures-timer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+futures-timer-devel-1.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-backon+futures-timer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+futures-timer-devel}"
SRC_URI[aarch64_rust-backon+futures-timer-devel.sha256sum] = "adb36ae07c72d56dce31483d10bce8b72d1726e22d8a30f735c48832de98102f"

URI_aarch64_rust-backon+futures-timer-sleep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+futures-timer-sleep-devel-1.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-backon+futures-timer-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+futures-timer-sleep-devel}"
SRC_URI[aarch64_rust-backon+futures-timer-sleep-devel.sha256sum] = "210caab030749c198fd4bf39cc62d6d7f16dd226044401b6a025b9941a7bb2b4"

URI_aarch64_rust-backon+std-blocking-sleep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+std-blocking-sleep-devel-1.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-backon+std-blocking-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+std-blocking-sleep-devel}"
SRC_URI[aarch64_rust-backon+std-blocking-sleep-devel.sha256sum] = "5f2cf0594f1ed2c1181a9f6498aa6537d0ba9a95589494bac077cc2f316bcee0"

URI_aarch64_rust-backon+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+std-devel-1.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-backon+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+std-devel}"
SRC_URI[aarch64_rust-backon+std-devel.sha256sum] = "0ec0d6e65614f908af8292a14c72720fc7a7d87eb8bbd97084b18ff9ae403faa"

URI_aarch64_rust-backon+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+tokio-devel-1.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-backon+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+tokio-devel}"
SRC_URI[aarch64_rust-backon+tokio-devel.sha256sum] = "c9271e3d24fb62e15e66df27a6a6336a83173291b22cb13b5f90df7ade2d89c5"

URI_aarch64_rust-backon+tokio-sleep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon+tokio-sleep-devel-1.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-backon+tokio-sleep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon+tokio-sleep-devel}"
SRC_URI[aarch64_rust-backon+tokio-sleep-devel.sha256sum] = "ccbf3c21d7b6c717ccb88a9fa055f07a1a5f9e31aa705b73906b896a07a96db7"

URI_aarch64_rust-backon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backon-devel-1.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-backon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backon-devel}"
SRC_URI[aarch64_rust-backon-devel.sha256sum] = "250b3b7c29b317e1da3d20bfe7ab6881c1052174e3845aaffe4b710e5ec7dee8"

RDEPENDS:rust-backon+default-devel = " \
 cargo \
 rust-backon+std-blocking-sleep-devel \
 rust-backon+std-devel \
 rust-backon+tokio-sleep-devel \
 rust-backon-devel \
 "
RDEPENDS:rust-backon+futures-timer-devel = " \
 cargo \
 rust-backon-devel \
 rust-futures-timer+default-devel \
 "
RDEPENDS:rust-backon+futures-timer-sleep-devel = " \
 cargo \
 rust-backon+futures-timer-devel \
 rust-backon-devel \
 "
RDEPENDS:rust-backon+std-blocking-sleep-devel = " \
 cargo \
 rust-backon-devel \
 "
RDEPENDS:rust-backon+std-devel = " \
 cargo \
 rust-backon-devel \
 rust-fastrand+std-devel \
 "
RDEPENDS:rust-backon+tokio-devel = " \
 cargo \
 rust-backon-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-backon+tokio-sleep-devel = " \
 cargo \
 rust-backon-devel \
 rust-tokio+default-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-backon-devel = " \
 cargo \
 rust \
 rust-fastrand-devel \
 "
