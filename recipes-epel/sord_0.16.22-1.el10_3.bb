# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sord"
PV = "0.16.22"
PR = "1.el10_3"
PACKAGES = " \
 sord \
 sord-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sord-0.16.22-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "251ee4f0c7293758d721dae72e14b8eb30bbc4809aa7d31e81ff225b8876c947"

URI_x86_64_v2_sord = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sord-0.16.22-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sord;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sord}"
SRC_URI[x86_64_v2_sord.sha256sum] = "eba556a9394777111cde46bcb672beb34675eabb1b33c4aecc0a6b826fb104c8"

URI_x86_64_v2_sord-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sord-devel-0.16.22-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sord-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sord-devel}"
SRC_URI[x86_64_v2_sord-devel.sha256sum] = "716c6c0af16b9529bfa15c19d9d22ae93bd51b70839dc6906205979c6db80510"

URI_aarch64_sord = "${EPEL_MIRROR}/aarch64/Packages/s/sord-0.16.22-1.el10_3.aarch64.rpm;name=aarch64_sord;unpack=0"
SRC_URI:append = " ${URI_aarch64_sord}"
SRC_URI[aarch64_sord.sha256sum] = "7d203cc8eb7783984efd775446e7b4754135b7f6b592fe7c6a1baacfa9b96a5c"

URI_aarch64_sord-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sord-devel-0.16.22-1.el10_3.aarch64.rpm;name=aarch64_sord-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sord-devel}"
SRC_URI[aarch64_sord-devel.sha256sum] = "648f4b6eafd36a19a71f9fa49ebc6232d5363aeac83379f841a98b51a5c43417"

RDEPENDS:sord = " \
 glibc \
 pcre2 \
 serd \
 zix \
 "
RDEPENDS:sord-devel = " \
 pkgconf-pkg-config \
 serd-devel \
 sord \
 zix-devel \
 "
