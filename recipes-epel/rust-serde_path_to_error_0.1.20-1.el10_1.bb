# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_path_to_error"
PV = "0.1.20"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde_path_to_error+default-devel \
 rust-serde_path_to_error-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_path_to_error-0.1.20-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85395586e3742731c0cfbe28d3e687dd2e1b3d2ef25e2f8a6353f78683a20a4f"

URI_x86_64_v2_rust-serde_path_to_error+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_path_to_error+default-devel-0.1.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_path_to_error+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_path_to_error+default-devel}"
SRC_URI[x86_64_v2_rust-serde_path_to_error+default-devel.sha256sum] = "4fd50f3cf261a4e734be0a32ec5734b16909cc6d381da44a6431c26b8289d615"

URI_x86_64_v2_rust-serde_path_to_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_path_to_error-devel-0.1.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_path_to_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_path_to_error-devel}"
SRC_URI[x86_64_v2_rust-serde_path_to_error-devel.sha256sum] = "477671f5fe97512712d729f5e4800ad22bce7db88ba005174c2c1420aa8946cf"

URI_aarch64_rust-serde_path_to_error+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_path_to_error+default-devel-0.1.20-1.el10_1.noarch.rpm;name=aarch64_rust-serde_path_to_error+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_path_to_error+default-devel}"
SRC_URI[aarch64_rust-serde_path_to_error+default-devel.sha256sum] = "2bfb44f2d11d07585ad6592f0744c8576e44c689785368ec20ba31e85cfbc091"

URI_aarch64_rust-serde_path_to_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_path_to_error-devel-0.1.20-1.el10_1.noarch.rpm;name=aarch64_rust-serde_path_to_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_path_to_error-devel}"
SRC_URI[aarch64_rust-serde_path_to_error-devel.sha256sum] = "d78bcd379bd2e0d76b8257b4ecba9518e8be7a1f8bc00bf6375f1bb7ac68af98"

RDEPENDS:rust-serde_path_to_error+default-devel = " \
 cargo \
 rust-serde_path_to_error-devel \
 "
RDEPENDS:rust-serde_path_to_error-devel = " \
 cargo \
 rust \
 rust-itoa+default-devel \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
