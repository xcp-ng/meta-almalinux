# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_test"
PV = "1.0.177"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_test+default-devel \
 rust-serde_test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_test-1.0.177-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "080307c2978fd9f89230881b4a5671895263058b23338d4d5b129ac9189e88c6"

URI_x86_64_v2_rust-serde_test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_test+default-devel-1.0.177-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_test+default-devel}"
SRC_URI[x86_64_v2_rust-serde_test+default-devel.sha256sum] = "d9fb196fb56ed2d9863059426db2d310b42768337670957f4868c7ef2b35d7ef"

URI_x86_64_v2_rust-serde_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_test-devel-1.0.177-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_test-devel}"
SRC_URI[x86_64_v2_rust-serde_test-devel.sha256sum] = "65b80045b5586c91d32826a2b24b3f19d86fdd7e6ea9afccd133d44d8ce65212"

URI_aarch64_rust-serde_test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_test+default-devel-1.0.177-1.el10_0.noarch.rpm;name=aarch64_rust-serde_test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_test+default-devel}"
SRC_URI[aarch64_rust-serde_test+default-devel.sha256sum] = "a0bc72edeae27a4b21125f806c1487633641cef6ed1ab1dc1ab92ee3125e33d7"

URI_aarch64_rust-serde_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_test-devel-1.0.177-1.el10_0.noarch.rpm;name=aarch64_rust-serde_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_test-devel}"
SRC_URI[aarch64_rust-serde_test-devel.sha256sum] = "90e3f3f244d1f0a5d11c8f04ae8b2c0f66551cd30c29c9f21d5dc28c08d015d5"

RDEPENDS:rust-serde_test+default-devel = " \
 cargo \
 rust-serde_test-devel \
 "
RDEPENDS:rust-serde_test-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 "
