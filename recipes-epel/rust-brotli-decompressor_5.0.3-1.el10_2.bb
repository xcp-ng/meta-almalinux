# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-brotli-decompressor"
PV = "5.0.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-brotli-decompressor+alloc-stdlib-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-decompressor+disable-timer-devel \
 rust-brotli-decompressor+ffi-api-devel \
 rust-brotli-decompressor+pass-through-ffi-panics-devel \
 rust-brotli-decompressor+seccomp-devel \
 rust-brotli-decompressor+std-devel \
 rust-brotli-decompressor+unsafe-devel \
 rust-brotli-decompressor-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-brotli-decompressor-5.0.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8be1cb063c0e74404e24fd71c9b4ad7063824b33fa63f6b57c144e5971b2a18f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+alloc-stdlib-devel-5.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel.sha256sum] = "038140e604625b69653ed3a7b8dd556d3db4710af3ed2f96a734589eeb1ad663"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+default-devel-5.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+default-devel.sha256sum] = "8dde796e4e7d2847799c9e4b9fed4a38dbd05c16f0bbe925005632bdd613108b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+disable-timer-devel-5.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+disable-timer-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+disable-timer-devel.sha256sum] = "306b190f0b9a6203b5c28e2f24167f63ad29093410d2231bf6af9196e682a3c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+ffi-api-devel-5.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+ffi-api-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+ffi-api-devel.sha256sum] = "a4f997b65047b273b1c4601c3cec221bb6d90f78cd25b596028c1f73be19d129"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+pass-through-ffi-panics-devel-5.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel.sha256sum] = "e5b17f5c503dd9a5ebf823fa7b9df9bf79b2705ea47a79fa607ebb7b3d60f83e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+seccomp-devel-5.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+seccomp-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+seccomp-devel.sha256sum] = "726f2bbb76f7f9fed877ecc8da7c7f3bb6d267e394a4dcd7b809b477c88791c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+std-devel-5.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+std-devel.sha256sum] = "18f417207269d7b62a66a5128dd9f5a3de155ef45f79d7ec3ef0d5715e2763bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+unsafe-devel-5.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+unsafe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor+unsafe-devel.sha256sum] = "b80ab1d4453a298ab6e52cdc235fdf4b77c126100204bca8f88adf0f92d150b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor-devel-5.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-brotli-decompressor-devel.sha256sum] = "4bdf1e87d34826c0dc8d25454b530d6faf8c3f7caa14d5926d97789fb564f643"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+alloc-stdlib-devel-5.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+alloc-stdlib-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+alloc-stdlib-devel.sha256sum] = "26eeaf7d47ec21e9c8bc85851571b9a06076067d30e2b8adc989ae06ce2f33e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+default-devel-5.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+default-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+default-devel.sha256sum] = "d516c7396830a64e08c6a2a3a81a50f5039f8dded24ba6263d8e2b37f8eac102"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+disable-timer-devel-5.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+disable-timer-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+disable-timer-devel.sha256sum] = "05b86b3d78ba82bef3cd06aefbe50643fe65413daa7fb6ca8b9f16ffd0ff31f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+ffi-api-devel-5.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+ffi-api-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+ffi-api-devel.sha256sum] = "9b05376426f7a01ac6baa3f3930e9d0ffa69a0e357d5b6fbe6658b6927217200"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+pass-through-ffi-panics-devel-5.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel.sha256sum] = "b93928f2c33c6df1435995e23adfe42de3a604a539d4ce2f98a4c89cd0c599df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+seccomp-devel-5.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+seccomp-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+seccomp-devel.sha256sum] = "02023d7c097d5360e1ee12e7b168a4a525127889e6b1ade8aaf12c0f87861b27"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+std-devel-5.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+std-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+std-devel.sha256sum] = "e2d728ffc9e37ba675d688d77758e53ba36985b270375fffda80f752f96162d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+unsafe-devel-5.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor+unsafe-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor+unsafe-devel.sha256sum] = "d89c2fca41e10b62d431e1afbbb415856e04d510dfb54d131702e9866996a51c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor-devel-5.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-brotli-decompressor-devel;unpack=0"
SRC_URI[aarch64_rust-brotli-decompressor-devel.sha256sum] = "aa189f8383c1d1ef01cf4c2822a5ab2497b0f19caaa8eb0173a00eb62ca73aa2"

RDEPENDS:rust-brotli-decompressor+alloc-stdlib-devel = " \
 cargo \
 rust-alloc-stdlib+default-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+default-devel = " \
 cargo \
 rust-brotli-decompressor+std-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+disable-timer-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+ffi-api-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+pass-through-ffi-panics-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+seccomp-devel = " \
 cargo \
 rust-alloc-no-stdlib+unsafe-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+std-devel = " \
 cargo \
 rust-brotli-decompressor+alloc-stdlib-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+unsafe-devel = " \
 cargo \
 rust-alloc-no-stdlib+unsafe-devel \
 rust-alloc-stdlib+default-devel \
 rust-alloc-stdlib+unsafe-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor-devel = " \
 cargo \
 rust-alloc-no-stdlib+default-devel \
 "
