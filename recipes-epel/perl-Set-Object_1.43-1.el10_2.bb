# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Set-Object"
PV = "1.43"
PR = "1.el10_2"
PACKAGES = " \
 perl-Set-Object \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Set-Object-1.43-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a6b5731687f28b8831726446816f499876547386273a59a6d51f78a321b466d"

URI_x86_64_v2_perl-Set-Object = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Set-Object-1.43-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Set-Object;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Set-Object}"
SRC_URI[x86_64_v2_perl-Set-Object.sha256sum] = "99b03139ac1cbf5a5aedbb4de42d5ec79b11227f6f61afbb9ea437dc0a6bea87"

URI_aarch64_perl-Set-Object = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Set-Object-1.43-1.el10_2.aarch64.rpm;name=aarch64_perl-Set-Object;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Set-Object}"
SRC_URI[aarch64_perl-Set-Object.sha256sum] = "2a046e244248cfca9074b6e4636fb6e57b95fbc55059369e975f77d4513bad0d"

RDEPENDS:perl-Set-Object = " \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-Set-Object \
 perl-base \
 perl-libs \
 perl-overload \
 perl-vars \
 "
