# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kinfocenter"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kinfocenter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kinfocenter-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75694658469ba704f681ab540be6ec796ed2e91a956d0f0a1a1cd3e5f925661f"

URI_x86_64_v2_kinfocenter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kinfocenter-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kinfocenter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kinfocenter}"
SRC_URI[x86_64_v2_kinfocenter.sha256sum] = "cffa5361eab015655e621460fc7ec9ca1fbe1585b7e677b07886f024f64341c8"

URI_aarch64_kinfocenter = "${EPEL_MIRROR}/aarch64/Packages/k/kinfocenter-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kinfocenter;unpack=0"
SRC_URI:append = " ${URI_aarch64_kinfocenter}"
SRC_URI[aarch64_kinfocenter.sha256sum] = "123e71cee6f1ab8f4f0452b6a716952b27f8ffc4854f949543381e5b327edc94"

RDEPENDS:kinfocenter = " \
 aha \
 clinfo \
 dmidecode \
 egl-utils \
 fwupd \
 glibc \
 hwdata \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kservice \
 kf6-solid \
 libdisplay-info-tools \
 libdrm \
 libstdc++ \
 libusb1 \
 plasma-systemsettings \
 pulseaudio-utils \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 vulkan-tools \
 wayland-utils \
 xdpyinfo \
 "
