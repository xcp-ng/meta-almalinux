# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-as-raw-xcb-connection"
PV = "1.0.1"
PR = "4.el10_1"
PACKAGES = " \
 rust-as-raw-xcb-connection+alloc-devel \
 rust-as-raw-xcb-connection+default-devel \
 rust-as-raw-xcb-connection-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-as-raw-xcb-connection-1.0.1-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09465a3eaa85f50c0d2bc0024d0c5a5f05d4a167a33c31fe3e758b6472098b8e"

URI_x86_64_v2_rust-as-raw-xcb-connection+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-as-raw-xcb-connection+alloc-devel-1.0.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-as-raw-xcb-connection+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-as-raw-xcb-connection+alloc-devel}"
SRC_URI[x86_64_v2_rust-as-raw-xcb-connection+alloc-devel.sha256sum] = "526ec2dfed2bb4bc95ac2307adc4db4602681f10a36963db0c05a6a48ffd0c07"

URI_x86_64_v2_rust-as-raw-xcb-connection+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-as-raw-xcb-connection+default-devel-1.0.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-as-raw-xcb-connection+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-as-raw-xcb-connection+default-devel}"
SRC_URI[x86_64_v2_rust-as-raw-xcb-connection+default-devel.sha256sum] = "3d88b41355298e6c8dd15c448b8f2affc06b776665529b4f2c596924e65ddab9"

URI_x86_64_v2_rust-as-raw-xcb-connection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-as-raw-xcb-connection-devel-1.0.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-as-raw-xcb-connection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-as-raw-xcb-connection-devel}"
SRC_URI[x86_64_v2_rust-as-raw-xcb-connection-devel.sha256sum] = "7943e1d61114d63c774b3e20ea4cebdfb479f4022a48833b9e67a8a4834e2431"

URI_aarch64_rust-as-raw-xcb-connection+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-as-raw-xcb-connection+alloc-devel-1.0.1-4.el10_1.noarch.rpm;name=aarch64_rust-as-raw-xcb-connection+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-as-raw-xcb-connection+alloc-devel}"
SRC_URI[aarch64_rust-as-raw-xcb-connection+alloc-devel.sha256sum] = "9df651d1ffffc099e0e8d50068b8e5ed1c95f563af7a2c99d3a8d5903cfb8a11"

URI_aarch64_rust-as-raw-xcb-connection+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-as-raw-xcb-connection+default-devel-1.0.1-4.el10_1.noarch.rpm;name=aarch64_rust-as-raw-xcb-connection+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-as-raw-xcb-connection+default-devel}"
SRC_URI[aarch64_rust-as-raw-xcb-connection+default-devel.sha256sum] = "036f5b7b7df61db031c55211cb0fdfba7056788bff333d8535a7017bc67d8260"

URI_aarch64_rust-as-raw-xcb-connection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-as-raw-xcb-connection-devel-1.0.1-4.el10_1.noarch.rpm;name=aarch64_rust-as-raw-xcb-connection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-as-raw-xcb-connection-devel}"
SRC_URI[aarch64_rust-as-raw-xcb-connection-devel.sha256sum] = "0d8310bbd4edb37becf519ff3b3b82c7560f9488288a69411f206ba1e703754c"

RDEPENDS:rust-as-raw-xcb-connection+alloc-devel = " \
 cargo \
 rust-as-raw-xcb-connection-devel \
 "
RDEPENDS:rust-as-raw-xcb-connection+default-devel = " \
 cargo \
 rust-as-raw-xcb-connection+alloc-devel \
 rust-as-raw-xcb-connection-devel \
 "
RDEPENDS:rust-as-raw-xcb-connection-devel = " \
 cargo \
 "
