# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libreswan"
PV = "5.3"
PR = "1.el10"
PACKAGES = " \
 libreswan \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libreswan-5.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c07aef7a1a06c36a810ca07f9dfaaa0c8ba5bb0a345b56cdaed61f7f62e5216"

URI_x86_64_v2_libreswan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libreswan-5.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_libreswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libreswan}"
SRC_URI[x86_64_v2_libreswan.sha256sum] = "c2b4970f1f8e6f6d2ca8ab021f32a29c1582b96078730525ece5a7750d227df4"

URI_aarch64_libreswan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libreswan-5.3-1.el10.aarch64.rpm;name=aarch64_libreswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libreswan}"
SRC_URI[aarch64_libreswan.sha256sum] = "c8f9563edadba68148de52fae9bb21a2e579713d979d710490f34968b438d68b"

RDEPENDS:libreswan = " \
 audit-libs \
 bash \
 glibc \
 iproute \
 ldns \
 libcap-ng \
 libevent \
 libgcc \
 libseccomp \
 libselinux \
 libxcrypt \
 logrotate \
 nspr \
 nss \
 nss-softokn \
 nss-tools \
 nss-util \
 openldap \
 pam-libs \
 procps-ng \
 systemd \
 unbound-libs \
 virtual/coreutils \
 virtual/libcurl.so.4___64bit_ \
 "
