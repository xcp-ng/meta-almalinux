# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-nikic-php-parser5"
PV = "5.7.0"
PR = "1.el10_1"
PACKAGES = " \
 php-nikic-php-parser5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-nikic-php-parser5-5.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "543049e8a78a6d8963dd59427f15df6a4d6f142debe48a8c14c19bc9e11bffc3"

URI_x86_64_v2_php-nikic-php-parser5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-nikic-php-parser5-5.7.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_php-nikic-php-parser5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-nikic-php-parser5}"
SRC_URI[x86_64_v2_php-nikic-php-parser5.sha256sum] = "a71477b3e56e89d72bd0d0de976a4c7b289d6ef973a28ed66ec6a2b4323a1b6f"

URI_aarch64_php-nikic-php-parser5 = "${EPEL_MIRROR}/aarch64/Packages/p/php-nikic-php-parser5-5.7.0-1.el10_1.noarch.rpm;name=aarch64_php-nikic-php-parser5;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-nikic-php-parser5}"
SRC_URI[aarch64_php-nikic-php-parser5.sha256sum] = "03db109bc3569403004eccb00f766d0f91d7ae82cb7d2732bc207ac8d09b3b32"

RDEPENDS:php-nikic-php-parser5 = " \
 php-cli \
 php-common \
 php-fedora-autoloader \
 "
