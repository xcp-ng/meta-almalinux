# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chezmoi"
PV = "2.63.1"
PR = "1.el10_0"
PACKAGES = " \
 chezmoi \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/chezmoi-2.63.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "135d876bb97fe12e7142224281fea0c1df88b9cbf1627daca70b222d02c96fbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chezmoi-2.63.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chezmoi;unpack=0"
SRC_URI[x86_64_v2_chezmoi.sha256sum] = "6892fa945a6ba9f33e25512e30dc8b22b7ca21ffc54a1fdfd7a8a1e80f6cc8a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/chezmoi-2.63.1-1.el10_0.aarch64.rpm;name=aarch64_chezmoi;unpack=0"
SRC_URI[aarch64_chezmoi.sha256sum] = "a00d73399993568705aceb03c9e149a1ce09a0f62cd2c097c4d81450acea7809"

RDEPENDS:chezmoi = " \
 glibc \
 "
