# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kile"
PV = "2.9.94"
PR = "3.el10_0"
PACKAGES = " \
 kile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kile-2.9.94-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98b9b018970d1da5f125b226e3f43a22bf4079e5117d172da557c211fbfee240"

URI_x86_64_v2_kile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kile-2.9.94-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kile}"
SRC_URI[x86_64_v2_kile.sha256sum] = "ff6f8ea98b87d5c2ef2ba3a42edf527a9f0cff8cec4becdf65c76855ebdb2f74"

URI_aarch64_kile = "${EPEL_MIRROR}/aarch64/Packages/k/kile-2.9.94-3.el10_0.aarch64.rpm;name=aarch64_kile;unpack=0"
SRC_URI:append = " ${URI_aarch64_kile}"
SRC_URI[aarch64_kile.sha256sum] = "04a19420b75c7e473264810d70cbe9bf8804a588003c518f6a8ba614208e9503"

RDEPENDS:kile = " \
 glibc \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 konsole-part \
 libgcc \
 libstdc++ \
 perl-interpreter \
 poppler-qt6 \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 texlive-collection-latexrecommended \
 "
