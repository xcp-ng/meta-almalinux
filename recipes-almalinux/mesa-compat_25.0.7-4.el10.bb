# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mesa-compat"
PV = "25.0.7"
PR = "4.el10"
PACKAGES = " \
 mesa-compat-libOSMesa \
 mesa-compat-libOSMesa-devel \
 mesa-compat-libxatracker \
 mesa-compat-libxatracker-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mesa-compat-25.0.7-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d6748ff271d7badd07aa5a0a49e4fe3b40042dec677f3d418ff5a499393b607"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libOSMesa-25.0.7-4.el10.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libOSMesa;unpack=0"
SRC_URI[x86_64_v2_mesa-compat-libOSMesa.sha256sum] = "a993a939ae029348959ceed829c13a65a26da1273e99e7f53ead04d48fbb3f34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libOSMesa-devel-25.0.7-4.el10.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libOSMesa-devel;unpack=0"
SRC_URI[x86_64_v2_mesa-compat-libOSMesa-devel.sha256sum] = "fc6691ea55abb3859b86408fb527fa769f7df112b80884bfc9bd38ab5011616a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libxatracker-25.0.7-4.el10.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libxatracker;unpack=0"
SRC_URI[x86_64_v2_mesa-compat-libxatracker.sha256sum] = "3b50045261a1f80f30320beb9d43018d9200088e1c478236f155112eb93dddef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libxatracker-devel-25.0.7-4.el10.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libxatracker-devel;unpack=0"
SRC_URI[x86_64_v2_mesa-compat-libxatracker-devel.sha256sum] = "7c54f57740a2577ee2d913d9c94497162e66b48c8b22aa224282d34eaadd40c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libOSMesa-25.0.7-4.el10.aarch64.rpm;name=aarch64_mesa-compat-libOSMesa;unpack=0"
SRC_URI[aarch64_mesa-compat-libOSMesa.sha256sum] = "fb0e080d8ce8f3e4492d2337b5df29491654558d91b2a254f5f24e55f887f86c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libOSMesa-devel-25.0.7-4.el10.aarch64.rpm;name=aarch64_mesa-compat-libOSMesa-devel;unpack=0"
SRC_URI[aarch64_mesa-compat-libOSMesa-devel.sha256sum] = "7f946840b6f81c385ec247535faf46006a0a96415289edc2992a23a5e9967ce9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libxatracker-25.0.7-4.el10.aarch64.rpm;name=aarch64_mesa-compat-libxatracker;unpack=0"
SRC_URI[aarch64_mesa-compat-libxatracker.sha256sum] = "fe0a044738b78d2f377347f0c1b4731035f2d03bd37870f3261726944ea85d56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libxatracker-devel-25.0.7-4.el10.aarch64.rpm;name=aarch64_mesa-compat-libxatracker-devel;unpack=0"
SRC_URI[aarch64_mesa-compat-libxatracker-devel.sha256sum] = "abdca55cabea8f232ec0a5a62db8b48fe676fa2f9b5cb0cb1871fbb07941d342"

RDEPENDS:mesa-compat-libOSMesa = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-compat-libOSMesa-devel = " \
 mesa-compat-libOSMesa \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-compat-libxatracker = " \
 expat \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-compat-libxatracker-devel = " \
 mesa-compat-libxatracker \
 pkgconf-pkg-config \
 "
