# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "butane"
PV = "0.27.0"
PR = "1.el10_2"
PACKAGES = " \
 butane \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/butane-0.27.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a50b288aae85901d6c44dfd4916746902a6c374327c1a01e971474da679488f"

URI_x86_64_v2_butane = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/butane-0.27.0-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_butane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_butane}"
SRC_URI[x86_64_v2_butane.sha256sum] = "5ea272067ee496451127edec2d0d3a8f84ca6feb51feded74151c195b38e39b7"

URI_aarch64_butane = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/butane-0.27.0-1.el10_2.aarch64.rpm;name=aarch64_butane;unpack=0"
SRC_URI:append = " ${URI_aarch64_butane}"
SRC_URI[aarch64_butane.sha256sum] = "63f413b40cd044d8dec5ade07ef19d015acc360661c25bf85a9db395005ed6ce"

RDEPENDS:butane = " \
 glibc \
 "
