# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-countme"
PV = "3.0.1"
PR = "4.el10_1"
PACKAGES = " \
 rust-countme+dashmap-devel \
 rust-countme+default-devel \
 rust-countme+enable-devel \
 rust-countme+once_cell-devel \
 rust-countme+print_at_exit-devel \
 rust-countme+rustc-hash-devel \
 rust-countme-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-countme-3.0.1-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dfccdf127bdce46d00050a035e80842cd8ed51a8c8f61b0d594b01029e33bdd"

URI_x86_64_v2_rust-countme+dashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-countme+dashmap-devel-3.0.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-countme+dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-countme+dashmap-devel}"
SRC_URI[x86_64_v2_rust-countme+dashmap-devel.sha256sum] = "39647864c2cc2d5d1ab085b21ed3f9012057841a2391f708ba238fe6b6c862eb"

URI_x86_64_v2_rust-countme+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-countme+default-devel-3.0.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-countme+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-countme+default-devel}"
SRC_URI[x86_64_v2_rust-countme+default-devel.sha256sum] = "6189f2357866ec7abc0fa8813553af04b5e8c8cb19e0534ca080229d13e715de"

URI_x86_64_v2_rust-countme+enable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-countme+enable-devel-3.0.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-countme+enable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-countme+enable-devel}"
SRC_URI[x86_64_v2_rust-countme+enable-devel.sha256sum] = "a13d8f7a4de93b504f604d2f91e3866f9831f564b9e2f760bdb22f32ef87570e"

URI_x86_64_v2_rust-countme+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-countme+once_cell-devel-3.0.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-countme+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-countme+once_cell-devel}"
SRC_URI[x86_64_v2_rust-countme+once_cell-devel.sha256sum] = "397f7dabe3c761fc215aef95ef47cc706053b909fa6fa105e4782331d4d736b5"

URI_x86_64_v2_rust-countme+print_at_exit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-countme+print_at_exit-devel-3.0.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-countme+print_at_exit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-countme+print_at_exit-devel}"
SRC_URI[x86_64_v2_rust-countme+print_at_exit-devel.sha256sum] = "6acb729eccd18ad13c36e5df297654fbcc97c97577f373f02184de9b96b1f2ff"

URI_x86_64_v2_rust-countme+rustc-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-countme+rustc-hash-devel-3.0.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-countme+rustc-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-countme+rustc-hash-devel}"
SRC_URI[x86_64_v2_rust-countme+rustc-hash-devel.sha256sum] = "6af4aed0277885d14e908ffb04af55c0ed42e1a8d1acd87640ba48811e4e7d8e"

URI_x86_64_v2_rust-countme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-countme-devel-3.0.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-countme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-countme-devel}"
SRC_URI[x86_64_v2_rust-countme-devel.sha256sum] = "86d633dac73cbadef4a7e5e7603c9fbed901cc54d18a36b5b445c3c94f6cd443"

URI_aarch64_rust-countme+dashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-countme+dashmap-devel-3.0.1-4.el10_1.noarch.rpm;name=aarch64_rust-countme+dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-countme+dashmap-devel}"
SRC_URI[aarch64_rust-countme+dashmap-devel.sha256sum] = "e6005d390015f2c031e826b609f1b68f52f14ff4d98a5e438b04012ba27f6276"

URI_aarch64_rust-countme+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-countme+default-devel-3.0.1-4.el10_1.noarch.rpm;name=aarch64_rust-countme+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-countme+default-devel}"
SRC_URI[aarch64_rust-countme+default-devel.sha256sum] = "b71ccb04fc3eefbb112b9bf617fd5a77703f4a82911770f67f14abba47dac48e"

URI_aarch64_rust-countme+enable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-countme+enable-devel-3.0.1-4.el10_1.noarch.rpm;name=aarch64_rust-countme+enable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-countme+enable-devel}"
SRC_URI[aarch64_rust-countme+enable-devel.sha256sum] = "87b67863671d0efc96a278a6b2c40a4a2dbc17e945782781fae443afb1f1bde4"

URI_aarch64_rust-countme+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-countme+once_cell-devel-3.0.1-4.el10_1.noarch.rpm;name=aarch64_rust-countme+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-countme+once_cell-devel}"
SRC_URI[aarch64_rust-countme+once_cell-devel.sha256sum] = "0087df771aa7272f6477ff49f6edc217c8800e76550c1f2bcfd875f6ef3c44a5"

URI_aarch64_rust-countme+print_at_exit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-countme+print_at_exit-devel-3.0.1-4.el10_1.noarch.rpm;name=aarch64_rust-countme+print_at_exit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-countme+print_at_exit-devel}"
SRC_URI[aarch64_rust-countme+print_at_exit-devel.sha256sum] = "27f77536a662b0b6944c018b38ae0244634e05190d112e44c1810d54b1620b16"

URI_aarch64_rust-countme+rustc-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-countme+rustc-hash-devel-3.0.1-4.el10_1.noarch.rpm;name=aarch64_rust-countme+rustc-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-countme+rustc-hash-devel}"
SRC_URI[aarch64_rust-countme+rustc-hash-devel.sha256sum] = "997c3203257c02606cdfe0072d0d24d095270a1fa96de699a6d8cb284b2b95ab"

URI_aarch64_rust-countme-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-countme-devel-3.0.1-4.el10_1.noarch.rpm;name=aarch64_rust-countme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-countme-devel}"
SRC_URI[aarch64_rust-countme-devel.sha256sum] = "960ea17f26cad27824a16f4e02446b142b7b780fae8e9bba7fe3883ef9b47a89"

RDEPENDS:rust-countme+dashmap-devel = " \
 cargo \
 rust-countme-devel \
 rust-dashmap5+default-devel \
 "
RDEPENDS:rust-countme+default-devel = " \
 cargo \
 rust-countme-devel \
 "
RDEPENDS:rust-countme+enable-devel = " \
 cargo \
 rust-countme+dashmap-devel \
 rust-countme+once_cell-devel \
 rust-countme+rustc-hash-devel \
 rust-countme-devel \
 "
RDEPENDS:rust-countme+once_cell-devel = " \
 cargo \
 rust-countme-devel \
 rust-once_cell+default-devel \
 "
RDEPENDS:rust-countme+print_at_exit-devel = " \
 cargo \
 rust-countme+enable-devel \
 rust-countme-devel \
 "
RDEPENDS:rust-countme+rustc-hash-devel = " \
 cargo \
 rust-countme-devel \
 rust-rustc-hash1+default-devel \
 "
RDEPENDS:rust-countme-devel = " \
 cargo \
 "
