# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_isaac"
PV = "0.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_isaac+default-devel \
 rust-rand_isaac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_isaac-0.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99705800087652332622516dc2d1c692da93b28970bccc498afd65ca2ca6ae95"

URI_x86_64_v2_rust-rand_isaac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac+default-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac+default-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac+default-devel.sha256sum] = "9bf7c7470beeef8c9e2363f58af5d162707db817a53045fc06c9f63b470ccaab"

URI_x86_64_v2_rust-rand_isaac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac-devel.sha256sum] = "415c39b0bbbe2727d269bbb0451406c5094663d2ed80027ce93889f287b017d5"

URI_aarch64_rust-rand_isaac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac+default-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac+default-devel}"
SRC_URI[aarch64_rust-rand_isaac+default-devel.sha256sum] = "da73afa9083d71e0c4743c864e334d6a50a1fd6d44381a8d24d1a5c077a199a1"

URI_aarch64_rust-rand_isaac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac-devel}"
SRC_URI[aarch64_rust-rand_isaac-devel.sha256sum] = "5ccf7259cd6b0ebf6448ed6380b56e2b8cdc38de2eedf6a00b5ba4f629b994b3"

RDEPENDS:rust-rand_isaac+default-devel = " \
 cargo \
 rust-rand_isaac-devel \
 "
RDEPENDS:rust-rand_isaac-devel = " \
 cargo \
 rust \
 rust-rand_core+default-devel \
 "
