# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-experimental"
PV = "0.032"
PR = "511.el10"
PACKAGES = " \
 perl-experimental \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-experimental-0.032-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "028e66b84037246879966dbccc31ff70e6e702dae84303ad2fb2f98344ae7b82"

URI_x86_64_v2_perl-experimental = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-experimental-0.032-511.el10.noarch.rpm;name=x86_64_v2_perl-experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-experimental}"
SRC_URI[x86_64_v2_perl-experimental.sha256sum] = "df3ccd55d1cdaf5ccd090abed5605e8579ebb0f572768badfd59f1837f3284d9"

URI_aarch64_perl-experimental = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-experimental-0.032-511.el10.noarch.rpm;name=aarch64_perl-experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-experimental}"
SRC_URI[aarch64_perl-experimental.sha256sum] = "df3ccd55d1cdaf5ccd090abed5605e8579ebb0f572768badfd59f1837f3284d9"

RDEPENDS:perl-experimental = " \
 perl-Carp \
 perl-experimental \
 perl-libs \
 perl-version \
 "
