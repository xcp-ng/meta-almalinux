# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-detect-secrets"
PV = "1.5.0"
PR = "7.el10_1"
PACKAGES = " \
 python3-detect-secrets \
 python3-detect-secrets+word_list \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-detect-secrets-1.5.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d225cf298fe94a037c777c9d4f212b2181c36c099171696eddf58cc46ef052a"

URI_x86_64_v2_python3-detect-secrets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-detect-secrets-1.5.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-detect-secrets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-detect-secrets}"
SRC_URI[x86_64_v2_python3-detect-secrets.sha256sum] = "0da0af6e33b8e48c1e472fa8b7750686a7cde6c0a48ca20ecb72181d91873c5b"

URI_x86_64_v2_python3-detect-secrets+word_list = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-detect-secrets+word_list-1.5.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-detect-secrets+word_list;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-detect-secrets+word_list}"
SRC_URI[x86_64_v2_python3-detect-secrets+word_list.sha256sum] = "578d12a174132e96a80404820c40d31e42181414501e1d21841f03707eb3df9f"

URI_aarch64_python3-detect-secrets = "${EPEL_MIRROR}/aarch64/Packages/p/python3-detect-secrets-1.5.0-7.el10_1.noarch.rpm;name=aarch64_python3-detect-secrets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-detect-secrets}"
SRC_URI[aarch64_python3-detect-secrets.sha256sum] = "c9aa0e8a69290a9cad05c3eca1d0be0f950276534303ba3e3e44f2a4458aa26e"

URI_aarch64_python3-detect-secrets+word_list = "${EPEL_MIRROR}/aarch64/Packages/p/python3-detect-secrets+word_list-1.5.0-7.el10_1.noarch.rpm;name=aarch64_python3-detect-secrets+word_list;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-detect-secrets+word_list}"
SRC_URI[aarch64_python3-detect-secrets+word_list.sha256sum] = "883f349d6d0c65b177d3154d2fe7d2db814f3785bcf46ea91a6c5f83f79e51fc"

RDEPENDS:python3-detect-secrets = " \
 python3 \
 python3-pyyaml \
 python3-requests \
 "
RDEPENDS:python3-detect-secrets+word_list = " \
 python3 \
 python3-detect-secrets \
 python3-pyahocorasick \
 "
