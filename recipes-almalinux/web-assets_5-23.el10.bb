# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "web-assets"
PV = "5"
PR = "23.el10"
PACKAGES = " \
 web-assets-filesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/web-assets-5-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a72973b8c9ad9788a8bbc7fe0274e1d2e1569a58e4fe868cbc24893b92252256"

URI_x86_64_v2_web-assets-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/web-assets-filesystem-5-23.el10.noarch.rpm;name=x86_64_v2_web-assets-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_web-assets-filesystem}"
SRC_URI[x86_64_v2_web-assets-filesystem.sha256sum] = "da3b9bb6e0ecbef765ccc0e98fc09a8169fa82d45f6a26c119ecfd705151a7c6"

URI_aarch64_web-assets-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/web-assets-filesystem-5-23.el10.noarch.rpm;name=aarch64_web-assets-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_web-assets-filesystem}"
SRC_URI[aarch64_web-assets-filesystem.sha256sum] = "da3b9bb6e0ecbef765ccc0e98fc09a8169fa82d45f6a26c119ecfd705151a7c6"

RDEPENDS:web-assets-filesystem = " \
 fonts-filesystem \
 "
