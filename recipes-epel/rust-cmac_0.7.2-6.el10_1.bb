# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cmac"
PV = "0.7.2"
PR = "6.el10_1"
PACKAGES = " \
 rust-cmac+default-devel \
 rust-cmac+std-devel \
 rust-cmac+zeroize-devel \
 rust-cmac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cmac-0.7.2-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da86690b799cb1f64819e499867bb4cb81091c35a8ec5387c3f15b9b62fc0be9"

URI_x86_64_v2_rust-cmac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmac+default-devel-0.7.2-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmac+default-devel}"
SRC_URI[x86_64_v2_rust-cmac+default-devel.sha256sum] = "0544abdcf95c5c479a13f06d115161bde6f9acf33f2e8fc9573e324bc1f35d08"

URI_x86_64_v2_rust-cmac+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmac+std-devel-0.7.2-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmac+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmac+std-devel}"
SRC_URI[x86_64_v2_rust-cmac+std-devel.sha256sum] = "979a4ec925ddc1fb06547449bbde783e9be08dabe32905210342747d291f594a"

URI_x86_64_v2_rust-cmac+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmac+zeroize-devel-0.7.2-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmac+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmac+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cmac+zeroize-devel.sha256sum] = "4bff1729b0b6734f4f8c6056335f27ec2989eee78bd9c44d84228cbde6464ac1"

URI_x86_64_v2_rust-cmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmac-devel-0.7.2-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmac-devel}"
SRC_URI[x86_64_v2_rust-cmac-devel.sha256sum] = "6a641fa2a89bff25e07e241f79d2d480d6b81ac7fb1e4c7df349fb437217e7cd"

URI_aarch64_rust-cmac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmac+default-devel-0.7.2-6.el10_1.noarch.rpm;name=aarch64_rust-cmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmac+default-devel}"
SRC_URI[aarch64_rust-cmac+default-devel.sha256sum] = "61d31b76e9bdcdac9bafb9cbede7e2d5ea3b1795dd4fb30f67b9cae618cb68b2"

URI_aarch64_rust-cmac+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmac+std-devel-0.7.2-6.el10_1.noarch.rpm;name=aarch64_rust-cmac+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmac+std-devel}"
SRC_URI[aarch64_rust-cmac+std-devel.sha256sum] = "5eef2224317fcdf28514dc77d08227b5bbdd17637f3cd8657962b3d179e78b52"

URI_aarch64_rust-cmac+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmac+zeroize-devel-0.7.2-6.el10_1.noarch.rpm;name=aarch64_rust-cmac+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmac+zeroize-devel}"
SRC_URI[aarch64_rust-cmac+zeroize-devel.sha256sum] = "ca6323e189cf23e16ffd18c93e78031a8f5c80c98848158e49fe26298217298c"

URI_aarch64_rust-cmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmac-devel-0.7.2-6.el10_1.noarch.rpm;name=aarch64_rust-cmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmac-devel}"
SRC_URI[aarch64_rust-cmac-devel.sha256sum] = "03e0c42e55d1204f589111eb3192be4220fa2b4522ec9a73e6a117b5c33851d9"

RDEPENDS:rust-cmac+default-devel = " \
 cargo \
 rust-cmac-devel \
 "
RDEPENDS:rust-cmac+std-devel = " \
 cargo \
 rust-cmac-devel \
 rust-digest+std-devel \
 "
RDEPENDS:rust-cmac+zeroize-devel = " \
 cargo \
 rust-cipher+zeroize-devel \
 rust-cmac-devel \
 "
RDEPENDS:rust-cmac-devel = " \
 cargo \
 rust \
 rust-cipher+default-devel \
 rust-dbl+default-devel \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
