# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-ocaml"
PV = "0.24.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-ocaml+default-devel \
 rust-tree-sitter-ocaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-ocaml-0.24.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e90bce349d8f14b79f800fa4804f6c41016338f148aa23a465be60043a477d5d"

URI_x86_64_v2_rust-tree-sitter-ocaml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ocaml+default-devel-0.24.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ocaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ocaml+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ocaml+default-devel.sha256sum] = "ddd26ff4eb29da9c76ba042e8ae82e8114e1e4d85f9f3a1689e6a9d11dcbc2ae"

URI_x86_64_v2_rust-tree-sitter-ocaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ocaml-devel-0.24.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ocaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ocaml-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ocaml-devel.sha256sum] = "0989fcb635a76f2b58fb5011bcda5799f7fae9ccb77d7f95e0c50fd9adb4ac1a"

URI_aarch64_rust-tree-sitter-ocaml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ocaml+default-devel-0.24.2-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-ocaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ocaml+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-ocaml+default-devel.sha256sum] = "1afae9063faf63847d45cabbacb1e85f4463b44e05d7679bb433ea606a0ace13"

URI_aarch64_rust-tree-sitter-ocaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ocaml-devel-0.24.2-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-ocaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ocaml-devel}"
SRC_URI[aarch64_rust-tree-sitter-ocaml-devel.sha256sum] = "721d4e74ca7459247f6e842ac164b8dc36ebd39398f2e8083d1bc0414c1ffc3e"

RDEPENDS:rust-tree-sitter-ocaml+default-devel = " \
 cargo \
 rust-tree-sitter-ocaml-devel \
 "
RDEPENDS:rust-tree-sitter-ocaml-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
