# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clevis-pin-tpm2"
PV = "0.5.3"
PR = "9.el10"
PACKAGES = " \
 clevis-pin-tpm2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/clevis-pin-tpm2-0.5.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cff9f1d597ee2eda6301701c0f253ca923472a733d5e71924947ca4d80b7aca5"

URI_x86_64_v2_clevis-pin-tpm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-pin-tpm2-0.5.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-pin-tpm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-pin-tpm2}"
SRC_URI[x86_64_v2_clevis-pin-tpm2.sha256sum] = "a8232892b2d75bab70d8eff73f5e524ec6f24b2a8f4235d0267a17c5f85a80a9"

URI_aarch64_clevis-pin-tpm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-pin-tpm2-0.5.3-9.el10.aarch64.rpm;name=aarch64_clevis-pin-tpm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-pin-tpm2}"
SRC_URI[aarch64_clevis-pin-tpm2.sha256sum] = "74060af62c1d6902501e2472bc1b0fc75e72e78e5958e37dc1334560e5799fbf"

RDEPENDS:clevis-pin-tpm2 = " \
 clevis \
 glibc \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
