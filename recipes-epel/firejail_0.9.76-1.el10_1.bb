# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firejail"
PV = "0.9.76"
PR = "1.el10_1"
PACKAGES = " \
 firejail \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/firejail-0.9.76-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84b31e2394a14f2caa3473458d772b001b63a3c120985ab9634cf1582d9480b4"

URI_x86_64_v2_firejail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firejail-0.9.76-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_firejail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firejail}"
SRC_URI[x86_64_v2_firejail.sha256sum] = "f9cdca3e8144f5d95140ee02a243d01418d9656128479d65c2dbdd303d42b5f8"

URI_aarch64_firejail = "${EPEL_MIRROR}/aarch64/Packages/f/firejail-0.9.76-1.el10_1.aarch64.rpm;name=aarch64_firejail;unpack=0"
SRC_URI:append = " ${URI_aarch64_firejail}"
SRC_URI[aarch64_firejail.sha256sum] = "7b9412a518c5f5d9bd241f42f1f516bd2263a162eafe84a4aace81c53b04c105"

RDEPENDS:firejail = " \
 bash \
 glibc \
 libselinux \
 python3 \
 xdg-dbus-proxy \
 "
