# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "i2c-tools"
PV = "4.3"
PR = "14.el10"
PACKAGES = " \
 i2c-tools \
 i2c-tools-perl \
 libi2c \
 libi2c-devel \
 python3-i2c-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/i2c-tools-4.3-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a95b481c34aca9668d90b55f452b0d6e7f3a1d1e97f36a3b8d6fb3ebdd0508f8"

URI_x86_64_v2_i2c-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/i2c-tools-4.3-14.el10.x86_64_v2.rpm;name=x86_64_v2_i2c-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_i2c-tools}"
SRC_URI[x86_64_v2_i2c-tools.sha256sum] = "fab74306243ec88d9bdecd4d3464032e3adbceb3763715279733c0f145d40b78"

URI_x86_64_v2_i2c-tools-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/i2c-tools-perl-4.3-14.el10.x86_64_v2.rpm;name=x86_64_v2_i2c-tools-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_i2c-tools-perl}"
SRC_URI[x86_64_v2_i2c-tools-perl.sha256sum] = "8c1a8d1bf9a7a8809c28b8033e053529cf39f529481e47f8708a2fb18242c22a"

URI_x86_64_v2_libi2c = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libi2c-4.3-14.el10.x86_64_v2.rpm;name=x86_64_v2_libi2c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libi2c}"
SRC_URI[x86_64_v2_libi2c.sha256sum] = "f58e96cdf103512c2d2331bfb160c3d19dac3dedd9ebcfb9fe361e56137024b5"

URI_x86_64_v2_libi2c-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libi2c-devel-4.3-14.el10.x86_64_v2.rpm;name=x86_64_v2_libi2c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libi2c-devel}"
SRC_URI[x86_64_v2_libi2c-devel.sha256sum] = "6b46d88802c4e25a0565ca16efaa09acd82c7fd287d042e1b2f9acdf64ddbfdf"

URI_x86_64_v2_python3-i2c-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-i2c-tools-4.3-14.el10.x86_64_v2.rpm;name=x86_64_v2_python3-i2c-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-i2c-tools}"
SRC_URI[x86_64_v2_python3-i2c-tools.sha256sum] = "266bec193e6a3f8dcfa5ff071fa721f16226450ea03880f1d01d3794233193a4"

URI_aarch64_i2c-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/i2c-tools-4.3-14.el10.aarch64.rpm;name=aarch64_i2c-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_i2c-tools}"
SRC_URI[aarch64_i2c-tools.sha256sum] = "3f55c81239f8c5315493c62b9244bd129d93d9c7d5e3ee7f30be23dd4c36f388"

URI_aarch64_i2c-tools-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/i2c-tools-perl-4.3-14.el10.aarch64.rpm;name=aarch64_i2c-tools-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_i2c-tools-perl}"
SRC_URI[aarch64_i2c-tools-perl.sha256sum] = "a59c6c5f875353c688a95a831aba6e925713856d52cab8f527149ebc7120eeb6"

URI_aarch64_libi2c = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libi2c-4.3-14.el10.aarch64.rpm;name=aarch64_libi2c;unpack=0"
SRC_URI:append = " ${URI_aarch64_libi2c}"
SRC_URI[aarch64_libi2c.sha256sum] = "e631863b1978378566c6314d35e895f4e6ae2ad0d448b3cf91e04223c371f772"

URI_aarch64_libi2c-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libi2c-devel-4.3-14.el10.aarch64.rpm;name=aarch64_libi2c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libi2c-devel}"
SRC_URI[aarch64_libi2c-devel.sha256sum] = "bfe22721502c7d939781560806f31a35b0a8d8a5f345ca5678ee1db8ece10bf1"

URI_aarch64_python3-i2c-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-i2c-tools-4.3-14.el10.aarch64.rpm;name=aarch64_python3-i2c-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-i2c-tools}"
SRC_URI[aarch64_python3-i2c-tools.sha256sum] = "d35878b978ec414df288f16bf1cf8b026cb3a2665c5801ec3f93b74ea7e945f1"

RDEPENDS:i2c-tools = " \
 bash \
 glibc \
 kmod \
 libi2c \
 systemd-udev \
 "
RDEPENDS:i2c-tools-perl = " \
 libi2c \
 perl-Fcntl \
 perl-File-Basename \
 perl-POSIX \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:libi2c = " \
 glibc \
 "
RDEPENDS:libi2c-devel = " \
 libi2c \
 "
RDEPENDS:python3-i2c-tools = " \
 glibc \
 libi2c \
 python3 \
 "
