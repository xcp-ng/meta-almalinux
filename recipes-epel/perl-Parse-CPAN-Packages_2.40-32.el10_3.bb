# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parse-CPAN-Packages"
PV = "2.40"
PR = "32.el10_3"
PACKAGES = " \
 perl-Parse-CPAN-Packages \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Parse-CPAN-Packages-2.40-32.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "39a9674b2696f65a5ff5230d72e05be8d8fe94d19a3e4af47ebd348d36e9908b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parse-CPAN-Packages-2.40-32.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parse-CPAN-Packages;unpack=0"
SRC_URI[x86_64_v2_perl-Parse-CPAN-Packages.sha256sum] = "51afb6b4e1fe3e0a95ef5e96196ea65c2aa25821c15e380282159879fd76cbd6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Parse-CPAN-Packages-2.40-32.el10_3.noarch.rpm;name=aarch64_perl-Parse-CPAN-Packages;unpack=0"
SRC_URI[aarch64_perl-Parse-CPAN-Packages.sha256sum] = "458b12a7e39d2f061398b3fd02e0713f87bfc11e36e1620896817e4eb112733d"

RDEPENDS:perl-Parse-CPAN-Packages = " \
 perl-Archive-Peek \
 perl-CPAN-DistnameInfo \
 perl-File-Slurp \
 perl-IO-Compress \
 perl-Moo \
 perl-PPI \
 perl-Path-Class \
 perl-Type-Tiny \
 perl-libs \
 perl-version \
 "
