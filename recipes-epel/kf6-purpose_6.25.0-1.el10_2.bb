# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-purpose"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-purpose \
 kf6-purpose-devel \
 kf6-purpose-doc \
 kf6-purpose-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-purpose-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7736a3371a8478c2f0aa1f7c173573c99f8571419e37ebee904d2f8ac3e6204f"

URI_x86_64_v2_kf6-purpose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-purpose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose}"
SRC_URI[x86_64_v2_kf6-purpose.sha256sum] = "c5b958cc4ce07edf25e141418d180fcf21ed7fcbdd5aeb12db3229d55d4e9cb5"

URI_x86_64_v2_kf6-purpose-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-purpose-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose-devel}"
SRC_URI[x86_64_v2_kf6-purpose-devel.sha256sum] = "0a456005366ff2bc9702421da481e2f92bdd2908006986b32d39b6c819232dd0"

URI_x86_64_v2_kf6-purpose-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-purpose-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose-doc}"
SRC_URI[x86_64_v2_kf6-purpose-doc.sha256sum] = "98c9b18e46255af98c789f17edbbe0b701ee1af0b2ac7b124e25a8c8d8a3c9ea"

URI_x86_64_v2_kf6-purpose-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-purpose-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-purpose-html}"
SRC_URI[x86_64_v2_kf6-purpose-html.sha256sum] = "f279762bd6443c60f10550be87a7703de1bde7690decbda52bcc5563e4302455"

URI_aarch64_kf6-purpose = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-purpose;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose}"
SRC_URI[aarch64_kf6-purpose.sha256sum] = "bf04f51b222ac754b70dba61896b58997d33444fccbce83f4d3870d93554341f"

URI_aarch64_kf6-purpose-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-purpose-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose-devel}"
SRC_URI[aarch64_kf6-purpose-devel.sha256sum] = "a6d86da224a7d7ea21558428bd3e86a2be157589e660895b0e49628f95e77ee2"

URI_aarch64_kf6-purpose-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-purpose-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose-doc}"
SRC_URI[aarch64_kf6-purpose-doc.sha256sum] = "2c1db27a57af79d39b3be100b58f5d20e1cea1b00a1ad2803e7b1d3a7034208e"

URI_aarch64_kf6-purpose-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-purpose-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-purpose-html}"
SRC_URI[aarch64_kf6-purpose-html.sha256sum] = "4ae7e919f90110b8f2b420c161b4bc89b27da204fa2a2880f9dbdc2bb5f171b2"

RDEPENDS:kf6-purpose = " \
 accounts-qml-module-qt6 \
 glibc \
 hicolor-icon-theme \
 kaccounts-integration-qt6 \
 kf6-bluez-qt \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-prison \
 libaccounts-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-purpose-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-purpose \
 "
RDEPENDS:kf6-purpose-doc = " \
 "
RDEPENDS:kf6-purpose-html = " \
 "
