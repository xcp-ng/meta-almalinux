# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-sa"
PV = "0.20110915"
PR = "29.el10"
PACKAGES = " \
 hyphen-sa \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-sa-0.20110915-29.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6e1d810606164af47077d0cca739cc0e960d659ac051ad9d285bd893c875e1f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-sa-0.20110915-29.el10.noarch.rpm;name=x86_64_v2_hyphen-sa;unpack=0"
SRC_URI[x86_64_v2_hyphen-sa.sha256sum] = "90e62fc3482f2814f07b94e92f730b07d55e1718cf906818dd193bf60f8a580a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-sa-0.20110915-29.el10.noarch.rpm;name=aarch64_hyphen-sa;unpack=0"
SRC_URI[aarch64_hyphen-sa.sha256sum] = "90e62fc3482f2814f07b94e92f730b07d55e1718cf906818dd193bf60f8a580a"

RDEPENDS:hyphen-sa = " \
 hyphen \
 "
