# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-bad-free"
PV = "1.26.7"
PR = "2.el10"
PACKAGES = " \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-bad-free-devel \
 gstreamer1-plugins-bad-free-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-bad-free-1.26.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5898fee52dc067991d03dfe9f933ac6e17acd9db75ea21cd2c227c34a5e4453"

URI_x86_64_v2_gstreamer1-plugins-bad-free = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-1.26.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free.sha256sum] = "c06ce7238572c0b66e3d6f7d7f8ca240e4c633223353db74ad7a4665ffee4705"

URI_x86_64_v2_gstreamer1-plugins-bad-free-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-devel-1.26.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free-devel}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free-devel.sha256sum] = "a13965725c570fd5bce4e6f394ff99dcacab6527569af49ffc00afca0c28f893"

URI_x86_64_v2_gstreamer1-plugins-bad-free-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-libs-1.26.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free-libs}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free-libs.sha256sum] = "5d2118cf9d1f214bfe9f37e0c252e24137a8a119e8d4b8a0f3f8589289428482"

URI_aarch64_gstreamer1-plugins-bad-free = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-bad-free-1.26.7-2.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free.sha256sum] = "cd3386fe9738b601286ac17e9b58decea9a8cda3f09a95135a35e1ef925df0bd"

URI_aarch64_gstreamer1-plugins-bad-free-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gstreamer1-plugins-bad-free-devel-1.26.7-2.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free-devel}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free-devel.sha256sum] = "13e8d129a3706fd7b726ef2694380aa7481c3d403a6cfe6b013cc66e86e2f416"

URI_aarch64_gstreamer1-plugins-bad-free-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-bad-free-libs-1.26.7-2.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free-libs}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free-libs.sha256sum] = "04856d1bbd05994dcbb1e85e0757eb0dbbc13ab00a4fb43560f1dea7bfe81355"

RDEPENDS:gstreamer1-plugins-bad-free = " \
 bzip2-libs \
 cairo \
 fdk-aac-free \
 glib2 \
 glibc \
 gsm \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk3 \
 json-glib \
 lcms2 \
 libdrm \
 libdvdnav \
 libdvdread \
 libgcc \
 libgudev \
 liblc3 \
 librsvg2 \
 libsndfile \
 libsrtp \
 libstdc++ \
 libusb1 \
 libva \
 libwayland-client \
 libwebp \
 libxml2 \
 openjpeg2 \
 openssl-libs \
 opus \
 orc \
 pango \
 soundtouch \
 vulkan-loader \
 webrtc-audio-processing \
 "
RDEPENDS:gstreamer1-plugins-bad-free-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-bad-free-devel \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base-devel \
 libdrm-devel \
 libva-devel \
 pkgconf-pkg-config \
 vulkan-loader-devel \
 wayland-devel \
 "
RDEPENDS:gstreamer1-plugins-bad-free-libs = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libdrm \
 libgcc \
 libstdc++ \
 libva \
 libwayland-client \
 vulkan-loader \
 "
