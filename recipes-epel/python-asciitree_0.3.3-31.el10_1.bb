# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-asciitree"
PV = "0.3.3"
PR = "31.el10_1"
PACKAGES = " \
 python3-asciitree \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-asciitree-0.3.3-31.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b19c3e0a5a45b25c6e2763095327ccd5b3397f073d18f03637349eac1428255f"

URI_x86_64_v2_python3-asciitree = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-asciitree-0.3.3-31.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-asciitree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-asciitree}"
SRC_URI[x86_64_v2_python3-asciitree.sha256sum] = "c3740b0161eadd39904d61b5d18c038982a799a7dd36b8c340e321337796bdd0"

URI_aarch64_python3-asciitree = "${EPEL_MIRROR}/aarch64/Packages/p/python3-asciitree-0.3.3-31.el10_1.noarch.rpm;name=aarch64_python3-asciitree;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-asciitree}"
SRC_URI[aarch64_python3-asciitree.sha256sum] = "14a0eeee5b3cf76cfc26b35864ce54cb52c98ac4bc9faee4bb231566c8e28675"

RDEPENDS:python3-asciitree = " \
 python3 \
 "
