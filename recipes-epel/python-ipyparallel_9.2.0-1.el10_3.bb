# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ipyparallel"
PV = "9.2.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-ipyparallel \
 python3-ipyparallel+test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ipyparallel-9.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12d9971f66b2bcf543acc23a055d5af4f233e8c6882b0a6ece33445882e61e6d"

URI_x86_64_v2_python3-ipyparallel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipyparallel-9.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipyparallel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipyparallel}"
SRC_URI[x86_64_v2_python3-ipyparallel.sha256sum] = "e12c854f8c1ecc1b83cacf28c1d7c84b0f090a06d75b2024029f4b3d206dd394"

URI_x86_64_v2_python3-ipyparallel+test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipyparallel+test-9.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipyparallel+test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipyparallel+test}"
SRC_URI[x86_64_v2_python3-ipyparallel+test.sha256sum] = "5eb82809cbca605b1c74429a4cda9e62714c1e9c35308840d050216ea6c652cd"

URI_aarch64_python3-ipyparallel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipyparallel-9.2.0-1.el10_3.noarch.rpm;name=aarch64_python3-ipyparallel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipyparallel}"
SRC_URI[aarch64_python3-ipyparallel.sha256sum] = "b15d6581328d4689082bdd7ac190220ec24b34f5fcfb5813c1533bc9a94dcfae"

URI_aarch64_python3-ipyparallel+test = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipyparallel+test-9.2.0-1.el10_3.noarch.rpm;name=aarch64_python3-ipyparallel+test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipyparallel+test}"
SRC_URI[aarch64_python3-ipyparallel+test.sha256sum] = "4c85fa20e43b80bca51781bbde4e70692390a11b3623d2000ff3f4cc3ded5db3"

RDEPENDS:python3-ipyparallel = " \
 python-jupyter-filesystem \
 python3 \
 python3-dateutil \
 python3-decorator \
 python3-ipykernel \
 python3-ipython \
 python3-jupyter-client \
 python3-psutil \
 python3-pyzmq \
 python3-tornado \
 python3-tqdm \
 python3-traitlets \
 "
RDEPENDS:python3-ipyparallel+test = " \
 python3 \
 python3-ipyparallel \
 python3-ipython \
 python3-ipython+test \
 python3-pytest \
 python3-pytest-asyncio \
 python3-pytest-cov \
 python3-testpath \
 "
