# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "multitail"
PV = "7.1.3"
PR = "2.el10_0"
PACKAGES = " \
 multitail \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/multitail-7.1.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbd83b42c2bfbb912c1565350550c84808e44d8b9b8e65f0a2ae3e19cab97df1"

URI_x86_64_v2_multitail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/multitail-7.1.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_multitail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_multitail}"
SRC_URI[x86_64_v2_multitail.sha256sum] = "210fd93520446e75f9b188c2d95be80105254c066a8ef9f25336cd9cf0441bfc"

URI_aarch64_multitail = "${EPEL_MIRROR}/aarch64/Packages/m/multitail-7.1.3-2.el10_0.aarch64.rpm;name=aarch64_multitail;unpack=0"
SRC_URI:append = " ${URI_aarch64_multitail}"
SRC_URI[aarch64_multitail.sha256sum] = "f4c920c14b3232ec8501a096e2c509a55ae58f4fcce2a4cc5a22f5d5836e1e6d"

RDEPENDS:multitail = " \
 glibc \
 ncurses-libs \
 "
