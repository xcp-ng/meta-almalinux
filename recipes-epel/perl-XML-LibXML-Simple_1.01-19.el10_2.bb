# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-LibXML-Simple"
PV = "1.01"
PR = "19.el10_2"
PACKAGES = " \
 perl-XML-LibXML-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-LibXML-Simple-1.01-19.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d9612f6f23e7588236fd55c184325cf0de18f04b09ccce2dc2ffa616225feb5"

URI_x86_64_v2_perl-XML-LibXML-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-LibXML-Simple-1.01-19.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-LibXML-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-LibXML-Simple}"
SRC_URI[x86_64_v2_perl-XML-LibXML-Simple.sha256sum] = "8ff37d0d66a8d2f4ea26ef59276ac0d21534b06bb7bf0c61da6f8ba1c4f986f4"

URI_aarch64_perl-XML-LibXML-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-LibXML-Simple-1.01-19.el10_2.noarch.rpm;name=aarch64_perl-XML-LibXML-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-LibXML-Simple}"
SRC_URI[aarch64_perl-XML-LibXML-Simple.sha256sum] = "f5a7c601b5bb2cb69a35ace8414db77c65c07777e4cac15021eddf5b22e54f0f"

RDEPENDS:perl-XML-LibXML-Simple = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-XML-LibXML \
 perl-base \
 perl-libs \
 perl-vars \
 "
