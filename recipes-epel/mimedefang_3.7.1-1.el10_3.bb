# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mimedefang"
PV = "3.7.1"
PR = "1.el10_3"
PACKAGES = " \
 mimedefang \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mimedefang-3.7.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be6422e2ba47a376855c575ec6560b344daf6226b7c51e8f553d4ecca5344626"

URI_x86_64_v2_mimedefang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimedefang-3.7.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimedefang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimedefang}"
SRC_URI[x86_64_v2_mimedefang.sha256sum] = "444317149d7d1b7f612735b7ef09cf732d3cf2a84d46ecfdc3a396bf499b48cd"

URI_aarch64_mimedefang = "${EPEL_MIRROR}/aarch64/Packages/m/mimedefang-3.7.1-1.el10_3.aarch64.rpm;name=aarch64_mimedefang;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimedefang}"
SRC_URI[aarch64_mimedefang.sha256sum] = "cbbf907f6b84a270f10d1ef64072fee49375597cc467e0b79cfdb6fde064544b"

RDEPENDS:mimedefang = " \
 bash \
 glibc \
 mimedefang \
 perl-Carp \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-Errno \
 perl-Exporter \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-Mail-SPF \
 perl-Net-DNS \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Socket \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 sendmail-milter \
 shadow-utils \
 systemd \
 "
