# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-seaborn"
PV = "0.13.2"
PR = "6.el10_0"
PACKAGES = " \
 python3-seaborn \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-seaborn-0.13.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f9b7489e64c34353c1da33ca19f8914b8aad067133d54ac70524a25175d7814"

URI_x86_64_v2_python3-seaborn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-seaborn-0.13.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-seaborn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-seaborn}"
SRC_URI[x86_64_v2_python3-seaborn.sha256sum] = "e640a8f15b9899bda6aba4adfedf00ffd5bc7bb358ce0bf9b55b7b013f06b929"

URI_aarch64_python3-seaborn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-seaborn-0.13.2-6.el10_0.noarch.rpm;name=aarch64_python3-seaborn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-seaborn}"
SRC_URI[aarch64_python3-seaborn.sha256sum] = "35455933439989ff58cd5ece8124f14682011f901032f92241c5cc11fe5f9074"

RDEPENDS:python3-seaborn = " \
 python3 \
 python3-husl \
 python3-matplotlib \
 python3-numpy \
 python3-numpydoc \
 python3-pandas \
 "
