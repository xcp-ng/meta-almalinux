# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sox"
PV = "14.4.2.0"
PR = "42.el10_0"
PACKAGES = " \
 sox \
 sox-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sox-14.4.2.0-42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac06ff24ed1983d0bbae462a60bf1be6709b8539e01fab3678ad5d25e1a086da"

URI_x86_64_v2_sox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sox-14.4.2.0-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sox}"
SRC_URI[x86_64_v2_sox.sha256sum] = "831bdda6e6810cf496d45303b46c4198b2881dc2f17571b17408728046b39760"

URI_x86_64_v2_sox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sox-devel-14.4.2.0-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sox-devel}"
SRC_URI[x86_64_v2_sox-devel.sha256sum] = "b660ef80ac3596daeae9ecde69b0646ca1ff5f74c1752bccae099bb3711aa22d"

URI_aarch64_sox = "${EPEL_MIRROR}/aarch64/Packages/s/sox-14.4.2.0-42.el10_0.aarch64.rpm;name=aarch64_sox;unpack=0"
SRC_URI:append = " ${URI_aarch64_sox}"
SRC_URI[aarch64_sox.sha256sum] = "3302133578929ff78957abeeef70d21b4daa4903bed84dd6299abd71423aff43"

URI_aarch64_sox-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sox-devel-14.4.2.0-42.el10_0.aarch64.rpm;name=aarch64_sox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sox-devel}"
SRC_URI[aarch64_sox-devel.sha256sum] = "7283e760fe159efb2f8abf782008faf8868e197a8768ca483c48d7dd4ea9efe4"

RDEPENDS:sox = " \
 alsa-lib \
 flac-libs \
 glibc \
 gsm \
 lame-libs \
 libao \
 libgcc \
 libgomp \
 libid3tag \
 libmad \
 libogg \
 libpng \
 libsndfile \
 libtool-ltdl \
 libvorbis \
 opusfile \
 pulseaudio-libs \
 twolame-libs \
 wavpack \
 zlib-ng-compat \
 "
RDEPENDS:sox-devel = " \
 pkgconf-pkg-config \
 sox \
 "
