# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project-lite"
PV = "0.2.17"
PR = "1.el10_2"
PACKAGES = " \
 rust-pin-project-lite+default-devel \
 rust-pin-project-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-lite-0.2.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59aa2a8854e0694faae36591029e8e5a202d8f076384957f70b89f7ef723562a"

URI_x86_64_v2_rust-pin-project-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-lite+default-devel-0.2.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-lite+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project-lite+default-devel.sha256sum] = "cd46e4026803b4f67d98271359ad9104cd54b1acb430839298ea77daf4047175"

URI_x86_64_v2_rust-pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-lite-devel-0.2.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-pin-project-lite-devel.sha256sum] = "6c659f83b5a632ab5198663d99ab67f4acba84ff1d970713ef82cdbf325bcdd9"

URI_aarch64_rust-pin-project-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-lite+default-devel-0.2.17-1.el10_2.noarch.rpm;name=aarch64_rust-pin-project-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-lite+default-devel}"
SRC_URI[aarch64_rust-pin-project-lite+default-devel.sha256sum] = "2dedfc404737505ca33327aa96da19b64957faf177c0ce04df78a5e16e4b1ad4"

URI_aarch64_rust-pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-lite-devel-0.2.17-1.el10_2.noarch.rpm;name=aarch64_rust-pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-lite-devel}"
SRC_URI[aarch64_rust-pin-project-lite-devel.sha256sum] = "107d39b119f2f606580e9b4122ff27a5d814ae70963fd1a86c71da34cca8ff01"

RDEPENDS:rust-pin-project-lite+default-devel = " \
 cargo \
 rust-pin-project-lite-devel \
 "
RDEPENDS:rust-pin-project-lite-devel = " \
 cargo \
 rust \
 "
