# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stress"
PV = "1.0.7"
PR = "5.el10_0"
PACKAGES = " \
 stress \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/stress-1.0.7-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f6048f66b4e8c1945aac1b8bff5eed85ff37e017ec43bec09332f7eeb360fb5b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stress-1.0.7-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stress;unpack=0"
SRC_URI[x86_64_v2_stress.sha256sum] = "d3572ef7d08e66bf6b0bdba8b8fe66d7694277821553634e257ae4d02a8dc9ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stress-1.0.7-5.el10_0.aarch64.rpm;name=aarch64_stress;unpack=0"
SRC_URI[aarch64_stress.sha256sum] = "a32fef109d0e0721bc22249789680fa23156c6d076267f2cae51c8505eba5ef3"

RDEPENDS:stress = " \
 glibc \
 "
