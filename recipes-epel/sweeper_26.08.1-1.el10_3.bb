# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sweeper"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 sweeper \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sweeper-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0200a5b4964a893a404440e21db288898cdefb9732849e67bfba8155406dcce0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sweeper-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sweeper;unpack=0"
SRC_URI[x86_64_v2_sweeper.sha256sum] = "c73286fc9af90375625edf19c888d5e466ba2bdcedbbe8024a1d3ca1fb149f79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sweeper-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_sweeper;unpack=0"
SRC_URI[aarch64_sweeper.sha256sum] = "2326c2bc1021dbc49412197bb317ee7c7cdd0b24c8dbacbcafc92c1579986767"

RDEPENDS:sweeper = " \
 glibc \
 hicolor-icon-theme \
 kf6-kbookmarks \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 plasma-activities-stats \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
