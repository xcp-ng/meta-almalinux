# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Tinyish"
PV = "0.19"
PR = "4.el10_0"
PACKAGES = " \
 perl-HTTP-Tinyish \
 perl-HTTP-Tinyish-Curl \
 perl-HTTP-Tinyish-HTTPTiny \
 perl-HTTP-Tinyish-LWP \
 perl-HTTP-Tinyish-Wget \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTTP-Tinyish-0.19-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70622cf01550c2fdbf64e5f9416d0676adab942306e155f06ebdd2b2f210101b"

URI_x86_64_v2_perl-HTTP-Tinyish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tinyish-0.19-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tinyish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tinyish}"
SRC_URI[x86_64_v2_perl-HTTP-Tinyish.sha256sum] = "e604d59516231563ce7fb85ec5be0270c46845b11fa4cc4ef00fb8d1e29de20b"

URI_x86_64_v2_perl-HTTP-Tinyish-Curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tinyish-Curl-0.19-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tinyish-Curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tinyish-Curl}"
SRC_URI[x86_64_v2_perl-HTTP-Tinyish-Curl.sha256sum] = "fe3cccbcb526e015872a17a771204ce47c90d072d5e5fdbadb6c36e9f86389ba"
RPROVIDES:perl-HTTP-Tinyish-Curl:x86_64_v2 = "virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_x86_64_v2_perl-HTTP-Tinyish-HTTPTiny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tinyish-HTTPTiny-0.19-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tinyish-HTTPTiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tinyish-HTTPTiny}"
SRC_URI[x86_64_v2_perl-HTTP-Tinyish-HTTPTiny.sha256sum] = "d2e8773f4cdbd4240ea99d93e0652a7fd970d43ba6bf711168020cdb37ed09e4"
RPROVIDES:perl-HTTP-Tinyish-HTTPTiny:x86_64_v2 = "virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_x86_64_v2_perl-HTTP-Tinyish-LWP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tinyish-LWP-0.19-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tinyish-LWP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tinyish-LWP}"
SRC_URI[x86_64_v2_perl-HTTP-Tinyish-LWP.sha256sum] = "4c38eaee2413de4217e784b5a169f81ad07fec064e81e280abee5334e2ef7a02"
RPROVIDES:perl-HTTP-Tinyish-LWP:x86_64_v2 = "virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_x86_64_v2_perl-HTTP-Tinyish-Wget = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tinyish-Wget-0.19-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tinyish-Wget;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tinyish-Wget}"
SRC_URI[x86_64_v2_perl-HTTP-Tinyish-Wget.sha256sum] = "857b3fc5cc68d3874dd85e789920c64d2710ef1cbabda345ad42d6fdcc6e0cc5"
RPROVIDES:perl-HTTP-Tinyish-Wget:x86_64_v2 = "virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_aarch64_perl-HTTP-Tinyish = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tinyish-0.19-4.el10_0.noarch.rpm;name=aarch64_perl-HTTP-Tinyish;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tinyish}"
SRC_URI[aarch64_perl-HTTP-Tinyish.sha256sum] = "d1efcd66dd22281e45a40b6a6da3f1faedeb371fee40fa015b4d4cf9599346f5"

URI_aarch64_perl-HTTP-Tinyish-Curl = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tinyish-Curl-0.19-4.el10_0.noarch.rpm;name=aarch64_perl-HTTP-Tinyish-Curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tinyish-Curl}"
SRC_URI[aarch64_perl-HTTP-Tinyish-Curl.sha256sum] = "f30c7aee02040f1d58512271f38a2015b94b65411088ea686e3cafaf7406fa16"
RPROVIDES:perl-HTTP-Tinyish-Curl:aarch64 = "virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_aarch64_perl-HTTP-Tinyish-HTTPTiny = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tinyish-HTTPTiny-0.19-4.el10_0.noarch.rpm;name=aarch64_perl-HTTP-Tinyish-HTTPTiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tinyish-HTTPTiny}"
SRC_URI[aarch64_perl-HTTP-Tinyish-HTTPTiny.sha256sum] = "021ce703986843d307b2a83448a238f599bbd3563df7a76c15b55a2b4c586df1"
RPROVIDES:perl-HTTP-Tinyish-HTTPTiny:aarch64 = "virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_aarch64_perl-HTTP-Tinyish-LWP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tinyish-LWP-0.19-4.el10_0.noarch.rpm;name=aarch64_perl-HTTP-Tinyish-LWP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tinyish-LWP}"
SRC_URI[aarch64_perl-HTTP-Tinyish-LWP.sha256sum] = "098c182670f9df8ec6d438e8d45abf43b5bf6be7e2f17282cb09cdadd53f0b71"
RPROVIDES:perl-HTTP-Tinyish-LWP:aarch64 = "virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_aarch64_perl-HTTP-Tinyish-Wget = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tinyish-Wget-0.19-4.el10_0.noarch.rpm;name=aarch64_perl-HTTP-Tinyish-Wget;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tinyish-Wget}"
SRC_URI[aarch64_perl-HTTP-Tinyish-Wget.sha256sum] = "2ad0879eddc4ed1a8e3fc2ebf392deef8ede52b7e1db409ef936e3db2fa3b941"
RPROVIDES:perl-HTTP-Tinyish-Wget:aarch64 = "virtual/perl__HTTP-Tinyish_backend__eq_0.19"

RDEPENDS:perl-HTTP-Tinyish = " \
 perl-Carp \
 perl-libs \
 virtual/perl__HTTP-Tinyish_backend__eq_0.19 \
 "
RDEPENDS:perl-HTTP-Tinyish-Curl = " \
 curl \
 perl-File-Temp \
 perl-File-Which \
 perl-HTTP-Tinyish \
 perl-IPC-Run3 \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-HTTP-Tinyish-HTTPTiny = " \
 perl-HTTP-Tiny \
 perl-HTTP-Tinyish \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-HTTP-Tinyish-LWP = " \
 perl-HTTP-Tinyish \
 perl-libs \
 perl-libwww-perl \
 perl-parent \
 "
RDEPENDS:perl-HTTP-Tinyish-Wget = " \
 perl-File-Which \
 perl-HTTP-Tinyish \
 perl-IPC-Run3 \
 perl-libs \
 perl-parent \
 wget \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/perl__HTTP-Tinyish_backend__eq_0.19"

PROVIDES:append:aarch64 = " rpm/virtual/perl__HTTP-Tinyish_backend__eq_0.19"
