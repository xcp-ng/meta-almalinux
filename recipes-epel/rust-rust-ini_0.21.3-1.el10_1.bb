# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-ini"
PV = "0.21.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-rust-ini+brackets-in-section-names-devel \
 rust-rust-ini+case-insensitive-devel \
 rust-rust-ini+default-devel \
 rust-rust-ini+inline-comment-devel \
 rust-rust-ini+unicase-devel \
 rust-rust-ini-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-ini-0.21.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05819b8a219af972094bfa6ccc79f86987bc2662bcc37a563644ba2161a24e66"

URI_x86_64_v2_rust-rust-ini+brackets-in-section-names-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini+brackets-in-section-names-devel-0.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini+brackets-in-section-names-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini+brackets-in-section-names-devel}"
SRC_URI[x86_64_v2_rust-rust-ini+brackets-in-section-names-devel.sha256sum] = "1a02d0e32444222e8b3f781ea46c9d8ee051c029a5d47340871b90c0fe718ebf"

URI_x86_64_v2_rust-rust-ini+case-insensitive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini+case-insensitive-devel-0.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini+case-insensitive-devel}"
SRC_URI[x86_64_v2_rust-rust-ini+case-insensitive-devel.sha256sum] = "9a12a378ba30b1878cb3a4ac0f74f04a844321eeed361b99c0e635dd56cb98fe"

URI_x86_64_v2_rust-rust-ini+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini+default-devel-0.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini+default-devel}"
SRC_URI[x86_64_v2_rust-rust-ini+default-devel.sha256sum] = "bc591e7c4fb945dadb6de3ca5af2aa0e5c62583bef3b1c654ba007515a1f4781"

URI_x86_64_v2_rust-rust-ini+inline-comment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini+inline-comment-devel-0.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini+inline-comment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini+inline-comment-devel}"
SRC_URI[x86_64_v2_rust-rust-ini+inline-comment-devel.sha256sum] = "3dd25121fc05fef1cf3a155bc87a0e15a99dc3d7afc4bc999bd9b817555ee263"

URI_x86_64_v2_rust-rust-ini+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini+unicase-devel-0.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini+unicase-devel}"
SRC_URI[x86_64_v2_rust-rust-ini+unicase-devel.sha256sum] = "2604c9c0cefcb5481efc2c8559fe3a55351c8dd7e34489a30aabc4922a3afe66"

URI_x86_64_v2_rust-rust-ini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini-devel-0.21.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini-devel}"
SRC_URI[x86_64_v2_rust-rust-ini-devel.sha256sum] = "8efaf78a60152d937ce34198c82f79d9bb052205d9ea9fc1589e3be9ffbd2745"

URI_aarch64_rust-rust-ini+brackets-in-section-names-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini+brackets-in-section-names-devel-0.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-rust-ini+brackets-in-section-names-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini+brackets-in-section-names-devel}"
SRC_URI[aarch64_rust-rust-ini+brackets-in-section-names-devel.sha256sum] = "b5166f6e32b1510112c4538e75163698f84053b79789f8dbc5158222f068b26d"

URI_aarch64_rust-rust-ini+case-insensitive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini+case-insensitive-devel-0.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-rust-ini+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini+case-insensitive-devel}"
SRC_URI[aarch64_rust-rust-ini+case-insensitive-devel.sha256sum] = "1ed8b1c43692ee77583d86bd8025a50e61cb1520c5b4ac48b1db89077c59a14a"

URI_aarch64_rust-rust-ini+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini+default-devel-0.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-rust-ini+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini+default-devel}"
SRC_URI[aarch64_rust-rust-ini+default-devel.sha256sum] = "7c8185bd9c6888fd1655543bbbbc1a0e4cb50b39de579b03fd2d5be01e31b600"

URI_aarch64_rust-rust-ini+inline-comment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini+inline-comment-devel-0.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-rust-ini+inline-comment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini+inline-comment-devel}"
SRC_URI[aarch64_rust-rust-ini+inline-comment-devel.sha256sum] = "3030043af44711753258c32f5b88ae7dbd87eb704c9b843d458c1a7a71b01465"

URI_aarch64_rust-rust-ini+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini+unicase-devel-0.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-rust-ini+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini+unicase-devel}"
SRC_URI[aarch64_rust-rust-ini+unicase-devel.sha256sum] = "121ee12cfde78185ff7e568b8e67d5d975567b9cbd61cac641b47e5c8ef6bf2c"

URI_aarch64_rust-rust-ini-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini-devel-0.21.3-1.el10_1.noarch.rpm;name=aarch64_rust-rust-ini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini-devel}"
SRC_URI[aarch64_rust-rust-ini-devel.sha256sum] = "62807608fefd397b92f6f3d0f1ea140be7b0d581400cd09ba05582db44d5996e"

RDEPENDS:rust-rust-ini+brackets-in-section-names-devel = " \
 cargo \
 rust-rust-ini-devel \
 "
RDEPENDS:rust-rust-ini+case-insensitive-devel = " \
 cargo \
 rust-rust-ini+unicase-devel \
 rust-rust-ini-devel \
 "
RDEPENDS:rust-rust-ini+default-devel = " \
 cargo \
 rust-rust-ini-devel \
 "
RDEPENDS:rust-rust-ini+inline-comment-devel = " \
 cargo \
 rust-rust-ini-devel \
 "
RDEPENDS:rust-rust-ini+unicase-devel = " \
 cargo \
 rust-rust-ini-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-rust-ini-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-ordered-multimap+default-devel \
 "
