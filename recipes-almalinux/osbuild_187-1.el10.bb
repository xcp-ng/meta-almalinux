# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osbuild"
PV = "187"
PR = "1.el10"
PACKAGES = " \
 osbuild \
 osbuild-container-selinux \
 osbuild-depsolve-dnf \
 osbuild-initrd \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 osbuild-selinux \
 python3-osbuild \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osbuild-187-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c61ed86122fb6a578bbfe78634b8873730ccb7184e30828eaf700136df926bd"

URI_x86_64_v2_osbuild = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-187-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild}"
SRC_URI[x86_64_v2_osbuild.sha256sum] = "6c523a14432d4e129418131c2116dd7d009ca8318f407a0ffef6a15298e395da"

URI_x86_64_v2_osbuild-container-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-container-selinux-187-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-container-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-container-selinux}"
SRC_URI[x86_64_v2_osbuild-container-selinux.sha256sum] = "c05e280e5a133ef9b837ca1b82c3facde878cd7400a37a26b32486e02fa3a998"

URI_x86_64_v2_osbuild-depsolve-dnf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-depsolve-dnf-187-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-depsolve-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-depsolve-dnf}"
SRC_URI[x86_64_v2_osbuild-depsolve-dnf.sha256sum] = "c5cfe196f1d2970df12dbd6ac37e8e33d0494655767c876fe63daa3a010c9023"

URI_x86_64_v2_osbuild-initrd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-initrd-187-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-initrd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-initrd}"
SRC_URI[x86_64_v2_osbuild-initrd.sha256sum] = "944c4f65120a58aaa7c656981b8b41364e27639da4b2a190b125598274d0334f"

URI_x86_64_v2_osbuild-luks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-luks2-187-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-luks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-luks2}"
SRC_URI[x86_64_v2_osbuild-luks2.sha256sum] = "ff627b0308869abce1f33b613a707c9c75a5f392b61281064539d3d45fa14112"

URI_x86_64_v2_osbuild-lvm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-lvm2-187-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-lvm2}"
SRC_URI[x86_64_v2_osbuild-lvm2.sha256sum] = "223030659af3844a910413b34cdc3d1422a62f049e09010a707fd205801d8d67"

URI_x86_64_v2_osbuild-ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-ostree-187-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-ostree}"
SRC_URI[x86_64_v2_osbuild-ostree.sha256sum] = "24e9dfd013d89136183f41516d4137c424647dccefb87321d97c9579f423c8b6"

URI_x86_64_v2_osbuild-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-selinux-187-1.el10.x86_64_v2.rpm;name=x86_64_v2_osbuild-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-selinux}"
SRC_URI[x86_64_v2_osbuild-selinux.sha256sum] = "0cd6878f10d1c0e74cd240b0f81aa966a52fbb68a25a2e84351727366b517a99"

URI_x86_64_v2_python3-osbuild = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-osbuild-187-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-osbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-osbuild}"
SRC_URI[x86_64_v2_python3-osbuild.sha256sum] = "889ca32783a2c7dccd6245e557796e0a6008f6e9f7e2493b3bcc5dd4d4460ba1"

URI_aarch64_osbuild = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-187-1.el10.aarch64.rpm;name=aarch64_osbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild}"
SRC_URI[aarch64_osbuild.sha256sum] = "99717512b8b30f228dbf9cf9eb2e85c714415bc5e00d0ef225c648daa2d2c504"

URI_aarch64_osbuild-container-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-container-selinux-187-1.el10.aarch64.rpm;name=aarch64_osbuild-container-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-container-selinux}"
SRC_URI[aarch64_osbuild-container-selinux.sha256sum] = "c35198a345a4e5eab25022e78a255825b9fa06dcc0f491fcfeda52349c9643bf"

URI_aarch64_osbuild-depsolve-dnf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-depsolve-dnf-187-1.el10.aarch64.rpm;name=aarch64_osbuild-depsolve-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-depsolve-dnf}"
SRC_URI[aarch64_osbuild-depsolve-dnf.sha256sum] = "708cac8ec9b53283008fe4590cbac3a5e21cbb289a2e88b063a248489de773b0"

URI_aarch64_osbuild-initrd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-initrd-187-1.el10.aarch64.rpm;name=aarch64_osbuild-initrd;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-initrd}"
SRC_URI[aarch64_osbuild-initrd.sha256sum] = "9a89008210cf7aa3c40a12df55c1945a11cf2eac0a56abd6de1fba74bb667dab"

URI_aarch64_osbuild-luks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-luks2-187-1.el10.aarch64.rpm;name=aarch64_osbuild-luks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-luks2}"
SRC_URI[aarch64_osbuild-luks2.sha256sum] = "ff4d2151938acddb1d1a2c02c8c5b8844661d4fe206c23ef026e7b1180a270de"

URI_aarch64_osbuild-lvm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-lvm2-187-1.el10.aarch64.rpm;name=aarch64_osbuild-lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-lvm2}"
SRC_URI[aarch64_osbuild-lvm2.sha256sum] = "473672e2f1d60c2e13de8f69a1b853c8d5cca4401b172af61274c1d34f0b9dca"

URI_aarch64_osbuild-ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-ostree-187-1.el10.aarch64.rpm;name=aarch64_osbuild-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-ostree}"
SRC_URI[aarch64_osbuild-ostree.sha256sum] = "77afd875f0813016263dca24e7a0b300e9a06967bb3e37508b28b11b544f9744"

URI_aarch64_osbuild-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-selinux-187-1.el10.aarch64.rpm;name=aarch64_osbuild-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-selinux}"
SRC_URI[aarch64_osbuild-selinux.sha256sum] = "17c831d9d63406ef1f8b6f453a968628c2f607bbd60e1db10b8493c7515c7c21"

URI_aarch64_python3-osbuild = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-osbuild-187-1.el10.aarch64.rpm;name=aarch64_python3-osbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-osbuild}"
SRC_URI[aarch64_python3-osbuild.sha256sum] = "a4584ac10aae8652bae31c59c22998cda656910f59242c95eb8a287a14dc4639"

RDEPENDS:osbuild = " \
 bash \
 bubblewrap \
 curl \
 e2fsprogs \
 glibc \
 osbuild-initrd \
 osbuild-selinux \
 policycoreutils \
 python3 \
 python3-librepo \
 python3-osbuild \
 qemu-img \
 skopeo \
 systemd \
 tar \
 util-linux \
 virtual//usr/bin/env \
 virtual/coreutils \
 "
RDEPENDS:osbuild-container-selinux = " \
 bash \
 container-selinux \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:osbuild-depsolve-dnf = " \
 osbuild \
 python3 \
 python3-dnf \
 "
RDEPENDS:osbuild-initrd = " \
 "
RDEPENDS:osbuild-luks2 = " \
 cryptsetup \
 osbuild \
 python3 \
 "
RDEPENDS:osbuild-lvm2 = " \
 lvm2 \
 osbuild \
 python3 \
 "
RDEPENDS:osbuild-ostree = " \
 osbuild \
 ostree \
 python3 \
 rpm-ostree \
 "
RDEPENDS:osbuild-selinux = " \
 bash \
 libselinux-utils \
 osbuild \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:python3-osbuild = " \
 python3 \
 python3-jsonschema \
 "
