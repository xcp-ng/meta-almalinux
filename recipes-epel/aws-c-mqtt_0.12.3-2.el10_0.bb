# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-mqtt"
PV = "0.12.3"
PR = "2.el10_0"
PACKAGES = " \
 aws-c-mqtt \
 aws-c-mqtt-devel \
 aws-c-mqtt-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-mqtt-0.12.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0007b2f9a3685d35fe1faa968e23a0b3c5aa6dac7020de348c9f2721a330d1e6"

URI_x86_64_v2_aws-c-mqtt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-mqtt-0.12.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-mqtt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-mqtt}"
SRC_URI[x86_64_v2_aws-c-mqtt.sha256sum] = "2d36d4f91c4dd6ca7cacf41cbd046486887383f332a1b59046884df2c94c6f19"

URI_x86_64_v2_aws-c-mqtt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-mqtt-devel-0.12.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-mqtt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-mqtt-devel}"
SRC_URI[x86_64_v2_aws-c-mqtt-devel.sha256sum] = "5aaf8ece42d87c6506cf8582b49f901c77de8ea8384fc0c5530339b2656ae811"

URI_x86_64_v2_aws-c-mqtt-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-mqtt-libs-0.12.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-mqtt-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-mqtt-libs}"
SRC_URI[x86_64_v2_aws-c-mqtt-libs.sha256sum] = "44a609a9f7019d3171597187aed96cc282d4c52690d00b0dff89996cf55aea42"

URI_aarch64_aws-c-mqtt = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-mqtt-0.12.3-2.el10_0.aarch64.rpm;name=aarch64_aws-c-mqtt;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-mqtt}"
SRC_URI[aarch64_aws-c-mqtt.sha256sum] = "9648fdefb24b1828e20006c1c7290e1c6e14461984c9cf7b7698a62726a42691"

URI_aarch64_aws-c-mqtt-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-mqtt-devel-0.12.3-2.el10_0.aarch64.rpm;name=aarch64_aws-c-mqtt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-mqtt-devel}"
SRC_URI[aarch64_aws-c-mqtt-devel.sha256sum] = "69476a2ae1dcc36460abb2e82c191118f557218092c49a4f901bb9aaa21f8f4b"

URI_aarch64_aws-c-mqtt-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-mqtt-libs-0.12.3-2.el10_0.aarch64.rpm;name=aarch64_aws-c-mqtt-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-mqtt-libs}"
SRC_URI[aarch64_aws-c-mqtt-libs.sha256sum] = "625de5c9bee4a8854e9c16b31efa99d2b66f821bedd4fd547bffa0afe5fe808f"

RDEPENDS:aws-c-mqtt = " \
 aws-c-common-libs \
 aws-c-io \
 aws-c-mqtt-libs \
 glibc \
 "
RDEPENDS:aws-c-mqtt-devel = " \
 aws-c-compression-devel \
 aws-c-http-devel \
 aws-c-io-devel \
 aws-c-mqtt-libs \
 cmake-filesystem \
 openssl-devel \
 "
RDEPENDS:aws-c-mqtt-libs = " \
 aws-c-common-libs \
 aws-c-http-libs \
 aws-c-io \
 glibc \
 "
