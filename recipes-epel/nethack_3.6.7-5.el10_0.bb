# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nethack"
PV = "3.6.7"
PR = "5.el10_0"
PACKAGES = " \
 nethack \
 nethack-bitmap-fonts \
 nethack-bitmap-fonts-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nethack-3.6.7-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25b2b6b5663e94cf2536b1076ed17f47696a86cad4f12490b1b2c22844a07d72"

URI_x86_64_v2_nethack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nethack-3.6.7-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nethack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nethack}"
SRC_URI[x86_64_v2_nethack.sha256sum] = "484fd69d59adc417335c6c4e878140800a15597a6bed5055cd68dde1eac69847"

URI_x86_64_v2_nethack-bitmap-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nethack-bitmap-fonts-3.6.7-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nethack-bitmap-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nethack-bitmap-fonts}"
SRC_URI[x86_64_v2_nethack-bitmap-fonts.sha256sum] = "c8a4eed03b6216659864b0aa7e140a8510d780a05344687ac8fa0a72e3c8109e"

URI_x86_64_v2_nethack-bitmap-fonts-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nethack-bitmap-fonts-core-3.6.7-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_nethack-bitmap-fonts-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nethack-bitmap-fonts-core}"
SRC_URI[x86_64_v2_nethack-bitmap-fonts-core.sha256sum] = "406b65e37cf1241acc8a2f7b79433b97494e2a1f3d76f98e43ddbebecea532c7"

URI_aarch64_nethack = "${EPEL_MIRROR}/aarch64/Packages/n/nethack-3.6.7-5.el10_0.aarch64.rpm;name=aarch64_nethack;unpack=0"
SRC_URI:append = " ${URI_aarch64_nethack}"
SRC_URI[aarch64_nethack.sha256sum] = "563ad013add1ae63021c9e13a3df3d3a5d7598f791631ba237b3d8a3473169e8"

URI_aarch64_nethack-bitmap-fonts = "${EPEL_MIRROR}/aarch64/Packages/n/nethack-bitmap-fonts-3.6.7-5.el10_0.noarch.rpm;name=aarch64_nethack-bitmap-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_nethack-bitmap-fonts}"
SRC_URI[aarch64_nethack-bitmap-fonts.sha256sum] = "110172bec7c5b03b5edecded671732db1866881852a5ce318fe8b9e897c988f8"

URI_aarch64_nethack-bitmap-fonts-core = "${EPEL_MIRROR}/aarch64/Packages/n/nethack-bitmap-fonts-core-3.6.7-5.el10_0.noarch.rpm;name=aarch64_nethack-bitmap-fonts-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_nethack-bitmap-fonts-core}"
SRC_URI[aarch64_nethack-bitmap-fonts-core.sha256sum] = "e37c469f7b2a389714721e7016afe44aa5ebfe5702a46e2696a59d4bc1f14810"

RDEPENDS:nethack = " \
 bash \
 glibc \
 libX11 \
 libXaw \
 libXext \
 libXmu \
 libXpm \
 libXt \
 ncurses-libs \
 nethack-bitmap-fonts-core \
 "
RDEPENDS:nethack-bitmap-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:nethack-bitmap-fonts-core = " \
 bash \
 mkfontscale \
 nethack-bitmap-fonts \
 virtual/coreutils \
 "
