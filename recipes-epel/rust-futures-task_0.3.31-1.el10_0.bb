# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-task"
PV = "0.3.31"
PR = "1.el10_0"
PACKAGES = " \
 rust-futures-task+alloc-devel \
 rust-futures-task+cfg-target-has-atomic-devel \
 rust-futures-task+default-devel \
 rust-futures-task+std-devel \
 rust-futures-task+unstable-devel \
 rust-futures-task-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-task-0.3.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef29c8c7df42afd358a9c7c1faefbb90a4938b95a91c130c064e82103df32af0"

URI_x86_64_v2_rust-futures-task+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+alloc-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-task+alloc-devel.sha256sum] = "b15704a3299b36abf9d0dd214c220ce1ec2fb3929ed450ce453d3d346960ab66"

URI_x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+cfg-target-has-atomic-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel.sha256sum] = "a720228de8ce6c72e2c81b563c21b9ab9444ddf6ffe0365c1220c41f405b990d"

URI_x86_64_v2_rust-futures-task+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+default-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+default-devel}"
SRC_URI[x86_64_v2_rust-futures-task+default-devel.sha256sum] = "0e23eb7ddb6f115819df275978ff05a1214d2ff57fa58c801b480bc81d8dd830"

URI_x86_64_v2_rust-futures-task+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+std-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+std-devel}"
SRC_URI[x86_64_v2_rust-futures-task+std-devel.sha256sum] = "c90cf18f2ae973e4957486f645237efc7376c6d43c5f0053902fbb920128066d"

URI_x86_64_v2_rust-futures-task+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+unstable-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-task+unstable-devel.sha256sum] = "88afcd00678155f3a49d9285b194a2bd3b4f797736667f9119e3b00a51d2453c"

URI_x86_64_v2_rust-futures-task-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task-devel}"
SRC_URI[x86_64_v2_rust-futures-task-devel.sha256sum] = "766be38c019993a11dd20b58ef9a55c02c41c053d8b7cc396dea9de304d41b31"

URI_aarch64_rust-futures-task+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+alloc-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-task+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+alloc-devel}"
SRC_URI[aarch64_rust-futures-task+alloc-devel.sha256sum] = "8e9fd3bf7f26c71f299c63af28b8bfe7f2573e52cf2c4a0efcf33364874dc1e8"

URI_aarch64_rust-futures-task+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+cfg-target-has-atomic-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-task+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-task+cfg-target-has-atomic-devel.sha256sum] = "654391eec8c3dc287f20324380c7f92e925d86d0569c6dcb5068db23e35b2ff9"

URI_aarch64_rust-futures-task+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+default-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-task+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+default-devel}"
SRC_URI[aarch64_rust-futures-task+default-devel.sha256sum] = "f918978baa2b39834817179d685a96cd88dc66a66199e5877f1265c679dbd387"

URI_aarch64_rust-futures-task+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+std-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-task+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+std-devel}"
SRC_URI[aarch64_rust-futures-task+std-devel.sha256sum] = "680b597006400e69d4cccb5d0f22acc069f210afd8171caaeda5375b050a6a35"

URI_aarch64_rust-futures-task+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+unstable-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-task+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+unstable-devel}"
SRC_URI[aarch64_rust-futures-task+unstable-devel.sha256sum] = "a5188ae7113704c277d0c07ecb1f4c39928c17555caad4a3a4480380dba63e4d"

URI_aarch64_rust-futures-task-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-task-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task-devel}"
SRC_URI[aarch64_rust-futures-task-devel.sha256sum] = "0f797593526023b563166d47f6b998108945c41a562ba725b4f132bc570e13a9"

RDEPENDS:rust-futures-task+alloc-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+default-devel = " \
 cargo \
 rust-futures-task+std-devel \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+std-devel = " \
 cargo \
 rust-futures-task+alloc-devel \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+unstable-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task-devel = " \
 cargo \
 rust \
 "
