# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernel"
PV = "6.12.0"
PR = "250.el10"
PACKAGES:x86_64_v2 = " \
 kernel \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-debug-uki-virt \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-modules-extra-matched \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"
PACKAGES:aarch64 = " \
 kernel \
 kernel-64k \
 kernel-64k-core \
 kernel-64k-debug \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 kernel-64k-debug-devel-matched \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 kernel-64k-devel \
 kernel-64k-devel-matched \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-modules-extra-matched \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kernel-6.12.0-250.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "febccc947c4b576b338ca88ec0e36550141f77eec0069a9d02019f8da269e0fe"

URI_x86_64_v2_kernel = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel}"
SRC_URI[x86_64_v2_kernel.sha256sum] = "e644112eb023535658bfb534a7b01f152a4d8a6eba0af6a2ed2ceb4ef868c48a"
RPROVIDES:kernel:x86_64_v2 = "virtual/kernel"

URI_x86_64_v2_kernel-abi-stablelists = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-abi-stablelists-6.12.0-250.el10.noarch.rpm;name=x86_64_v2_kernel-abi-stablelists;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-abi-stablelists}"
SRC_URI[x86_64_v2_kernel-abi-stablelists.sha256sum] = "967beb7187d3a0636ac9b2d82c79886951de76557b61c5f7fc176563c0c50ffc"

URI_x86_64_v2_kernel-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-core-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-core}"
SRC_URI[x86_64_v2_kernel-core.sha256sum] = "c495cb9a4a8396cb10bf5d6e74c42195d20abe75d69e43e556a0fc8b5b12d242"
RPROVIDES:kernel-core:x86_64_v2 = "virtual/kernel virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2"

URI_x86_64_v2_kernel-cross-headers = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-cross-headers-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-cross-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-cross-headers}"
SRC_URI[x86_64_v2_kernel-cross-headers.sha256sum] = "c60ba64e470173ff2e83e47bf0938c58fc8f5b07c5e9307d32c4f40be0bb8616"

URI_x86_64_v2_kernel-debug = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug}"
SRC_URI[x86_64_v2_kernel-debug.sha256sum] = "954ecb9934bf04b35170cb4c26a35ea2060bf215220dc598a8ad5538a09c6351"

URI_x86_64_v2_kernel-debug-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-core-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-core}"
SRC_URI[x86_64_v2_kernel-debug-core.sha256sum] = "7c5183e0c27dc5314105d12f037a0411f09850f2ce86cc41a6afe9202af1ec70"
RPROVIDES:kernel-debug-core:x86_64_v2 = "virtual/kernel virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2+debug"

URI_x86_64_v2_kernel-debug-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-devel}"
SRC_URI[x86_64_v2_kernel-debug-devel.sha256sum] = "4aa10a5086c2052b710abbc88bf541dc8d14867998888686f11b5e51eaf0cc10"
RPROVIDES:kernel-debug-devel:x86_64_v2 = "virtual/kernel-devel-uname-r"

URI_x86_64_v2_kernel-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-matched-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-devel-matched}"
SRC_URI[x86_64_v2_kernel-debug-devel-matched.sha256sum] = "b31b2f4b620f109fae6eafb0d69f156c620f386f2d832b4ea5903af417c7a1ca"

URI_x86_64_v2_kernel-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules}"
SRC_URI[x86_64_v2_kernel-debug-modules.sha256sum] = "8ca0db5a69f79b48c64261ba20e582a1eb2126660b28cc7b45b923e1b98bb7ac"
RPROVIDES:kernel-debug-modules:x86_64_v2 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_x86_64_v2_kernel-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-core-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules-core}"
SRC_URI[x86_64_v2_kernel-debug-modules-core.sha256sum] = "83c6e8e9a3eee6383aae7df362971bd47e20450def3c42f2ae40ac00af49af19"

URI_x86_64_v2_kernel-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-extra-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules-extra}"
SRC_URI[x86_64_v2_kernel-debug-modules-extra.sha256sum] = "2c53f046370b98b34430a05dfa52654824c5651e7cb002a026b529aaeeacef58"
RPROVIDES:kernel-debug-modules-extra:x86_64_v2 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_x86_64_v2_kernel-debug-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-uki-virt-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-uki-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-uki-virt}"
SRC_URI[x86_64_v2_kernel-debug-uki-virt.sha256sum] = "9b37e74e261e6e3802a4566b24cfe92e00f9848f145715c15140fd3211d4c443"
RPROVIDES:kernel-debug-uki-virt:x86_64_v2 = "virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2+debug"

URI_x86_64_v2_kernel-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-devel}"
SRC_URI[x86_64_v2_kernel-devel.sha256sum] = "e05217fd898dd6d4341c0440ef304f404f0354a14aa0ce983eed71b3a2e8667c"
RPROVIDES:kernel-devel:x86_64_v2 = "virtual/kernel-devel-uname-r"

URI_x86_64_v2_kernel-devel-matched = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-matched-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-devel-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-devel-matched}"
SRC_URI[x86_64_v2_kernel-devel-matched.sha256sum] = "a445f195ab9cafaa846c124ebb0a22d6bc0f81e82d80dfd9517e9b69efe4d706"

URI_x86_64_v2_kernel-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-doc-6.12.0-250.el10.noarch.rpm;name=x86_64_v2_kernel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-doc}"
SRC_URI[x86_64_v2_kernel-doc.sha256sum] = "60c96a5a3b86b0f42076b61915fd2e792460b7ab5e72d6638cd21b0865951736"

URI_x86_64_v2_kernel-headers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-headers-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-headers}"
SRC_URI[x86_64_v2_kernel-headers.sha256sum] = "dcc77ba739938eb46ac169174d72f54b4fa1d4b3aac94c982352a5155c588f07"

URI_x86_64_v2_kernel-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules}"
SRC_URI[x86_64_v2_kernel-modules.sha256sum] = "be4a22d70609046683834363a74abd09397be45ad3884d1687b1512c3288670f"
RPROVIDES:kernel-modules:x86_64_v2 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_x86_64_v2_kernel-modules-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-core-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-core}"
SRC_URI[x86_64_v2_kernel-modules-core.sha256sum] = "117de7a4d6d12dd0a417c51204b8a9483f19fba7ff5d40dadf9a8b46dd0866c0"

URI_x86_64_v2_kernel-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-extra}"
SRC_URI[x86_64_v2_kernel-modules-extra.sha256sum] = "7a53203531c7e21431bb07b53ece064772f804778170b9a8fc0a1ee2a916e55a"
RPROVIDES:kernel-modules-extra:x86_64_v2 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_x86_64_v2_kernel-modules-extra-matched = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-matched-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-extra-matched}"
SRC_URI[x86_64_v2_kernel-modules-extra-matched.sha256sum] = "46ad925710575b669760d8f022600dea9444f5090e0f4e26bd07f6a82f39227b"

URI_x86_64_v2_kernel-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools}"
SRC_URI[x86_64_v2_kernel-tools.sha256sum] = "25e41abcf38b7bc1ae6ce3b89878c07e4dca5c479a699384d958f0a6076a4e65"

URI_x86_64_v2_kernel-tools-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-libs-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools-libs}"
SRC_URI[x86_64_v2_kernel-tools-libs.sha256sum] = "b7e4b86da7859a66b3de5f7fc86a6fe492308da5c0313e308dd4c8a55dacbe18"

URI_x86_64_v2_kernel-tools-libs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-tools-libs-devel-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools-libs-devel}"
SRC_URI[x86_64_v2_kernel-tools-libs-devel.sha256sum] = "ba706e5b35b62e056ed4e42b3f464466fe3e7df66834a21950b61516c5d968db"

URI_x86_64_v2_kernel-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-uki-virt}"
SRC_URI[x86_64_v2_kernel-uki-virt.sha256sum] = "80b044c4e6d17c7e71b4ae8ae48bcecff011a7d0381692567d0d22dafba312cf"
RPROVIDES:kernel-uki-virt:x86_64_v2 = "virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2"

URI_x86_64_v2_kernel-uki-virt-addons = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-addons-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-uki-virt-addons}"
SRC_URI[x86_64_v2_kernel-uki-virt-addons.sha256sum] = "651a3d0792f8374375a0e60847b67413528f3ed9bdfd7e37a03ae84891346115"

URI_x86_64_v2_libperf = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libperf-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_libperf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libperf}"
SRC_URI[x86_64_v2_libperf.sha256sum] = "ba2cc5cda4b0308d426c5cb473feea9068e62832b9e01b16cf080e309a9c3259"

URI_x86_64_v2_perf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perf-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_perf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perf}"
SRC_URI[x86_64_v2_perf.sha256sum] = "ca7aa916eb6b07077b7dd57ddb25e052fff5077504dd58ca23b438aeff06aaa9"

URI_x86_64_v2_python3-perf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-perf-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_python3-perf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-perf}"
SRC_URI[x86_64_v2_python3-perf.sha256sum] = "1fc920fc6eaee30b07ebcc01cc41dbbec89c3ff447c96bf2219deea9cd8f062f"

URI_x86_64_v2_rtla = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rtla-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_rtla;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rtla}"
SRC_URI[x86_64_v2_rtla.sha256sum] = "a93adf03a0e8e2c448148b6b7ecef270001b5e62ba36f2460d46f1a29752e79a"

URI_x86_64_v2_rv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rv-6.12.0-250.el10.x86_64_v2.rpm;name=x86_64_v2_rv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rv}"
SRC_URI[x86_64_v2_rv.sha256sum] = "cca2bb8b7ab85b4fb3e8796638c449190f553ca29273318ccef87317aa8dabd5"

URI_aarch64_kernel = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel}"
SRC_URI[aarch64_kernel.sha256sum] = "ce3d1dfa3d524ef29e5cb0be6ecdda7d75e80fd8d01920beac72ebaaf421f983"
RPROVIDES:kernel:aarch64 = "virtual/kernel"

URI_aarch64_kernel-64k = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k}"
SRC_URI[aarch64_kernel-64k.sha256sum] = "2fc509f608a71b465c9df64ecbb94ef2a5773353f70c77e4035fb8129bd54364"

URI_aarch64_kernel-64k-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-core-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-core}"
SRC_URI[aarch64_kernel-64k-core.sha256sum] = "35c7408973f913f4ddd76b4ba631d46b32b29198c3dbdd5d1c4aa5dea935dce5"
RPROVIDES:kernel-64k-core:aarch64 = "virtual/kernel"

URI_aarch64_kernel-64k-debug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug}"
SRC_URI[aarch64_kernel-64k-debug.sha256sum] = "836ad78a2c6fe3cc0501e1145866ecf28d067901233d91b0f224277ef321e249"

URI_aarch64_kernel-64k-debug-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-core-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-core}"
SRC_URI[aarch64_kernel-64k-debug-core.sha256sum] = "335eb0500a4e060b83dce8fe944f38ec87b2afe45c25a0cc0388447ee6491472"
RPROVIDES:kernel-64k-debug-core:aarch64 = "virtual/kernel"

URI_aarch64_kernel-64k-debug-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-devel}"
SRC_URI[aarch64_kernel-64k-debug-devel.sha256sum] = "c17ca5098b4d6b98705f5389d430c59238580a427210c59934f3ea156bbd3973"
RPROVIDES:kernel-64k-debug-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-64k-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-matched-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-devel-matched}"
SRC_URI[aarch64_kernel-64k-debug-devel-matched.sha256sum] = "4ce6b0b8e756a1a97b268c8fbaf7ae71f593e634170f0e023b485dbcf420a1c9"

URI_aarch64_kernel-64k-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules}"
SRC_URI[aarch64_kernel-64k-debug-modules.sha256sum] = "1409aa6893a31cd269eacf2c8615c63b0c7cca5315ca383265144a164e328798"
RPROVIDES:kernel-64k-debug-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-64k-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-core-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules-core}"
SRC_URI[aarch64_kernel-64k-debug-modules-core.sha256sum] = "81d212084d88288e07d8ef543b9bb19fb59739ea2fb5b54eba522b1b55ae6498"

URI_aarch64_kernel-64k-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-extra-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules-extra}"
SRC_URI[aarch64_kernel-64k-debug-modules-extra.sha256sum] = "cc4f85190f8729ae67054bac724df94f2ddcdc3d35cb9bbddd4579625b279cea"
RPROVIDES:kernel-64k-debug-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-64k-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-devel}"
SRC_URI[aarch64_kernel-64k-devel.sha256sum] = "33e61c8bb7e50a43734f3dccbb578b9e029ada1f2ad7de013e66a60ba76b5150"
RPROVIDES:kernel-64k-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-64k-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-matched-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-devel-matched}"
SRC_URI[aarch64_kernel-64k-devel-matched.sha256sum] = "8c5c9ce18ced0f5b97039768a369342e77fb3871977a0c27b46c8edd3298352f"

URI_aarch64_kernel-64k-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules}"
SRC_URI[aarch64_kernel-64k-modules.sha256sum] = "a7fd0ebcb33e91a7c83220e9cd9901d0a1e15367b58d099176faae4535f9b0ea"
RPROVIDES:kernel-64k-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-64k-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-core-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules-core}"
SRC_URI[aarch64_kernel-64k-modules-core.sha256sum] = "3478d1ed384c05ed06638e8a9c7957dd37b30e30deaff5e408649492316e62a2"

URI_aarch64_kernel-64k-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-extra-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-64k-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules-extra}"
SRC_URI[aarch64_kernel-64k-modules-extra.sha256sum] = "7641bf9bc47f7316a91304cfd6226b4f290140ecbd45c0e5047ea0b02db2ca96"
RPROVIDES:kernel-64k-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-abi-stablelists = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-abi-stablelists-6.12.0-250.el10.noarch.rpm;name=aarch64_kernel-abi-stablelists;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-abi-stablelists}"
SRC_URI[aarch64_kernel-abi-stablelists.sha256sum] = "967beb7187d3a0636ac9b2d82c79886951de76557b61c5f7fc176563c0c50ffc"

URI_aarch64_kernel-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-core-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-core}"
SRC_URI[aarch64_kernel-core.sha256sum] = "b52cda5780d99d847de10f04654972ee887b0742578153942c8bd44b2a7e7a51"
RPROVIDES:kernel-core:aarch64 = "virtual/kernel virtual/kernel-uname-r_eq_6.12.0-250.el10.aarch64"

URI_aarch64_kernel-cross-headers = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-cross-headers-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-cross-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-cross-headers}"
SRC_URI[aarch64_kernel-cross-headers.sha256sum] = "10d3bae4801d72d3ab8feb20b918d48f1924631b7b569c59f766142d874ba27e"

URI_aarch64_kernel-debug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug}"
SRC_URI[aarch64_kernel-debug.sha256sum] = "28db50465b83abd3d349ecb7901f7644d1e67a5e3fac80bafc77bd77834f9acf"

URI_aarch64_kernel-debug-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-core-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-debug-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-core}"
SRC_URI[aarch64_kernel-debug-core.sha256sum] = "1341555bb6d5a4f7fd84899e1db8692c12be0e3096154b85f5e78b62d326c8c2"
RPROVIDES:kernel-debug-core:aarch64 = "virtual/kernel"

URI_aarch64_kernel-debug-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-devel}"
SRC_URI[aarch64_kernel-debug-devel.sha256sum] = "00aee7b4d22f15ea5de525fcc14daf25cf11c25ff66c32f72873cfe741a10155"
RPROVIDES:kernel-debug-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-matched-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-devel-matched}"
SRC_URI[aarch64_kernel-debug-devel-matched.sha256sum] = "05247f2dc413059ddeb76d0f85e5f29fa4feb7caeecb1ac861a9630a16692afe"

URI_aarch64_kernel-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-debug-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules}"
SRC_URI[aarch64_kernel-debug-modules.sha256sum] = "7559b9482be6c3ed045290ce71ecce5b26a3ffa53402b602a985e2b5ecb6135b"
RPROVIDES:kernel-debug-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-core-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules-core}"
SRC_URI[aarch64_kernel-debug-modules-core.sha256sum] = "cf51a0615794ce4b679132f8f51fef7fbc61c2a362ce844c0991c48e96c8856e"

URI_aarch64_kernel-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-extra-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules-extra}"
SRC_URI[aarch64_kernel-debug-modules-extra.sha256sum] = "e76fe70af73555a1a2b6ef970d9f75b3330a0627da3d03f0ccf004f541178833"
RPROVIDES:kernel-debug-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-devel}"
SRC_URI[aarch64_kernel-devel.sha256sum] = "01d06e73c375f6b38bfd564be63e83a6d63b1d998d772b357a4c4349e200288f"
RPROVIDES:kernel-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-matched-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-devel-matched}"
SRC_URI[aarch64_kernel-devel-matched.sha256sum] = "d40db178dc2a5bdb70c4f6a7aaa67d3b5bb2e961b8fc7b36e2307311285befdb"

URI_aarch64_kernel-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-doc-6.12.0-250.el10.noarch.rpm;name=aarch64_kernel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-doc}"
SRC_URI[aarch64_kernel-doc.sha256sum] = "60c96a5a3b86b0f42076b61915fd2e792460b7ab5e72d6638cd21b0865951736"

URI_aarch64_kernel-headers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-headers-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-headers}"
SRC_URI[aarch64_kernel-headers.sha256sum] = "2e09190ef02fc1249cfd50c475b274e82f786069203dca68725e5e1c2d79d076"

URI_aarch64_kernel-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules}"
SRC_URI[aarch64_kernel-modules.sha256sum] = "69cf31b72f64e98485fbf733e221c5fef75b499b99a9c3a34b961b02c504b393"
RPROVIDES:kernel-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-core-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-core}"
SRC_URI[aarch64_kernel-modules-core.sha256sum] = "932200a1e133c487a1c23dbd0f1a662dce2ed746913ef132bc8307bd2e9124af"

URI_aarch64_kernel-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-extra}"
SRC_URI[aarch64_kernel-modules-extra.sha256sum] = "c3de955e9d552b409313bb97a749074234f20f56dceb33b3b4d98c5c6f2f277a"
RPROVIDES:kernel-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-modules-extra-matched = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-matched-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-modules-extra-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-extra-matched}"
SRC_URI[aarch64_kernel-modules-extra-matched.sha256sum] = "715e273cbd042d4cc5e274234f7d107c86d2ad177e43f68f62e957e16b14a1ee"

URI_aarch64_kernel-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools}"
SRC_URI[aarch64_kernel-tools.sha256sum] = "49385412bea691feb8072919bca790e16274bcd0b369b5e372ffc24c5ff9891b"

URI_aarch64_kernel-tools-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-libs-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-tools-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools-libs}"
SRC_URI[aarch64_kernel-tools-libs.sha256sum] = "49aac2b74cf152bd95c0660655e278c2e9a9f12ff8d31d04d444ae34521c5ff2"

URI_aarch64_kernel-tools-libs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-tools-libs-devel-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-tools-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools-libs-devel}"
SRC_URI[aarch64_kernel-tools-libs-devel.sha256sum] = "d2ad3981cc3f7e46b2acb1f02fec02768fa0285e38cafce514b59675975f9093"

URI_aarch64_kernel-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-uki-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-uki-virt}"
SRC_URI[aarch64_kernel-uki-virt.sha256sum] = "a7aeb880d91a5a3f517bee95a9b25f3359d02d976ea6d334709492e0068bea5a"
RPROVIDES:kernel-uki-virt:aarch64 = "virtual/kernel-uname-r_eq_6.12.0-250.el10.aarch64"

URI_aarch64_kernel-uki-virt-addons = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-addons-6.12.0-250.el10.aarch64.rpm;name=aarch64_kernel-uki-virt-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-uki-virt-addons}"
SRC_URI[aarch64_kernel-uki-virt-addons.sha256sum] = "81ad30b4340fa0ab005a6c3c4957f9b45bf240f747d00678e4acd0e34b9ddda2"

URI_aarch64_libperf = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libperf-6.12.0-250.el10.aarch64.rpm;name=aarch64_libperf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libperf}"
SRC_URI[aarch64_libperf.sha256sum] = "dd2a0000f6af2deefa0fb9c8c444472a3ac17da8690f76556ca90293b8b2c4f9"

URI_aarch64_perf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perf-6.12.0-250.el10.aarch64.rpm;name=aarch64_perf;unpack=0"
SRC_URI:append = " ${URI_aarch64_perf}"
SRC_URI[aarch64_perf.sha256sum] = "be4a4d80952ec160b6692c59e39273f047f63178b52365489647b4941e8313df"

URI_aarch64_python3-perf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-perf-6.12.0-250.el10.aarch64.rpm;name=aarch64_python3-perf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-perf}"
SRC_URI[aarch64_python3-perf.sha256sum] = "fd52310b1b3b62c0b5a8883ec51013827019d6f935fec04a1c65c35f33d63806"

URI_aarch64_rtla = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rtla-6.12.0-250.el10.aarch64.rpm;name=aarch64_rtla;unpack=0"
SRC_URI:append = " ${URI_aarch64_rtla}"
SRC_URI[aarch64_rtla.sha256sum] = "36823cd3fa59706b60ecf51a2c7514e465e5db2c7f434b978a2479655000b8f4"

URI_aarch64_rv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rv-6.12.0-250.el10.aarch64.rpm;name=aarch64_rv;unpack=0"
SRC_URI:append = " ${URI_aarch64_rv}"
SRC_URI[aarch64_rv.sha256sum] = "ebfa0081fc5eff1ea537d1a928946688b5f0f3081fb060b7527f72fbaf93f377"

RDEPENDS:kernel = " \
 kernel-core \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 "
RDEPENDS:kernel-abi-stablelists = " \
 "
RDEPENDS:kernel-core = " \
 bash \
 dracut \
 kernel-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-cross-headers = " \
 "
RDEPENDS:kernel-debug = " \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 "
RDEPENDS:kernel-debug-core = " \
 bash \
 dracut \
 kernel-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-debug-devel-matched = " \
 kernel-debug-core \
 kernel-debug-devel \
 "
RDEPENDS:kernel-debug-modules:x86_64_v2 = " \
 bash \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules-core:aarch64 = " \
 bash \
 kernel-debug-core \
"
RDEPENDS:kernel-debug-modules-extra:x86_64_v2 = " \
 bash \
 kernel-debug-modules \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules-extra:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-uki-virt = " \
 bash \
 kernel-debug-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-devel-matched = " \
 kernel-core \
 kernel-devel \
 "
RDEPENDS:kernel-doc = " \
 "
RDEPENDS:kernel-headers = " \
 "
RDEPENDS:kernel-modules:x86_64_v2 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2 \
"
RDEPENDS:kernel-modules:aarch64 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-250.el10.aarch64 \
"
RDEPENDS:kernel-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2 \
"
RDEPENDS:kernel-modules-core:aarch64 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-250.el10.aarch64 \
"
RDEPENDS:kernel-modules-extra:x86_64_v2 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2 \
"
RDEPENDS:kernel-modules-extra:aarch64 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-250.el10.aarch64 \
"
RDEPENDS:kernel-modules-extra-matched = " \
 "
RDEPENDS:kernel-tools:x86_64_v2 = " \
 glibc \
 kernel-tools-libs \
 libcap \
 libnl3 \
 ncurses-libs \
 pciutils-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools:aarch64 = " \
 glibc \
 kernel-tools-libs \
 ncurses-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools-libs = " \
 bash \
 glibc \
 "
RDEPENDS:kernel-tools-libs-devel = " \
 glibc \
 kernel-tools \
 kernel-tools-libs \
 python3 \
 "
RDEPENDS:kernel-uki-virt = " \
 bash \
 kernel-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-uki-virt-addons = " \
 kernel-uki-virt \
 systemd \
 "
RDEPENDS:libperf = " \
 glibc \
 "
RDEPENDS:perf:x86_64_v2 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:perf:aarch64 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:x86_64_v2 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:aarch64 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:rtla = " \
 glibc \
 kernel-tools-libs \
 libbpf \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:rv = " \
 glibc \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:kernel-64k = " \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 "
RDEPENDS:kernel-64k-core = " \
 bash \
 dracut \
 kernel-64k-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug = " \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 "
RDEPENDS:kernel-64k-debug-core = " \
 bash \
 dracut \
 kernel-64k-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-debug-devel-matched = " \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 "
RDEPENDS:kernel-64k-debug-modules = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-debug-modules-core = " \
 bash \
 kernel-64k-debug-core \
 "
RDEPENDS:kernel-64k-debug-modules-extra = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-devel-matched = " \
 kernel-64k-core \
 kernel-64k-devel \
 "
RDEPENDS:kernel-64k-modules = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules-core \
 "
RDEPENDS:kernel-64k-modules-core = " \
 bash \
 kernel-64k-core \
 "
RDEPENDS:kernel-64k-modules-extra = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_ rpm/virtual/kernel rpm/virtual/kernel-devel-uname-r rpm/virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2 rpm/virtual/kernel-uname-r_eq_6.12.0-250.el10.x86_64_v2+debug rpm/virtual/kmod_cuse.ko_ rpm/virtual/kmod_l2tp_ppp.ko_"

PROVIDES:append:aarch64 = " rpm/virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_ rpm/virtual/kernel rpm/virtual/kernel-devel-uname-r rpm/virtual/kernel-uname-r_eq_6.12.0-250.el10.aarch64 rpm/virtual/kmod_cuse.ko_ rpm/virtual/kmod_l2tp_ppp.ko_"
