# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-pem"
PV = "0.2.4"
PR = "30.el10_0"
PACKAGES = " \
 ghc-pem \
 ghc-pem-devel \
 ghc-pem-doc \
 ghc-pem-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-pem-0.2.4-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f482f8e2d9cc92748a14beba2064e8d1bc0b7d84a9b8f385d4d223f979277133"

URI_x86_64_v2_ghc-pem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pem-0.2.4-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pem}"
SRC_URI[x86_64_v2_ghc-pem.sha256sum] = "b7361be4af1692fa0bcba5f437b2ea9c1b211c220fdecee37522c91554143c83"

URI_x86_64_v2_ghc-pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pem-devel-0.2.4-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pem-devel}"
SRC_URI[x86_64_v2_ghc-pem-devel.sha256sum] = "cbe107fae313d88aafdd2eb66d234c99eb84bdc4567f57adb294a3bcdc2444ac"

URI_x86_64_v2_ghc-pem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pem-doc-0.2.4-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pem-doc}"
SRC_URI[x86_64_v2_ghc-pem-doc.sha256sum] = "ca986798e71144fad93d53ea6ec2e8e372d68e3748fcfd1cfa555d82a039a1cc"

URI_x86_64_v2_ghc-pem-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pem-prof-0.2.4-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pem-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pem-prof}"
SRC_URI[x86_64_v2_ghc-pem-prof.sha256sum] = "e1347ff8e2ebd6a477f68a851ef6d2dc35341740cad5c8abcf4e4b7130ebace0"

URI_aarch64_ghc-pem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pem-0.2.4-30.el10_0.aarch64.rpm;name=aarch64_ghc-pem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pem}"
SRC_URI[aarch64_ghc-pem.sha256sum] = "70806af6b07b135cdaef56a8463df4b60476d7e181d57eb3b131d6fc54cf489c"

URI_aarch64_ghc-pem-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pem-devel-0.2.4-30.el10_0.aarch64.rpm;name=aarch64_ghc-pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pem-devel}"
SRC_URI[aarch64_ghc-pem-devel.sha256sum] = "55ac83d6cd3f61e7206fcb0daa738c733af66ce8cce199a625484bbfb57ca398"

URI_aarch64_ghc-pem-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pem-doc-0.2.4-30.el10_0.noarch.rpm;name=aarch64_ghc-pem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pem-doc}"
SRC_URI[aarch64_ghc-pem-doc.sha256sum] = "0d2f99fe17bd3109931dc311b12a62a3aa7428a133f207e079cc8cc477fbce22"

URI_aarch64_ghc-pem-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pem-prof-0.2.4-30.el10_0.aarch64.rpm;name=aarch64_ghc-pem-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pem-prof}"
SRC_URI[aarch64_ghc-pem-prof.sha256sum] = "9d714bffdf46836522405a5a13d0d02ea18db35e02e4cac94794122c3c20ac81"

RDEPENDS:ghc-pem = " \
 ghc-array \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-memory \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-pem-devel = " \
 ghc-base-devel \
 ghc-basement-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-memory-devel \
 ghc-pem \
 "
RDEPENDS:ghc-pem-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pem-prof = " \
 ghc-base-prof \
 ghc-basement-prof \
 ghc-bytestring-prof \
 ghc-memory-prof \
 ghc-pem-devel \
 "
