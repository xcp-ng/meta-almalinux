# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-eapache-resiliency"
PV = "1.2.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-eapache-resiliency-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-eapache-resiliency-1.2.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d9d270cdd1fd29d4193095e6cd70cbfa02f3ee9e82a71352f88d2afca936a44"

URI_x86_64_v2_golang-github-eapache-resiliency-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-eapache-resiliency-devel-1.2.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-eapache-resiliency-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-eapache-resiliency-devel}"
SRC_URI[x86_64_v2_golang-github-eapache-resiliency-devel.sha256sum] = "0239bbad56e9d6dbafd4f058d87abc6eeb069680f6f210b5087da92aa5eac537"

URI_aarch64_golang-github-eapache-resiliency-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-eapache-resiliency-devel-1.2.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-eapache-resiliency-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-eapache-resiliency-devel}"
SRC_URI[aarch64_golang-github-eapache-resiliency-devel.sha256sum] = "78759d03bdf690e5c83e0cca81aac5b7c271821c8b52cfb32ccd447584a2bc44"

RDEPENDS:golang-github-eapache-resiliency-devel = " \
 go-filesystem \
 "
