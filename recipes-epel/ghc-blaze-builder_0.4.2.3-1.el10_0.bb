# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-blaze-builder"
PV = "0.4.2.3"
PR = "1.el10_0"
PACKAGES = " \
 ghc-blaze-builder \
 ghc-blaze-builder-devel \
 ghc-blaze-builder-doc \
 ghc-blaze-builder-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-blaze-builder-0.4.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbd1c6ff959cc4621ddbd7fb6b8ef606c8a698ee8bd9623032454cd09fb9d287"

URI_x86_64_v2_ghc-blaze-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-builder-0.4.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-blaze-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-builder}"
SRC_URI[x86_64_v2_ghc-blaze-builder.sha256sum] = "f7c5a37bd06b06c50aeb8a5daa16b3fd591b0346a34f2fb1bf7a54291e828946"

URI_x86_64_v2_ghc-blaze-builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-builder-devel-0.4.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-blaze-builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-builder-devel}"
SRC_URI[x86_64_v2_ghc-blaze-builder-devel.sha256sum] = "0851bf75bba4a849db3867a0ae019188f8e04bd2e5d0cd74979a6000814d6c08"

URI_x86_64_v2_ghc-blaze-builder-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-builder-doc-0.4.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-blaze-builder-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-builder-doc}"
SRC_URI[x86_64_v2_ghc-blaze-builder-doc.sha256sum] = "663eb836eaa49a44edaeffa285f7077b93f4ee3cb95b935df727c0be4a0a62b1"

URI_x86_64_v2_ghc-blaze-builder-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-builder-prof-0.4.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-blaze-builder-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-builder-prof}"
SRC_URI[x86_64_v2_ghc-blaze-builder-prof.sha256sum] = "2def8784c1f44bc6d70bd961342140e4c0c8eb2eb1dfc60e4b2cbed6be54efcc"

URI_aarch64_ghc-blaze-builder = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-builder-0.4.2.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-blaze-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-builder}"
SRC_URI[aarch64_ghc-blaze-builder.sha256sum] = "46ff9c7255329fd09b408635905888eec2c17363f7b8c12516068240ddaea134"

URI_aarch64_ghc-blaze-builder-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-builder-devel-0.4.2.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-blaze-builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-builder-devel}"
SRC_URI[aarch64_ghc-blaze-builder-devel.sha256sum] = "77776cb23500ca5cd3fe2d523a834569c1273b6c3def9011e822b5c0e74e554a"

URI_aarch64_ghc-blaze-builder-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-builder-doc-0.4.2.3-1.el10_0.noarch.rpm;name=aarch64_ghc-blaze-builder-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-builder-doc}"
SRC_URI[aarch64_ghc-blaze-builder-doc.sha256sum] = "af9f30c4fee452075716902af38ab906848c13f202528cf21ddf66ad62e2c583"

URI_aarch64_ghc-blaze-builder-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-builder-prof-0.4.2.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-blaze-builder-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-builder-prof}"
SRC_URI[aarch64_ghc-blaze-builder-prof.sha256sum] = "bad1fb78cd57e928ec4e47914e72c659f9b3a423cd7b1e91943696c734f7817a"

RDEPENDS:ghc-blaze-builder = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-blaze-builder-devel = " \
 ghc-base-devel \
 ghc-blaze-builder \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-blaze-builder-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-blaze-builder-prof = " \
 ghc-base-prof \
 ghc-blaze-builder-devel \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-text-prof \
 "
