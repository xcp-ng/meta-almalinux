# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "containerd"
PV = "2.2.5"
PR = "1.el10_3"
PACKAGES = " \
 containerd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/containerd-2.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "966d171accabe72a3ab63bacbfa472e77f87088e487c5d1a652e3cee82eb741e"

URI_x86_64_v2_containerd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/containerd-2.2.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_containerd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_containerd}"
SRC_URI[x86_64_v2_containerd.sha256sum] = "d8dc1821f71f92148ee8d64486195a4670ac36cc2de4c845a3bbd2b1b6b72a05"

URI_aarch64_containerd = "${EPEL_MIRROR}/aarch64/Packages/c/containerd-2.2.5-1.el10_3.aarch64.rpm;name=aarch64_containerd;unpack=0"
SRC_URI:append = " ${URI_aarch64_containerd}"
SRC_URI[aarch64_containerd.sha256sum] = "8e9dfef3760834769b9d1e75fe702685a84bc32ebf1838edc26591a7cd2cbabc"

RDEPENDS:containerd = " \
 bash \
 glibc \
 "
