# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Finance-Quote"
PV = "1.7100"
PR = "1.el10_3"
PACKAGES = " \
 perl-Finance-Quote \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Finance-Quote-1.7100-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dbe7ab132cc67fa9b655e3468eeedae8a1749a9d37dabaf91f1a0275b5a955e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Finance-Quote-1.7100-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Finance-Quote;unpack=0"
SRC_URI[x86_64_v2_perl-Finance-Quote.sha256sum] = "c04f359495dbcd093bd5112e7d10a985dfe14dae514c21ed49949b04aff21770"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Finance-Quote-1.7100-1.el10_3.noarch.rpm;name=aarch64_perl-Finance-Quote;unpack=0"
SRC_URI[aarch64_perl-Finance-Quote.sha256sum] = "0916bd3ff75c2f4b849afa8e05a783711f628272492e36a49233cfb8b514de78"

RDEPENDS:perl-Finance-Quote = " \
 perl-Carp \
 perl-DateTime-Format-Strptime \
 perl-Encode \
 perl-Exporter \
 perl-Finance-Quote \
 perl-HTML-Parser \
 perl-HTML-TableExtract \
 perl-HTML-Tree \
 perl-HTML-TreeBuilder-XPath \
 perl-HTTP-CookieJar \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO-Compress \
 perl-IO-String \
 perl-JSON \
 perl-LWP-Protocol-https \
 perl-Module-Load \
 perl-POSIX \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-String-Util \
 perl-Text-Template \
 perl-Time-Piece \
 perl-TimeDate \
 perl-URI \
 perl-Web-Scraper \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-if \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 "
