# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdivide"
PV = "5.2.0"
PR = "1.el10_0"
PACKAGES = " \
 libdivide-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdivide-5.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc0cf9dacdfe81f2e47264ccbfae98b75c0e51378f8dfa8c9d97b38df4fae147"

URI_x86_64_v2_libdivide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdivide-devel-5.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdivide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdivide-devel}"
SRC_URI[x86_64_v2_libdivide-devel.sha256sum] = "e2bf5c0ea16c8363de17e9744383ac3f49fe91fe81a3c26d868925e90ceaf48f"

URI_aarch64_libdivide-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdivide-devel-5.2.0-1.el10_0.aarch64.rpm;name=aarch64_libdivide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdivide-devel}"
SRC_URI[aarch64_libdivide-devel.sha256sum] = "82d6bbacc7d6fb9015c367d99d5553e995822538f371eb389c0b5707140c075d"

RDEPENDS:libdivide-devel = " \
 cmake-filesystem \
 "
