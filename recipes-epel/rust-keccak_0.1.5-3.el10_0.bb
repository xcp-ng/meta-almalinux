# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-keccak"
PV = "0.1.5"
PR = "3.el10_0"
PACKAGES = " \
 rust-keccak+asm-devel \
 rust-keccak+default-devel \
 rust-keccak+no_unroll-devel \
 rust-keccak+simd-devel \
 rust-keccak-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-keccak-0.1.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8cbec04ad3622933a1ec33a62cb3fd2d6a93465b185f6f218e0c5ed5403e8a9"

URI_x86_64_v2_rust-keccak+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+asm-devel-0.1.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+asm-devel}"
SRC_URI[x86_64_v2_rust-keccak+asm-devel.sha256sum] = "f50056acf7cc51b8c3a58f753bf0630398efedfe3e3537b7c0aa5723a8f03c0c"

URI_x86_64_v2_rust-keccak+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+default-devel-0.1.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+default-devel}"
SRC_URI[x86_64_v2_rust-keccak+default-devel.sha256sum] = "642f2b4c199df59feada354159c754e1421000715382f31012ca6146debfb7c8"

URI_x86_64_v2_rust-keccak+no_unroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+no_unroll-devel-0.1.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+no_unroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+no_unroll-devel}"
SRC_URI[x86_64_v2_rust-keccak+no_unroll-devel.sha256sum] = "b39557ea633b0213e2d7e5678689758a3877b0f6d9bf77d6173d156048a4fa0a"

URI_x86_64_v2_rust-keccak+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak+simd-devel-0.1.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak+simd-devel}"
SRC_URI[x86_64_v2_rust-keccak+simd-devel.sha256sum] = "9e6f15ed4c10c677de4d5bf2cde0f883592e4fe3f13595a06bb83bf563a2e4e7"

URI_x86_64_v2_rust-keccak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-keccak-devel-0.1.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-keccak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-keccak-devel}"
SRC_URI[x86_64_v2_rust-keccak-devel.sha256sum] = "8c3c5254168ac0540a40e04c1a601cceb248180005d8f923175182d255c6e80d"

URI_aarch64_rust-keccak+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+asm-devel-0.1.5-3.el10_0.noarch.rpm;name=aarch64_rust-keccak+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+asm-devel}"
SRC_URI[aarch64_rust-keccak+asm-devel.sha256sum] = "c9a75416287989b82cddcfddb1c6acfe2409ba92de949e7bf4596df4d0134756"

URI_aarch64_rust-keccak+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+default-devel-0.1.5-3.el10_0.noarch.rpm;name=aarch64_rust-keccak+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+default-devel}"
SRC_URI[aarch64_rust-keccak+default-devel.sha256sum] = "4ce9b5b8b92431eb454d7e385c768b56f5ef60f48630c8e47adbc21cf08ff5b2"

URI_aarch64_rust-keccak+no_unroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+no_unroll-devel-0.1.5-3.el10_0.noarch.rpm;name=aarch64_rust-keccak+no_unroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+no_unroll-devel}"
SRC_URI[aarch64_rust-keccak+no_unroll-devel.sha256sum] = "5ae106dfe2d29c08f48912c81bb8ac26f39a3d3c3bdcd9483c6f6899f3e55823"

URI_aarch64_rust-keccak+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak+simd-devel-0.1.5-3.el10_0.noarch.rpm;name=aarch64_rust-keccak+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak+simd-devel}"
SRC_URI[aarch64_rust-keccak+simd-devel.sha256sum] = "bdc10d3bbff7085ae2e77fffe8e04e878a435e9d9f5a4707629701fae2ac5ad9"

URI_aarch64_rust-keccak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-keccak-devel-0.1.5-3.el10_0.noarch.rpm;name=aarch64_rust-keccak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-keccak-devel}"
SRC_URI[aarch64_rust-keccak-devel.sha256sum] = "989b5cd84131e097b65085d83b08ee72f36bf55682aef5be7ab470a61a30914b"

RDEPENDS:rust-keccak+asm-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak+default-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak+no_unroll-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak+simd-devel = " \
 cargo \
 rust-keccak-devel \
 "
RDEPENDS:rust-keccak-devel = " \
 cargo \
 rust-cpufeatures+default-devel \
 "
