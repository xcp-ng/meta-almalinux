# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest"
PV = "2.8.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-pest+const_prec_climber-devel \
 rust-pest+default-devel \
 rust-pest+memchr-devel \
 rust-pest+miette-error-devel \
 rust-pest+pretty-print-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest-2.8.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03e962b774387978bb91067a941e824fbf206d7f7eaa7aeece15097d3f119326"

URI_x86_64_v2_rust-pest+const_prec_climber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+const_prec_climber-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+const_prec_climber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+const_prec_climber-devel}"
SRC_URI[x86_64_v2_rust-pest+const_prec_climber-devel.sha256sum] = "db7483ef5bf9155596adb6ce15295d78216912ab2aeb6f221b4873448ea660da"

URI_x86_64_v2_rust-pest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+default-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+default-devel}"
SRC_URI[x86_64_v2_rust-pest+default-devel.sha256sum] = "4bf5d4c7d4dacea7c9df2b692b88dd094617685898958a47a26f59c50602d255"

URI_x86_64_v2_rust-pest+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+memchr-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+memchr-devel}"
SRC_URI[x86_64_v2_rust-pest+memchr-devel.sha256sum] = "996cdcecbcb5504a263e72206b4dc97bc6ac75f459f676840a278f077bd304f1"

URI_x86_64_v2_rust-pest+miette-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+miette-error-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+miette-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+miette-error-devel}"
SRC_URI[x86_64_v2_rust-pest+miette-error-devel.sha256sum] = "c96453d61261e3f710ffe0e69b4ccbc472488ef202d63e3bb07b462e9e1ab882"

URI_x86_64_v2_rust-pest+pretty-print-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+pretty-print-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+pretty-print-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+pretty-print-devel}"
SRC_URI[x86_64_v2_rust-pest+pretty-print-devel.sha256sum] = "361568cf0e104aaad7ebc30e603b4a5b18c303c84cc6a7566670b23f1c228c2f"

URI_x86_64_v2_rust-pest+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+std-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+std-devel}"
SRC_URI[x86_64_v2_rust-pest+std-devel.sha256sum] = "ec2a80dc128def009d901e6c533ef0990d2df15f69fbaed7500cb0ed7cdf65db"

URI_x86_64_v2_rust-pest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest-devel-2.8.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest-devel}"
SRC_URI[x86_64_v2_rust-pest-devel.sha256sum] = "60e00596a8ddc91066ccea8d06cd436e7f75f0aa24cdd7f3dda8f75ade796e93"

URI_aarch64_rust-pest+const_prec_climber-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+const_prec_climber-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest+const_prec_climber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+const_prec_climber-devel}"
SRC_URI[aarch64_rust-pest+const_prec_climber-devel.sha256sum] = "c95084df5202639c9f294d3b2076f7f6119b131cc0aea54f965203b8b3b92dda"

URI_aarch64_rust-pest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+default-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+default-devel}"
SRC_URI[aarch64_rust-pest+default-devel.sha256sum] = "9b16a78b0a5064bf63a111d9e85a6a147a0a9bf5eef11cf04723367aebcdf12c"

URI_aarch64_rust-pest+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+memchr-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+memchr-devel}"
SRC_URI[aarch64_rust-pest+memchr-devel.sha256sum] = "9bc458ff86feba9da618b2ea76e51143a52c1af2410700fa98006a265052401f"

URI_aarch64_rust-pest+miette-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+miette-error-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest+miette-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+miette-error-devel}"
SRC_URI[aarch64_rust-pest+miette-error-devel.sha256sum] = "4a8ea291bef5ca0a8d9bb8b501fd3102088e8ae9cc21370729b106ef68a7f3dc"

URI_aarch64_rust-pest+pretty-print-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+pretty-print-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest+pretty-print-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+pretty-print-devel}"
SRC_URI[aarch64_rust-pest+pretty-print-devel.sha256sum] = "e13fc96bf7bf54f2d32e5cd21baad04cb040422ff8763371eef28eff6076d6db"

URI_aarch64_rust-pest+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+std-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+std-devel}"
SRC_URI[aarch64_rust-pest+std-devel.sha256sum] = "6b7f7df039ec5fb02fdf25146ea9518439def7fca822d558f180657f3a324866"

URI_aarch64_rust-pest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest-devel-2.8.4-1.el10_1.noarch.rpm;name=aarch64_rust-pest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest-devel}"
SRC_URI[aarch64_rust-pest-devel.sha256sum] = "1b8a7fa79c1a411bcb376540eae9985cfe1694986d387523c04ccc5dfbb20290"

RDEPENDS:rust-pest+const_prec_climber-devel = " \
 cargo \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+default-devel = " \
 cargo \
 rust-pest+memchr-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+memchr-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+miette-error-devel = " \
 cargo \
 rust-miette+default-devel \
 rust-miette+fancy-devel \
 rust-pest+pretty-print-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+pretty-print-devel = " \
 cargo \
 rust-pest-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-pest+std-devel = " \
 cargo \
 rust-pest-devel \
 rust-ucd-trie+std-devel \
 "
RDEPENDS:rust-pest-devel = " \
 cargo \
 rust \
 rust-ucd-trie-devel \
 "
