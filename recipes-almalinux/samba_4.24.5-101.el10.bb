# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samba"
PV = "4.24.5"
PR = "101.el10"
PACKAGES:x86_64_v2 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-tools \
 samba-core-libs \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-ndr-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
 samba-winexe \
"
PACKAGES:aarch64 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-tools \
 samba-core-libs \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-ndr-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/samba-4.24.5-101.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d7fec4835e2a1cf7e8be9d1ecff438a3a569fc43df4f2a01d9c9fd04b7ea4159"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - samba-client-libs: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ldb-tools-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_ldb-tools;unpack=0"
SRC_URI[x86_64_v2_ldb-tools.sha256sum] = "bf69dd81850564e6f7df81e27d45a90559fa99f58853031e6b93cae7a1087608"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libldb-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_libldb;unpack=0"
SRC_URI[x86_64_v2_libldb.sha256sum] = "dcef8069497631b0ce79405aad8e351c0f6140fad7efadfd4f61df949e58074c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libldb-devel-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_libldb-devel;unpack=0"
SRC_URI[x86_64_v2_libldb-devel.sha256sum] = "303192e9bd1604598dc2d593b82f0c4446f2b3569e167339cd13e62acd727c4d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnetapi-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_libnetapi;unpack=0"
SRC_URI[x86_64_v2_libnetapi.sha256sum] = "a33a854c67d194e443af5ec04c4c147ce72d1189990b548c5478101e7a6ad712"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnetapi-devel-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_libnetapi-devel;unpack=0"
SRC_URI[x86_64_v2_libnetapi-devel.sha256sum] = "1e9cc7be81bf0837b9b67dec37e63a642bbaea664a796636e29c99850257c46c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmbclient-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_libsmbclient;unpack=0"
SRC_URI[x86_64_v2_libsmbclient.sha256sum] = "e94e6cf9fac7caa6795eb594e7969da867c5193b3c458933c39c2c930fca6bdf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmbclient-devel-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_libsmbclient-devel;unpack=0"
SRC_URI[x86_64_v2_libsmbclient-devel.sha256sum] = "86b7b6f02083b782ea7ef14c08cdcd242903368c5c19f72e815058a061dbbc05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libwbclient-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_libwbclient;unpack=0"
SRC_URI[x86_64_v2_libwbclient.sha256sum] = "1f5afc28464d14d01832c619ef25bf5bbd6f72753effa38a9ab894867b1715b9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwbclient-devel-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_libwbclient-devel;unpack=0"
SRC_URI[x86_64_v2_libwbclient-devel.sha256sum] = "65209096358146331fdaef58ce8b96738a3cb69c0cac74a5bf332ab4aa047ee3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-ldb-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_python3-ldb;unpack=0"
SRC_URI[x86_64_v2_python3-ldb.sha256sum] = "8bcfe7ed244516256f2873b1a978083899e0f4fd86054787a10b2733a064722b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_python3-samba;unpack=0"
SRC_URI[x86_64_v2_python3-samba.sha256sum] = "ce314fc25e5e4c77af9f39a793e15948054cbae95e8e3de16f8a3da60afe3451"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-dc-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_python3-samba-dc;unpack=0"
SRC_URI[x86_64_v2_python3-samba-dc.sha256sum] = "85260ddf26078ad24444aba64825608711ae91abe032690a574eb36c7bc1d6a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-samba-test-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_python3-samba-test;unpack=0"
SRC_URI[x86_64_v2_python3-samba-test.sha256sum] = "e901639c0da782c43ec8ac2fcce0573d72627d314ff780f9574b61ecf055854c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba;unpack=0"
SRC_URI[x86_64_v2_samba.sha256sum] = "40dba3b0d3419ef22258bafe4a59c14f3bb8c8f0883019a48b0bf3471c8f9fd4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-client-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-client;unpack=0"
SRC_URI[x86_64_v2_samba-client.sha256sum] = "97266ad2a043d336544d7010e2097f7a29f2340ec0beab0c5fdaad9bdd944c08"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-client-libs-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-client-libs;unpack=0"
SRC_URI[x86_64_v2_samba-client-libs.sha256sum] = "862324bc09e43327ea11dff12573ecf5f13b7491f8fd824749c68e045e1a3ef2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-4.24.5-101.el10.noarch.rpm;name=x86_64_v2_samba-common;unpack=0"
SRC_URI[x86_64_v2_samba-common.sha256sum] = "7ba018ee5005fa4578002140bf3e33ae0d68f2972d35cc15c09f6853e2cc4953"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-tools-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-common-tools;unpack=0"
SRC_URI[x86_64_v2_samba-common-tools.sha256sum] = "91877c62332003339d29995cf2fc018986c860e9eb26787c4b144ef3adaf60d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-core-libs-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-core-libs;unpack=0"
SRC_URI[x86_64_v2_samba-core-libs.sha256sum] = "1fe63b51abe8b8ed7073d6b2e0f4a13ae1bb890c7f54e42ce64f05c118fbe9c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dc-libs-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-dc-libs;unpack=0"
SRC_URI[x86_64_v2_samba-dc-libs.sha256sum] = "7e11c66ee5330f87986e28b9b5647200bf50d13dd8572f41ebdfd2485b642a3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dcerpc-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-dcerpc;unpack=0"
SRC_URI[x86_64_v2_samba-dcerpc.sha256sum] = "c77dd56dd81119b00c7d09f3a7d66130f656731c8af9dbaf4708246c2df03a7c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-devel-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-devel;unpack=0"
SRC_URI[x86_64_v2_samba-devel.sha256sum] = "ff9123c7b61236970ab2fe07c575c51bbbd815a53abf704977043c119a08bf95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-gpupdate-4.24.5-101.el10.noarch.rpm;name=x86_64_v2_samba-gpupdate;unpack=0"
SRC_URI[x86_64_v2_samba-gpupdate.sha256sum] = "f4b78af78ba5d2eec24c87b44e6e8f31ece9c972abfe6696dd4369fd561f1057"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-krb5-printing-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-krb5-printing;unpack=0"
SRC_URI[x86_64_v2_samba-krb5-printing.sha256sum] = "d147863a050e5846f60f975d72dd7d75079015c170b3d3e3926197bb94dad6d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-ldb-ldap-modules-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-ldb-ldap-modules;unpack=0"
SRC_URI[x86_64_v2_samba-ldb-ldap-modules.sha256sum] = "b0c6a558335e5c5da6c86ff361155981f6d90c20e00831cc1deeab78e61f807c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-libs-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-libs;unpack=0"
SRC_URI[x86_64_v2_samba-libs.sha256sum] = "5ce2b1ab1b0a462d0c5f5d9ec218d2d7d17801b375a85827fd033c2bb17bfff4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-ndr-libs-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-ndr-libs;unpack=0"
SRC_URI[x86_64_v2_samba-ndr-libs.sha256sum] = "2f24a399c9a8a91cc60f16c3d01c73530f084d15d89d4691eb110bf6c56e1fe2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-pidl-4.24.5-101.el10.noarch.rpm;name=x86_64_v2_samba-pidl;unpack=0"
SRC_URI[x86_64_v2_samba-pidl.sha256sum] = "7fe7254898aabd863608a8213855c80ffc2fb0c3aac6d1d9509d3bf9904b66b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-test;unpack=0"
SRC_URI[x86_64_v2_samba-test.sha256sum] = "6d24263697e1238d92db94d02bdd429970c71ac4162fa9605008223ce6a51e14"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-libs-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-test-libs;unpack=0"
SRC_URI[x86_64_v2_samba-test-libs.sha256sum] = "80f77ce54b147ae2f30ccc7bd8abda64698629dddd51a56f96a64cdcd0a1e9d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-tools-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-tools;unpack=0"
SRC_URI[x86_64_v2_samba-tools.sha256sum] = "6c4f01b530a9ca5ad7f25a32464b9731ce66ed4d7ef23d6a43a2fc23238785f1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-usershares-4.24.5-101.el10.noarch.rpm;name=x86_64_v2_samba-usershares;unpack=0"
SRC_URI[x86_64_v2_samba-usershares.sha256sum] = "1361cbdac178252ae2bb61ae752e97a088c5ee0624cab24d742c1bbebf86659b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-vfs-iouring-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-vfs-iouring;unpack=0"
SRC_URI[x86_64_v2_samba-vfs-iouring.sha256sum] = "0719f5446181241cc6724b80969f5f6055f98fbb18d2d7b715ef790a8f2a5f66"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-winbind;unpack=0"
SRC_URI[x86_64_v2_samba-winbind.sha256sum] = "21b6c2eaea1d116884783b440be62623ae98e778d5ea81297f543673ddda1374"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-clients-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-clients;unpack=0"
SRC_URI[x86_64_v2_samba-winbind-clients.sha256sum] = "c0f63b103aa2341cb31f657174200922e8a9e1f50230394b7075fd955741e405"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-krb5-locator-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-krb5-locator;unpack=0"
SRC_URI[x86_64_v2_samba-winbind-krb5-locator.sha256sum] = "e9fb3771fe434c87461fc0fae1ff4a01f6a9f59cace9a7506b12b2f63737d2ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-modules-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-modules;unpack=0"
SRC_URI[x86_64_v2_samba-winbind-modules.sha256sum] = "3c87b60df88d5a727df4937f24179e4d53e91f0487e5bfed1204f85c84cc2a66"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winexe-4.24.5-101.el10.x86_64_v2.rpm;name=x86_64_v2_samba-winexe;unpack=0"
SRC_URI[x86_64_v2_samba-winexe.sha256sum] = "2c8fb2bb5e83f2c129f00b8a3080cedaa0535c3e14efc894b8605a162670b43c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ldb-tools-4.24.5-101.el10.aarch64.rpm;name=aarch64_ldb-tools;unpack=0"
SRC_URI[aarch64_ldb-tools.sha256sum] = "463668892fb431c4a9fe3784dc208d7eca602a85d9355a7dbfc5ac19dd2128ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libldb-4.24.5-101.el10.aarch64.rpm;name=aarch64_libldb;unpack=0"
SRC_URI[aarch64_libldb.sha256sum] = "2b36c135d34e9f03490c56180ef1c34047ab8cd1612b75e813255a021a61db74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libldb-devel-4.24.5-101.el10.aarch64.rpm;name=aarch64_libldb-devel;unpack=0"
SRC_URI[aarch64_libldb-devel.sha256sum] = "c400db0c832e21e1fbe5d380a3c3c1a7561eb849f2c6f16800c31fb771fb46da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnetapi-4.24.5-101.el10.aarch64.rpm;name=aarch64_libnetapi;unpack=0"
SRC_URI[aarch64_libnetapi.sha256sum] = "cb791ec479322751ca579dac32c041da0d8717455c08a61953c3c9a44d2628e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnetapi-devel-4.24.5-101.el10.aarch64.rpm;name=aarch64_libnetapi-devel;unpack=0"
SRC_URI[aarch64_libnetapi-devel.sha256sum] = "e1bad479fba9d39cad4a82174705971872f7bfb73d52d6e1c0b19e7cf532e5ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmbclient-4.24.5-101.el10.aarch64.rpm;name=aarch64_libsmbclient;unpack=0"
SRC_URI[aarch64_libsmbclient.sha256sum] = "425de4d2955ca83e0d1afa2b85ba46b10552c269137ea2c6f10f1d3601a70b68"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmbclient-devel-4.24.5-101.el10.aarch64.rpm;name=aarch64_libsmbclient-devel;unpack=0"
SRC_URI[aarch64_libsmbclient-devel.sha256sum] = "116b050351d872a171f1620133d32850c4cd9447c20a487112eb01ac2370b28c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libwbclient-4.24.5-101.el10.aarch64.rpm;name=aarch64_libwbclient;unpack=0"
SRC_URI[aarch64_libwbclient.sha256sum] = "ef47d613afd4995af322614a654439287e6fa2f575d9a3e1bf7d8c3f389580f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwbclient-devel-4.24.5-101.el10.aarch64.rpm;name=aarch64_libwbclient-devel;unpack=0"
SRC_URI[aarch64_libwbclient-devel.sha256sum] = "019ee74bedc223bdce405fea3c807d5dbe7611997aba3a4738ac0efecedc2e04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-ldb-4.24.5-101.el10.aarch64.rpm;name=aarch64_python3-ldb;unpack=0"
SRC_URI[aarch64_python3-ldb.sha256sum] = "7abd7b720050f436ce295422b43642305471b8d7d5658c3ff54d5ad5e7cd456a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-4.24.5-101.el10.aarch64.rpm;name=aarch64_python3-samba;unpack=0"
SRC_URI[aarch64_python3-samba.sha256sum] = "c50cc19d9504db97175d5355fd9153422e7c565f7a191a9d36fb6a660d726d4c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-dc-4.24.5-101.el10.aarch64.rpm;name=aarch64_python3-samba-dc;unpack=0"
SRC_URI[aarch64_python3-samba-dc.sha256sum] = "f37cbe27a0d1241527bf6cd3789e9c3195c43e42b1df1c09fa15b973a8d39258"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-samba-test-4.24.5-101.el10.aarch64.rpm;name=aarch64_python3-samba-test;unpack=0"
SRC_URI[aarch64_python3-samba-test.sha256sum] = "c21658ec7457e13351b6f1f582814dbda8d8f16463650459a7e05003ab06a516"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba;unpack=0"
SRC_URI[aarch64_samba.sha256sum] = "978121808e37d39075efadcc777858abd68f4f637901b85ed832b8134135c597"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-client-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-client;unpack=0"
SRC_URI[aarch64_samba-client.sha256sum] = "f5d48e19d9390d7f84f67e4e27aeaf5ab90d91f55116a03536e561f08966042f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-client-libs-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-client-libs;unpack=0"
SRC_URI[aarch64_samba-client-libs.sha256sum] = "ad52c266fd014cbea6cf72f07c501af6d631af3f6c92a0fcf52d687bf3a80f18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-4.24.5-101.el10.noarch.rpm;name=aarch64_samba-common;unpack=0"
SRC_URI[aarch64_samba-common.sha256sum] = "7ba018ee5005fa4578002140bf3e33ae0d68f2972d35cc15c09f6853e2cc4953"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-tools-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-common-tools;unpack=0"
SRC_URI[aarch64_samba-common-tools.sha256sum] = "c30a90a8f7cab1513b290e095e8e8d7c1281f1136317aa97b450b07b62424bff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-core-libs-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-core-libs;unpack=0"
SRC_URI[aarch64_samba-core-libs.sha256sum] = "a4de434261b96da3a47df0c8df60ed1747e2d231d5b3a69a93131c13caf743ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dc-libs-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-dc-libs;unpack=0"
SRC_URI[aarch64_samba-dc-libs.sha256sum] = "eb25edd9b4ed1ee7f41ef95e0bce8ef211d5296aa2552ea3ce1142f469d4d098"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dcerpc-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-dcerpc;unpack=0"
SRC_URI[aarch64_samba-dcerpc.sha256sum] = "ffa172ea92df455909dfb366455ed9b28055c3072d676362ab7e3853a1986704"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-devel-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-devel;unpack=0"
SRC_URI[aarch64_samba-devel.sha256sum] = "e8616affbb738f14604e8bd5209cd96bcd4f692c8137ca2b6fe9a1fcf91cc1ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-gpupdate-4.24.5-101.el10.noarch.rpm;name=aarch64_samba-gpupdate;unpack=0"
SRC_URI[aarch64_samba-gpupdate.sha256sum] = "f4b78af78ba5d2eec24c87b44e6e8f31ece9c972abfe6696dd4369fd561f1057"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-krb5-printing-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-krb5-printing;unpack=0"
SRC_URI[aarch64_samba-krb5-printing.sha256sum] = "52ac5d3e0fdcbff0943fe21d1a8b2afc170a0ec2631dc03075dead5f3f3e7755"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-ldb-ldap-modules-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-ldb-ldap-modules;unpack=0"
SRC_URI[aarch64_samba-ldb-ldap-modules.sha256sum] = "0d5e6d9e6745cc015a63e45ecd1a7218ceef2c86801e17af80d7d065ab1ae203"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-libs-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-libs;unpack=0"
SRC_URI[aarch64_samba-libs.sha256sum] = "5316c43848322f1e4a41fcd781eb10f18fa26370dd7b6a358f6e065c2eabbbc7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-ndr-libs-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-ndr-libs;unpack=0"
SRC_URI[aarch64_samba-ndr-libs.sha256sum] = "d9055d168a64e7531b6d67fa3683c01d384bdd76aa803f84bdc2d173b465a78e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-pidl-4.24.5-101.el10.noarch.rpm;name=aarch64_samba-pidl;unpack=0"
SRC_URI[aarch64_samba-pidl.sha256sum] = "7fe7254898aabd863608a8213855c80ffc2fb0c3aac6d1d9509d3bf9904b66b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-test;unpack=0"
SRC_URI[aarch64_samba-test.sha256sum] = "d6c4b13e2f23baf948f6bc7be4f04457dd861941c8ac971bcf5c2ae6be2c9506"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-libs-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-test-libs;unpack=0"
SRC_URI[aarch64_samba-test-libs.sha256sum] = "f47b8d5ecfa4534c4c4e1afc2d90c24033bbc5e8cbef9cfe901414a67514d15d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-tools-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-tools;unpack=0"
SRC_URI[aarch64_samba-tools.sha256sum] = "5d4e12561279210a51e887ae4814c24fe1d643e31416d9de349afaf33feb9859"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-usershares-4.24.5-101.el10.noarch.rpm;name=aarch64_samba-usershares;unpack=0"
SRC_URI[aarch64_samba-usershares.sha256sum] = "1361cbdac178252ae2bb61ae752e97a088c5ee0624cab24d742c1bbebf86659b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-vfs-iouring-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-vfs-iouring;unpack=0"
SRC_URI[aarch64_samba-vfs-iouring.sha256sum] = "2ba3c08eac84f655356e0bdcafd45cd4f9f62f1fca6a778aea490233f60b0af1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-winbind;unpack=0"
SRC_URI[aarch64_samba-winbind.sha256sum] = "ef7026fd8ffa33010e33cf3b0c2d0b98386f3fec6532a5153f44966691fa0ef2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-clients-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-winbind-clients;unpack=0"
SRC_URI[aarch64_samba-winbind-clients.sha256sum] = "a5e12e906f47879c40cf263aa18eadb0691169866c72913438b9217b945f240a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-krb5-locator-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-winbind-krb5-locator;unpack=0"
SRC_URI[aarch64_samba-winbind-krb5-locator.sha256sum] = "6820bfd94b53ccd4e41f5cee632b7650da16754d830691caabac079b60dfd8c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-modules-4.24.5-101.el10.aarch64.rpm;name=aarch64_samba-winbind-modules;unpack=0"
SRC_URI[aarch64_samba-winbind-modules.sha256sum] = "57931cb268c832c1717c9ff6fea96de575daedce2727d78cdc6e59b425c0157e"

RDEPENDS:ldb-tools = " \
 glibc \
 libldb \
 libtalloc \
 popt \
 "
RDEPENDS:libldb = " \
 glibc \
 libtalloc \
 libtdb \
 libtevent \
 lmdb-libs \
 "
RDEPENDS:libldb-devel = " \
 libldb \
 libtalloc-devel \
 libtdb-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libnetapi = " \
 glibc \
 gnutls \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-core-libs \
 samba-ndr-libs \
 "
RDEPENDS:libnetapi-devel = " \
 libnetapi \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmbclient = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-core-libs \
 samba-ndr-libs \
 "
RDEPENDS:libsmbclient-devel = " \
 libsmbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:libwbclient = " \
 bash \
 glibc \
 "
RDEPENDS:libwbclient-devel = " \
 libwbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-ldb = " \
 glibc \
 libldb \
 libtalloc \
 python3 \
 python3-libs \
 python3-tdb \
 samba-client-libs \
 samba-core-libs \
 "
RDEPENDS:python3-samba = " \
 glibc \
 gnutls \
 krb5-libs \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 python3 \
 python3-cryptography \
 python3-dns \
 python3-ldb \
 python3-libs \
 python3-requests \
 python3-talloc \
 python3-tdb \
 python3-tevent \
 samba-client-libs \
 samba-core-libs \
 samba-dc-libs \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:python3-samba-dc = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 python3 \
 python3-libs \
 python3-markdown \
 python3-samba \
 python3-talloc \
 samba-client-libs \
 samba-core-libs \
 samba-dc-libs \
 samba-ndr-libs \
 "
RDEPENDS:python3-samba-test = " \
 python3 \
 python3-samba \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba = " \
 bash \
 cups-libs \
 dbus-libs \
 glibc \
 gnutls \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 pam \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-tools \
 samba-core-libs \
 samba-dcerpc \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-client = " \
 alternatives \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libarchive \
 libcom_err \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 ncurses-libs \
 popt \
 readline \
 samba-client-libs \
 samba-common \
 samba-core-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-client-libs:x86_64_v2 = " \
 glibc \
 glibc-gconv-extra \
 gnutls \
 jansson \
 krb5-libs \
 libcap \
 libcom_err \
 libldb \
 libtalloc \
 libtasn1 \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-common \
 samba-core-libs \
 samba-ndr-libs \
 zlib-ng-compat \
"
RDEPENDS:samba-client-libs:aarch64 = " \
 glibc \
 glibc-gconv-extra \
 gnutls \
 jansson \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtasn1 \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-common \
 samba-core-libs \
 samba-ndr-libs \
 zlib-ng-compat \
"
RDEPENDS:samba-common = " \
 bash \
 systemd \
 "
RDEPENDS:samba-common-tools = " \
 glibc \
 gnutls \
 jansson \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 python3 \
 readline \
 samba-client-libs \
 samba-core-libs \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-core-libs = " \
 glibc \
 gnutls \
 libicu \
 libtalloc \
 libtevent \
 samba-common \
 systemd-libs \
 "
RDEPENDS:samba-dc-libs = " \
 glibc \
 gnutls \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-core-libs \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-dcerpc = " \
 cups-libs \
 glibc \
 gnutls \
 jansson \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-devel = " \
 libldb-devel \
 libnetapi \
 libtalloc-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 samba-client-libs \
 samba-core-libs \
 samba-dc-libs \
 samba-devel \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-gpupdate = " \
 cepces-certmonger \
 certmonger \
 python3 \
 python3-samba \
 python3-samba-dc \
 samba-ldb-ldap-modules \
 "
RDEPENDS:samba-krb5-printing = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 samba-client \
 samba-client-libs \
 samba-core-libs \
 "
RDEPENDS:samba-ldb-ldap-modules = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 openldap \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-libs = " \
 avahi-libs \
 glibc \
 gnutls \
 krb5-libs \
 libacl \
 libcom_err \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libtirpc \
 libwbclient \
 libxcrypt \
 openldap \
 pam-libs \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-ndr-libs = " \
 glibc \
 libtalloc \
 libtdb \
 libtevent \
 samba-common \
 samba-core-libs \
 zlib-ng-compat \
 "
RDEPENDS:samba-pidl = " \
 perl-Exporter \
 perl-File-Basename \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Parse-Yapp \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-parent \
 perl-vars \
 samba-pidl \
 "
RDEPENDS:samba-test = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libsmbclient \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 perl-Archive-Tar \
 popt \
 python3-samba \
 readline \
 samba \
 samba-client-libs \
 samba-common \
 samba-core-libs \
 samba-dc-libs \
 samba-libs \
 samba-ndr-libs \
 samba-test-libs \
 samba-winbind \
 "
RDEPENDS:samba-test-libs = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-core-libs \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-tools = " \
 python3 \
 python3-samba \
 python3-samba-dc \
 "
RDEPENDS:samba-usershares = " \
 bash \
 samba \
 samba-common-tools \
 "
RDEPENDS:samba-vfs-iouring = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 liburing \
 libwbclient \
 samba \
 samba-client-libs \
 samba-core-libs \
 samba-libs \
 "
RDEPENDS:samba-winbind = " \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-tools \
 samba-core-libs \
 samba-dcerpc \
 samba-libs \
 samba-ndr-libs \
 samba-winbind-modules \
 "
RDEPENDS:samba-winbind-clients = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common \
 samba-core-libs \
 samba-libs \
 samba-ndr-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-krb5-locator = " \
 alternatives \
 bash \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-core-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-modules = " \
 glibc \
 libtalloc \
 libwbclient \
 pam \
 pam-libs \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba-winexe = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 "
