# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-Eksblowfish"
PV = "0.009"
PR = "42.el10_0"
PACKAGES = " \
 perl-Crypt-Eksblowfish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-Eksblowfish-0.009-42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19b040d34d75288a26916d1ea203c5595e2b5ee932e22b3aed51da59426f5c31"

URI_x86_64_v2_perl-Crypt-Eksblowfish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-Eksblowfish-0.009-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-Eksblowfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-Eksblowfish}"
SRC_URI[x86_64_v2_perl-Crypt-Eksblowfish.sha256sum] = "6f0a1ed2bb4d78618441981af2c909f73b08221e89706f9ed3f4d56c9a8144d9"

URI_aarch64_perl-Crypt-Eksblowfish = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-Eksblowfish-0.009-42.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-Eksblowfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-Eksblowfish}"
SRC_URI[aarch64_perl-Crypt-Eksblowfish.sha256sum] = "7d2e825d3af3b7f8ad115187c89bd02f9e36522a2e2be65b950edf33ffeaa776"

RDEPENDS:perl-Crypt-Eksblowfish = " \
 glibc \
 perl-Carp \
 perl-Class-Mix \
 perl-Crypt-Eksblowfish \
 perl-Exporter \
 perl-MIME-Base64 \
 perl-libs \
 perl-parent \
 "
