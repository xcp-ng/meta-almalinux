# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clamav"
PV = "1.4.6"
PR = "2.el10_3"
PACKAGES = " \
 clamav \
 clamav-data \
 clamav-devel \
 clamav-doc \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 clamav-milter \
 clamd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/clamav-1.4.6-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ad56df3d432d1219fe71a4469f6a12f1e5abe4f528d810c3066c36472274322e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-1.4.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav;unpack=0"
SRC_URI[x86_64_v2_clamav.sha256sum] = "44e54cd2e25acc132a4dfeb5b927698a219b3ed76d7b64f417ec3e52c76aeb29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-data-1.4.6-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-data;unpack=0"
SRC_URI[x86_64_v2_clamav-data.sha256sum] = "f2d728861b3b1466545a31bf2ee040fea63cd013ec4ba8684c8aca3b22f810a2"
RPROVIDES:clamav-data:append:x86_64_v2 = " virtual/data_clamav_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-devel-1.4.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-devel;unpack=0"
SRC_URI[x86_64_v2_clamav-devel.sha256sum] = "22d39cc590d415268fd05a08a4bb55b4739538e2cdf33d51ea157fbd2070dbc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-doc-1.4.6-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-doc;unpack=0"
SRC_URI[x86_64_v2_clamav-doc.sha256sum] = "eff8ba2c7933e80ff6f7eeab25dd7328aa26213fc3ee32512fa263c51fce09f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-filesystem-1.4.6-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_clamav-filesystem;unpack=0"
SRC_URI[x86_64_v2_clamav-filesystem.sha256sum] = "19aa51fae7a55d118bef8c3a1f50273f8e25bc27e3c94f1704e2c61b8adcaafc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-freshclam-1.4.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-freshclam;unpack=0"
SRC_URI[x86_64_v2_clamav-freshclam.sha256sum] = "5ee8f4747d374af9bf9aa3b17bf8c033b8d1de4846068ffbe4140eb74ed52190"
RPROVIDES:clamav-freshclam:append:x86_64_v2 = " virtual/data_clamav_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-lib-1.4.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-lib;unpack=0"
SRC_URI[x86_64_v2_clamav-lib.sha256sum] = "a9a9384c2b52550c430516e1154990ba7d5731c586825262eab8149c0e18ae36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamav-milter-1.4.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamav-milter;unpack=0"
SRC_URI[x86_64_v2_clamav-milter.sha256sum] = "bab01e002badf8e964370a10de27c810ff964f48ba504f769f8962e4853b0f4e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clamd-1.4.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clamd;unpack=0"
SRC_URI[x86_64_v2_clamd.sha256sum] = "4f836844e5fecf8212457f8cd99bbb987973c0aef83a234a1c6fe14ea846dbc5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-1.4.6-2.el10_3.aarch64.rpm;name=aarch64_clamav;unpack=0"
SRC_URI[aarch64_clamav.sha256sum] = "b9bb186c2fd65d903c4a6bec494613b81f9a91377213846dff5e3a46cb71ba61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-data-1.4.6-2.el10_3.noarch.rpm;name=aarch64_clamav-data;unpack=0"
SRC_URI[aarch64_clamav-data.sha256sum] = "3daaf32f1ece61cfb223c8b5ba78abcddd524ebae3945c16ee395ae929c8e7e3"
RPROVIDES:clamav-data:append:aarch64 = " virtual/data_clamav_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-devel-1.4.6-2.el10_3.aarch64.rpm;name=aarch64_clamav-devel;unpack=0"
SRC_URI[aarch64_clamav-devel.sha256sum] = "0701c977c137c1bd658f62a6bebecc82470dd67af889c3314d4bae384d86d757"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-doc-1.4.6-2.el10_3.noarch.rpm;name=aarch64_clamav-doc;unpack=0"
SRC_URI[aarch64_clamav-doc.sha256sum] = "5bdcd45fc174ccf32647e6ee1be8fd4554dd28bc4b3d8bb75cf9489099cf6536"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-filesystem-1.4.6-2.el10_3.noarch.rpm;name=aarch64_clamav-filesystem;unpack=0"
SRC_URI[aarch64_clamav-filesystem.sha256sum] = "098ecc99383a71a198d5e14a0d4a7136e5139831b05671592fe81b6441ac93b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-freshclam-1.4.6-2.el10_3.aarch64.rpm;name=aarch64_clamav-freshclam;unpack=0"
SRC_URI[aarch64_clamav-freshclam.sha256sum] = "95c5bb6ca0a078684a353fc55108acf57d5ac709598651f5f63805156edb3fed"
RPROVIDES:clamav-freshclam:append:aarch64 = " virtual/data_clamav_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-lib-1.4.6-2.el10_3.aarch64.rpm;name=aarch64_clamav-lib;unpack=0"
SRC_URI[aarch64_clamav-lib.sha256sum] = "291436b98ac697457e4cff0d6668710b07ed15651466ebc6f9e8992a3ae960b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamav-milter-1.4.6-2.el10_3.aarch64.rpm;name=aarch64_clamav-milter;unpack=0"
SRC_URI[aarch64_clamav-milter.sha256sum] = "17fbccb9bc1f66a066b067660add750cde0fcccdb6aeb85f74b80a54985a3833"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clamd-1.4.6-2.el10_3.aarch64.rpm;name=aarch64_clamd;unpack=0"
SRC_URI[aarch64_clamd.sha256sum] = "4a405328a2bc3ef12f12ce21db867d2002f1122cddbdee259eb2173ee704aad5"

RDEPENDS:clamav = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 json-c \
 libgcc \
 ncurses-libs \
 shadow-utils \
 systemd \
 virtual/data_clamav_ \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-data = " \
 bash \
 clamav-filesystem \
 "
RDEPENDS:clamav-devel = " \
 bash \
 clamav-filesystem \
 clamav-freshclam \
 clamav-lib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:clamav-doc = " \
 clamav-filesystem \
 "
RDEPENDS:clamav-filesystem = " \
 bash \
 "
RDEPENDS:clamav-freshclam = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 libgcc \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:clamav-lib = " \
 bzip2-libs \
 glibc \
 json-c \
 libgcc \
 libxml2 \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:clamav-milter = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 clamd \
 glibc \
 sendmail-milter \
 "
RDEPENDS:clamd = " \
 bash \
 clamav-filesystem \
 clamav-lib \
 glibc \
 systemd-libs \
 virtual/coreutils \
 virtual/data_clamav_ \
 "
