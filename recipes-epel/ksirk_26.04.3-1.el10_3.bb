# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksirk"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ksirk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksirk-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db4654aebab7ca0397546f5dfa214710a0ae3bd5382795f722d333caa7b36d1d"

URI_x86_64_v2_ksirk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksirk-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksirk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksirk}"
SRC_URI[x86_64_v2_ksirk.sha256sum] = "29a7d98bf6e543aa972d94dc7cc7a3839ff63798753e16c6024b505037a8c785"

URI_aarch64_ksirk = "${EPEL_MIRROR}/aarch64/Packages/k/ksirk-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ksirk;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksirk}"
SRC_URI[aarch64_ksirk.sha256sum] = "0f5f267f39ce45ba567350dc2c76c0b950b42a73d3fb2323f541481acf5e2a65"

RDEPENDS:ksirk = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qca-qt6-ossl \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
