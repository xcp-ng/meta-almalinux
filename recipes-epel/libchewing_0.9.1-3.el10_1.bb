# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libchewing"
PV = "0.9.1"
PR = "3.el10_1"
PACKAGES = " \
 libchewing \
 libchewing-devel \
 python3-libchewing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libchewing-0.9.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "721c86c834a541145edc0cd5bc5941d31a4972d56fbc2f35514ec7176780bac3"

URI_x86_64_v2_libchewing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libchewing-0.9.1-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libchewing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libchewing}"
SRC_URI[x86_64_v2_libchewing.sha256sum] = "bc855ba25162624d2b093ab063aa86f89695866df79773f7e7a582bed8d57306"

URI_x86_64_v2_libchewing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libchewing-devel-0.9.1-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libchewing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libchewing-devel}"
SRC_URI[x86_64_v2_libchewing-devel.sha256sum] = "40d4a7c4ae1cc6853e81c2eddf4ba78df7b4f406c7b334e415bfa49d829f5161"

URI_x86_64_v2_python3-libchewing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libchewing-0.9.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-libchewing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libchewing}"
SRC_URI[x86_64_v2_python3-libchewing.sha256sum] = "49df1196d0b263d5c4dae46038a76b2f38ec8e37347bea78338ac2fc61bb9e68"

URI_aarch64_libchewing = "${EPEL_MIRROR}/aarch64/Packages/l/libchewing-0.9.1-3.el10_1.aarch64.rpm;name=aarch64_libchewing;unpack=0"
SRC_URI:append = " ${URI_aarch64_libchewing}"
SRC_URI[aarch64_libchewing.sha256sum] = "188ea3a1c3cdea7bc829b3274b618313130fcb4f27a8266da44a68d24fa7e7e5"

URI_aarch64_libchewing-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libchewing-devel-0.9.1-3.el10_1.aarch64.rpm;name=aarch64_libchewing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libchewing-devel}"
SRC_URI[aarch64_libchewing-devel.sha256sum] = "57f6994b07cb870156e6d9ae210e0122173f0232f88c12fa8076ef5c7fd71062"

URI_aarch64_python3-libchewing = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libchewing-0.9.1-3.el10_1.noarch.rpm;name=aarch64_python3-libchewing;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libchewing}"
SRC_URI[aarch64_python3-libchewing.sha256sum] = "8ece426b6dece9ea53d225c5e78990150d84bc87a58eefc05444f292cd547ae3"

RDEPENDS:libchewing = " \
 glibc \
 libgcc \
 sqlite-libs \
 "
RDEPENDS:libchewing-devel = " \
 cmake-filesystem \
 libchewing \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libchewing = " \
 libchewing \
 python3 \
 "
