# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-keystoneauth1"
PV = "5.13.1"
PR = "4.el10_2"
PACKAGES = " \
 python-keystoneauth1-doc \
 python3-keystoneauth1 \
 python3-keystoneauth1+betamax \
 python3-keystoneauth1+kerberos \
 python3-keystoneauth1+oauth1 \
 python3-keystoneauth1+saml2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-keystoneauth1-5.13.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71f11be96b08c29226dda031a1e373987b31ffa42e9cdf14a2b65d67de616575"

URI_x86_64_v2_python-keystoneauth1-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-keystoneauth1-doc-5.13.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-keystoneauth1-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-keystoneauth1-doc}"
SRC_URI[x86_64_v2_python-keystoneauth1-doc.sha256sum] = "7ad93d137335378e440885ca27b4bd0127ffec6dd313ae9b53f367f6e24625d7"

URI_x86_64_v2_python3-keystoneauth1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneauth1-5.13.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneauth1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneauth1}"
SRC_URI[x86_64_v2_python3-keystoneauth1.sha256sum] = "03f61f69d4da1777d9bb3e75a014a79bafa454327c2e35225df1958ea469c2e8"

URI_x86_64_v2_python3-keystoneauth1+betamax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneauth1+betamax-5.13.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneauth1+betamax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneauth1+betamax}"
SRC_URI[x86_64_v2_python3-keystoneauth1+betamax.sha256sum] = "30a166ce262152197d2a870ca5d9d6fb566666e87bfb01f7718322a01d0be882"

URI_x86_64_v2_python3-keystoneauth1+kerberos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneauth1+kerberos-5.13.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneauth1+kerberos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneauth1+kerberos}"
SRC_URI[x86_64_v2_python3-keystoneauth1+kerberos.sha256sum] = "ce02dbaaacf027ee1e4e031fc153a12aad89aaab6e673b496ab1dbee61ce1e8f"

URI_x86_64_v2_python3-keystoneauth1+oauth1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneauth1+oauth1-5.13.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneauth1+oauth1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneauth1+oauth1}"
SRC_URI[x86_64_v2_python3-keystoneauth1+oauth1.sha256sum] = "70964c2604a2921b3d49b30b5ee36a298461f33a594aced4ceb5745fccfa8e2c"

URI_x86_64_v2_python3-keystoneauth1+saml2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keystoneauth1+saml2-5.13.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keystoneauth1+saml2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keystoneauth1+saml2}"
SRC_URI[x86_64_v2_python3-keystoneauth1+saml2.sha256sum] = "e69874b12672da558b753495920bc2f4b44ef51051251d02eeb983031befa929"

URI_aarch64_python-keystoneauth1-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-keystoneauth1-doc-5.13.1-4.el10_2.noarch.rpm;name=aarch64_python-keystoneauth1-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-keystoneauth1-doc}"
SRC_URI[aarch64_python-keystoneauth1-doc.sha256sum] = "0fcf507ca8c85c6be6af1fa0d6fe2cf5f84f7735ec3bcb68373fdc2656e160da"

URI_aarch64_python3-keystoneauth1 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneauth1-5.13.1-4.el10_2.noarch.rpm;name=aarch64_python3-keystoneauth1;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneauth1}"
SRC_URI[aarch64_python3-keystoneauth1.sha256sum] = "10d11d8e943df477ad996fd0bc7f41702278483cf4c01677e7e054c96a4a98db"

URI_aarch64_python3-keystoneauth1+betamax = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneauth1+betamax-5.13.1-4.el10_2.noarch.rpm;name=aarch64_python3-keystoneauth1+betamax;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneauth1+betamax}"
SRC_URI[aarch64_python3-keystoneauth1+betamax.sha256sum] = "c09877d257ecd3cfae6c0344c43ba350848aa410411bb227199e47c790524717"

URI_aarch64_python3-keystoneauth1+kerberos = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneauth1+kerberos-5.13.1-4.el10_2.noarch.rpm;name=aarch64_python3-keystoneauth1+kerberos;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneauth1+kerberos}"
SRC_URI[aarch64_python3-keystoneauth1+kerberos.sha256sum] = "06684a2eeb10bf1536e1454aa14a1016373bbb430fe890327457d2d3136ba485"

URI_aarch64_python3-keystoneauth1+oauth1 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneauth1+oauth1-5.13.1-4.el10_2.noarch.rpm;name=aarch64_python3-keystoneauth1+oauth1;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneauth1+oauth1}"
SRC_URI[aarch64_python3-keystoneauth1+oauth1.sha256sum] = "621527876f1b7911e499b9f58b0d16f0a40a52a98e625abfacb35417cc792809"

URI_aarch64_python3-keystoneauth1+saml2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keystoneauth1+saml2-5.13.1-4.el10_2.noarch.rpm;name=aarch64_python3-keystoneauth1+saml2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keystoneauth1+saml2}"
SRC_URI[aarch64_python3-keystoneauth1+saml2.sha256sum] = "074a83f14f42648e9fe78088ebd4e23f3ce842a02fa655162ba7914aeba85e43"

RDEPENDS:python-keystoneauth1-doc = " \
 "
RDEPENDS:python3-keystoneauth1 = " \
 python3 \
 python3-iso8601 \
 python3-os-service-types \
 python3-pbr \
 python3-requests \
 python3-stevedore \
 python3-typing-extensions \
 "
RDEPENDS:python3-keystoneauth1+betamax = " \
 python3 \
 python3-betamax \
 python3-fixtures \
 python3-keystoneauth1 \
 python3-pyyaml \
 "
RDEPENDS:python3-keystoneauth1+kerberos = " \
 python3 \
 python3-keystoneauth1 \
 python3-requests-kerberos \
 "
RDEPENDS:python3-keystoneauth1+oauth1 = " \
 python3 \
 python3-keystoneauth1 \
 python3-oauthlib \
 "
RDEPENDS:python3-keystoneauth1+saml2 = " \
 python3 \
 python3-keystoneauth1 \
 python3-lxml \
 "
