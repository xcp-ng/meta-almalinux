# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand"
PV = "0.9.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-rand+alloc-devel \
 rust-rand+default-devel \
 rust-rand+log-devel \
 rust-rand+os_rng-devel \
 rust-rand+serde-devel \
 rust-rand+small_rng-devel \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand+unbiased-devel \
 rust-rand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand-0.9.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64a4ba193ef0c2765cf42e54538149596443aece30f18bc2bf0a61152edc1168"

URI_x86_64_v2_rust-rand+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+alloc-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand+alloc-devel.sha256sum] = "d4499b4970ea53566562aed3e513e241513013de691f063725ca9bcc441d0dcd"

URI_x86_64_v2_rust-rand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+default-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+default-devel}"
SRC_URI[x86_64_v2_rust-rand+default-devel.sha256sum] = "93a44529635af20a4f8a04e6bf0b5771244c0ac81d8046d0f2391dfcafd10a11"

URI_x86_64_v2_rust-rand+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+log-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+log-devel}"
SRC_URI[x86_64_v2_rust-rand+log-devel.sha256sum] = "96584c0fb0fd195843ba8a0948a367dceb631d041efdb6a74668fbf15598cf32"

URI_x86_64_v2_rust-rand+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+os_rng-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+os_rng-devel.sha256sum] = "de68f3b2394b49ebf19bcf24fcee4fb85b23794ad5f70ecd880c9a3930d5abc9"

URI_x86_64_v2_rust-rand+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+serde-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+serde-devel}"
SRC_URI[x86_64_v2_rust-rand+serde-devel.sha256sum] = "ee823e374bbccc12176e59f7e8a802b47171166548361f6feed0e9a7d74feb34"

URI_x86_64_v2_rust-rand+small_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+small_rng-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+small_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+small_rng-devel.sha256sum] = "2daae58a61a7a081cb3eb0d2ab7f0861eb752cc8446d4ab1dbac7c93113654ff"

URI_x86_64_v2_rust-rand+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+std-devel}"
SRC_URI[x86_64_v2_rust-rand+std-devel.sha256sum] = "eacc0e558568aa36bfff6c2df73333a71311f74f92f769a0d6c56b7a31a71e91"

URI_x86_64_v2_rust-rand+std_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std_rng-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+std_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+std_rng-devel.sha256sum] = "001e258f2785f1c6d2f68e8b9ee6b281e20a049e8c61ba012473d6c4ebeacd6b"

URI_x86_64_v2_rust-rand+thread_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+thread_rng-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+thread_rng-devel}"
SRC_URI[x86_64_v2_rust-rand+thread_rng-devel.sha256sum] = "f7651e67f168f58ac40133964db71a7846eaa185424c6c4d4b2edeb6b9cb02c8"

URI_x86_64_v2_rust-rand+unbiased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+unbiased-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand+unbiased-devel}"
SRC_URI[x86_64_v2_rust-rand+unbiased-devel.sha256sum] = "728e5771bea7ebcd36a95ef31cceef2c9dae9f3b01d60a0806a80d8a11907ec3"

URI_x86_64_v2_rust-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand-devel-0.9.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand-devel}"
SRC_URI[x86_64_v2_rust-rand-devel.sha256sum] = "345767a6de687e156c0ecd7382e24cb2f4b038b921d33e1f77e448976891ebe9"

URI_aarch64_rust-rand+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+alloc-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+alloc-devel}"
SRC_URI[aarch64_rust-rand+alloc-devel.sha256sum] = "61c49debe73db226b2e76017fd81114bc38ec37999dfb0a4483107ed03c77d2a"

URI_aarch64_rust-rand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+default-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+default-devel}"
SRC_URI[aarch64_rust-rand+default-devel.sha256sum] = "93dd781dd755473a4eef5ef17a3dd2d617124735943c0059f60e6ff0fea8f8ee"

URI_aarch64_rust-rand+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+log-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+log-devel}"
SRC_URI[aarch64_rust-rand+log-devel.sha256sum] = "223b8b1ea9cb9ebf734cfbc7320869835681f607fc3af240f1208b1fde7fc15e"

URI_aarch64_rust-rand+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+os_rng-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+os_rng-devel}"
SRC_URI[aarch64_rust-rand+os_rng-devel.sha256sum] = "5bba59d4e1736d491de92c760006f1fc63ee53d73a242d23b2499fb5c541fae0"

URI_aarch64_rust-rand+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+serde-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+serde-devel}"
SRC_URI[aarch64_rust-rand+serde-devel.sha256sum] = "b06c9f0df243e5d02d8137541f4c49f95d828f4da7e58d79154edf17858da302"

URI_aarch64_rust-rand+small_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+small_rng-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+small_rng-devel}"
SRC_URI[aarch64_rust-rand+small_rng-devel.sha256sum] = "68c5150f246013a7e7612191ebe33766933f0fcd9503e1ae4aa7d0193426deaf"

URI_aarch64_rust-rand+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+std-devel}"
SRC_URI[aarch64_rust-rand+std-devel.sha256sum] = "300eb7053fad7d5b71b050e7a9e0acfcc28ce818da4d6c0d499a3df2755e7afd"

URI_aarch64_rust-rand+std_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std_rng-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+std_rng-devel}"
SRC_URI[aarch64_rust-rand+std_rng-devel.sha256sum] = "9e5d5a70bc9eb85231c5b064725a9ca36dbecc88a3e8de438a531098a9c7221b"

URI_aarch64_rust-rand+thread_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+thread_rng-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand+thread_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+thread_rng-devel}"
SRC_URI[aarch64_rust-rand+thread_rng-devel.sha256sum] = "df952fee60bb1e484c09983796f597dea23d9c3297a8e1f1fe57a761f98065a0"

URI_aarch64_rust-rand+unbiased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+unbiased-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand+unbiased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand+unbiased-devel}"
SRC_URI[aarch64_rust-rand+unbiased-devel.sha256sum] = "c83d2b0b9b08362e0a9dfdbb5ae2d69b6a992c794b40be2062f3129a3c56879e"

URI_aarch64_rust-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand-devel-0.9.2-1.el10_0.noarch.rpm;name=aarch64_rust-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand-devel}"
SRC_URI[aarch64_rust-rand-devel.sha256sum] = "0759e4d6af1486adcb50353c9a80e692efb5bca2eb58bb84fd328c0c8eab8590"

RDEPENDS:rust-rand+alloc-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+default-devel = " \
 cargo \
 rust-rand+os_rng-devel \
 rust-rand+small_rng-devel \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+os_rng-devel = " \
 cargo \
 rust-rand-devel \
 rust-rand_core+os_rng-devel \
 "
RDEPENDS:rust-rand+serde-devel = " \
 cargo \
 rust-rand-devel \
 rust-rand_core+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand+small_rng-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+std-devel = " \
 cargo \
 rust-rand+alloc-devel \
 rust-rand-devel \
 rust-rand_chacha+std-devel \
 rust-rand_chacha-devel \
 rust-rand_core+std-devel \
 "
RDEPENDS:rust-rand+std_rng-devel = " \
 cargo \
 rust-rand-devel \
 rust-rand_chacha-devel \
 "
RDEPENDS:rust-rand+thread_rng-devel = " \
 cargo \
 rust-rand+os_rng-devel \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+unbiased-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand-devel = " \
 cargo \
 rust \
 rust-rand_core-devel \
 "
