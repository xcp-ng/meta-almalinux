# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvirt"
PV = "11.10.0"
PR = "12.4.el10_2.alma.1"
PACKAGES = " \
 libvirt \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-common \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 libvirt-daemon-kvm \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-plugin-sanlock \
 libvirt-daemon-proxy \
 libvirt-devel \
 libvirt-docs \
 libvirt-libs \
 libvirt-nss \
 libvirt-ssh-proxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvirt-11.10.0-12.4.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bece919fa89af4490a18ba9bf35dc0866abf24ace2700af88110ede81ce909b"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - libvirt-daemon-plugin-sanlock: augeas

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - libvirt-daemon-plugin-sanlock: augeas

URI_x86_64_v2_libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt}"
SRC_URI[x86_64_v2_libvirt.sha256sum] = "7b2763345243f33379a5c26668d3538b90bd287073f5bedb8cc83625e0d4be77"

URI_x86_64_v2_libvirt-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-client}"
SRC_URI[x86_64_v2_libvirt-client.sha256sum] = "3d2d2d9be985ff8a08e21f383022b2141ee181b57df705283014bc06913a1aaa"

URI_x86_64_v2_libvirt-client-qemu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-qemu-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client-qemu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-client-qemu}"
SRC_URI[x86_64_v2_libvirt-client-qemu.sha256sum] = "b8a652616caebc19b00cc9c6399829f4808f65e5e451126d4a07e89f1c06d76a"

URI_x86_64_v2_libvirt-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon}"
SRC_URI[x86_64_v2_libvirt-daemon.sha256sum] = "887cfdeeeba43405cea870010352d37b671d9c23007744dfd179bddf970c04fe"

URI_x86_64_v2_libvirt-daemon-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-common-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-common}"
SRC_URI[x86_64_v2_libvirt-daemon-common.sha256sum] = "db1e992defb236e574cb46f16bb4c27348cc1b26e9c1978e11a283a4d8a3798a"

URI_x86_64_v2_libvirt-daemon-config-network = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-network-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-config-network}"
SRC_URI[x86_64_v2_libvirt-daemon-config-network.sha256sum] = "024a3028cc12624eab89c89140c4aa66b525bd48630a53e5ded5d815dec9972b"

URI_x86_64_v2_libvirt-daemon-config-nwfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-nwfilter-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-config-nwfilter}"
SRC_URI[x86_64_v2_libvirt-daemon-config-nwfilter.sha256sum] = "1990ef9417ffa87fc44ff41125c34caa9220216194d602c653a7a8024d006ed8"

URI_x86_64_v2_libvirt-daemon-driver-interface = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-interface-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-interface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-interface}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-interface.sha256sum] = "3cd97143458f51a420a592756a448d91315f3e2483d250daa24f28a479ade82b"

URI_x86_64_v2_libvirt-daemon-driver-network = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-network-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-network}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-network.sha256sum] = "a01f5175eba0f68bea7250f7a46bcc0c0831f762c2a49a6d6c7b360022217e87"

URI_x86_64_v2_libvirt-daemon-driver-nodedev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nodedev-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-nodedev}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nodedev.sha256sum] = "3c0571d966e761c4c23fdd31d43a724c63d3c546f0a3728a9a3da72388207401"

URI_x86_64_v2_libvirt-daemon-driver-nwfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nwfilter-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-nwfilter}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nwfilter.sha256sum] = "f827f42f661c0c12c91d4478e14193253f06a03014ad77b3385ff6d9d20744d4"

URI_x86_64_v2_libvirt-daemon-driver-qemu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-qemu-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-qemu}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-qemu.sha256sum] = "86cc6a27e15bc83524544afea41d67d04412348a17c710b179ffc573cc50cc17"

URI_x86_64_v2_libvirt-daemon-driver-secret = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-secret-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-secret;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-secret}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-secret.sha256sum] = "412861fe65792f8ffedd105709a312e7f296b81d8fe4905bfce1377bd0afd2a8"

URI_x86_64_v2_libvirt-daemon-driver-storage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage.sha256sum] = "9933dc3a746f7a7d4bfb1c639bb22560921b95a86586839a6915da88b2369354"

URI_x86_64_v2_libvirt-daemon-driver-storage-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-core-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-core}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-core.sha256sum] = "98397e2be622c1f42222bc0f3b201b28c340cfbabd78575971203838613dce8f"

URI_x86_64_v2_libvirt-daemon-driver-storage-disk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-disk-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-disk}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-disk.sha256sum] = "e6bb6ad8bca9004d95dc3fc29e7f68147c54aadf7f13a64ec9a932e4fbd3dd5a"

URI_x86_64_v2_libvirt-daemon-driver-storage-iscsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-iscsi-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-iscsi}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-iscsi.sha256sum] = "cbfdcee4d3da139e6cd3b5c3b93676fbd32ef4547729c25436d4bbc09a77028d"

URI_x86_64_v2_libvirt-daemon-driver-storage-logical = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-logical-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-logical}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-logical.sha256sum] = "13069236659b63b2c9c24cfbfae22de6d1fe36b15b76cc95678533213c343e6e"

URI_x86_64_v2_libvirt-daemon-driver-storage-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-mpath-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-mpath}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-mpath.sha256sum] = "fc1a306cb96a83bed7977383f75201359a31c74ce0bfa253b2a0302233f0e19b"

URI_x86_64_v2_libvirt-daemon-driver-storage-rbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-rbd-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-rbd}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-rbd.sha256sum] = "9e49ffd48fa71ca126a09fa7c3e546789eb5481455dc84d08f8d181aba66d8ec"

URI_x86_64_v2_libvirt-daemon-driver-storage-scsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-scsi-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-scsi}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-scsi.sha256sum] = "be4490fe2f66141c2c8a8b841fa489b652af138f99c8924be4d483bf102fe691"

URI_x86_64_v2_libvirt-daemon-kvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-kvm-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-kvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-kvm}"
SRC_URI[x86_64_v2_libvirt-daemon-kvm.sha256sum] = "820b6ff7244c90cffe4762ea675f1249dd5df9c5e1da99a89f2c6562be92bf67"

URI_x86_64_v2_libvirt-daemon-lock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-lock-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-lock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-lock}"
SRC_URI[x86_64_v2_libvirt-daemon-lock.sha256sum] = "d30a5f6eb461f8773bf180bc9052d1785216047e4902983b538f74daba726ad8"

URI_x86_64_v2_libvirt-daemon-log = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-log-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-log}"
SRC_URI[x86_64_v2_libvirt-daemon-log.sha256sum] = "685eff276a92a7d2edfb8414807be4b62de7a5338fb1b5ef6c13704a1cb2f6a0"

URI_x86_64_v2_libvirt-daemon-plugin-lockd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-plugin-lockd-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-plugin-lockd}"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-lockd.sha256sum] = "f0b7e1b5905fe1d25c40f40664d23e9173fddcd4da63077d862047fe2ce64e37"

URI_x86_64_v2_libvirt-daemon-plugin-sanlock = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-daemon-plugin-sanlock-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-plugin-sanlock}"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-sanlock.sha256sum] = "25604790f5ffb74f509d7a2b881e3f323c9c9ad1900a44b0c53fa89e50dee391"

URI_x86_64_v2_libvirt-daemon-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-proxy-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-proxy}"
SRC_URI[x86_64_v2_libvirt-daemon-proxy.sha256sum] = "7f89506a76cf25fb887ea1a174b1353749dd16d5e4415fc3a3e88fd2a7e8fac1"

URI_x86_64_v2_libvirt-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-devel-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-devel}"
SRC_URI[x86_64_v2_libvirt-devel.sha256sum] = "2d890517079f64f9ef3c1ac8b23e32d56fff01fb9a37de7db174547a2ad52589"

URI_x86_64_v2_libvirt-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-docs-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-docs}"
SRC_URI[x86_64_v2_libvirt-docs.sha256sum] = "e84bbc52e6d79e3320126b317c0bc1f93bfa16b2faf3a864ab06d0d168ab5d35"

URI_x86_64_v2_libvirt-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-libs-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-libs}"
SRC_URI[x86_64_v2_libvirt-libs.sha256sum] = "bb8e95d994ec77eb246f208eaf0baaec3f3ffb09690155af47b1f0bfcad661c3"

URI_x86_64_v2_libvirt-nss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-nss-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-nss}"
SRC_URI[x86_64_v2_libvirt-nss.sha256sum] = "2ab3600c06c6ee3d300ca794bd6f398051a517fbfd0fdedb80c12ca5a7a2c694"

URI_x86_64_v2_libvirt-ssh-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-ssh-proxy-11.10.0-12.4.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-ssh-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-ssh-proxy}"
SRC_URI[x86_64_v2_libvirt-ssh-proxy.sha256sum] = "445d68b0ed961ed85b3463e9fb1ff1f32bc0a4bcd11e08743b7875fc7c87e452"

URI_aarch64_libvirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt}"
SRC_URI[aarch64_libvirt.sha256sum] = "48f85da8024b95152a5ea6f89c4bbf3209760adfc79f27672079811c9f97a5fa"

URI_aarch64_libvirt-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-client}"
SRC_URI[aarch64_libvirt-client.sha256sum] = "40de4c5ec7f500d09df5916ada0d257fed0130199a69a5d71485c4347614e5de"

URI_aarch64_libvirt-client-qemu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-qemu-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-client-qemu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-client-qemu}"
SRC_URI[aarch64_libvirt-client-qemu.sha256sum] = "e5714169f9aa66ec84d9c97af8309cb6d6d3a72e2cb4c9d99385391fff88a2e2"

URI_aarch64_libvirt-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon}"
SRC_URI[aarch64_libvirt-daemon.sha256sum] = "9c5792b9f7d6ad1c63e355e67d173ef6d434cd688fef604697d87ed257da2f43"

URI_aarch64_libvirt-daemon-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-common-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-common}"
SRC_URI[aarch64_libvirt-daemon-common.sha256sum] = "c31f2f77fc716daaa8c3871766481860f36aa4ae2a1ccab30081bd120b211f2d"

URI_aarch64_libvirt-daemon-config-network = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-network-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-config-network}"
SRC_URI[aarch64_libvirt-daemon-config-network.sha256sum] = "b58ff4aaa420734ee35b25e50b39c6bff0689c7f562ce0da67d289826e9606e8"

URI_aarch64_libvirt-daemon-config-nwfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-nwfilter-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-config-nwfilter}"
SRC_URI[aarch64_libvirt-daemon-config-nwfilter.sha256sum] = "148ae42a84903b19912ddf39f8f87e2b0bce61ef4a8a9248637b9fa63214ae93"

URI_aarch64_libvirt-daemon-driver-interface = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-interface-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-interface;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-interface}"
SRC_URI[aarch64_libvirt-daemon-driver-interface.sha256sum] = "0b72f3be605620d3c35dd0640b87a1fb34ba81c0adc72fb51e45ad3c29350c12"

URI_aarch64_libvirt-daemon-driver-network = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-network-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-network}"
SRC_URI[aarch64_libvirt-daemon-driver-network.sha256sum] = "74adf87c5a45f61489bdf95c1bd6ce0da0a1f258a53a5dbb310ff4a6b7152e4c"

URI_aarch64_libvirt-daemon-driver-nodedev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nodedev-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-nodedev}"
SRC_URI[aarch64_libvirt-daemon-driver-nodedev.sha256sum] = "5e968f2d2180e122979e612e459b7d96d1aec257cfb66c594782337e9d377b5b"

URI_aarch64_libvirt-daemon-driver-nwfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nwfilter-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-nwfilter}"
SRC_URI[aarch64_libvirt-daemon-driver-nwfilter.sha256sum] = "d668e8cf26fcda014c9639b051a52913399e799ba40bb7e809fb92344f6a3a62"

URI_aarch64_libvirt-daemon-driver-qemu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-qemu-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-qemu}"
SRC_URI[aarch64_libvirt-daemon-driver-qemu.sha256sum] = "9d72305059fae7348eab3de479bb7c8f84cbde77dda0d6e169ef161d799cbb15"

URI_aarch64_libvirt-daemon-driver-secret = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-secret-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-secret;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-secret}"
SRC_URI[aarch64_libvirt-daemon-driver-secret.sha256sum] = "6dce5557f518f16c10326c12aa68c63fc879290a55e17e096861d4d054af9108"

URI_aarch64_libvirt-daemon-driver-storage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage}"
SRC_URI[aarch64_libvirt-daemon-driver-storage.sha256sum] = "44cb88402a1b4330637b49e13266820bf0c8a5314745549bf17ceb9a28183949"

URI_aarch64_libvirt-daemon-driver-storage-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-core-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-core}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-core.sha256sum] = "c7b64cee95df1543cc68078eda3d29b5bb60ace445cf8ef5e3101ae2ed340d4f"

URI_aarch64_libvirt-daemon-driver-storage-disk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-disk-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-disk}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-disk.sha256sum] = "29be6aa74162f86dc12faa156baa587628ee923d364d743967c83186b250a327"

URI_aarch64_libvirt-daemon-driver-storage-iscsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-iscsi-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-iscsi}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-iscsi.sha256sum] = "83c7d78a093a2cca57b77ba1d5f4fa5449eda53cd396dabf9f4dcced53fc8ca4"

URI_aarch64_libvirt-daemon-driver-storage-logical = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-logical-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-logical}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-logical.sha256sum] = "a8afb4c1aa812ab1529116a48bbbaf0e0619e2053cd854218b82dae6ae278ac1"

URI_aarch64_libvirt-daemon-driver-storage-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-mpath-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-mpath}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-mpath.sha256sum] = "bcafd8b3d726c2fbc8091207f107187346806372afc3ebef2ceaa59823cf5549"

URI_aarch64_libvirt-daemon-driver-storage-rbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-rbd-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-rbd}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-rbd.sha256sum] = "998f1e9c432cfc5f20cd2e1a91f683088516cc9440a835c6d1fd920cbd7739de"

URI_aarch64_libvirt-daemon-driver-storage-scsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-scsi-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-scsi}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-scsi.sha256sum] = "b43e1c6b7147b7299361a2ee76f41699790cf748d9ea887a5829ac4bad729f98"

URI_aarch64_libvirt-daemon-kvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-kvm-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-kvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-kvm}"
SRC_URI[aarch64_libvirt-daemon-kvm.sha256sum] = "4d30066f9517d1ca75d3ce38737ac372ecc8e906a21a94be80519cfefade0d8f"

URI_aarch64_libvirt-daemon-lock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-lock-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-lock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-lock}"
SRC_URI[aarch64_libvirt-daemon-lock.sha256sum] = "ab9dbb7ff9b926eaeb8ef5df0700cc19ed605a771161bdd61c94aaeca817d997"

URI_aarch64_libvirt-daemon-log = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-log-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-log}"
SRC_URI[aarch64_libvirt-daemon-log.sha256sum] = "0b4c5efc12612e2d533995a4faa9bc23bf80e7be2a6154534f3cb87a4498f236"

URI_aarch64_libvirt-daemon-plugin-lockd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-plugin-lockd-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-plugin-lockd}"
SRC_URI[aarch64_libvirt-daemon-plugin-lockd.sha256sum] = "14814ad9fcf32a34663232b37b08fcab1510473507f016ac9644688753d85c73"

URI_aarch64_libvirt-daemon-plugin-sanlock = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-daemon-plugin-sanlock-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-plugin-sanlock}"
SRC_URI[aarch64_libvirt-daemon-plugin-sanlock.sha256sum] = "74c455f1fec2268cd63a486dc7e28a37eb7d35bcf3e985333f7fdb9a99f530dc"

URI_aarch64_libvirt-daemon-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-proxy-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-proxy}"
SRC_URI[aarch64_libvirt-daemon-proxy.sha256sum] = "a46563827e4ac5b24a9d16b01435ce199f60148dfe89edd2e148de9511c22c3d"

URI_aarch64_libvirt-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-devel-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-devel}"
SRC_URI[aarch64_libvirt-devel.sha256sum] = "43c718dcef873fcbc848d101979ae5bb520fc4ef5fda902185c348b05c143686"

URI_aarch64_libvirt-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-docs-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-docs}"
SRC_URI[aarch64_libvirt-docs.sha256sum] = "eadbb58c89bedd6f5162f80936e0f91a51d1496b1b3ca3ba75f2d439edf5da33"

URI_aarch64_libvirt-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-libs-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-libs}"
SRC_URI[aarch64_libvirt-libs.sha256sum] = "329b6f089a2683d25868b513ab3e1ea108dd087040a26c1c48bad32e143f3fc7"

URI_aarch64_libvirt-nss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-nss-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-nss}"
SRC_URI[aarch64_libvirt-nss.sha256sum] = "244c6410584bb23d85017e9d9e95501098aa6dd3fd7c3486841416e62be3eecf"

URI_aarch64_libvirt-ssh-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-ssh-proxy-11.10.0-12.4.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-ssh-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-ssh-proxy}"
SRC_URI[aarch64_libvirt-ssh-proxy.sha256sum] = "f4ef0699b80aa8810af3399468258e485eaac010c69ecf2bc26e8372a48cb09a"

RDEPENDS:libvirt = " \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-libs \
 "
RDEPENDS:libvirt-client = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libvirt-libs \
 libxml2 \
 readline \
 "
RDEPENDS:libvirt-client-qemu = " \
 libvirt-libs \
 python3 \
 python3-cryptography \
 python3-libvirt \
 python3-lxml \
 "
RDEPENDS:libvirt-daemon = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-common = " \
 bash \
 dbus \
 dmidecode \
 gettext \
 glib2 \
 glibc \
 iproute \
 iproute-tc \
 kmod \
 libacl \
 libgcc \
 libvirt-libs \
 polkit \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:libvirt-daemon-config-network = " \
 bash \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-daemon-config-nwfilter = " \
 bash \
 libvirt-daemon-driver-nwfilter \
 "
RDEPENDS:libvirt-daemon-driver-interface = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-network = " \
 bash \
 dnsmasq \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 nftables \
 "
RDEPENDS:libvirt-daemon-driver-nodedev = " \
 bash \
 glib2 \
 glibc \
 kmod \
 libgcc \
 libpciaccess \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 mdevctl \
 systemd \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-nwfilter = " \
 bash \
 glib2 \
 glibc \
 iptables-nft \
 libgcc \
 libpcap \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-qemu = " \
 bash \
 bzip2 \
 glib2 \
 glibc \
 gnutls \
 gzip \
 libgcc \
 libnbd \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-log \
 libvirt-libs \
 libxml2 \
 lzop \
 numad \
 qemu-img \
 swtpm-tools \
 systemd-container \
 xz \
 zstd \
 "
RDEPENDS:libvirt-daemon-driver-secret = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage = " \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 "
RDEPENDS:libvirt-daemon-driver-storage-core = " \
 bash \
 glib2 \
 glibc \
 libblkid \
 libgcc \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 libxml2 \
 parted \
 qemu-img \
 scrub \
 util-linux \
 "
RDEPENDS:libvirt-daemon-driver-storage-disk = " \
 device-mapper \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 parted \
 "
RDEPENDS:libvirt-daemon-driver-storage-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-logical = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 lvm2 \
 "
RDEPENDS:libvirt-daemon-driver-storage-mpath = " \
 device-mapper \
 device-mapper-libs \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-rbd = " \
 glib2 \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-scsi = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-kvm = " \
 libvirt-daemon-common \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-ssh-proxy \
 qemu-kvm \
 "
RDEPENDS:libvirt-daemon-lock = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-log = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-lockd = " \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-sanlock = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-common \
 libvirt-libs \
 sanlock \
 sanlock-lib \
 "
RDEPENDS:libvirt-daemon-proxy = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-devel = " \
 libvirt-devel \
 libvirt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libvirt-docs = " \
 "
RDEPENDS:libvirt-libs = " \
 audit-libs \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 glib2 \
 glibc \
 gnutls \
 json-c \
 libacl \
 libcap-ng \
 libgcc \
 libnl3 \
 libselinux \
 libssh \
 libtirpc \
 libxml2 \
 numactl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libvirt-nss = " \
 glibc \
 json-c \
 libgcc \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-ssh-proxy = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-libs \
 libxml2 \
 "
