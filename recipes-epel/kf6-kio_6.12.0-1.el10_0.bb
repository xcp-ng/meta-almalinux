# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kio"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kio \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kio-devel \
 kf6-kio-doc \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-qch-doc \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kio-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "774da55d890e36bd3f6c70908fbcc93d5f3503ab00b3038f15de242e2c3005b2"

URI_x86_64_v2_kf6-kio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio}"
SRC_URI[x86_64_v2_kf6-kio.sha256sum] = "78ec01c8184c7158fb5ae3a601de2d49c25c7e8b09998d8ae6eb619356a5a732"

URI_x86_64_v2_kf6-kio-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-core-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-core}"
SRC_URI[x86_64_v2_kf6-kio-core.sha256sum] = "4bb9427ccf2f1e66e2c8ec79b216bafed87efdbe559d154b9fc399bef68813f6"

URI_x86_64_v2_kf6-kio-core-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-core-libs-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-core-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-core-libs}"
SRC_URI[x86_64_v2_kf6-kio-core-libs.sha256sum] = "b0469b357035ee6238bb0b9b16a5bfab1bb5678d03810b44b3faf6e28565b6a9"

URI_x86_64_v2_kf6-kio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-devel}"
SRC_URI[x86_64_v2_kf6-kio-devel.sha256sum] = "e515d18c102c63e867ee8fdf0815c64616a8e0ddbe39a42907c35ae4bd9911f8"

URI_x86_64_v2_kf6-kio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-doc}"
SRC_URI[x86_64_v2_kf6-kio-doc.sha256sum] = "abe170c2975dca8f933755293dcb0e4515312d7b0e4ec1aed6ce40504c363a80"

URI_x86_64_v2_kf6-kio-file-widgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-file-widgets-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-file-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-file-widgets}"
SRC_URI[x86_64_v2_kf6-kio-file-widgets.sha256sum] = "79bec5885e7b25c1edc84b644d7491a8403a6b9fd13d16640b5718a642a899b5"

URI_x86_64_v2_kf6-kio-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-gui-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-gui}"
SRC_URI[x86_64_v2_kf6-kio-gui.sha256sum] = "caa07831266178c4356164b1ceac19e65ebdee804ec1a06df973ebe36a4c917e"

URI_x86_64_v2_kf6-kio-qch-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-qch-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-qch-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-qch-doc}"
SRC_URI[x86_64_v2_kf6-kio-qch-doc.sha256sum] = "fbbedc149579dc8c8b9d16d354be314342a946814699eb983538ceac039c1b3a"

URI_x86_64_v2_kf6-kio-widgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-widgets-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-widgets}"
SRC_URI[x86_64_v2_kf6-kio-widgets.sha256sum] = "7325bfd8a80ee548e6549f6a63e37ca2d33a5b39b052fbc29efc4bdec5c21727"

URI_x86_64_v2_kf6-kio-widgets-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-widgets-libs-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-widgets-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-widgets-libs}"
SRC_URI[x86_64_v2_kf6-kio-widgets-libs.sha256sum] = "2436086f0fdc3343f71966a2d111d896a55c6a3f70ce55e6a0027047e1d5d5b1"

URI_aarch64_kf6-kio = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kio;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio}"
SRC_URI[aarch64_kf6-kio.sha256sum] = "a4edbe473202f7ad2161b7fd19b680bcf27f3abfe03b79498e80dbfadcc1e282"

URI_aarch64_kf6-kio-core = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-core-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kio-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-core}"
SRC_URI[aarch64_kf6-kio-core.sha256sum] = "e99cbc8e1aa7a6ab222b6fd98f3fcf91d70aa9022724f024c1e9873be10b0d5f"

URI_aarch64_kf6-kio-core-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-core-libs-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kio-core-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-core-libs}"
SRC_URI[aarch64_kf6-kio-core-libs.sha256sum] = "d6c99ee621c8952e69718023af4fbe75495c49d88fc13fb1903d0a299f06be6a"

URI_aarch64_kf6-kio-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-devel}"
SRC_URI[aarch64_kf6-kio-devel.sha256sum] = "d01ba4a3640980b35552bf27c2a2642b54381c3584c7e7e625642704dd95b8b0"

URI_aarch64_kf6-kio-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-doc}"
SRC_URI[aarch64_kf6-kio-doc.sha256sum] = "69c30e456e709aeb8ce5ee68a7583d6a7c6f2390e3c6716f3c547579d733373f"

URI_aarch64_kf6-kio-file-widgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-file-widgets-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kio-file-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-file-widgets}"
SRC_URI[aarch64_kf6-kio-file-widgets.sha256sum] = "c091021de9dbbb2d833c0954a73452cb925c7f01d1688120c1d778d33f6c1432"

URI_aarch64_kf6-kio-gui = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-gui-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kio-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-gui}"
SRC_URI[aarch64_kf6-kio-gui.sha256sum] = "4b0e4f4466f05ed53f8d381f76efb159a7b2e1a143d2e12228fcfed6caa5044d"

URI_aarch64_kf6-kio-qch-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-qch-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kio-qch-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-qch-doc}"
SRC_URI[aarch64_kf6-kio-qch-doc.sha256sum] = "27f8fa332db117da97a840c321cb87cd3810edd0daf97895d33b8f83f18943d8"

URI_aarch64_kf6-kio-widgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-widgets-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kio-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-widgets}"
SRC_URI[aarch64_kf6-kio-widgets.sha256sum] = "f577a59b1a49c498c8dd8603221459102b30729a6977c94602bf40a48a9e05c9"

URI_aarch64_kf6-kio-widgets-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-widgets-libs-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kio-widgets-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-widgets-libs}"
SRC_URI[aarch64_kf6-kio-widgets-libs.sha256sum] = "8f109046cc04927e0952b792bf420251a96bc1df4e9f2c305ad6b8b822df5d38"

RDEPENDS:kf6-kio = " \
 kf6-kded \
 kf6-kio-core \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets \
 "
RDEPENDS:kf6-kio-core = " \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdoctools \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-doc \
 kf6-kio-gui \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-solid \
 libacl \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-core-libs = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kservice \
 libacl \
 libmount \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kio-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kbookmarks-devel \
 kf6-kcompletion-devel \
 kf6-kconfig-devel \
 kf6-kcoreaddons-devel \
 kf6-kio \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemviews-devel \
 kf6-kjobwidgets-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 kf6-kxmlgui-devel \
 kf6-solid-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-doc = " \
 kf6-kio-core \
 "
RDEPENDS:kf6-kio-file-widgets = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-gui = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-qch-doc = " \
 "
RDEPENDS:kf6-kio-widgets = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kio-widgets-libs = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
