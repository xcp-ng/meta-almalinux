# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ldc"
PE = "1"
PV = "1.40.0"
PR = "2.el10_0"
PACKAGES = " \
 ldc \
 ldc-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/ldc-1.40.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5698ef451d73c7f7dafa40d1bc5a933ba235c16955d2575ea7b52f2b330edc8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ldc-1.40.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ldc;unpack=0"
SRC_URI[x86_64_v2_ldc.sha256sum] = "4776958c6dee47968372ca2cbad91d0bfbaee6161778d3b539e62b374c2add51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ldc-libs-1.40.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ldc-libs;unpack=0"
SRC_URI[x86_64_v2_ldc-libs.sha256sum] = "7311e5d1e5aa325b013641dd33de2fbfcbdf9ff154690a2c9423c5702f0090e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/ldc-1.40.0-2.el10_0.aarch64.rpm;name=aarch64_ldc;unpack=0"
SRC_URI[aarch64_ldc.sha256sum] = "eb4ec1dc543849595faa3617e2bc43f74d49d7c9f5bbf14dbea494a94e36bceb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/ldc-libs-1.40.0-2.el10_0.aarch64.rpm;name=aarch64_ldc-libs;unpack=0"
SRC_URI[aarch64_ldc-libs.sha256sum] = "e9a48f985669a42b718f818efc00bc26e27fed7607e30ff1242ade674ec9ad0b"

RDEPENDS:ldc = " \
 gcc \
 glibc \
 ldc-libs \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:ldc-libs = " \
 glibc \
 libgcc \
 zlib-ng-compat \
 "
