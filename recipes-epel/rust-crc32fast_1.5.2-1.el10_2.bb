# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crc32fast"
PV = "1.5.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-crc32fast+default-devel \
 rust-crc32fast+nightly-devel \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crc32fast-1.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a193d0ea5e208efabd3b124b810910cb7f9913135fd3f1439aefbe9db3b78bcf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+default-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crc32fast+default-devel.sha256sum] = "2c4d27e5098a236528a2c99b2c86d86d7c7e5e3167805fe8035bfeccbddfa943"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+nightly-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crc32fast+nightly-devel.sha256sum] = "c7daf3f0c9cdf16a442a96589e105b437df39a94f7c436a5cd6c7c6d785a058c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast+std-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crc32fast+std-devel.sha256sum] = "9b1911a5351b613e9f4f5a5fa24ee626ea18cd9d4db49f278217caf2555d0ce1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crc32fast-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crc32fast-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crc32fast-devel.sha256sum] = "bb68baa3acb795458e95012b7f31d8d5351d9840b0b4130efd86355aec46dfa7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+default-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-crc32fast+default-devel;unpack=0"
SRC_URI[aarch64_rust-crc32fast+default-devel.sha256sum] = "5d4837da5b892383abaf0a91f382887fa6cb2f5ad946fb27b00f6c11433bf3c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+nightly-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-crc32fast+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-crc32fast+nightly-devel.sha256sum] = "e19ebecd1b9eba83e5647cb21bfdb23b35446e03da27ec40268048edcfc960a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast+std-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-crc32fast+std-devel;unpack=0"
SRC_URI[aarch64_rust-crc32fast+std-devel.sha256sum] = "5d522dbb4ab7e1a78cf241cdc98e107d1c9006d0f565007db74490f5fce27dcb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crc32fast-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-crc32fast-devel;unpack=0"
SRC_URI[aarch64_rust-crc32fast-devel.sha256sum] = "2a1af4cf52aabb233b8617d2f2eb8dda11da0223a1fa224b449307ca89af8947"

RDEPENDS:rust-crc32fast+default-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast+nightly-devel = " \
 cargo \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast+std-devel = " \
 cargo \
 rust-crc32fast-devel \
 "
RDEPENDS:rust-crc32fast-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
