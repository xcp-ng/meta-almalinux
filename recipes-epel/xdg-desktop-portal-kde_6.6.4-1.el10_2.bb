# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal-kde"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 xdg-desktop-portal-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xdg-desktop-portal-kde-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8be819de8c42347e8a6c46a74bb603c43bf03618046c9cf941cca946406f2c6f"

URI_x86_64_v2_xdg-desktop-portal-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xdg-desktop-portal-kde-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal-kde}"
SRC_URI[x86_64_v2_xdg-desktop-portal-kde.sha256sum] = "1dd5711d48e4b1a69318522e8447f7570e3bd65830424cb12c56fa87a39c7a5f"

URI_aarch64_xdg-desktop-portal-kde = "${EPEL_MIRROR}/aarch64/Packages/x/xdg-desktop-portal-kde-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_xdg-desktop-portal-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal-kde}"
SRC_URI[aarch64_xdg-desktop-portal-kde.sha256sum] = "33398305e93441db806b41fe678e5382f143e5318eaf149eb952de4a51384c45"

RDEPENDS:xdg-desktop-portal-kde = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kwayland \
 libstdc++ \
 libwayland-client \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xdg-desktop-portal \
 xdg-desktop-portal-gtk \
 "
