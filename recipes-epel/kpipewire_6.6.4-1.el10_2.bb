# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpipewire"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kpipewire \
 kpipewire-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpipewire-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7907d5a7480d84474df917ddecc2989cbb60488cf519cedd5189b1a1f3eebd8"

URI_x86_64_v2_kpipewire = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpipewire-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpipewire}"
SRC_URI[x86_64_v2_kpipewire.sha256sum] = "1d8fec8ccaee5205e9e747ed1d534114ddc4945b9362ee6fda97e4fbe6cf3f47"

URI_x86_64_v2_kpipewire-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpipewire-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpipewire-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpipewire-devel}"
SRC_URI[x86_64_v2_kpipewire-devel.sha256sum] = "56008e150822a3778c8afbb4c13123fe824900d1af25de1bd5e51df186b0fbdf"

URI_aarch64_kpipewire = "${EPEL_MIRROR}/aarch64/Packages/k/kpipewire-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kpipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpipewire}"
SRC_URI[aarch64_kpipewire.sha256sum] = "e7a3c43c8a507882c17aa2e76a1b2553b784543f1cef9016ac48850362930069"

URI_aarch64_kpipewire-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpipewire-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kpipewire-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpipewire-devel}"
SRC_URI[aarch64_kpipewire-devel.sha256sum] = "87580c6d3b575d2720fc6c674db4e2c1f549fb8386afe1d2b4ed6a8a0708c441"

RDEPENDS:kpipewire = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libdrm \
 libepoxy \
 libgcc \
 libstdc++ \
 libva \
 mesa-libgbm \
 pipewire-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kpipewire-devel = " \
 cmake-filesystem \
 kpipewire \
 pipewire-devel \
 "
