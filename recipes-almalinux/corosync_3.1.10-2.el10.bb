# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "corosync"
PV = "3.1.10"
PR = "2.el10"
PACKAGES = " \
 corosync-vqsim \
 corosynclib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/corosync-3.1.10-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf14997beb6ddd8340e7f611f6797f49199942c54050ccab538ad6e678a08630"

URI_x86_64_v2_corosync-vqsim = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/corosync-vqsim-3.1.10-2.el10.x86_64_v2.rpm;name=x86_64_v2_corosync-vqsim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_corosync-vqsim}"
SRC_URI[x86_64_v2_corosync-vqsim.sha256sum] = "6ea731ff8b326ed9ae3f3fc8d3d643e7861e4324b581413947163ac943bfc232"

URI_x86_64_v2_corosynclib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/corosynclib-3.1.10-2.el10.x86_64_v2.rpm;name=x86_64_v2_corosynclib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_corosynclib}"
SRC_URI[x86_64_v2_corosynclib.sha256sum] = "de76d47edc113b950f452a14146a0cfd39fac75c32b462adbc7345a0d9b940f2"

URI_aarch64_corosync-vqsim = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/corosync-vqsim-3.1.10-2.el10.aarch64.rpm;name=aarch64_corosync-vqsim;unpack=0"
SRC_URI:append = " ${URI_aarch64_corosync-vqsim}"
SRC_URI[aarch64_corosync-vqsim.sha256sum] = "45c5c25348cd0800101900a18cdb1b93f51080af9d19dd6b8c77871a23c2bcf3"

URI_aarch64_corosynclib = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/corosynclib-3.1.10-2.el10.aarch64.rpm;name=aarch64_corosynclib;unpack=0"
SRC_URI:append = " ${URI_aarch64_corosynclib}"
SRC_URI[aarch64_corosynclib.sha256sum] = "e6e30fb388b0677dd498a2675907cfbd36aa0eb7e90c18d1296b323fd0958ee4"

RDEPENDS:corosync-vqsim = " \
 corosynclib \
 glibc \
 libknet1 \
 libqb \
 pkgconf-pkg-config \
 readline \
 "
RDEPENDS:corosynclib = " \
 glibc \
 libqb \
 "
