# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-b4"
PV = "0.14.3"
PR = "2.el10_1"
PACKAGES = " \
 b4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-b4-0.14.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11c3d3c5e09159b9060caba950be7cf0608db50ae13a9434be0c85cd077a7008"

URI_x86_64_v2_b4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/b4-0.14.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_b4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_b4}"
SRC_URI[x86_64_v2_b4.sha256sum] = "1f0c7e068aa20fbf3344124431cb63963582bf4f8d1a5cf1f845afd21674ece4"

URI_aarch64_b4 = "${EPEL_MIRROR}/aarch64/Packages/b/b4-0.14.3-2.el10_1.noarch.rpm;name=aarch64_b4;unpack=0"
SRC_URI:append = " ${URI_aarch64_b4}"
SRC_URI[aarch64_b4.sha256sum] = "1761f5a435b8f025c1332c7729c74b2105b0bc3cc4394c53e86b00af42eb6b96"

RDEPENDS:b4 = " \
 git-filter-repo \
 patatt \
 python3 \
 python3-dkimpy \
 python3-requests \
 "
