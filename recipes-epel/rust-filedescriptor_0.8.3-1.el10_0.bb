# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-filedescriptor"
PV = "0.8.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-filedescriptor+default-devel \
 rust-filedescriptor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-filedescriptor-0.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb50ddee3e060126793077c1689b218fefeea67e60930fba1b8aecdd2edb452f"

URI_x86_64_v2_rust-filedescriptor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filedescriptor+default-devel-0.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filedescriptor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filedescriptor+default-devel}"
SRC_URI[x86_64_v2_rust-filedescriptor+default-devel.sha256sum] = "2b746ac45c7bc5eafb6fe5b583ee2bab0bc60030c1d2e66b15162ba94de720c7"

URI_x86_64_v2_rust-filedescriptor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filedescriptor-devel-0.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filedescriptor-devel}"
SRC_URI[x86_64_v2_rust-filedescriptor-devel.sha256sum] = "a12fb0556ae5106541feadcc86abddf99dcfa30955d7d3ddd5f0f8d3403625a9"

URI_aarch64_rust-filedescriptor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filedescriptor+default-devel-0.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-filedescriptor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filedescriptor+default-devel}"
SRC_URI[aarch64_rust-filedescriptor+default-devel.sha256sum] = "6ee53e5c99522c6e2b2dac553ac73f8201a902ae1fd9b989f30ada3c3215a034"

URI_aarch64_rust-filedescriptor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filedescriptor-devel-0.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filedescriptor-devel}"
SRC_URI[aarch64_rust-filedescriptor-devel.sha256sum] = "1612188a3837bb6c86db39139eefbdc29b2ab0b9480a4d4776af875e3a90baa7"

RDEPENDS:rust-filedescriptor+default-devel = " \
 cargo \
 rust-filedescriptor-devel \
 "
RDEPENDS:rust-filedescriptor-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-thiserror1+default-devel \
 "
