# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-compression"
PV = "0.3.1"
PR = "2.el10_1"
PACKAGES = " \
 aws-c-compression \
 aws-c-compression-devel \
 aws-c-compression-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-compression-0.3.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d9499861f06b95acf602ea2979743880ea63c99364df4eba6c4a1652476d9fe"

URI_x86_64_v2_aws-c-compression = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-compression-0.3.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-compression;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-compression}"
SRC_URI[x86_64_v2_aws-c-compression.sha256sum] = "d53495708937961aaf9b01069e4a7fd2def72e790899bd94f20fb5cb655fb937"

URI_x86_64_v2_aws-c-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-compression-devel-0.3.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-compression-devel}"
SRC_URI[x86_64_v2_aws-c-compression-devel.sha256sum] = "00bb097652007903711d8531a233777a3237759d093a0fed7d1a7d2a406011ea"

URI_x86_64_v2_aws-c-compression-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-compression-libs-0.3.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-compression-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-compression-libs}"
SRC_URI[x86_64_v2_aws-c-compression-libs.sha256sum] = "1e5bed3d771ec8a57194556ee831e3e1ecca6c124e33a42f9a984282ce598745"

URI_aarch64_aws-c-compression = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-compression-0.3.1-2.el10_1.aarch64.rpm;name=aarch64_aws-c-compression;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-compression}"
SRC_URI[aarch64_aws-c-compression.sha256sum] = "751f5eeb622bfdb5f32ce67fdc9f691aff580244c6c7ab7f3688217d30fe7b0c"

URI_aarch64_aws-c-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-compression-devel-0.3.1-2.el10_1.aarch64.rpm;name=aarch64_aws-c-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-compression-devel}"
SRC_URI[aarch64_aws-c-compression-devel.sha256sum] = "caf0e6669fcd390fc0cb22ed6ca12d60ccf9279a08fb8e7eb027482468de8328"

URI_aarch64_aws-c-compression-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-compression-libs-0.3.1-2.el10_1.aarch64.rpm;name=aarch64_aws-c-compression-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-compression-libs}"
SRC_URI[aarch64_aws-c-compression-libs.sha256sum] = "0ab076cbd2d98bc125658a93a4d7bd74adfc04e53e9765a38a58075a2e372843"

RDEPENDS:aws-c-compression = " \
 aws-c-common-libs \
 "
RDEPENDS:aws-c-compression-devel = " \
 aws-c-common-devel \
 aws-c-compression \
 aws-c-compression-libs \
 cmake-filesystem \
 "
RDEPENDS:aws-c-compression-libs = " \
 aws-c-common-libs \
 aws-c-compression \
 glibc \
 "
