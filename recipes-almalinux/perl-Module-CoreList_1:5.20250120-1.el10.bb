# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-CoreList"
PE = "1"
PV = "5.20250120"
PR = "1.el10"
PACKAGES = " \
 perl-Module-CoreList \
 perl-Module-CoreList-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Module-CoreList-5.20250120-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "552865106e9c211d44db6df7ecb055fac4c5da192c0069f1bd61e78bfbbb7988"

URI_x86_64_v2_perl-Module-CoreList = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-CoreList-5.20250120-1.el10.noarch.rpm;name=x86_64_v2_perl-Module-CoreList;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-CoreList}"
SRC_URI[x86_64_v2_perl-Module-CoreList.sha256sum] = "7c61ed21d3071321c70148f3e539e7955d59f6ba1b7349d9cac2064710c21697"

URI_x86_64_v2_perl-Module-CoreList-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-CoreList-tools-5.20250120-1.el10.noarch.rpm;name=x86_64_v2_perl-Module-CoreList-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-CoreList-tools}"
SRC_URI[x86_64_v2_perl-Module-CoreList-tools.sha256sum] = "b5da03f1ec597fd282899217bc8db0246842c796c00f3423859152b1c5937f0d"

URI_aarch64_perl-Module-CoreList = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-CoreList-5.20250120-1.el10.noarch.rpm;name=aarch64_perl-Module-CoreList;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-CoreList}"
SRC_URI[aarch64_perl-Module-CoreList.sha256sum] = "7c61ed21d3071321c70148f3e539e7955d59f6ba1b7349d9cac2064710c21697"

URI_aarch64_perl-Module-CoreList-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-CoreList-tools-5.20250120-1.el10.noarch.rpm;name=aarch64_perl-Module-CoreList-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-CoreList-tools}"
SRC_URI[aarch64_perl-Module-CoreList-tools.sha256sum] = "b5da03f1ec597fd282899217bc8db0246842c796c00f3423859152b1c5937f0d"

RDEPENDS:perl-Module-CoreList = " \
 perl-Module-CoreList \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-version \
 "
RDEPENDS:perl-Module-CoreList-tools = " \
 perl-Getopt-Long \
 perl-Module-CoreList \
 perl-Pod-Usage \
 perl-Scalar-List-Utils \
 perl-interpreter \
 perl-libs \
 perl-version \
 "
