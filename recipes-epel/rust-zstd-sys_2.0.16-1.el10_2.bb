# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zstd-sys"
PV = "2.0.16"
PR = "1.el10_2"
PACKAGES = " \
 rust-zstd-sys+bindgen-devel \
 rust-zstd-sys+debug-devel \
 rust-zstd-sys+default-devel \
 rust-zstd-sys+experimental-devel \
 rust-zstd-sys+fat-lto-devel \
 rust-zstd-sys+legacy-devel \
 rust-zstd-sys+no_asm-devel \
 rust-zstd-sys+non-cargo-devel \
 rust-zstd-sys+pkg-config-devel \
 rust-zstd-sys+seekable-devel \
 rust-zstd-sys+std-devel \
 rust-zstd-sys+thin-devel \
 rust-zstd-sys+thin-lto-devel \
 rust-zstd-sys+zdict_builder-devel \
 rust-zstd-sys+zstdmt-devel \
 rust-zstd-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zstd-sys-2.0.16-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f95047a1fb5b2d81ea8e291c6137fe331d3bf9eb7d5ccd02bdbb7a6a48f07da7"

URI_x86_64_v2_rust-zstd-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+bindgen-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+bindgen-devel.sha256sum] = "5caba1584e93be25d64b996110b9205289af86abdac0dbf7f7dd789e2847cfc2"

URI_x86_64_v2_rust-zstd-sys+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+debug-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+debug-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+debug-devel.sha256sum] = "af0e4db635739dc8c0af6e50a71bd04a0477d8e7040cd2b73f67cd33c2aa5083"

URI_x86_64_v2_rust-zstd-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+default-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+default-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+default-devel.sha256sum] = "514cda415fdc44b561f5dbe2bba9db41204bd8aa1c5c573abf0272869bb822de"

URI_x86_64_v2_rust-zstd-sys+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+experimental-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+experimental-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+experimental-devel.sha256sum] = "b14f71b88fb085065ba239ff96784e0a05cac821d366be400639d9a7204b8a9d"

URI_x86_64_v2_rust-zstd-sys+fat-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+fat-lto-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+fat-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+fat-lto-devel.sha256sum] = "5d7329d1cc78262fdcb110f4bbe32c298777e6b195ecc4cef8cf1f2a1e552271"

URI_x86_64_v2_rust-zstd-sys+legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+legacy-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+legacy-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+legacy-devel.sha256sum] = "5f8023b39f66e8483b0a2767e02fb61531feb106d953cd52d001577e2667cf6f"

URI_x86_64_v2_rust-zstd-sys+no_asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+no_asm-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+no_asm-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+no_asm-devel.sha256sum] = "516bc396c541eefc6b0cc237e8258b17392128a93e537c8d155b976c31649999"

URI_x86_64_v2_rust-zstd-sys+non-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+non-cargo-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+non-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+non-cargo-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+non-cargo-devel.sha256sum] = "d028b27da6d4e4e8ac71e1f0d6c70dd6f0875f059fd5098fbe9218a6bacd89c2"

URI_x86_64_v2_rust-zstd-sys+pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+pkg-config-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+pkg-config-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+pkg-config-devel.sha256sum] = "2835d245f7e29fdcf0f968f06ec250a533cd3f53966d7eeebdaacf2e5543a414"

URI_x86_64_v2_rust-zstd-sys+seekable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+seekable-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+seekable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+seekable-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+seekable-devel.sha256sum] = "b8f62859739633a4b541e83ed66ab9b44f89fece65a4cc3dff095c7968ec2325"

URI_x86_64_v2_rust-zstd-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+std-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+std-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+std-devel.sha256sum] = "04ac7bf6e3aec31e1ef8844de49d2d660da0239469f76bcdc9ccaaa9cdba6634"

URI_x86_64_v2_rust-zstd-sys+thin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+thin-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+thin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+thin-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+thin-devel.sha256sum] = "7e3b0f4fb7efea070213d6525013b9e24d430c4f2bd77b9884a72a9a0bb15651"

URI_x86_64_v2_rust-zstd-sys+thin-lto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+thin-lto-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+thin-lto-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+thin-lto-devel.sha256sum] = "4d20ea8aaad92c677e653598c2d24af7f773b020970d96c438a99521a996d150"

URI_x86_64_v2_rust-zstd-sys+zdict_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+zdict_builder-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+zdict_builder-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+zdict_builder-devel.sha256sum] = "18e4f5c61b6786dcc252d202e54186d5c2c07e2a9807b628a68d128f2551e3ad"

URI_x86_64_v2_rust-zstd-sys+zstdmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys+zstdmt-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys+zstdmt-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys+zstdmt-devel.sha256sum] = "95aad11790068e8ceb29f89f03f8ed91195e8da9c06399ea7e033bc7e8725ce6"

URI_x86_64_v2_rust-zstd-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zstd-sys-devel-2.0.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zstd-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zstd-sys-devel}"
SRC_URI[x86_64_v2_rust-zstd-sys-devel.sha256sum] = "640665415450d09446e9506b27fecf0bf8277fce99415b68c81a8e3f9164379f"

URI_aarch64_rust-zstd-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+bindgen-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+bindgen-devel}"
SRC_URI[aarch64_rust-zstd-sys+bindgen-devel.sha256sum] = "31607685d3d1df589f38c57bf77795523d9fa3abd134a14e583dae613f0f8117"

URI_aarch64_rust-zstd-sys+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+debug-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+debug-devel}"
SRC_URI[aarch64_rust-zstd-sys+debug-devel.sha256sum] = "ce7dee9b5b7a617a4b9154b9af6d3bd59155f4d195bd3ecc1f4fe28c6291baee"

URI_aarch64_rust-zstd-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+default-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+default-devel}"
SRC_URI[aarch64_rust-zstd-sys+default-devel.sha256sum] = "154a558d0fb31ba612ef6019b65bc1801438331899ae3a0e51d7a95d50bb4aef"

URI_aarch64_rust-zstd-sys+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+experimental-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+experimental-devel}"
SRC_URI[aarch64_rust-zstd-sys+experimental-devel.sha256sum] = "3da0786127a648106701f291c4f2d4b4fcf46a42245f73744f1dcfd7bd6a9846"

URI_aarch64_rust-zstd-sys+fat-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+fat-lto-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+fat-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+fat-lto-devel}"
SRC_URI[aarch64_rust-zstd-sys+fat-lto-devel.sha256sum] = "47da4aa741261e9df042124c7c545323cea15ec8be4b3559f504d30593b10809"

URI_aarch64_rust-zstd-sys+legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+legacy-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+legacy-devel}"
SRC_URI[aarch64_rust-zstd-sys+legacy-devel.sha256sum] = "1192de40436a4228175f931e6b096a305ca377232d7e95604eb04a422d5378c2"

URI_aarch64_rust-zstd-sys+no_asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+no_asm-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+no_asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+no_asm-devel}"
SRC_URI[aarch64_rust-zstd-sys+no_asm-devel.sha256sum] = "8fb9a92fe25c02cda343709cd8cabb466a4c78662507c1316282314def64af0b"

URI_aarch64_rust-zstd-sys+non-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+non-cargo-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+non-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+non-cargo-devel}"
SRC_URI[aarch64_rust-zstd-sys+non-cargo-devel.sha256sum] = "b3f0a7bcf7587bd7874825115bd0ebe1444b90ce8fa89658dc8f37215a357157"

URI_aarch64_rust-zstd-sys+pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+pkg-config-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+pkg-config-devel}"
SRC_URI[aarch64_rust-zstd-sys+pkg-config-devel.sha256sum] = "f7a26d8bcc1431ad109734bc0897309f07b00239a49e9fbc3a8777c5c47c7c83"

URI_aarch64_rust-zstd-sys+seekable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+seekable-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+seekable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+seekable-devel}"
SRC_URI[aarch64_rust-zstd-sys+seekable-devel.sha256sum] = "1fe04e4edc11a3a1fd454882957b84a67086d07d25b1089e0986b45412f43e5e"

URI_aarch64_rust-zstd-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+std-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+std-devel}"
SRC_URI[aarch64_rust-zstd-sys+std-devel.sha256sum] = "359f718a60f02c850b51dbe6f77587ad213ac0e8acc5e0cb9db9107a613b53e3"

URI_aarch64_rust-zstd-sys+thin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+thin-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+thin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+thin-devel}"
SRC_URI[aarch64_rust-zstd-sys+thin-devel.sha256sum] = "ae148f178ef0a58b1cf30d89e372974aa363024897f9306b7771efee10ad9f79"

URI_aarch64_rust-zstd-sys+thin-lto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+thin-lto-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+thin-lto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+thin-lto-devel}"
SRC_URI[aarch64_rust-zstd-sys+thin-lto-devel.sha256sum] = "4e4a40415731089ef30c8644b20bdb57ea52cc763ef1ee88a7b800615be565ec"

URI_aarch64_rust-zstd-sys+zdict_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+zdict_builder-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+zdict_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+zdict_builder-devel}"
SRC_URI[aarch64_rust-zstd-sys+zdict_builder-devel.sha256sum] = "3fe42c9d07c4d1e41cdaf5d6b2e28affc95c4d2fbcdfe896434950bbad2d5380"

URI_aarch64_rust-zstd-sys+zstdmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys+zstdmt-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys+zstdmt-devel}"
SRC_URI[aarch64_rust-zstd-sys+zstdmt-devel.sha256sum] = "72d0febcd3ce90be862ad9795cd0d936cc4985aaeb1c0bfd9edb9071b3defe5d"

URI_aarch64_rust-zstd-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zstd-sys-devel-2.0.16-1.el10_2.noarch.rpm;name=aarch64_rust-zstd-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zstd-sys-devel}"
SRC_URI[aarch64_rust-zstd-sys-devel.sha256sum] = "7252ea8ad00352065e440fad230550c10b199f9c2e9384d0db75ff28489c18b0"

RDEPENDS:rust-zstd-sys+bindgen-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+debug-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+default-devel = " \
 cargo \
 rust-zstd-sys+bindgen-devel \
 rust-zstd-sys+legacy-devel \
 rust-zstd-sys+zdict_builder-devel \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+experimental-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+fat-lto-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+legacy-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+no_asm-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+non-cargo-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+pkg-config-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+seekable-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+std-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+thin-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+thin-lto-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+zdict_builder-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys+zstdmt-devel = " \
 cargo \
 rust-zstd-sys-devel \
 "
RDEPENDS:rust-zstd-sys-devel = " \
 cargo \
 libzstd-devel \
 rust \
 rust-bindgen+runtime-devel \
 rust-bindgen-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-pkg-config+default-devel \
 "
