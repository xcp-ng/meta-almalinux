# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "edk2"
PV = "20250523"
PR = "2.el10_1.2"
PACKAGES = " \
 edk2-aarch64 \
 edk2-ovmf \
 edk2-tools \
 edk2-tools-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/edk2-20250523-2.el10_1.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a423e31aa702e757051b106e7222d704f9282f255ee8232ec40677e595083ae"

URI_x86_64_v2_edk2-aarch64 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-aarch64-20250523-2.el10_1.2.noarch.rpm;name=x86_64_v2_edk2-aarch64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-aarch64}"
SRC_URI[x86_64_v2_edk2-aarch64.sha256sum] = "9a8ce66044fe58d0d437e7966f71403d9ae8e6715524993106e6bb62e4430f5e"

URI_x86_64_v2_edk2-ovmf = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-ovmf-20250523-2.el10_1.2.noarch.rpm;name=x86_64_v2_edk2-ovmf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-ovmf}"
SRC_URI[x86_64_v2_edk2-ovmf.sha256sum] = "f5afccfbd8d513f535e7c33cbee409924edd8404ec13ec3244b26b849aff0209"

URI_x86_64_v2_edk2-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-tools-20250523-2.el10_1.2.x86_64_v2.rpm;name=x86_64_v2_edk2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-tools}"
SRC_URI[x86_64_v2_edk2-tools.sha256sum] = "ada43c606ced568cfab063c08f15a265383605ff193872e388ec90648e86ca9b"

URI_x86_64_v2_edk2-tools-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-tools-doc-20250523-2.el10_1.2.noarch.rpm;name=x86_64_v2_edk2-tools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edk2-tools-doc}"
SRC_URI[x86_64_v2_edk2-tools-doc.sha256sum] = "afa843b0cd8f5e3561a868b9073eb26da2ad273a1862cb5fcdf5da4adc451bd2"

URI_aarch64_edk2-aarch64 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-aarch64-20250523-2.el10_1.2.noarch.rpm;name=aarch64_edk2-aarch64;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-aarch64}"
SRC_URI[aarch64_edk2-aarch64.sha256sum] = "9a8ce66044fe58d0d437e7966f71403d9ae8e6715524993106e6bb62e4430f5e"

URI_aarch64_edk2-ovmf = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-ovmf-20250523-2.el10_1.2.noarch.rpm;name=aarch64_edk2-ovmf;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-ovmf}"
SRC_URI[aarch64_edk2-ovmf.sha256sum] = "f5afccfbd8d513f535e7c33cbee409924edd8404ec13ec3244b26b849aff0209"

URI_aarch64_edk2-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-tools-20250523-2.el10_1.2.aarch64.rpm;name=aarch64_edk2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-tools}"
SRC_URI[aarch64_edk2-tools.sha256sum] = "062bcedaa308562f92b27e9c3c9b9d2c51c8f3d129c1de5a00bb6ff86cb2f955"

URI_aarch64_edk2-tools-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-tools-doc-20250523-2.el10_1.2.noarch.rpm;name=aarch64_edk2-tools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_edk2-tools-doc}"
SRC_URI[aarch64_edk2-tools-doc.sha256sum] = "afa843b0cd8f5e3561a868b9073eb26da2ad273a1862cb5fcdf5da4adc451bd2"

RDEPENDS:edk2-aarch64 = " \
 "
RDEPENDS:edk2-ovmf = " \
 "
RDEPENDS:edk2-tools = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:edk2-tools-doc = " \
 "
