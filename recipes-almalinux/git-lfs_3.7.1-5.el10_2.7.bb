# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-lfs"
PV = "3.7.1"
PR = "5.el10_2.7"
PACKAGES = " \
 git-lfs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/git-lfs-3.7.1-5.el10_2.7.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "493fe322579dd8bc31ce2d3bb54d728cd234cc4ad1c14b05f1743e1f723e6f65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-lfs-3.7.1-5.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_git-lfs;unpack=0"
SRC_URI[x86_64_v2_git-lfs.sha256sum] = "e670ab9d3b9eef42e5d60f4548ba385b6e60f1d142b93e5846988c3d63743877"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-lfs-3.7.1-5.el10_2.7.aarch64.rpm;name=aarch64_git-lfs;unpack=0"
SRC_URI[aarch64_git-lfs.sha256sum] = "bdc912e8e9c70a67b81b87ca06d75706e176ec84ef96838903b2c6668aed99b2"

RDEPENDS:git-lfs = " \
 bash \
 git-core \
 glibc \
 "
