# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-common"
PV = "18.15"
PR = "1.el10_1"
PACKAGES = " \
 globus-common \
 globus-common-devel \
 globus-common-doc \
 globus-common-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-common-18.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "874caa2660450093c53fabbb1db795df5e95259badaf99107bf4c6a19ebb11ba"

URI_x86_64_v2_globus-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-18.15-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common}"
SRC_URI[x86_64_v2_globus-common.sha256sum] = "124ee4ddb041d827675afbf4b2121901faa5dbd9bbbf667b285e4ea7dda39d15"

URI_x86_64_v2_globus-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-devel-18.15-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common-devel}"
SRC_URI[x86_64_v2_globus-common-devel.sha256sum] = "7c6064b35e236571391f084f72fda186d782ada5bfb8995d855098f6b079ec8f"

URI_x86_64_v2_globus-common-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-doc-18.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-common-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common-doc}"
SRC_URI[x86_64_v2_globus-common-doc.sha256sum] = "26eaafae78f137d5e2f13f6a9759ca7c797726b0b104de8863087025e03164aa"

URI_x86_64_v2_globus-common-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-common-progs-18.15-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-common-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-common-progs}"
SRC_URI[x86_64_v2_globus-common-progs.sha256sum] = "c7d73d776636d5173c034410ab8011b3fc8af25a98df7a408024d9d5406cde8e"

URI_aarch64_globus-common = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-18.15-1.el10_1.aarch64.rpm;name=aarch64_globus-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common}"
SRC_URI[aarch64_globus-common.sha256sum] = "67b5d7dfa9ae7ce74697d421ce34a5c64385b366cebde353d6da056ea5257fea"

URI_aarch64_globus-common-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-devel-18.15-1.el10_1.aarch64.rpm;name=aarch64_globus-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common-devel}"
SRC_URI[aarch64_globus-common-devel.sha256sum] = "6fa9d81ee7b2afbdcfb45ebd74baf8fe3fb04da6bb42132b3ab8297c1c7124b2"

URI_aarch64_globus-common-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-doc-18.15-1.el10_1.noarch.rpm;name=aarch64_globus-common-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common-doc}"
SRC_URI[aarch64_globus-common-doc.sha256sum] = "9608b386d35e12b1af58aa57e81ab840bb07c43394ee8d8d3c95f39806523a1f"

URI_aarch64_globus-common-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-common-progs-18.15-1.el10_1.aarch64.rpm;name=aarch64_globus-common-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-common-progs}"
SRC_URI[aarch64_globus-common-progs.sha256sum] = "8e6f8ecc988c82ee95c4f36e8cbe9e19380b8b8b4fb4f07ffef15207adf7c8e2"

RDEPENDS:globus-common = " \
 glibc \
 libtool-ltdl \
 perl-Exporter \
 perl-File-Basename \
 perl-libs \
 "
RDEPENDS:globus-common-devel = " \
 globus-common \
 libtool-ltdl-devel \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Usage \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-common-doc = " \
 "
RDEPENDS:globus-common-progs = " \
 bash \
 glibc \
 globus-common \
 libtool-ltdl \
 "
