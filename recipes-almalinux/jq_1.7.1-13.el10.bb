# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jq"
PV = "1.7.1"
PR = "13.el10"
PACKAGES = " \
 jq \
 jq-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/jq-1.7.1-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2107532d89adb5f813e3436fe916aec5a14b299d9b36be9fb394e76c51e20083"

URI_x86_64_v2_jq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/jq-1.7.1-13.el10.x86_64_v2.rpm;name=x86_64_v2_jq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jq}"
SRC_URI[x86_64_v2_jq.sha256sum] = "96706d783a07216c3c7ceb6143765bdbd4d3151e6c92f682d042dd6334f1b54b"

URI_x86_64_v2_jq-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jq-devel-1.7.1-13.el10.x86_64_v2.rpm;name=x86_64_v2_jq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jq-devel}"
SRC_URI[x86_64_v2_jq-devel.sha256sum] = "b675cac806a6315412f162262072a09449213427a636510b44ccde2d4b0aa58e"

URI_aarch64_jq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/jq-1.7.1-13.el10.aarch64.rpm;name=aarch64_jq;unpack=0"
SRC_URI:append = " ${URI_aarch64_jq}"
SRC_URI[aarch64_jq.sha256sum] = "90b37d444c801bd6a99aa59862102856097d4a833ad690f3935146ea57fcf5c5"

URI_aarch64_jq-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jq-devel-1.7.1-13.el10.aarch64.rpm;name=aarch64_jq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jq-devel}"
SRC_URI[aarch64_jq-devel.sha256sum] = "229bd3331f67427a5ef3e1764fdd4f554f708e9ae2a2540e41a73d40de1329b2"

RDEPENDS:jq = " \
 glibc \
 oniguruma \
 "
RDEPENDS:jq-devel = " \
 jq \
 pkgconf-pkg-config \
 "
