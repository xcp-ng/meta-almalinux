# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netrate"
PV = "0.1"
PR = "5.el10_1"
PACKAGES = " \
 netrate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netrate-0.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dd06ee59a5fb316d6ddf3ebf5785b4750d2750fa0aaa65118f4a09c4cacae43"

URI_x86_64_v2_netrate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netrate-0.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netrate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netrate}"
SRC_URI[x86_64_v2_netrate.sha256sum] = "8e605d974241d70d0cd7b844fd6f2b70ca848263bc34c2c98b6180feeec00231"

URI_aarch64_netrate = "${EPEL_MIRROR}/aarch64/Packages/n/netrate-0.1-5.el10_1.aarch64.rpm;name=aarch64_netrate;unpack=0"
SRC_URI:append = " ${URI_aarch64_netrate}"
SRC_URI[aarch64_netrate.sha256sum] = "7d05389ea5ed9fb8bc7354e152bc77c28f8bcb3ce6cf95779a01f7231b34b09d"

RDEPENDS:netrate = " \
 glibc \
 "
