# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fdk-aac-free"
PV = "2.0.0"
PR = "15.el10"
PACKAGES = " \
 fdk-aac-free \
 fdk-aac-free-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fdk-aac-free-2.0.0-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40ed18ee08711c92962a228a7576c30a50e2e4b25184ab4d9c81159ae0e46554"

URI_x86_64_v2_fdk-aac-free = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fdk-aac-free-2.0.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_fdk-aac-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdk-aac-free}"
SRC_URI[x86_64_v2_fdk-aac-free.sha256sum] = "c4ee7693a7743eff31ceac6c22801e86e00aef9f57340931171e4aabc1c0bee3"

URI_x86_64_v2_fdk-aac-free-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fdk-aac-free-devel-2.0.0-15.el10.x86_64_v2.rpm;name=x86_64_v2_fdk-aac-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fdk-aac-free-devel}"
SRC_URI[x86_64_v2_fdk-aac-free-devel.sha256sum] = "1ef0680faa089cac6f58538963ae085335a86e31bd29fd65088cbe2c95cfc77f"

URI_aarch64_fdk-aac-free = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fdk-aac-free-2.0.0-15.el10.aarch64.rpm;name=aarch64_fdk-aac-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdk-aac-free}"
SRC_URI[aarch64_fdk-aac-free.sha256sum] = "86b404b29b5e6b3db5ffc58bfa185f372e38394c68048baa2cb410e82c6d3b79"

URI_aarch64_fdk-aac-free-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fdk-aac-free-devel-2.0.0-15.el10.aarch64.rpm;name=aarch64_fdk-aac-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fdk-aac-free-devel}"
SRC_URI[aarch64_fdk-aac-free-devel.sha256sum] = "9ba9c7a87a824c349760eb68a0a32a33cd435f90bc288d945e4ea30ee81f2f91"

RDEPENDS:fdk-aac-free = " \
 glibc \
 "
RDEPENDS:fdk-aac-free-devel = " \
 fdk-aac-free \
 pkgconf-pkg-config \
 "
