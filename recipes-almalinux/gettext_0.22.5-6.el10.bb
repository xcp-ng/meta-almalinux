# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gettext"
PV = "0.22.5"
PR = "6.el10"
PACKAGES = " \
 gettext \
 gettext-common-devel \
 gettext-devel \
 gettext-envsubst \
 gettext-libs \
 gettext-runtime \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gettext-0.22.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43c76b83ae97f7b60bdc925f92ea21987c915d0db00f21ae0255d9e3e4a00928"

URI_x86_64_v2_gettext = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gettext-0.22.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_gettext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gettext}"
SRC_URI[x86_64_v2_gettext.sha256sum] = "becbdec11d8fde48db87c7301ea82d4a53d38672a6d917a1da21c7273ab22d70"

URI_x86_64_v2_gettext-common-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gettext-common-devel-0.22.5-6.el10.noarch.rpm;name=x86_64_v2_gettext-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gettext-common-devel}"
SRC_URI[x86_64_v2_gettext-common-devel.sha256sum] = "13bd4495ee74787311558d412eb9a7fb995c464bc7ec620304a6c9da79f535c4"

URI_x86_64_v2_gettext-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gettext-devel-0.22.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_gettext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gettext-devel}"
SRC_URI[x86_64_v2_gettext-devel.sha256sum] = "e187a7662e5283bcd2a34a0b8a18bd0fc1e15681debb9232000fc5d5c475869c"

URI_x86_64_v2_gettext-envsubst = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gettext-envsubst-0.22.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_gettext-envsubst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gettext-envsubst}"
SRC_URI[x86_64_v2_gettext-envsubst.sha256sum] = "fc8056cd1047ea086f1d36587feebed03fae65ad3eed04a33e42ef073525587e"

URI_x86_64_v2_gettext-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gettext-libs-0.22.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_gettext-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gettext-libs}"
SRC_URI[x86_64_v2_gettext-libs.sha256sum] = "74f2fa25353c96174a143fb1402f8a43b2285e59d7fd095f82a0193ad80c6201"

URI_x86_64_v2_gettext-runtime = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gettext-runtime-0.22.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_gettext-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gettext-runtime}"
SRC_URI[x86_64_v2_gettext-runtime.sha256sum] = "896b91c1684b056ece3653b2efc26a57b7d318520a38b57931fcf10475570285"

URI_aarch64_gettext = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gettext-0.22.5-6.el10.aarch64.rpm;name=aarch64_gettext;unpack=0"
SRC_URI:append = " ${URI_aarch64_gettext}"
SRC_URI[aarch64_gettext.sha256sum] = "2f1834811a4fe3abc5b7e958da5667ef27ded91658095a69400dc08c5a6b963b"

URI_aarch64_gettext-common-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gettext-common-devel-0.22.5-6.el10.noarch.rpm;name=aarch64_gettext-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gettext-common-devel}"
SRC_URI[aarch64_gettext-common-devel.sha256sum] = "13bd4495ee74787311558d412eb9a7fb995c464bc7ec620304a6c9da79f535c4"

URI_aarch64_gettext-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gettext-devel-0.22.5-6.el10.aarch64.rpm;name=aarch64_gettext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gettext-devel}"
SRC_URI[aarch64_gettext-devel.sha256sum] = "c741d0d2fec9d9b69fb4fbd9f9fd97461085691e1281d403ff26ab101da6693c"

URI_aarch64_gettext-envsubst = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gettext-envsubst-0.22.5-6.el10.aarch64.rpm;name=aarch64_gettext-envsubst;unpack=0"
SRC_URI:append = " ${URI_aarch64_gettext-envsubst}"
SRC_URI[aarch64_gettext-envsubst.sha256sum] = "4e664b21174af01e13cee80576fae21a5382961bd90d434f429d8a16a3921581"

URI_aarch64_gettext-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gettext-libs-0.22.5-6.el10.aarch64.rpm;name=aarch64_gettext-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gettext-libs}"
SRC_URI[aarch64_gettext-libs.sha256sum] = "2c2999f1aeb9e194a1aa58ee062e8af14943651639bb8af3ff0ff0ac95991159"

URI_aarch64_gettext-runtime = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gettext-runtime-0.22.5-6.el10.aarch64.rpm;name=aarch64_gettext-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_gettext-runtime}"
SRC_URI[aarch64_gettext-runtime.sha256sum] = "dacfe30d94d17809bf48cbeb3c8100e90561b3fefe800bf9d7693793656a8dfb"

RDEPENDS:gettext = " \
 bash \
 gettext-libs \
 gettext-runtime \
 glibc \
 libgcc \
 libgomp \
 libunistring \
 libxml2 \
 "
RDEPENDS:gettext-common-devel = " \
 "
RDEPENDS:gettext-devel = " \
 bash \
 diffutils \
 gettext \
 gettext-common-devel \
 gettext-libs \
 glibc \
 xz \
 "
RDEPENDS:gettext-envsubst = " \
 glibc \
 "
RDEPENDS:gettext-libs = " \
 glibc \
 libacl \
 libattr \
 libstdc++ \
 libunistring \
 libxml2 \
 "
RDEPENDS:gettext-runtime = " \
 bash \
 gettext-envsubst \
 gettext-libs \
 glibc \
 "
