# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smol_str0.1"
PV = "0.1.24"
PR = "3.el10_0"
PACKAGES = " \
 rust-smol_str0.1+arbitrary-devel \
 rust-smol_str0.1+default-devel \
 rust-smol_str0.1+serde-devel \
 rust-smol_str0.1+std-devel \
 rust-smol_str0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smol_str0.1-0.1.24-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42f9b72d2022cc6a647dac3b4d25e6b3966a5ccf10c03928fc3c79afe8244702"

URI_x86_64_v2_rust-smol_str0.1+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str0.1+arbitrary-devel-0.1.24-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str0.1+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str0.1+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-smol_str0.1+arbitrary-devel.sha256sum] = "e412d3a5cebe0d591132b7c2c6a8c9034f28fb7e5a64cb74a19b95c7079a9f2f"

URI_x86_64_v2_rust-smol_str0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str0.1+default-devel-0.1.24-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str0.1+default-devel}"
SRC_URI[x86_64_v2_rust-smol_str0.1+default-devel.sha256sum] = "956ae2179db73d943a544f840d9939109e02f3cdffa05893cc583279499ce572"

URI_x86_64_v2_rust-smol_str0.1+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str0.1+serde-devel-0.1.24-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str0.1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str0.1+serde-devel}"
SRC_URI[x86_64_v2_rust-smol_str0.1+serde-devel.sha256sum] = "01cf13d5c1992dae196d5fa34a78858e76f7b9e6b7034b064344ac1d8696dd37"

URI_x86_64_v2_rust-smol_str0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str0.1+std-devel-0.1.24-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str0.1+std-devel}"
SRC_URI[x86_64_v2_rust-smol_str0.1+std-devel.sha256sum] = "a80f4f743a3a13286285d69458a50a78c8196fa66501aed5963dc95d18a3077b"

URI_x86_64_v2_rust-smol_str0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str0.1-devel-0.1.24-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str0.1-devel}"
SRC_URI[x86_64_v2_rust-smol_str0.1-devel.sha256sum] = "d5c0ad2cabc256d968169356f2074227bc6143d4e5eb6dde121aea2ca7569f33"

URI_aarch64_rust-smol_str0.1+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str0.1+arbitrary-devel-0.1.24-3.el10_0.noarch.rpm;name=aarch64_rust-smol_str0.1+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str0.1+arbitrary-devel}"
SRC_URI[aarch64_rust-smol_str0.1+arbitrary-devel.sha256sum] = "f5f35b877fdc6a8244bb0920ff3dad36153acf63e6b2ac43f589abd75e57fa70"

URI_aarch64_rust-smol_str0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str0.1+default-devel-0.1.24-3.el10_0.noarch.rpm;name=aarch64_rust-smol_str0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str0.1+default-devel}"
SRC_URI[aarch64_rust-smol_str0.1+default-devel.sha256sum] = "9eebc8ab9d0d718c1cd4ef6e622d61cc0039d3bb856afc36af4db1d7fe1a0cc7"

URI_aarch64_rust-smol_str0.1+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str0.1+serde-devel-0.1.24-3.el10_0.noarch.rpm;name=aarch64_rust-smol_str0.1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str0.1+serde-devel}"
SRC_URI[aarch64_rust-smol_str0.1+serde-devel.sha256sum] = "920b79997726a4e74ede0f9c340d1c1ea7894a2790d90fff3684003f2283b3f8"

URI_aarch64_rust-smol_str0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str0.1+std-devel-0.1.24-3.el10_0.noarch.rpm;name=aarch64_rust-smol_str0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str0.1+std-devel}"
SRC_URI[aarch64_rust-smol_str0.1+std-devel.sha256sum] = "4172133535cca6e5cb44d7a40d6eca984c0baa3f864502d1c1f5fab28e4073ad"

URI_aarch64_rust-smol_str0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str0.1-devel-0.1.24-3.el10_0.noarch.rpm;name=aarch64_rust-smol_str0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str0.1-devel}"
SRC_URI[aarch64_rust-smol_str0.1-devel.sha256sum] = "7b8c145f454dc11e130fea1d25a33220c48ea63f573c7a45688e35de3500a851"

RDEPENDS:rust-smol_str0.1+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smol_str0.1-devel \
 "
RDEPENDS:rust-smol_str0.1+default-devel = " \
 cargo \
 rust-smol_str0.1+std-devel \
 rust-smol_str0.1-devel \
 "
RDEPENDS:rust-smol_str0.1+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-smol_str0.1-devel \
 "
RDEPENDS:rust-smol_str0.1+std-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-smol_str0.1-devel \
 "
RDEPENDS:rust-smol_str0.1-devel = " \
 cargo \
 "
