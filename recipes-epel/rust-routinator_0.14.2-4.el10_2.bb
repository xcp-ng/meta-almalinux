# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-routinator"
PV = "0.14.2"
PR = "4.el10_2"
PACKAGES = " \
 routinator \
 rust-routinator+arbitrary-devel \
 rust-routinator+default-devel \
 rust-routinator+native-tls-devel \
 rust-routinator+rta-devel \
 rust-routinator+socks-devel \
 rust-routinator+ui-devel \
 rust-routinator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-routinator-0.14.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b12fea36b0a7ca7040598da26b7c31f6bfa781ec270604a856722484f418b3ee"

URI_x86_64_v2_routinator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/routinator-0.14.2-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_routinator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_routinator}"
SRC_URI[x86_64_v2_routinator.sha256sum] = "f4c859ce28b08f6ec1d1dcdf99eb8db51b91dc1e39bfbb437e70bbbe37e7f08e"

URI_x86_64_v2_rust-routinator+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+arbitrary-devel-0.14.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-routinator+arbitrary-devel.sha256sum] = "e51fff5a04f5d67617ffcbf1ab9e669962f3ec3b6d2839b99d0f4bfb59b4a43a"

URI_x86_64_v2_rust-routinator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+default-devel-0.14.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+default-devel}"
SRC_URI[x86_64_v2_rust-routinator+default-devel.sha256sum] = "4d5703dca7878a17d45870f7185549d68038a5bc54045644559d3c60ff93e912"

URI_x86_64_v2_rust-routinator+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+native-tls-devel-0.14.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+native-tls-devel}"
SRC_URI[x86_64_v2_rust-routinator+native-tls-devel.sha256sum] = "8f6ed4d9ca3505a7365231625f45cf00ffb169743c56f2c7d747b60fc09852fb"

URI_x86_64_v2_rust-routinator+rta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+rta-devel-0.14.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+rta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+rta-devel}"
SRC_URI[x86_64_v2_rust-routinator+rta-devel.sha256sum] = "8b120168d7920a7d71dde800ae047f6deb3478a32afbde586e07b22a853e3482"

URI_x86_64_v2_rust-routinator+socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+socks-devel-0.14.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+socks-devel}"
SRC_URI[x86_64_v2_rust-routinator+socks-devel.sha256sum] = "96383b00b83756b2e489a7e8d542952584fc59f6033d44b8d3f9210583cab431"

URI_x86_64_v2_rust-routinator+ui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+ui-devel-0.14.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+ui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+ui-devel}"
SRC_URI[x86_64_v2_rust-routinator+ui-devel.sha256sum] = "757df2a42dd03d10d3eebab7ce25d6effc446d0f9ff596edf87c843cc6704078"

URI_x86_64_v2_rust-routinator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator-devel-0.14.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator-devel}"
SRC_URI[x86_64_v2_rust-routinator-devel.sha256sum] = "82d11dc02603c3c0ead063cc17cc6f9c38dabb2f5582bb2bd83c5f01933df8ba"

URI_aarch64_routinator = "${EPEL_MIRROR}/aarch64/Packages/r/routinator-0.14.2-4.el10_2.aarch64.rpm;name=aarch64_routinator;unpack=0"
SRC_URI:append = " ${URI_aarch64_routinator}"
SRC_URI[aarch64_routinator.sha256sum] = "0c09c5ddd36f6b9ee65ebec7b1e32706d2408470de541c993d3cda6185cd34c1"

URI_aarch64_rust-routinator+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+arbitrary-devel-0.14.2-4.el10_2.noarch.rpm;name=aarch64_rust-routinator+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+arbitrary-devel}"
SRC_URI[aarch64_rust-routinator+arbitrary-devel.sha256sum] = "0ecfa2087970158384d08750494683de896bcb175c49446d2dec270e705b49f8"

URI_aarch64_rust-routinator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+default-devel-0.14.2-4.el10_2.noarch.rpm;name=aarch64_rust-routinator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+default-devel}"
SRC_URI[aarch64_rust-routinator+default-devel.sha256sum] = "fce664c8e4355dac3d1e7b14c3dc25f70db1321b783cf678339b886131326a82"

URI_aarch64_rust-routinator+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+native-tls-devel-0.14.2-4.el10_2.noarch.rpm;name=aarch64_rust-routinator+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+native-tls-devel}"
SRC_URI[aarch64_rust-routinator+native-tls-devel.sha256sum] = "568f459c6b1c03e87699975d403645b43bd1ac9062a6ad025143ed902bbf3dd5"

URI_aarch64_rust-routinator+rta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+rta-devel-0.14.2-4.el10_2.noarch.rpm;name=aarch64_rust-routinator+rta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+rta-devel}"
SRC_URI[aarch64_rust-routinator+rta-devel.sha256sum] = "aa85b5171c7efaf024a3a47c81946b51a9133e5aa23ca5badddfc57594b02005"

URI_aarch64_rust-routinator+socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+socks-devel-0.14.2-4.el10_2.noarch.rpm;name=aarch64_rust-routinator+socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+socks-devel}"
SRC_URI[aarch64_rust-routinator+socks-devel.sha256sum] = "0ba8755dbe3928dec934962f5cefabc4067673a605d85370924d863de103b460"

URI_aarch64_rust-routinator+ui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+ui-devel-0.14.2-4.el10_2.noarch.rpm;name=aarch64_rust-routinator+ui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+ui-devel}"
SRC_URI[aarch64_rust-routinator+ui-devel.sha256sum] = "29eae21e9f53c3305562b2dd722c74435dbb2d45e91b63166657c0ad22ae02d4"

URI_aarch64_rust-routinator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator-devel-0.14.2-4.el10_2.noarch.rpm;name=aarch64_rust-routinator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator-devel}"
SRC_URI[aarch64_rust-routinator-devel.sha256sum] = "f02f3d14338fec499241c5186cc89368c8633e54ebcdbfdaa5016be9285d8e1b"

RDEPENDS:routinator = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-routinator+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono+arbitrary-devel \
 rust-routinator-devel \
 rust-rpki+arbitrary-devel \
 "
RDEPENDS:rust-routinator+default-devel = " \
 cargo \
 rust-routinator+socks-devel \
 rust-routinator+ui-devel \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+native-tls-devel = " \
 cargo \
 rust-reqwest0.12+native-tls-devel \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+rta-devel = " \
 cargo \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+socks-devel = " \
 cargo \
 rust-reqwest0.12+socks-devel \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+ui-devel = " \
 cargo \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator-devel = " \
 bash \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-chrono+default-devel \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+wrap_help-devel \
 rust-crossbeam-queue+default-devel \
 rust-dirs+default-devel \
 rust-form_urlencoded+default-devel \
 rust-futures+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+default-devel \
 rust-hyper+server-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-devel \
 rust-listenfd+default-devel \
 rust-log+default-devel \
 rust-nix0.27+default-devel \
 rust-nix0.27+fs-devel \
 rust-nix0.27+mman-devel \
 rust-nix0.27+net-devel \
 rust-nix0.27+process-devel \
 rust-nix0.27+socket-devel \
 rust-nix0.27+user-devel \
 rust-pin-project-lite+default-devel \
 rust-rand0.8+default-devel \
 rust-reqwest0.12+blocking-devel \
 rust-reqwest0.12+gzip-devel \
 rust-reqwest0.12+rustls-tls-devel \
 rust-reqwest0.12-devel \
 rust-ring+default-devel \
 rust-rpki+default-devel \
 rust-rpki+repository-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-devel \
 rust-rpki+slurm-devel \
 rust-rustls-pemfile+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-siphasher+default-devel \
 rust-syslog+default-devel \
 rust-tempfile+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+sync-devel \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 rust-toml_edit0.22+default-devel \
 rust-uuid+default-devel \
 "
