# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prost-build"
PV = "0.14.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-prost-build+default-devel \
 rust-prost-build+format-devel \
 rust-prost-build-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prost-build-0.14.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f1a3eead0e32fc1223c17fa685e1e7fecbe1d54f6d661f9068add9d21acd3f2"

URI_x86_64_v2_rust-prost-build+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-build+default-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-build+default-devel}"
SRC_URI[x86_64_v2_rust-prost-build+default-devel.sha256sum] = "fed5ea9fe676e7d9af9cebbe8cb1160346db481c10de4bc07736320c1e04ff50"

URI_x86_64_v2_rust-prost-build+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-build+format-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-build+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-build+format-devel}"
SRC_URI[x86_64_v2_rust-prost-build+format-devel.sha256sum] = "f3c4c082b236d631887795c0dffd876823bb5bff302433176df593c240c68fd1"

URI_x86_64_v2_rust-prost-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-build-devel-0.14.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-build-devel}"
SRC_URI[x86_64_v2_rust-prost-build-devel.sha256sum] = "a76455f95728b80597aa0f16a05eb9ddc1331b0da22dfe8bbc2d482887d686b4"

URI_aarch64_rust-prost-build+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-build+default-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-build+default-devel}"
SRC_URI[aarch64_rust-prost-build+default-devel.sha256sum] = "4f5d9d2f5715fca00bf8d557be14f1e7fe393266498d3ac7e2ccbc7e1a8276e3"

URI_aarch64_rust-prost-build+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-build+format-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-build+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-build+format-devel}"
SRC_URI[aarch64_rust-prost-build+format-devel.sha256sum] = "843ef017e53fda4594089cb786690cc882b509a04e8c05e6a6daddd79dd71b5a"

URI_aarch64_rust-prost-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-build-devel-0.14.3-1.el10_3.noarch.rpm;name=aarch64_rust-prost-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-build-devel}"
SRC_URI[aarch64_rust-prost-build-devel.sha256sum] = "ca917edb73da29c26525184bb0f228efc94ed295047b01c7a4542518436854cb"

RDEPENDS:rust-prost-build+default-devel = " \
 cargo \
 rust-prost-build+format-devel \
 rust-prost-build-devel \
 "
RDEPENDS:rust-prost-build+format-devel = " \
 cargo \
 rust-prettyplease+default-devel \
 rust-prost-build-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
RDEPENDS:rust-prost-build-devel = " \
 cargo \
 protobuf-compiler \
 rust \
 rust-heck+default-devel \
 rust-log+default-devel \
 rust-multimap-devel \
 rust-petgraph+std-devel \
 rust-petgraph-devel \
 rust-prost-devel \
 rust-prost-types-devel \
 rust-regex+std-devel \
 rust-regex+unicode-bool-devel \
 rust-regex-devel \
 rust-tempfile+default-devel \
 virtual/crate_itertools/use_alloc__ge_0.10.0_with_crate_itertools/use_alloc__lt_0.15.0~ \
 virtual/crate_itertools__ge_0.10.0_with_crate_itertools__lt_0.15.0~ \
 "
