# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yggdrasil"
PV = "0.4.9.2"
PR = "1.el10_2.3"
PACKAGES = " \
 yggdrasil \
 yggdrasil-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yggdrasil-0.4.9.2-1.el10_2.3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2814f8c048b3d4a6e04977fb7224cb096e5a632f5f663ccef4ce94ab910f2bc5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yggdrasil-0.4.9.2-1.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_yggdrasil;unpack=0"
SRC_URI[x86_64_v2_yggdrasil.sha256sum] = "6eacf972bb046f9f9a191b2facde527e94777362239a757cd53da28af5b26a7b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/yggdrasil-devel-0.4.9.2-1.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_yggdrasil-devel;unpack=0"
SRC_URI[x86_64_v2_yggdrasil-devel.sha256sum] = "6eb5bb95773264d15c88780491f22423dd26e6ea9143fcfeb015a16a0eb67c0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yggdrasil-0.4.9.2-1.el10_2.3.aarch64.rpm;name=aarch64_yggdrasil;unpack=0"
SRC_URI[aarch64_yggdrasil.sha256sum] = "4416f312e5238d7842c34fab7e5a6af67d43c5bdbd1ca584687b3fa95154081b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/yggdrasil-devel-0.4.9.2-1.el10_2.3.aarch64.rpm;name=aarch64_yggdrasil-devel;unpack=0"
SRC_URI[aarch64_yggdrasil-devel.sha256sum] = "284d3c51812457bc6dab3e3ec9a9b42477108e4e9c7ce4daae528ede79c2d678"

RDEPENDS:yggdrasil = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:yggdrasil-devel = " \
 pkgconf-pkg-config \
 "
