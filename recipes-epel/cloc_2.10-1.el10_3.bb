# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cloc"
PV = "2.10"
PR = "1.el10_3"
PACKAGES = " \
 cloc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cloc-2.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f2da9719d300a61a79f96dfb2f02630964de4a159e530308c045132b7a15b76"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cloc-2.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_cloc;unpack=0"
SRC_URI[x86_64_v2_cloc.sha256sum] = "c2d25fea4831515f9cb35cff23f7712e6a322fd654413c32e314be8eaa576c92"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cloc-2.10-1.el10_3.noarch.rpm;name=aarch64_cloc;unpack=0"
SRC_URI[aarch64_cloc.sha256sum] = "4cf09f6a8842b64a2076189de2fd6ed927bc6737a5b645a5924056c60c581bf2"

RDEPENDS:cloc = " \
 perl-Algorithm-Diff \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Encode \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-POSIX \
 perl-Parallel-ForkManager \
 perl-PathTools \
 perl-Regexp-Common \
 perl-Scalar-List-Utils \
 perl-Text-Tabs+Wrap \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 "
