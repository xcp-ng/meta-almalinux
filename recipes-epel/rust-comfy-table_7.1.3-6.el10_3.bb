# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-comfy-table"
PV = "7.1.3"
PR = "6.el10_3"
PACKAGES = " \
 rust-comfy-table+ansi-str-devel \
 rust-comfy-table+console-devel \
 rust-comfy-table+crossterm-devel \
 rust-comfy-table+custom_styling-devel \
 rust-comfy-table+debug-devel \
 rust-comfy-table+default-devel \
 rust-comfy-table+integration_test-devel \
 rust-comfy-table+reexport_crossterm-devel \
 rust-comfy-table+tty-devel \
 rust-comfy-table-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-comfy-table-7.1.3-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55e1c38c5bae7f396e7cc6c822f126e2607f1c637dde23fa91002ee0b9589c5e"

URI_x86_64_v2_rust-comfy-table+ansi-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-comfy-table+ansi-str-devel-7.1.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-comfy-table+ansi-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-comfy-table+ansi-str-devel}"
SRC_URI[x86_64_v2_rust-comfy-table+ansi-str-devel.sha256sum] = "35e50fffa0f33ac96e2738a15f1f4202a80a2969779c81a71f41162b176c4d69"

URI_x86_64_v2_rust-comfy-table+console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-comfy-table+console-devel-7.1.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-comfy-table+console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-comfy-table+console-devel}"
SRC_URI[x86_64_v2_rust-comfy-table+console-devel.sha256sum] = "0e70f47da143f71a144bc5b7b2ae507b9fd9b6ce773484b1814b3333080e8ef2"

URI_x86_64_v2_rust-comfy-table+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-comfy-table+crossterm-devel-7.1.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-comfy-table+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-comfy-table+crossterm-devel}"
SRC_URI[x86_64_v2_rust-comfy-table+crossterm-devel.sha256sum] = "3d00dce91afe49d59bd22d35b1926c9cd44aaf8f8ebdac5347fae54d4444f226"

URI_x86_64_v2_rust-comfy-table+custom_styling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-comfy-table+custom_styling-devel-7.1.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-comfy-table+custom_styling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-comfy-table+custom_styling-devel}"
SRC_URI[x86_64_v2_rust-comfy-table+custom_styling-devel.sha256sum] = "9d32d42a2d350e586a758e6fd3531e9258f809e6cc9ba7b137bc7b2509104d56"

URI_x86_64_v2_rust-comfy-table+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-comfy-table+debug-devel-7.1.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-comfy-table+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-comfy-table+debug-devel}"
SRC_URI[x86_64_v2_rust-comfy-table+debug-devel.sha256sum] = "9ef9e5ab78dbda7bccec5147789d7841111df460ef27f25ea1f884f370cacc1b"

URI_x86_64_v2_rust-comfy-table+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-comfy-table+default-devel-7.1.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-comfy-table+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-comfy-table+default-devel}"
SRC_URI[x86_64_v2_rust-comfy-table+default-devel.sha256sum] = "89e8eb7a8cc80ae2b539ffeaf792a091335a3636b3c4721527252f7f0dfbd6a0"

URI_x86_64_v2_rust-comfy-table+integration_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-comfy-table+integration_test-devel-7.1.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-comfy-table+integration_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-comfy-table+integration_test-devel}"
SRC_URI[x86_64_v2_rust-comfy-table+integration_test-devel.sha256sum] = "1f6ab57d995d9617a56346c4c38510513cfe6ef6411ceb17c27166e5f8134a52"

URI_x86_64_v2_rust-comfy-table+reexport_crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-comfy-table+reexport_crossterm-devel-7.1.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-comfy-table+reexport_crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-comfy-table+reexport_crossterm-devel}"
SRC_URI[x86_64_v2_rust-comfy-table+reexport_crossterm-devel.sha256sum] = "a5d070d682bcfc325c59f66153e3967d388b2c4b1398b74839b3e1a91364b187"

URI_x86_64_v2_rust-comfy-table+tty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-comfy-table+tty-devel-7.1.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-comfy-table+tty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-comfy-table+tty-devel}"
SRC_URI[x86_64_v2_rust-comfy-table+tty-devel.sha256sum] = "11c40d26f51f8bd06e95d4f2c74395a451f67ea4c3255a060faf54fea146fee1"

URI_x86_64_v2_rust-comfy-table-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-comfy-table-devel-7.1.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-comfy-table-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-comfy-table-devel}"
SRC_URI[x86_64_v2_rust-comfy-table-devel.sha256sum] = "845776ad9976ea5ab35e0853c2ece74bc2b7c3ddb1e43cd7fc57a95e53131ea5"

URI_aarch64_rust-comfy-table+ansi-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-comfy-table+ansi-str-devel-7.1.3-6.el10_3.noarch.rpm;name=aarch64_rust-comfy-table+ansi-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-comfy-table+ansi-str-devel}"
SRC_URI[aarch64_rust-comfy-table+ansi-str-devel.sha256sum] = "17c18465e24767c482c5101b46a815a93e56644b93deab788652045084b67aa9"

URI_aarch64_rust-comfy-table+console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-comfy-table+console-devel-7.1.3-6.el10_3.noarch.rpm;name=aarch64_rust-comfy-table+console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-comfy-table+console-devel}"
SRC_URI[aarch64_rust-comfy-table+console-devel.sha256sum] = "6083fd587684bfaefcf7f97ffb9424cb2a1315f89130af0c659bb9062bdd3cc3"

URI_aarch64_rust-comfy-table+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-comfy-table+crossterm-devel-7.1.3-6.el10_3.noarch.rpm;name=aarch64_rust-comfy-table+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-comfy-table+crossterm-devel}"
SRC_URI[aarch64_rust-comfy-table+crossterm-devel.sha256sum] = "48de903d63e7b3d67ff360264ff08623f035919884954a1081782c18ac83883b"

URI_aarch64_rust-comfy-table+custom_styling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-comfy-table+custom_styling-devel-7.1.3-6.el10_3.noarch.rpm;name=aarch64_rust-comfy-table+custom_styling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-comfy-table+custom_styling-devel}"
SRC_URI[aarch64_rust-comfy-table+custom_styling-devel.sha256sum] = "ea098c3d47f8535117a4b12a96902208e4587c21cd87b07bd75bf93319628bd8"

URI_aarch64_rust-comfy-table+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-comfy-table+debug-devel-7.1.3-6.el10_3.noarch.rpm;name=aarch64_rust-comfy-table+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-comfy-table+debug-devel}"
SRC_URI[aarch64_rust-comfy-table+debug-devel.sha256sum] = "84c8d77cafc1e80c93607e7403d78e59e2a55a846f8095888b2f3312dc48c494"

URI_aarch64_rust-comfy-table+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-comfy-table+default-devel-7.1.3-6.el10_3.noarch.rpm;name=aarch64_rust-comfy-table+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-comfy-table+default-devel}"
SRC_URI[aarch64_rust-comfy-table+default-devel.sha256sum] = "e0b6f0429fe0ca5de9ee48fcd0821a6601fc68a571e4e7837acb2990d9862041"

URI_aarch64_rust-comfy-table+integration_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-comfy-table+integration_test-devel-7.1.3-6.el10_3.noarch.rpm;name=aarch64_rust-comfy-table+integration_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-comfy-table+integration_test-devel}"
SRC_URI[aarch64_rust-comfy-table+integration_test-devel.sha256sum] = "3b550dc6e37a0ff65c7c004c6197fcf94ea69f790441b4b6ac8116710ec2f2d8"

URI_aarch64_rust-comfy-table+reexport_crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-comfy-table+reexport_crossterm-devel-7.1.3-6.el10_3.noarch.rpm;name=aarch64_rust-comfy-table+reexport_crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-comfy-table+reexport_crossterm-devel}"
SRC_URI[aarch64_rust-comfy-table+reexport_crossterm-devel.sha256sum] = "5c242c0d229cce22d023eb380fbf7ec4faaa63179e9edafd8746c3175d05a17a"

URI_aarch64_rust-comfy-table+tty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-comfy-table+tty-devel-7.1.3-6.el10_3.noarch.rpm;name=aarch64_rust-comfy-table+tty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-comfy-table+tty-devel}"
SRC_URI[aarch64_rust-comfy-table+tty-devel.sha256sum] = "5569f1421d4105484192875c69d3895c32d41f7b5a14dd0aa61d04bf5d8570d6"

URI_aarch64_rust-comfy-table-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-comfy-table-devel-7.1.3-6.el10_3.noarch.rpm;name=aarch64_rust-comfy-table-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-comfy-table-devel}"
SRC_URI[aarch64_rust-comfy-table-devel.sha256sum] = "4bb4b762c1f3195caa9d1bbf54142604bdb1f7cf08e4201a8b589a513be2f16e"

RDEPENDS:rust-comfy-table+ansi-str-devel = " \
 cargo \
 rust-ansi-str+default-devel \
 rust-comfy-table-devel \
 "
RDEPENDS:rust-comfy-table+console-devel = " \
 cargo \
 rust-comfy-table-devel \
 rust-console+default-devel \
 "
RDEPENDS:rust-comfy-table+crossterm-devel = " \
 cargo \
 rust-comfy-table-devel \
 rust-crossterm0.28-devel \
 "
RDEPENDS:rust-comfy-table+custom_styling-devel = " \
 cargo \
 rust-comfy-table+ansi-str-devel \
 rust-comfy-table+console-devel \
 rust-comfy-table+tty-devel \
 rust-comfy-table-devel \
 "
RDEPENDS:rust-comfy-table+debug-devel = " \
 cargo \
 rust-comfy-table-devel \
 "
RDEPENDS:rust-comfy-table+default-devel = " \
 cargo \
 rust-comfy-table+tty-devel \
 rust-comfy-table-devel \
 "
RDEPENDS:rust-comfy-table+integration_test-devel = " \
 cargo \
 rust-comfy-table-devel \
 "
RDEPENDS:rust-comfy-table+reexport_crossterm-devel = " \
 cargo \
 rust-comfy-table+tty-devel \
 rust-comfy-table-devel \
 "
RDEPENDS:rust-comfy-table+tty-devel = " \
 cargo \
 rust-comfy-table+crossterm-devel \
 rust-comfy-table-devel \
 "
RDEPENDS:rust-comfy-table-devel = " \
 cargo \
 rust \
 rust-strum0.26+default-devel \
 rust-strum_macros0.26+default-devel \
 rust-unicode-width+default-devel \
 "
