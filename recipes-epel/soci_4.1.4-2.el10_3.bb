# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "soci"
PV = "4.1.4"
PR = "2.el10_3"
PACKAGES = " \
 soci \
 soci-devel \
 soci-doc \
 soci-empty \
 soci-empty-devel \
 soci-mysql \
 soci-mysql-devel \
 soci-postgresql \
 soci-postgresql-devel \
 soci-sqlite3 \
 soci-sqlite3-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/soci-4.1.4-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3924a7b928a27fff4fd189d08ae849ce3c3b7e22c8cf324e3caa0ce686e5888a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-4.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci;unpack=0"
SRC_URI[x86_64_v2_soci.sha256sum] = "e7dab68e450f2310775fa06d3f777f34c225bf30775965e1d0ccb4766eadadcd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-devel-4.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-devel;unpack=0"
SRC_URI[x86_64_v2_soci-devel.sha256sum] = "91eeb7f6e4dd696dd327af9196e06d5a599c97f659b6874498efd2f48803258f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-doc-4.1.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_soci-doc;unpack=0"
SRC_URI[x86_64_v2_soci-doc.sha256sum] = "ea113dc5e3c107ccb7fa89e24d35c3d03360128792b58d1ba0a302c368cc4d8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-empty-4.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-empty;unpack=0"
SRC_URI[x86_64_v2_soci-empty.sha256sum] = "745e0ed5a2ffc30522cdef7beccc791920d89bc98394f44c87e7214b1f8486a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-empty-devel-4.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-empty-devel;unpack=0"
SRC_URI[x86_64_v2_soci-empty-devel.sha256sum] = "df24ba533316232b53ed6ee7b6eaca5096f06c1fa53cd6a221cac84695c06366"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-mysql-4.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-mysql;unpack=0"
SRC_URI[x86_64_v2_soci-mysql.sha256sum] = "499d221fb067bdf4523c66fae79c0be60d37a4a7f7b44e6f5bdabfbced35bc53"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-mysql-devel-4.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-mysql-devel;unpack=0"
SRC_URI[x86_64_v2_soci-mysql-devel.sha256sum] = "deb6c3ec6ee2f7abfc3ace6081675ab682df6e16f7654fcc8ef7dd13d81537a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-postgresql-4.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-postgresql;unpack=0"
SRC_URI[x86_64_v2_soci-postgresql.sha256sum] = "7c3abaa22deab8a86a054aed3bf220e5abb0469bcecadd011c4736d4b789ff62"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-postgresql-devel-4.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-postgresql-devel;unpack=0"
SRC_URI[x86_64_v2_soci-postgresql-devel.sha256sum] = "3585febcd71f7fbb26a5d4b5834a121b68deb3ad633635daebe70384f2ada12d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-sqlite3-4.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-sqlite3;unpack=0"
SRC_URI[x86_64_v2_soci-sqlite3.sha256sum] = "a73ecf233df3cc960d43c98f7d9c72aa1b72eba88494555d62589099a75d691e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/soci-sqlite3-devel-4.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_soci-sqlite3-devel;unpack=0"
SRC_URI[x86_64_v2_soci-sqlite3-devel.sha256sum] = "96577f0e89e777b29928095657489fd48f4fb18e5cb698a872c4e30fd28422c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-4.1.4-2.el10_3.aarch64.rpm;name=aarch64_soci;unpack=0"
SRC_URI[aarch64_soci.sha256sum] = "6cbc8922c4014beb78818f18827aea8ff5c6a2e5a8fc98fd2e9c3b59f6e851e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-devel-4.1.4-2.el10_3.aarch64.rpm;name=aarch64_soci-devel;unpack=0"
SRC_URI[aarch64_soci-devel.sha256sum] = "3a2eeddcd5e23d64cec52e3a6db999194bd652f34e3e0cee5c68527bef50f299"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-doc-4.1.4-2.el10_3.noarch.rpm;name=aarch64_soci-doc;unpack=0"
SRC_URI[aarch64_soci-doc.sha256sum] = "cd2f37a4f1ddc191d832ee8ff97fb3348a6c09d612dff903cc04d2263ff61746"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-empty-4.1.4-2.el10_3.aarch64.rpm;name=aarch64_soci-empty;unpack=0"
SRC_URI[aarch64_soci-empty.sha256sum] = "e3999a288fc480c0a7d96c312eb2c0a44486c1f62819dd5a8a1a9bf5ca89c60c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-empty-devel-4.1.4-2.el10_3.aarch64.rpm;name=aarch64_soci-empty-devel;unpack=0"
SRC_URI[aarch64_soci-empty-devel.sha256sum] = "759324c6cdbe4132eb423140ae4b2200e7ebb39c0447bc80a5b090d5fb5fc56a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-mysql-4.1.4-2.el10_3.aarch64.rpm;name=aarch64_soci-mysql;unpack=0"
SRC_URI[aarch64_soci-mysql.sha256sum] = "0f8dc4d70757a45760f098262a863d4b37745a57a5655b895ea0bba2f724df44"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-mysql-devel-4.1.4-2.el10_3.aarch64.rpm;name=aarch64_soci-mysql-devel;unpack=0"
SRC_URI[aarch64_soci-mysql-devel.sha256sum] = "e985ce8a688e0447385de4b90ce372d7ed00843a43ac730327023e2bd134131b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-postgresql-4.1.4-2.el10_3.aarch64.rpm;name=aarch64_soci-postgresql;unpack=0"
SRC_URI[aarch64_soci-postgresql.sha256sum] = "37bf85fbf1bc043a6a2f28252a44c584aad5bd98033ed863aa1e7b4de734bac0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-postgresql-devel-4.1.4-2.el10_3.aarch64.rpm;name=aarch64_soci-postgresql-devel;unpack=0"
SRC_URI[aarch64_soci-postgresql-devel.sha256sum] = "a5d3acfcb535908043d86f116060242846c305ac16d4a7ff322a4374a6f41fc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-sqlite3-4.1.4-2.el10_3.aarch64.rpm;name=aarch64_soci-sqlite3;unpack=0"
SRC_URI[aarch64_soci-sqlite3.sha256sum] = "0ca428aacc0c8f52f3af5f4ec0e906defa190f0d5096faae9da1285598496643"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/soci-sqlite3-devel-4.1.4-2.el10_3.aarch64.rpm;name=aarch64_soci-sqlite3-devel;unpack=0"
SRC_URI[aarch64_soci-sqlite3-devel.sha256sum] = "03a86de12a4e58151a888121352595d42f4a4c75f48fe2ae1ccf99dffd6ff3e1"

RDEPENDS:soci = " \
 fmt \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:soci-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 soci \
 "
RDEPENDS:soci-doc = " \
 "
RDEPENDS:soci-empty = " \
 glibc \
 libgcc \
 libstdc++ \
 soci \
 "
RDEPENDS:soci-empty-devel = " \
 soci-devel \
 soci-empty \
 "
RDEPENDS:soci-mysql = " \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 soci \
 "
RDEPENDS:soci-mysql-devel = " \
 mariadb-connector-c-devel \
 soci-devel \
 soci-mysql \
 "
RDEPENDS:soci-postgresql = " \
 fmt \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 soci \
 "
RDEPENDS:soci-postgresql-devel = " \
 libpq-devel \
 soci-devel \
 soci-postgresql \
 "
RDEPENDS:soci-sqlite3 = " \
 fmt \
 glibc \
 libgcc \
 libstdc++ \
 soci \
 sqlite-libs \
 "
RDEPENDS:soci-sqlite3-devel = " \
 soci-devel \
 soci-sqlite3 \
 sqlite-devel \
 "
