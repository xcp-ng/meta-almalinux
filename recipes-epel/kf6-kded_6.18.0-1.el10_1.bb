# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kded"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kded \
 kf6-kded-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kded-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c9b599ebb861483eeaa10ed5edfc6224f42676af04ea662ea38cd6f784b74c2"

URI_x86_64_v2_kf6-kded = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kded-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kded}"
SRC_URI[x86_64_v2_kf6-kded.sha256sum] = "274daf921be47f739999f377e8e3cbf038e9a7241d565beea55ccb3eb4d82701"

URI_x86_64_v2_kf6-kded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kded-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kded-devel}"
SRC_URI[x86_64_v2_kf6-kded-devel.sha256sum] = "727d37f5020c1ec77725617c1abc5b55615fc1a7562e0ff4bf765e197ab148a5"

URI_aarch64_kf6-kded = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kded-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kded;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kded}"
SRC_URI[aarch64_kf6-kded.sha256sum] = "a0aa24f9f9a9589cd4c22a70c989c15d88904c6bbae5e7421f695bf42e867fb1"

URI_aarch64_kf6-kded-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kded-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kded-devel}"
SRC_URI[aarch64_kf6-kded-devel.sha256sum] = "2bcb5bf406a21a6b25d7e5d5046a868c98e5ab4d543d8f4639d821b4f56ce322"

RDEPENDS:kf6-kded = " \
 bash \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kded-devel = " \
 cmake-filesystem \
 kf6-kded \
 "
