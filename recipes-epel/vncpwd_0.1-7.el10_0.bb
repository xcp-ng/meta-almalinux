# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vncpwd"
PV = "0.1"
PR = "7.el10_0"
PACKAGES = " \
 vncpwd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vncpwd-0.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "445168e267c6b12ab431fb4bc9c496a906702483b3a731e5db00e0a370e8f40f"

URI_x86_64_v2_vncpwd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vncpwd-0.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vncpwd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vncpwd}"
SRC_URI[x86_64_v2_vncpwd.sha256sum] = "a2df9914fdc627dcd48cd7f9e33cf0ca995b4c34b96ecd9a146ff269a92d4a4b"

URI_aarch64_vncpwd = "${EPEL_MIRROR}/aarch64/Packages/v/vncpwd-0.1-7.el10_0.aarch64.rpm;name=aarch64_vncpwd;unpack=0"
SRC_URI:append = " ${URI_aarch64_vncpwd}"
SRC_URI[aarch64_vncpwd.sha256sum] = "3229b70ad9b99a5d7f760bb284bac28dcc7527d8c593d1afe1f836766e02a594"

RDEPENDS:vncpwd = " \
 glibc \
 "
