# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lsvpd"
PV = "1.7.15"
PR = "6.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lsvpd-1.7.15-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42696312b55673b00c11e12d06e119d4866aea57dd514608e2d9653b43313043"

