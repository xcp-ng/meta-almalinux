# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-openprinting-ipp-usb"
PV = "0.9.27"
PR = "6.el10"
PACKAGES = " \
 ipp-usb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-github-openprinting-ipp-usb-0.9.27-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb3c103c91a69b5857baa37b43cb0d03dbd1c9794953c380c1b64d4c8d344cc0"

URI_x86_64_v2_ipp-usb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipp-usb-0.9.27-6.el10.x86_64_v2.rpm;name=x86_64_v2_ipp-usb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipp-usb}"
SRC_URI[x86_64_v2_ipp-usb.sha256sum] = "025fd2cfad3484091134713e407a1ce37e32f3d9d444fb46d255ddf56c71d1a7"

URI_aarch64_ipp-usb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipp-usb-0.9.27-6.el10.aarch64.rpm;name=aarch64_ipp-usb;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipp-usb}"
SRC_URI[aarch64_ipp-usb.sha256sum] = "8985760856cb1494bfb832c6a11618f9cc26c888d3642e0905eda9e772803077"

RDEPENDS:ipp-usb = " \
 avahi-libs \
 bash \
 glibc \
 libusb1 \
 systemd \
 systemd-udev \
 "
