# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-bmatcuk-doublestar-4"
PV = "4.6.1"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-bmatcuk-doublestar-4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-bmatcuk-doublestar-4-4.6.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "852364da19111d59c39d810070b7b4141f1abee27eee3c331d594121feb18c21"

URI_x86_64_v2_golang-github-bmatcuk-doublestar-4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-bmatcuk-doublestar-4-devel-4.6.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-bmatcuk-doublestar-4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-bmatcuk-doublestar-4-devel}"
SRC_URI[x86_64_v2_golang-github-bmatcuk-doublestar-4-devel.sha256sum] = "20f48a2506c5b49ff02f160e397295288a537f0ed24f8eef61bac220ea0edd85"

URI_aarch64_golang-github-bmatcuk-doublestar-4-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-bmatcuk-doublestar-4-devel-4.6.1-4.el10_0.noarch.rpm;name=aarch64_golang-github-bmatcuk-doublestar-4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-bmatcuk-doublestar-4-devel}"
SRC_URI[aarch64_golang-github-bmatcuk-doublestar-4-devel.sha256sum] = "a84aab59d31b87f3b6e773c90393c14cc2c018c37b5a9337453cf00254d7fce2"

RDEPENDS:golang-github-bmatcuk-doublestar-4-devel = " \
 go-filesystem \
 "
