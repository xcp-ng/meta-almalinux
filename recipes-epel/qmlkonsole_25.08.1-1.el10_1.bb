# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qmlkonsole"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 qmlkonsole \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qmlkonsole-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f02c42ac10f7731c60eacdd33f3cedc17741e6629e9d844baaafdf347f2a0cc8"

URI_x86_64_v2_qmlkonsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmlkonsole-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmlkonsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qmlkonsole}"
SRC_URI[x86_64_v2_qmlkonsole.sha256sum] = "23c3d135f601f9aaccb3b2f1bf1447dea989b774d449fec7e66475b9bfb9a07b"

URI_aarch64_qmlkonsole = "${EPEL_MIRROR}/aarch64/Packages/q/qmlkonsole-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_qmlkonsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_qmlkonsole}"
SRC_URI[aarch64_qmlkonsole.sha256sum] = "e2b5712290aa408e60f0f66d20225376dc14fb2fc6e87b7b73a47b37736f897d"

RDEPENDS:qmlkonsole = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpty \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
