# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs-packaging"
PV = "2023.10"
PR = "12.el10_1"
PACKAGES = " \
 nodejs-packaging \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs-packaging-2023.10-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70385e9fb9c4faf5796165f9e11d5368e2ffae3f5ab4ebed2c3e0a4f6e8aa9b4"

URI_x86_64_v2_nodejs-packaging = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-packaging-2023.10-12.el10_1.noarch.rpm;name=x86_64_v2_nodejs-packaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-packaging}"
SRC_URI[x86_64_v2_nodejs-packaging.sha256sum] = "7387a7c0d4cd3b292c1b3d04124b9b219963944e8dbe3e6a01691ab5e74edbcd"

URI_aarch64_nodejs-packaging = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-packaging-2023.10-12.el10_1.noarch.rpm;name=aarch64_nodejs-packaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-packaging}"
SRC_URI[aarch64_nodejs-packaging.sha256sum] = "7387a7c0d4cd3b292c1b3d04124b9b219963944e8dbe3e6a01691ab5e74edbcd"

RDEPENDS:nodejs-packaging = " \
 python3 \
 redhat-rpm-config \
 "
