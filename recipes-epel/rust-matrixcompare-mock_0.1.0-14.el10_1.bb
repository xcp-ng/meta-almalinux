# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matrixcompare-mock"
PV = "0.1.0"
PR = "14.el10_1"
PACKAGES = " \
 rust-matrixcompare-mock+default-devel \
 rust-matrixcompare-mock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matrixcompare-mock-0.1.0-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54e9c65465158a7a150bd21f3fc2dfc61359e20df324b76910d738f62a734e0d"

URI_x86_64_v2_rust-matrixcompare-mock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixcompare-mock+default-devel-0.1.0-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixcompare-mock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixcompare-mock+default-devel}"
SRC_URI[x86_64_v2_rust-matrixcompare-mock+default-devel.sha256sum] = "8c3a6741708b31df978c585d4a03bb23ee8a11bb3a4741c4b43508c287aede06"

URI_x86_64_v2_rust-matrixcompare-mock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixcompare-mock-devel-0.1.0-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixcompare-mock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixcompare-mock-devel}"
SRC_URI[x86_64_v2_rust-matrixcompare-mock-devel.sha256sum] = "f9bf385216fe5fc2d2a57ffe33c4d17f78a1f0afc01bbe20b021793f5089c7f1"

URI_aarch64_rust-matrixcompare-mock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixcompare-mock+default-devel-0.1.0-14.el10_1.noarch.rpm;name=aarch64_rust-matrixcompare-mock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixcompare-mock+default-devel}"
SRC_URI[aarch64_rust-matrixcompare-mock+default-devel.sha256sum] = "b5522e914c8b2aad97b71d06b707e88207ff864b8072434f4d300a06cbdc2f3c"

URI_aarch64_rust-matrixcompare-mock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixcompare-mock-devel-0.1.0-14.el10_1.noarch.rpm;name=aarch64_rust-matrixcompare-mock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixcompare-mock-devel}"
SRC_URI[aarch64_rust-matrixcompare-mock-devel.sha256sum] = "cf1324dbae05acb4866c2ccac112a7e74873810354c1b77da9b555ce18a93be2"

RDEPENDS:rust-matrixcompare-mock+default-devel = " \
 cargo \
 rust-matrixcompare-mock-devel \
 "
RDEPENDS:rust-matrixcompare-mock-devel = " \
 cargo \
 rust-matrixcompare-core+default-devel \
 rust-num+default-devel \
 rust-proptest+default-devel \
 "
