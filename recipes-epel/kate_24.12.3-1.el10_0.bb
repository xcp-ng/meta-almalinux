# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kate"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kate \
 kate-libs \
 kate-plugins \
 kwrite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kate-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d72b2bc7135ce84ce8528bc68c363c4875ab43abad9b9834f347fb616fbfb85"

URI_x86_64_v2_kate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate}"
SRC_URI[x86_64_v2_kate.sha256sum] = "05e0d2cb6c541241ee78b11760324f547c9dabb16eb1c1d3b8456a2def5a0d1b"

URI_x86_64_v2_kate-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate-libs}"
SRC_URI[x86_64_v2_kate-libs.sha256sum] = "05ef38fe7b85b5ccf11cb8a3768025bc3386e46fa80ffc5c9ac3b5d7ea6e0afc"

URI_x86_64_v2_kate-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-plugins-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kate-plugins}"
SRC_URI[x86_64_v2_kate-plugins.sha256sum] = "ecf071880d6fee249e61b6bb2a25ce832639eb614f3bffb79764b918a0c778b1"

URI_x86_64_v2_kwrite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwrite-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwrite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwrite}"
SRC_URI[x86_64_v2_kwrite.sha256sum] = "bd276acebdd07815379b4ebf8adc4b69f922b014bccee7d73dcb0717a0dac519"

URI_aarch64_kate = "${EPEL_MIRROR}/aarch64/Packages/k/kate-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kate;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate}"
SRC_URI[aarch64_kate.sha256sum] = "084d9e64d1c1deb331864de00ed24b316fdfd97f9c22958145af098e7cc056ff"

URI_aarch64_kate-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kate-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kate-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate-libs}"
SRC_URI[aarch64_kate-libs.sha256sum] = "6f2ca198b5cbce1a19235cd5d8d0cdef442035d933b4bea3d3880d6a2367a2be"

URI_aarch64_kate-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/kate-plugins-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kate-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_kate-plugins}"
SRC_URI[aarch64_kate-plugins.sha256sum] = "abd3fa18f3b31cce05649351849fa4eac6945a5d348144df24eee045754d858d"

URI_aarch64_kwrite = "${EPEL_MIRROR}/aarch64/Packages/k/kwrite-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kwrite;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwrite}"
SRC_URI[aarch64_kwrite.sha256sum] = "c2b692444e28bcb7d8bb4165668cd252b484743156647bd941d40eb0ec312024"

RDEPENDS:kate = " \
 glibc \
 kate-libs \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kate-libs = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kate-plugins = " \
 glibc \
 kate \
 kate-libs \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-kparts \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:kwrite = " \
 glibc \
 kate-libs \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
