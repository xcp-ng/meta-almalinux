# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hello"
PV = "2.12.2"
PR = "1.el10_1"
PACKAGES = " \
 hello \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hello-2.12.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71f66a280a805131bdf4521634a10d592fc9378128b1141c9b1b0ee477e2ce2b"

URI_x86_64_v2_hello = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hello-2.12.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hello;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hello}"
SRC_URI[x86_64_v2_hello.sha256sum] = "fa417287f34e8f7e43d8d85d8ed8ad56bc6f3ef6428bf7d99fb596c00db99f25"

URI_aarch64_hello = "${EPEL_MIRROR}/aarch64/Packages/h/hello-2.12.2-1.el10_1.aarch64.rpm;name=aarch64_hello;unpack=0"
SRC_URI:append = " ${URI_aarch64_hello}"
SRC_URI[aarch64_hello.sha256sum] = "dfdb5c57d052a55c5c56c8d3a93e1ce1791c06a54ca6ba44a895cdec65f946af"

RDEPENDS:hello = " \
 glibc \
 "
