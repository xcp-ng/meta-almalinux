# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libayatana-appindicator"
PV = "0.5.94"
PR = "3.el10_0"
PACKAGES = " \
 libayatana-appindicator-gtk3 \
 libayatana-appindicator-gtk3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libayatana-appindicator-0.5.94-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42ea206bce2141ad77bd6bd8b857801be964ca8f33c29e50844ee71ca4410760"

URI_x86_64_v2_libayatana-appindicator-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-appindicator-gtk3-0.5.94-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-appindicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-appindicator-gtk3}"
SRC_URI[x86_64_v2_libayatana-appindicator-gtk3.sha256sum] = "12a3c664caddfd31e4441d93e8f6dc31447ee30d68d59e7e785d74c2a6eb59e4"

URI_x86_64_v2_libayatana-appindicator-gtk3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-appindicator-gtk3-devel-0.5.94-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-appindicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-appindicator-gtk3-devel}"
SRC_URI[x86_64_v2_libayatana-appindicator-gtk3-devel.sha256sum] = "20b57914b75acd3486f561e40e1541333270777ae5bd78620ae3d1eb0ba17d9b"

URI_aarch64_libayatana-appindicator-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-appindicator-gtk3-0.5.94-3.el10_0.aarch64.rpm;name=aarch64_libayatana-appindicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-appindicator-gtk3}"
SRC_URI[aarch64_libayatana-appindicator-gtk3.sha256sum] = "451e79b3ec971803908b34c7e43acc7b84e68ed8051512b9b12c34b744abfc7e"

URI_aarch64_libayatana-appindicator-gtk3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-appindicator-gtk3-devel-0.5.94-3.el10_0.aarch64.rpm;name=aarch64_libayatana-appindicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-appindicator-gtk3-devel}"
SRC_URI[aarch64_libayatana-appindicator-gtk3-devel.sha256sum] = "73fb55b9a6f6f4f024983d574696583897e7f4f348322dee5104d08b7eb168d4"

RDEPENDS:libayatana-appindicator-gtk3 = " \
 glib2 \
 glibc \
 gtk3 \
 libayatana-indicator-gtk3 \
 libdbusmenu \
 libdbusmenu-gtk3 \
 libgcc \
 "
RDEPENDS:libayatana-appindicator-gtk3-devel = " \
 glib2-devel \
 gtk3-devel \
 libayatana-appindicator-gtk3 \
 libayatana-indicator-gtk3-devel \
 libdbusmenu-devel \
 pkgconf-pkg-config \
 "
