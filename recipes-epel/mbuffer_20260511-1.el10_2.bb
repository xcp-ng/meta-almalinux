# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbuffer"
PV = "20260511"
PR = "1.el10_2"
PACKAGES = " \
 mbuffer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mbuffer-20260511-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bfc244a5e059fce45f468d88a98d6959909e574d00c3ccdead68b8d613ce760"

URI_x86_64_v2_mbuffer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbuffer-20260511-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbuffer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbuffer}"
SRC_URI[x86_64_v2_mbuffer.sha256sum] = "c1ef025185acc1e0539313e7a2946f3150718b76153c940bbb67844690d4299d"

URI_aarch64_mbuffer = "${EPEL_MIRROR}/aarch64/Packages/m/mbuffer-20260511-1.el10_2.aarch64.rpm;name=aarch64_mbuffer;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbuffer}"
SRC_URI[aarch64_mbuffer.sha256sum] = "cb809f77be7777f71277a2b69eee9db04a111efd3ce9f259881f5176941e28c7"

RDEPENDS:mbuffer = " \
 glibc \
 libgcc \
 "
