# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "device-mapper-persistent-data"
PV = "1.3.2"
PR = "1.el10"
PACKAGES = " \
 device-mapper-persistent-data \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/device-mapper-persistent-data-1.3.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07e6ee7111b059c0aa94b32b06c86d98147e37ac2013557ad82f77d9ffcba27f"

URI_x86_64_v2_device-mapper-persistent-data = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-persistent-data-1.3.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-persistent-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-persistent-data}"
SRC_URI[x86_64_v2_device-mapper-persistent-data.sha256sum] = "09c9689d26a8727493e5f7e2c9cfa7c4e7a672ba53534f6b6613efe3ec5db74f"

URI_aarch64_device-mapper-persistent-data = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-persistent-data-1.3.2-1.el10.aarch64.rpm;name=aarch64_device-mapper-persistent-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-persistent-data}"
SRC_URI[aarch64_device-mapper-persistent-data.sha256sum] = "54a1470e348c1d8346dc55aaeba90d53982795d36514a1e8cc64bfccd224d129"

RDEPENDS:device-mapper-persistent-data = " \
 glibc \
 libgcc \
 systemd-libs \
 "
