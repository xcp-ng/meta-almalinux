# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-or"
PE = "1"
PV = "1.0.0"
PR = "27.el10"
PACKAGES = " \
 hunspell-or \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-or-1.0.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57460067fc615a4613238d0e3cb1286d136e2e34dc2c0aff10555a02c57148ac"

URI_x86_64_v2_hunspell-or = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-or-1.0.0-27.el10.noarch.rpm;name=x86_64_v2_hunspell-or;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-or}"
SRC_URI[x86_64_v2_hunspell-or.sha256sum] = "886a5b4a825fa6c6a8ae261a9af64804e6dff5c0524cd7672b4f6210a014a130"

URI_aarch64_hunspell-or = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-or-1.0.0-27.el10.noarch.rpm;name=aarch64_hunspell-or;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-or}"
SRC_URI[aarch64_hunspell-or.sha256sum] = "886a5b4a825fa6c6a8ae261a9af64804e6dff5c0524cd7672b4f6210a014a130"

RDEPENDS:hunspell-or = " \
 hunspell \
 "
