# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ndisc6"
PV = "1.0.8"
PR = "4.el10_1"
PACKAGES = " \
 ndisc6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ndisc6-1.0.8-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45ba37872135ce9ade6d830d508a1f632139b6870cfb4e88393f8449a8e21a8d"

URI_x86_64_v2_ndisc6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ndisc6-1.0.8-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ndisc6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ndisc6}"
SRC_URI[x86_64_v2_ndisc6.sha256sum] = "c116bd3e57ec5a272939756afcd0a53359c0a61ca4b0f0798544796164359d4f"

URI_aarch64_ndisc6 = "${EPEL_MIRROR}/aarch64/Packages/n/ndisc6-1.0.8-4.el10_1.aarch64.rpm;name=aarch64_ndisc6;unpack=0"
SRC_URI:append = " ${URI_aarch64_ndisc6}"
SRC_URI[aarch64_ndisc6.sha256sum] = "031590a5abe886065f6c55cab4486d24e6d5b4a790d604cdce93f7e5840c438b"

RDEPENDS:ndisc6 = " \
 bash \
 glibc \
 perl-Getopt-Std \
 perl-interpreter \
 perl-libs \
 "
