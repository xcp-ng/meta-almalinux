# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-retry-policies"
PV = "0.5.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-retry-policies+default-devel \
 rust-retry-policies-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-retry-policies-0.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8671e64eb9f989d433b403d6785d404a01c999aa369d4e111a02c859ac14dc5"

URI_x86_64_v2_rust-retry-policies+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-retry-policies+default-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-retry-policies+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-retry-policies+default-devel}"
SRC_URI[x86_64_v2_rust-retry-policies+default-devel.sha256sum] = "f438be5823d4ac2ca2e54a74c09ca2a4dd9077d6b38179d73fe030c5797a1ac4"

URI_x86_64_v2_rust-retry-policies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-retry-policies-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-retry-policies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-retry-policies-devel}"
SRC_URI[x86_64_v2_rust-retry-policies-devel.sha256sum] = "1d091a49e19832614218b2f680119b20718fe6ca707f131e33991cc258575abf"

URI_aarch64_rust-retry-policies+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-retry-policies+default-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-retry-policies+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-retry-policies+default-devel}"
SRC_URI[aarch64_rust-retry-policies+default-devel.sha256sum] = "5d692ee675e1a4301268511d1492c653099c48017942487a9d5b29574b439bdf"

URI_aarch64_rust-retry-policies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-retry-policies-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-retry-policies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-retry-policies-devel}"
SRC_URI[aarch64_rust-retry-policies-devel.sha256sum] = "62c8a4fadaee5ea65b8f7efdae5c4958251140309ae4a08bbf76413c4bd0b1f2"

RDEPENDS:rust-retry-policies+default-devel = " \
 cargo \
 rust-retry-policies-devel \
 "
RDEPENDS:rust-retry-policies-devel = " \
 cargo \
 rust-rand+default-devel \
 "
