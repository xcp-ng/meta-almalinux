# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16-decoderbufs"
PV = "1.9.7"
PR = "9.Final.el10"
PACKAGES = " \
 postgres-decoderbufs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-decoderbufs-1.9.7-9.Final.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dc9e83844e4a3a4ede88d19624951d39a18f039413608aa393fb96e3c92377d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgres-decoderbufs-1.9.7-9.Final.el10.x86_64_v2.rpm;name=x86_64_v2_postgres-decoderbufs;unpack=0"
SRC_URI[x86_64_v2_postgres-decoderbufs.sha256sum] = "0369f55cf64d1f129dd6f044678ca4a343b3df9056171e3018acb5b981b71b9d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgres-decoderbufs-1.9.7-9.Final.el10.aarch64.rpm;name=aarch64_postgres-decoderbufs;unpack=0"
SRC_URI[aarch64_postgres-decoderbufs.sha256sum] = "8934037e3b0ff1fe121504671da30be21eb44a12a7f4ebe46c38c9b0be34041b"

RDEPENDS:postgres-decoderbufs = " \
 glibc \
 postgresql-server \
 protobuf-c \
 "
