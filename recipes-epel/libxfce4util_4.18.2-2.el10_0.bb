# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxfce4util"
PV = "4.18.2"
PR = "2.el10_0"
PACKAGES = " \
 libxfce4util \
 libxfce4util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libxfce4util-4.18.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88d1658731320516207dab970309c6984ae3de119a0e60b2f024843bce4ec862"

URI_x86_64_v2_libxfce4util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxfce4util-4.18.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxfce4util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxfce4util}"
SRC_URI[x86_64_v2_libxfce4util.sha256sum] = "f618e55a455ca56f553988b05ad2786bb6246c22baa965be88d4242867e3c25a"

URI_x86_64_v2_libxfce4util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxfce4util-devel-4.18.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxfce4util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxfce4util-devel}"
SRC_URI[x86_64_v2_libxfce4util-devel.sha256sum] = "68de971af07ce991617a8fc5ced70672b9653c5f40e65692a6d22b28eebabc48"

URI_aarch64_libxfce4util = "${EPEL_MIRROR}/aarch64/Packages/l/libxfce4util-4.18.2-2.el10_0.aarch64.rpm;name=aarch64_libxfce4util;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxfce4util}"
SRC_URI[aarch64_libxfce4util.sha256sum] = "fd32707d7883aa6a83bc8c856ea6019f9783eb79c2244da456d409c25204b25f"

URI_aarch64_libxfce4util-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libxfce4util-devel-4.18.2-2.el10_0.aarch64.rpm;name=aarch64_libxfce4util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxfce4util-devel}"
SRC_URI[aarch64_libxfce4util-devel.sha256sum] = "36cadff570e52756f4c3c347d605859eba54c6d370479cb8f969a6189d512abe"

RDEPENDS:libxfce4util = " \
 glib2 \
 glibc \
 "
RDEPENDS:libxfce4util-devel = " \
 glib2-devel \
 gtk3-devel \
 libxfce4util \
 pkgconf-pkg-config \
 "
