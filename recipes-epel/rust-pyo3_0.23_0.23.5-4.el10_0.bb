# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3_0.23"
PV = "0.23.5"
PR = "4.el10_0"
PACKAGES = " \
 rust-pyo3_0.23+abi3-devel \
 rust-pyo3_0.23+abi3-py310-devel \
 rust-pyo3_0.23+abi3-py311-devel \
 rust-pyo3_0.23+abi3-py312-devel \
 rust-pyo3_0.23+abi3-py37-devel \
 rust-pyo3_0.23+abi3-py38-devel \
 rust-pyo3_0.23+abi3-py39-devel \
 rust-pyo3_0.23+anyhow-devel \
 rust-pyo3_0.23+auto-initialize-devel \
 rust-pyo3_0.23+chrono-devel \
 rust-pyo3_0.23+chrono-tz-devel \
 rust-pyo3_0.23+default-devel \
 rust-pyo3_0.23+either-devel \
 rust-pyo3_0.23+experimental-async-devel \
 rust-pyo3_0.23+experimental-inspect-devel \
 rust-pyo3_0.23+extension-module-devel \
 rust-pyo3_0.23+eyre-devel \
 rust-pyo3_0.23+full-devel \
 rust-pyo3_0.23+hashbrown-devel \
 rust-pyo3_0.23+indexmap-devel \
 rust-pyo3_0.23+indoc-devel \
 rust-pyo3_0.23+inventory-devel \
 rust-pyo3_0.23+macros-devel \
 rust-pyo3_0.23+multiple-pymethods-devel \
 rust-pyo3_0.23+nightly-devel \
 rust-pyo3_0.23+num-bigint-devel \
 rust-pyo3_0.23+num-complex-devel \
 rust-pyo3_0.23+num-rational-devel \
 rust-pyo3_0.23+py-clone-devel \
 rust-pyo3_0.23+pyo3-macros-devel \
 rust-pyo3_0.23+rust_decimal-devel \
 rust-pyo3_0.23+serde-devel \
 rust-pyo3_0.23+smallvec-devel \
 rust-pyo3_0.23+unindent-devel \
 rust-pyo3_0.23-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3_0.23-0.23.5-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3286f417280a94ec3fe6f49e57822b35a92064b9a09de6db8078d60d9a15665c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-devel.sha256sum] = "002191b0536819331b863d76debdf44f78aeeae01014e3df5a5e1bd484629508"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py310-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py310-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py310-devel.sha256sum] = "eec85a1ae43c3748596061da7176507055bf1de519874cbe3ca72136f5edbcb1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py311-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py311-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py311-devel.sha256sum] = "71fd90f8dbd72ea32b8ec5df871f447104a98d68d0b9564b16c30312ffc4cb90"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py312-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py312-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py312-devel.sha256sum] = "9c070efcb6b62d06e948ca99ff20e9fe1a9c34c9164f779d2c2f519ac2cde7a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py37-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py37-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py37-devel.sha256sum] = "105fd36b869c5b0e4b498138384f8344c7c058f8737a33614c137993613cf198"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py38-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py38-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py38-devel.sha256sum] = "ca1d9f9edcc13736611aa6f0fa08939c534d48844a3ab84eb7ac5b84e39ff13e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+abi3-py39-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+abi3-py39-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+abi3-py39-devel.sha256sum] = "02c76dce4026b506a7cdb449800b2ec2eb8c652f92d84fea906cf692a719214d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+anyhow-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+anyhow-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+anyhow-devel.sha256sum] = "aa933d9b11b7fedeb7a95d95894b960f8ac5e15411068958866748c22aa38e97"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+auto-initialize-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+auto-initialize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+auto-initialize-devel.sha256sum] = "2e30b1d3f3c69c95d0991f74364ce2f55371c1eae481baaa9640f13c895f3834"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+chrono-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+chrono-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+chrono-devel.sha256sum] = "bb73c60e35f03d1dff01286a5f462722e38ad4e476923d094ce00d2080cc8c10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+chrono-tz-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+chrono-tz-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+chrono-tz-devel.sha256sum] = "1816d2c91058f7d68b5cf2ca2405ab0baee605207a60f0692844062fe7ba488d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+default-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+default-devel.sha256sum] = "81ee949d9d7b9f0dd8c8a2180c6873faec190f728d194849f565aab1bf3262f6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+either-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+either-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+either-devel.sha256sum] = "04b57ded76e74a86bcb538416ae27f49a560875feff2414ae9fdab9c6d07d440"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+experimental-async-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+experimental-async-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+experimental-async-devel.sha256sum] = "09d38636ccacaddffebefb8c54aa340ac8669d063efa4bfafe0286e6cfa4214b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+experimental-inspect-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+experimental-inspect-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+experimental-inspect-devel.sha256sum] = "d7f6be9c47bcbe08aeb0e11d444d8286aaa867c3b80fddb9a47310c69f101703"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+extension-module-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+extension-module-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+extension-module-devel.sha256sum] = "bef9ca2fd96ffd8801f43123261cc898f1b89adabb7dd80853a078c6ed3c82db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+eyre-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+eyre-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+eyre-devel.sha256sum] = "cadea096ce8c9a1b70db983daa2a9119ae1d327a8057f281caa4e30663a697ad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+full-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+full-devel.sha256sum] = "fff8194a188850fe767d8407a3aec5f54acd4896feb3b2e0aea4cc667c83e000"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+hashbrown-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+hashbrown-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+hashbrown-devel.sha256sum] = "e178dd25850bdc3cc08570b79ed0a4ab1415cfe95f18f602b6e3001fea26d530"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+indexmap-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+indexmap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+indexmap-devel.sha256sum] = "7253e9efc40d2f54e51e5141e241b4a5553e68daae87986f0a1d00bf2c81c896"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+indoc-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+indoc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+indoc-devel.sha256sum] = "765575cd0f0106e5be7b78374ef6006fd4bbcedde56f7409115c767c847d8633"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+inventory-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+inventory-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+inventory-devel.sha256sum] = "01794f80eb832a1f3c625fde859924dc8eb3d9790b78f906244de9f04cc8e796"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+macros-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+macros-devel.sha256sum] = "d9a9dde11dc23657b3ee9c048f6606965a22c18479f68862c1977235e65ed2e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+multiple-pymethods-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+multiple-pymethods-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+multiple-pymethods-devel.sha256sum] = "4aaeb493416b00ece28fbdd2028a8c16069354cba4deb7c32a3a488a9f673ef3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+nightly-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+nightly-devel.sha256sum] = "71eef300b1eb23795c7f90e1b6811ee2e1f832b4dfc70acc29b96ecfe1443f06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+num-bigint-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+num-bigint-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+num-bigint-devel.sha256sum] = "e79faad9223a7453c7fdfe633aacc5cf33c33ea1026b6aae93058a149464804c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+num-complex-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+num-complex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+num-complex-devel.sha256sum] = "52773b5550ce01856e5236a93afe5d01d7a1078820ecd29684fb4911c72416e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+num-rational-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+num-rational-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+num-rational-devel.sha256sum] = "0b60d2805a6a3ffdf04d60311babf31a9cce8746698a9a13ac23b8aa8f5d629a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+py-clone-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+py-clone-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+py-clone-devel.sha256sum] = "5234622ee1632c2f4e53ea13be1b875081dcdb714e87c865de223c69d15d31cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+pyo3-macros-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+pyo3-macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+pyo3-macros-devel.sha256sum] = "2aa2ad6b5f281a223e55bd225e6ebee345be180ad16f5542bb605334a34ea1da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+rust_decimal-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+rust_decimal-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+rust_decimal-devel.sha256sum] = "717870ff0c396f4b1638a0f6c0d493a2535e3b552aaa43d5687b56310d95934f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+serde-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+serde-devel.sha256sum] = "db2a00d32b60c7a2cf8138a22957818250f4ef16fa633c90858c706efb5090f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+smallvec-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+smallvec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+smallvec-devel.sha256sum] = "06064504cbfe7d89d5359f9c7975999b1b6ceea2136fe7fe679bf4051069690c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23+unindent-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23+unindent-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23+unindent-devel.sha256sum] = "0376e3d9be06feac2700f2b4bca6156ce39960503828547208051fccfd3649b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.23-devel-0.23.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.23-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pyo3_0.23-devel.sha256sum] = "b5a7f1d6c80b18f24fe7fbe1d14258fab048d2aaca8a8b98018989287f15088d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-devel.sha256sum] = "64bcb787ade478be2d1d767aa4ebbefd3cc299204ebf427ce202348e5d547834"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py310-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py310-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py310-devel.sha256sum] = "cf3ba10b804d96af2d00cc509af9afe7954ecf7408f9b53832d5c5785679ff12"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py311-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py311-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py311-devel.sha256sum] = "60348edc9e0e2b15b5f78324d2a50428be679aefb058bd826e7195cd2e597ce4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py312-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py312-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py312-devel.sha256sum] = "9aa227b47215e2ab561b34a57bf9bf5e0efe75f0f35e8e3d8067a30a9d98a525"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py37-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py37-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py37-devel.sha256sum] = "a8d1f555e84abfd295451bedb92c3fc45856101630eb5ee4af21788a4956ba26"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py38-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py38-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py38-devel.sha256sum] = "a7bd79db7a3df68529a84a1a5f51372d2be16eea3809d29f5be3493bbd39dfc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+abi3-py39-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+abi3-py39-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+abi3-py39-devel.sha256sum] = "cb35317276ae74b3d8bee3ac80962d43cd8b1d645e01a933908aefb97317ec18"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+anyhow-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+anyhow-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+anyhow-devel.sha256sum] = "40f43f3e841b06a6eebb873b274747213b92294cb0c7649bab573cceea81f186"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+auto-initialize-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+auto-initialize-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+auto-initialize-devel.sha256sum] = "c867a45ef313c6ffe33d9ff31a078d5dac342ca547060564f581ca7cec42f0e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+chrono-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+chrono-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+chrono-devel.sha256sum] = "fc7a3fcb508b7012ae8ef0f9409d47c071bbecf8a1344396531b5bac956192f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+chrono-tz-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+chrono-tz-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+chrono-tz-devel.sha256sum] = "96dbeec6cc81b304a701ce9ff648332d6d3a14ad1396d19e5ccc3734ecacd876"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+default-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+default-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+default-devel.sha256sum] = "82a12b1ddfdb762cd579b52d6dde281ce3c7bc41c6e3baaf439f4479a2bd6638"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+either-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+either-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+either-devel.sha256sum] = "c77843898b5350dd9218363944a76186f94ae8692af72064e09f489a6cb7a805"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+experimental-async-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+experimental-async-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+experimental-async-devel.sha256sum] = "f63cbf3d7b4078c86926bc7993943e7630fca2b275e4f78d2d39cefede5a7907"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+experimental-inspect-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+experimental-inspect-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+experimental-inspect-devel.sha256sum] = "768c5ae6014005929d33eea383361639b7a55237b5c2730a78822120410c51fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+extension-module-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+extension-module-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+extension-module-devel.sha256sum] = "d6cc1fd2077ff9efaece963604954aa4bfabc173d8a18b081cc94b3e27a06113"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+eyre-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+eyre-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+eyre-devel.sha256sum] = "68e3edf2b2c3cd718390a993628f11e215c021f945716335100f97961e47a6cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+full-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+full-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+full-devel.sha256sum] = "8b249020bd457957c794cdbbf5a13e1c9da46906cb22c22ee23554d443e90673"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+hashbrown-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+hashbrown-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+hashbrown-devel.sha256sum] = "4e451c304cef0cca4ba50767c15ad9ae37fdb2b46f22937b24803488cbe3a4f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+indexmap-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+indexmap-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+indexmap-devel.sha256sum] = "9620480aa37b37b53908c60fa4a249b07197aa6b56178e87877ed1710eabb51b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+indoc-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+indoc-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+indoc-devel.sha256sum] = "294f5e7ac409a66d4d8f3920b378ce3fd936dd24d9dc924f81599c43482c6510"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+inventory-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+inventory-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+inventory-devel.sha256sum] = "d724c8265bcd30759bf289adfe3d73e75282f0d5969506b09174e944d1bb2c11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+macros-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+macros-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+macros-devel.sha256sum] = "a900b21a6148cebf463e988e03e2ad71a18e107924aa1c977c888dd42fe8537b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+multiple-pymethods-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+multiple-pymethods-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+multiple-pymethods-devel.sha256sum] = "209d41b8598c8940af454d94fadc639c4ce1b250ef892c6e0049232f20521cdb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+nightly-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+nightly-devel.sha256sum] = "bc67eb4983cc116aaabe652f2aa3041e259258c1326077c79d254abf0c0e13ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+num-bigint-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+num-bigint-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+num-bigint-devel.sha256sum] = "71d9d71eb02efbcf71e10d2c1b0004e5584f8d9651b71dea5efcc62843525197"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+num-complex-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+num-complex-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+num-complex-devel.sha256sum] = "8ced3af5f45293cbeebff84576bd05b468d25625b369e7dd9b1d79a00acd2896"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+num-rational-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+num-rational-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+num-rational-devel.sha256sum] = "f70584d42f99a50ef4c6e137366fc8592a4053991fa878b94d28720849d47a34"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+py-clone-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+py-clone-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+py-clone-devel.sha256sum] = "36a71ba9c74ad4fba5f32ec34bad9fb166fb529a93b2da234c19a47f05737762"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+pyo3-macros-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+pyo3-macros-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+pyo3-macros-devel.sha256sum] = "067d118f8ccb501ea43ce401adfc79ec8ad5c5fa80d5c71f347afdc01b112b2b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+rust_decimal-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+rust_decimal-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+rust_decimal-devel.sha256sum] = "b7d7aa3d7c66e4545cd6124880b64de1a9389661efaaab257555b25b4a768a86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+serde-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+serde-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+serde-devel.sha256sum] = "65ddc4a33e91d329fbb0b693a19e2788ad83ad21a355113d445f60354fcc6edb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+smallvec-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+smallvec-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+smallvec-devel.sha256sum] = "96e24430b8161155daf536852fe86d751a1fad25f6fb18e7aa7fe8fd7279d44a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23+unindent-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23+unindent-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23+unindent-devel.sha256sum] = "fb659bb229793eb9a9c76fb6635ebbcbfd5e36d7f3e37eee2d54e90499a13e3f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.23-devel-0.23.5-4.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.23-devel;unpack=0"
SRC_URI[aarch64_rust-pyo3_0.23-devel.sha256sum] = "3609c536221cbabcda1f9a9f1493c64b46d02539fcdc03018878dd60d499c5ac"

RDEPENDS:rust-pyo3_0.23+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py310-devel \
 rust-pyo3_0.23+abi3-py311-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py311-devel \
 rust-pyo3_0.23+abi3-py312-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py312-devel \
 rust-pyo3_0.23+abi3-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py37-devel \
 rust-pyo3_0.23+abi3-py38-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py38-devel \
 rust-pyo3_0.23+abi3-py39-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py39-devel \
 rust-pyo3_0.23+abi3-py310-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+auto-initialize-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+default-devel = " \
 cargo \
 rust-pyo3_0.23+macros-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros0.23+default-devel \
 rust-pyo3-macros0.23+experimental-async-devel \
 rust-pyo3_0.23+macros-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+experimental-inspect-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.23+extension-module-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+full-devel = " \
 cargo \
 rust-pyo3_0.23+anyhow-devel \
 rust-pyo3_0.23+chrono-devel \
 rust-pyo3_0.23+chrono-tz-devel \
 rust-pyo3_0.23+either-devel \
 rust-pyo3_0.23+experimental-async-devel \
 rust-pyo3_0.23+experimental-inspect-devel \
 rust-pyo3_0.23+eyre-devel \
 rust-pyo3_0.23+hashbrown-devel \
 rust-pyo3_0.23+indexmap-devel \
 rust-pyo3_0.23+macros-devel \
 rust-pyo3_0.23+num-bigint-devel \
 rust-pyo3_0.23+num-complex-devel \
 rust-pyo3_0.23+num-rational-devel \
 rust-pyo3_0.23+py-clone-devel \
 rust-pyo3_0.23+rust_decimal-devel \
 rust-pyo3_0.23+serde-devel \
 rust-pyo3_0.23+smallvec-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+hashbrown-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ \
 "
RDEPENDS:rust-pyo3_0.23+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+indoc-devel = " \
 cargo \
 rust-indoc+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+macros-devel = " \
 cargo \
 rust-pyo3_0.23+indoc-devel \
 rust-pyo3_0.23+pyo3-macros-devel \
 rust-pyo3_0.23+unindent-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.23+default-devel \
 rust-pyo3-macros0.23+multiple-pymethods-devel \
 rust-pyo3_0.23+inventory-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+nightly-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+py-clone-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-macros0.23+default-devel \
 rust-pyo3_0.23-devel \
 "
RDEPENDS:rust-pyo3_0.23+rust_decimal-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3_0.23+serde-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3_0.23+smallvec-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3_0.23+unindent-devel = " \
 cargo \
 rust-pyo3_0.23-devel \
 rust-unindent+default-devel \
 "
RDEPENDS:rust-pyo3_0.23-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-memoffset+default-devel \
 rust-once_cell+default-devel \
 rust-portable-atomic+default-devel \
 rust-pyo3-build-config0.23+default-devel \
 rust-pyo3-build-config0.23+resolve-config-devel \
 rust-pyo3-ffi0.23+default-devel \
 "
