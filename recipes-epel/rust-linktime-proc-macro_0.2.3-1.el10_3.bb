# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-linktime-proc-macro"
PV = "0.2.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-linktime-proc-macro+ctor-devel \
 rust-linktime-proc-macro+default-devel \
 rust-linktime-proc-macro+dtor-devel \
 rust-linktime-proc-macro+link_section-devel \
 rust-linktime-proc-macro+scattered_collect-devel \
 rust-linktime-proc-macro-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-linktime-proc-macro-0.2.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fd3400270b5ade0f1be820438512278fa0e617e6a7c3825bcb10282e4e802830"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro+ctor-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro+ctor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-linktime-proc-macro+ctor-devel.sha256sum] = "1d63a60bd639180a22253391771d052577d720fb0f6521919e487856a0295660"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro+default-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-linktime-proc-macro+default-devel.sha256sum] = "eb59e7de051f977c7df28ff9770d68d3066ba9c231e6c3e3459c0d55d5ec3681"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro+dtor-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro+dtor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-linktime-proc-macro+dtor-devel.sha256sum] = "4cd44cf145008a7a02b2695fc7cfcbdda0e428964186e4b42bb665bb84b55fe8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro+link_section-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro+link_section-devel;unpack=0"
SRC_URI[x86_64_v2_rust-linktime-proc-macro+link_section-devel.sha256sum] = "61a050d5da52bcc681ff27dea073e288f8b02665d08c96290bf93a743182e30d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro+scattered_collect-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro+scattered_collect-devel;unpack=0"
SRC_URI[x86_64_v2_rust-linktime-proc-macro+scattered_collect-devel.sha256sum] = "b05897b2b5e4682ba0594664268dcc927f82d4bbd0bf56d57c88270e3049bdfa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-linktime-proc-macro-devel.sha256sum] = "0353bdc44c7a7f8748cdeadcb225a9148bbc5307ff0bc31940698e1d26fb7a9e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro+ctor-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro+ctor-devel;unpack=0"
SRC_URI[aarch64_rust-linktime-proc-macro+ctor-devel.sha256sum] = "4f72fbc78ca68b467f39e8dabf407ac4c209e2395c1119551fa40c381271e9bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro+default-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro+default-devel;unpack=0"
SRC_URI[aarch64_rust-linktime-proc-macro+default-devel.sha256sum] = "79b210f407b1e5c2b4da351e311e186e405fedf2d2f2aa88227d54a000489448"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro+dtor-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro+dtor-devel;unpack=0"
SRC_URI[aarch64_rust-linktime-proc-macro+dtor-devel.sha256sum] = "9dd1da6e497b3bd7512cab74d53da996707b9f1a6cba5d1c0ebe788b2d452de8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro+link_section-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro+link_section-devel;unpack=0"
SRC_URI[aarch64_rust-linktime-proc-macro+link_section-devel.sha256sum] = "51fc0c9f96d8ea69ba69af25d0764bffe08f405500922a525b25fd6456ec2d0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro+scattered_collect-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro+scattered_collect-devel;unpack=0"
SRC_URI[aarch64_rust-linktime-proc-macro+scattered_collect-devel.sha256sum] = "a6596cd28c904aba161f2f586a528a90b170498de38ac766f9c5fc000a4b0b18"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro-devel;unpack=0"
SRC_URI[aarch64_rust-linktime-proc-macro-devel.sha256sum] = "2a361b3c942d1096a88bcc14c3c046ee20f875fdd1e8d39ee6faed90e70ce6e5"

RDEPENDS:rust-linktime-proc-macro+ctor-devel = " \
 cargo \
 rust-linktime-proc-macro-devel \
 "
RDEPENDS:rust-linktime-proc-macro+default-devel = " \
 cargo \
 rust-linktime-proc-macro-devel \
 "
RDEPENDS:rust-linktime-proc-macro+dtor-devel = " \
 cargo \
 rust-linktime-proc-macro-devel \
 "
RDEPENDS:rust-linktime-proc-macro+link_section-devel = " \
 cargo \
 rust-linktime-proc-macro-devel \
 "
RDEPENDS:rust-linktime-proc-macro+scattered_collect-devel = " \
 cargo \
 rust-linktime-proc-macro-devel \
 "
RDEPENDS:rust-linktime-proc-macro-devel = " \
 cargo \
 "
