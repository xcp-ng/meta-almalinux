# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-wayland"
PV = "1.1.21"
PR = "1.el10_2"
PACKAGES = " \
 egl-wayland \
 egl-wayland-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-wayland-1.1.21-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "964f2131eda15316811aac22b2862e74bd37c8e5ca46ef777f858493aebd0f90"

URI_x86_64_v2_egl-wayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland-1.1.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-wayland}"
SRC_URI[x86_64_v2_egl-wayland.sha256sum] = "fe9ef2ad4a02ccc17763fcb009c66619a38d64ea8647ad5350df301ef5b22e6a"

URI_x86_64_v2_egl-wayland-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland-devel-1.1.21-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-wayland-devel}"
SRC_URI[x86_64_v2_egl-wayland-devel.sha256sum] = "c58fc07f22c0d3c8f7766940b1ca1bd9130a75c3c4142cacb317146a60404e76"

URI_aarch64_egl-wayland = "${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland-1.1.21-1.el10_2.aarch64.rpm;name=aarch64_egl-wayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-wayland}"
SRC_URI[aarch64_egl-wayland.sha256sum] = "d9d9e1a3016caefb3ca7dbd8313c5e0647f892375160131c9b8e621926892cea"

URI_aarch64_egl-wayland-devel = "${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland-devel-1.1.21-1.el10_2.aarch64.rpm;name=aarch64_egl-wayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-wayland-devel}"
SRC_URI[aarch64_egl-wayland-devel.sha256sum] = "d3c364fc2322bcb4715e2c4fcc3a4397d80a477316bd77139a2da042f126d88b"

RDEPENDS:egl-wayland = " \
 glibc \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 libwayland-server \
 "
RDEPENDS:egl-wayland-devel = " \
 egl-wayland \
 eglexternalplatform-devel \
 pkgconf-pkg-config \
 "
