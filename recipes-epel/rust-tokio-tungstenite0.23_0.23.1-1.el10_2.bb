# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-tungstenite0.23"
PV = "0.23.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tokio-tungstenite0.23+__rustls-tls-devel \
 rust-tokio-tungstenite0.23+connect-devel \
 rust-tokio-tungstenite0.23+default-devel \
 rust-tokio-tungstenite0.23+handshake-devel \
 rust-tokio-tungstenite0.23+native-tls-crate-devel \
 rust-tokio-tungstenite0.23+native-tls-devel \
 rust-tokio-tungstenite0.23+rustls-devel \
 rust-tokio-tungstenite0.23+rustls-native-certs-devel \
 rust-tokio-tungstenite0.23+rustls-pki-types-devel \
 rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel \
 rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel \
 rust-tokio-tungstenite0.23+stream-devel \
 rust-tokio-tungstenite0.23+tokio-native-tls-devel \
 rust-tokio-tungstenite0.23+tokio-rustls-devel \
 rust-tokio-tungstenite0.23+url-devel \
 rust-tokio-tungstenite0.23+webpki-roots-devel \
 rust-tokio-tungstenite0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-tungstenite0.23-0.23.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "708d67116e41e8192e96015c0d6f6cfe35702878efb695ef610fda0aba13bf4c"

URI_x86_64_v2_rust-tokio-tungstenite0.23+__rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+__rustls-tls-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+__rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+__rustls-tls-devel.sha256sum] = "f616286b448a81e1a43e6732ff091dcd5dcf30389f2bb1d803b4683071cf5fd2"

URI_x86_64_v2_rust-tokio-tungstenite0.23+connect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+connect-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+connect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+connect-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+connect-devel.sha256sum] = "8e785f0d13ec6725eff1a2b507bac921fbce21f2e351a47830f92696befa7bc5"

URI_x86_64_v2_rust-tokio-tungstenite0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+default-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+default-devel.sha256sum] = "12dffd9d0bf40937eb094893b8ef4f1ed029896deef46bbf4155bb74fc1fe7ad"

URI_x86_64_v2_rust-tokio-tungstenite0.23+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+handshake-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+handshake-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+handshake-devel.sha256sum] = "1aae606093d62b98d0bb8bd3ab0a0a5ce76640dea006961a1208731f70a381f0"

URI_x86_64_v2_rust-tokio-tungstenite0.23+native-tls-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+native-tls-crate-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+native-tls-crate-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+native-tls-crate-devel.sha256sum] = "f5b327354e5852ff6eedc88a76f8856b55a6f193e9f3ea22959cccaf15d35420"

URI_x86_64_v2_rust-tokio-tungstenite0.23+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+native-tls-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+native-tls-devel.sha256sum] = "3db88103d8a9398cf9b58bf1d719d75f069d95c3a1d5e3e2318f4883829466eb"

URI_x86_64_v2_rust-tokio-tungstenite0.23+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+rustls-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+rustls-devel.sha256sum] = "af6cc5c2faa7e731cc658301bef399573035a0f2c2f07ba8466bd15c229f6fdf"

URI_x86_64_v2_rust-tokio-tungstenite0.23+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+rustls-native-certs-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+rustls-native-certs-devel.sha256sum] = "37979f4cbc1626004900828e84a91e9e65ab3ef8f3823693464feef03cf885c8"

URI_x86_64_v2_rust-tokio-tungstenite0.23+rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+rustls-pki-types-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+rustls-pki-types-devel.sha256sum] = "15269e29c8fd6079964d048eee9d5d546a98c208499311450809a937a995335b"

URI_x86_64_v2_rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel.sha256sum] = "05dbad06b3487ef4be4086ab17a07266ea11853bcbcf2b09fd84b08de71fede6"

URI_x86_64_v2_rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel.sha256sum] = "009af5c92712ab28cfad24746fcba349681b04b31a30a812d35a7a7eb4449c8f"

URI_x86_64_v2_rust-tokio-tungstenite0.23+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+stream-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+stream-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+stream-devel.sha256sum] = "4322648e3fd35dc54d05201bbf718f5fe8178989fcadb9894f1851069f1519bc"

URI_x86_64_v2_rust-tokio-tungstenite0.23+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+tokio-native-tls-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+tokio-native-tls-devel.sha256sum] = "1ec4167d35e2fcf6ac5732f91dcf1242e85e7c28c226b697176858ee027f9d1f"

URI_x86_64_v2_rust-tokio-tungstenite0.23+tokio-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+tokio-rustls-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+tokio-rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+tokio-rustls-devel.sha256sum] = "d2f5f3f1075a6458dcc67769333e73fdfcac0e80820a2203828cc2e92832477f"

URI_x86_64_v2_rust-tokio-tungstenite0.23+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+url-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+url-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+url-devel.sha256sum] = "234e3f6245abe8eb6352361ed1295cbaaf6ae5e61138866f44e7170b791d70f6"

URI_x86_64_v2_rust-tokio-tungstenite0.23+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23+webpki-roots-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23+webpki-roots-devel.sha256sum] = "ec85cbae08600eea72df2e60d1165c40de86dccc02a532405da07bfece7374ec"

URI_x86_64_v2_rust-tokio-tungstenite0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite0.23-devel-0.23.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite0.23-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite0.23-devel.sha256sum] = "88bcfeb25898eaa2d2fbd9bc36803f4e29d344aace677bfd44cdf36ac4dd0fa0"

URI_aarch64_rust-tokio-tungstenite0.23+__rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+__rustls-tls-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+__rustls-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+__rustls-tls-devel.sha256sum] = "087db5f7d413f2567db6760e1bbbcef9049c68b63b8e988f10d3665d72a5d589"

URI_aarch64_rust-tokio-tungstenite0.23+connect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+connect-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+connect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+connect-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+connect-devel.sha256sum] = "36270fff38f1e354dfdda6db95deb4d74001dce961d91040aa1bb8bc9fe59536"

URI_aarch64_rust-tokio-tungstenite0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+default-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+default-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+default-devel.sha256sum] = "08bf8be2e2ea4449f9a485598de721599aecbd832f2baf95e9cf7750eb9ca3a8"

URI_aarch64_rust-tokio-tungstenite0.23+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+handshake-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+handshake-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+handshake-devel.sha256sum] = "62858c835c282cdec15008de9daf3adf6afd358b052b877b3329cdd99ebe84aa"

URI_aarch64_rust-tokio-tungstenite0.23+native-tls-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+native-tls-crate-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+native-tls-crate-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+native-tls-crate-devel.sha256sum] = "13bcd3f1b6602950308f9f1923183b3f41437ea773cc07066b523defd290285c"

URI_aarch64_rust-tokio-tungstenite0.23+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+native-tls-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+native-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+native-tls-devel.sha256sum] = "04c9c6bd09a35a93dcd5eb299727f40d636f370c44e7e9dd5706e135d2b2886c"

URI_aarch64_rust-tokio-tungstenite0.23+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+rustls-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+rustls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+rustls-devel.sha256sum] = "af697cdd10a78eb5f66b929ee6d221d96117e0d3e6e4c3b946910e031e33994b"

URI_aarch64_rust-tokio-tungstenite0.23+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+rustls-native-certs-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+rustls-native-certs-devel.sha256sum] = "960867a89aac155f242afe7bdde025cfe6ca7f4b9f8216bced2e1d01ddd5e839"

URI_aarch64_rust-tokio-tungstenite0.23+rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+rustls-pki-types-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+rustls-pki-types-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+rustls-pki-types-devel.sha256sum] = "734e516400c06829110ae0458aeaf596c2f7bc16bd6cbb45858c021b836e809b"

URI_aarch64_rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel.sha256sum] = "86cf6aa70a47ce413b441340cc8e55d67f4296f47f278bb740405757b60e4b0e"

URI_aarch64_rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel.sha256sum] = "5595688b356d2e3eb398e660225ab647801536979c2568668e2ca1dcd5cb7dd3"

URI_aarch64_rust-tokio-tungstenite0.23+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+stream-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+stream-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+stream-devel.sha256sum] = "b327d1f20bd08fb95fad598aecdb7208d0e555550b6c4f8f115a60549921ffaa"

URI_aarch64_rust-tokio-tungstenite0.23+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+tokio-native-tls-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+tokio-native-tls-devel.sha256sum] = "45f4edc48f070e475eb4e8bc34e56601b1768541649c958ceec9e1a8626a7e9c"

URI_aarch64_rust-tokio-tungstenite0.23+tokio-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+tokio-rustls-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+tokio-rustls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+tokio-rustls-devel.sha256sum] = "8bb32b5e1154eeded7f379b3d2132ca5e2e3de4fe2d5d4b6b54bc1ce725265fa"

URI_aarch64_rust-tokio-tungstenite0.23+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+url-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+url-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+url-devel.sha256sum] = "2eee1f4e45620ab32a6abeb4ac2704bb166e3d470b81b74874da1a6a0e94df4f"

URI_aarch64_rust-tokio-tungstenite0.23+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23+webpki-roots-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23+webpki-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23+webpki-roots-devel.sha256sum] = "c2b97f8841c047eef626652c8681ba742372f8f714d1305aef30a01c4ae2f676"

URI_aarch64_rust-tokio-tungstenite0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite0.23-devel-0.23.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-tungstenite0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite0.23-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite0.23-devel.sha256sum] = "9bcc799cddfb9f8e76cfdb16c1fd7c5e2681d05b0bc52979759ac2f0f9a6215c"

RDEPENDS:rust-tokio-tungstenite0.23+__rustls-tls-devel = " \
 cargo \
 rust-tokio-tungstenite0.23+handshake-devel \
 rust-tokio-tungstenite0.23+rustls-devel \
 rust-tokio-tungstenite0.23+rustls-pki-types-devel \
 rust-tokio-tungstenite0.23+stream-devel \
 rust-tokio-tungstenite0.23+tokio-rustls-devel \
 rust-tokio-tungstenite0.23-devel \
 rust-tungstenite0.23+__rustls-tls-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+connect-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-tungstenite0.23+handshake-devel \
 rust-tokio-tungstenite0.23+stream-devel \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+default-devel = " \
 cargo \
 rust-tokio-tungstenite0.23+connect-devel \
 rust-tokio-tungstenite0.23+handshake-devel \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+handshake-devel = " \
 cargo \
 rust-tokio-tungstenite0.23-devel \
 rust-tungstenite0.23+handshake-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+native-tls-crate-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+native-tls-devel = " \
 cargo \
 rust-tokio-tungstenite0.23+handshake-devel \
 rust-tokio-tungstenite0.23+native-tls-crate-devel \
 rust-tokio-tungstenite0.23+stream-devel \
 rust-tokio-tungstenite0.23+tokio-native-tls-devel \
 rust-tokio-tungstenite0.23-devel \
 rust-tungstenite0.23+native-tls-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+rustls-devel = " \
 cargo \
 rust-rustls-devel \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs0.7+default-devel \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+rustls-pki-types-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+rustls-tls-native-roots-devel = " \
 cargo \
 rust-tokio-tungstenite0.23+__rustls-tls-devel \
 rust-tokio-tungstenite0.23+rustls-native-certs-devel \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-tokio-tungstenite0.23+__rustls-tls-devel \
 rust-tokio-tungstenite0.23+webpki-roots-devel \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+stream-devel = " \
 cargo \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+tokio-native-tls-devel = " \
 cargo \
 rust-tokio-native-tls+default-devel \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+tokio-rustls-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 rust-tokio-tungstenite0.23-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+url-devel = " \
 cargo \
 rust-tokio-tungstenite0.23-devel \
 rust-tungstenite0.23+url-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23+webpki-roots-devel = " \
 cargo \
 rust-tokio-tungstenite0.23-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-tokio-tungstenite0.23-devel = " \
 cargo \
 rust \
 rust-futures-util+sink-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-log+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 rust-tungstenite0.23-devel \
 "
