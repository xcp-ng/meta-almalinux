# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5ct"
PV = "1.1"
PR = "31.el10_1"
PACKAGES = " \
 qt5ct \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5ct-1.1-31.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32b4e837bbde30f48188a4180976cf75a3fdaa05d226188631a847bc4abf597b"

URI_x86_64_v2_qt5ct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5ct-1.1-31.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5ct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5ct}"
SRC_URI[x86_64_v2_qt5ct.sha256sum] = "10ec86cc6f988e81d284f8f85ce420657d71f580676494c88be0695889503547"

URI_aarch64_qt5ct = "${EPEL_MIRROR}/aarch64/Packages/q/qt5ct-1.1-31.el10_1.aarch64.rpm;name=aarch64_qt5ct;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5ct}"
SRC_URI[aarch64_qt5ct.sha256sum] = "7a16c2a0b189eb9ada77e75b326b8c02692e4a3537ca65d07cdab51ad51d48d9"

RDEPENDS:qt5ct = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
