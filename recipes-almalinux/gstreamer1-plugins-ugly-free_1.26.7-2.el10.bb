# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-ugly-free"
PV = "1.26.7"
PR = "2.el10"
PACKAGES = " \
 gstreamer1-plugins-ugly-free \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-ugly-free-1.26.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a71ee6c660752c8d1497b3f29600448e612fbab20e0494e7f53a20f3b2e484b"

URI_x86_64_v2_gstreamer1-plugins-ugly-free = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-ugly-free-1.26.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-ugly-free}"
SRC_URI[x86_64_v2_gstreamer1-plugins-ugly-free.sha256sum] = "3368bef3726881cf53bf18b2be11545c9624499277d98f2f2583c4eecc8ed451"

URI_aarch64_gstreamer1-plugins-ugly-free = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-ugly-free-1.26.7-2.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-ugly-free}"
SRC_URI[aarch64_gstreamer1-plugins-ugly-free.sha256sum] = "1ff4e9ce16aaae01bdae4cda81e8ff4b360bdd884b4a268281ddf4b783bc89e0"

RDEPENDS:gstreamer1-plugins-ugly-free = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 liba52 \
 libcdio \
 libdvdread \
 libmpeg2 \
 orc \
 "
