# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-lru-2"
PV = "2.0.7"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-hashicorp-lru-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-lru-2-2.0.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dccbbd2c19b176791548cf9ad4dbe18147413422205a1e1dcc9230cfe96af31"

URI_x86_64_v2_golang-github-hashicorp-lru-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-lru-2-devel-2.0.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-lru-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-lru-2-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-lru-2-devel.sha256sum] = "63d131344cfdf939461dae2c7bcfc893c57a73d46bf73bbbc23e2659aba0d758"

URI_aarch64_golang-github-hashicorp-lru-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-lru-2-devel-2.0.7-4.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-lru-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-lru-2-devel}"
SRC_URI[aarch64_golang-github-hashicorp-lru-2-devel.sha256sum] = "edb70ea001d50b771954178084cfbe80dc897b8dad0b9bcd12e0f0b5377d5abd"

RDEPENDS:golang-github-hashicorp-lru-2-devel = " \
 go-filesystem \
 "
