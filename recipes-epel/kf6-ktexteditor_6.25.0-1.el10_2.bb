# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktexteditor"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-ktexteditor \
 kf6-ktexteditor-devel \
 kf6-ktexteditor-doc \
 kf6-ktexteditor-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ktexteditor-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cf94e5a41b220cd75252b8509fb69419503e87758932c31f9c0ca2d44cb0d91"

URI_x86_64_v2_kf6-ktexteditor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexteditor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor}"
SRC_URI[x86_64_v2_kf6-ktexteditor.sha256sum] = "1eb6824ee6f58e589406dfd49b508778914f7c31d9c23bdbeb5cd2a97ab7f1f2"

URI_x86_64_v2_kf6-ktexteditor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexteditor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor-devel}"
SRC_URI[x86_64_v2_kf6-ktexteditor-devel.sha256sum] = "5015b8720d3e793e565b3deddb6b1e0431a003b039a424ee14b6da94dc3b1562"

URI_x86_64_v2_kf6-ktexteditor-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexteditor-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor-doc}"
SRC_URI[x86_64_v2_kf6-ktexteditor-doc.sha256sum] = "0f83df36be78f451463ffabcea5af0769596c054ebc86bd6e530d1a0fd7cdc13"

URI_x86_64_v2_kf6-ktexteditor-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexteditor-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor-html}"
SRC_URI[x86_64_v2_kf6-ktexteditor-html.sha256sum] = "1be84fa3cd017854499f93baf2dfcd89fbfb7667548d33ede0c962fd237d7eed"

URI_aarch64_kf6-ktexteditor = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-ktexteditor;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor}"
SRC_URI[aarch64_kf6-ktexteditor.sha256sum] = "8e0fcd7a85c7a32fbcc54aba0603f74fb358786c15399bdf4c5699b17c35f601"

URI_aarch64_kf6-ktexteditor-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-ktexteditor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor-devel}"
SRC_URI[aarch64_kf6-ktexteditor-devel.sha256sum] = "4ca151739e4fb07fc26969c584567f3d9792a2720d22244eadf80f5a0a90795e"

URI_aarch64_kf6-ktexteditor-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-ktexteditor-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor-doc}"
SRC_URI[aarch64_kf6-ktexteditor-doc.sha256sum] = "0d1ccfc71339a0745a44b7ad38287e16703fe8e33cad32a34d889d439ccbf565"

URI_aarch64_kf6-ktexteditor-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-ktexteditor-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor-html}"
SRC_URI[aarch64_kf6-ktexteditor-html.sha256sum] = "5402a97a98c45c93220987090ef7893ec419a8519fa66d2f76bd15a3ec487097"

RDEPENDS:kf6-ktexteditor = " \
 editorconfig-libs \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kauth \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
RDEPENDS:kf6-ktexteditor-devel = " \
 cmake-filesystem \
 kf6-kparts-devel \
 kf6-ktexteditor \
 kf6-syntax-highlighting-devel \
 "
RDEPENDS:kf6-ktexteditor-doc = " \
 "
RDEPENDS:kf6-ktexteditor-html = " \
 "
