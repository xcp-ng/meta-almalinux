# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-MethodMaker"
PV = "2.24"
PR = "27.el10_0"
PACKAGES = " \
 perl-Class-MethodMaker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-MethodMaker-2.24-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b93733169c11f37b9faa5ef15b42ecc6e5bae97aa15693868faecc18992897f6"

URI_x86_64_v2_perl-Class-MethodMaker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-MethodMaker-2.24-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Class-MethodMaker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-MethodMaker}"
SRC_URI[x86_64_v2_perl-Class-MethodMaker.sha256sum] = "83a4fe63f7e8b2ba7e028a3c12aee1f8ef084db076c207cb482f9c08ac75cd62"

URI_aarch64_perl-Class-MethodMaker = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-MethodMaker-2.24-27.el10_0.aarch64.rpm;name=aarch64_perl-Class-MethodMaker;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-MethodMaker}"
SRC_URI[aarch64_perl-Class-MethodMaker.sha256sum] = "86f782a23161fdeebcfa100330078fd4632d6bd634850ff3aba42e078d395da0"

RDEPENDS:perl-Class-MethodMaker = " \
 glibc \
 perl-AutoLoader \
 perl-B \
 perl-Carp \
 perl-Class-MethodMaker \
 perl-Data-Dumper \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-libs \
 "
