# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-op-logging"
PV = "2.0.0"
PR = "17.20190623git970db52.el10_0"
PACKAGES = " \
 golang-github-op-logging-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-op-logging-2.0.0-17.20190623git970db52.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4f63780545127c8411ba59217942d50b1e4f1ce9dad291ae7345545e1818599"

URI_aarch64_golang-github-op-logging-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-op-logging-devel-2.0.0-17.20190623git970db52.el10_0.noarch.rpm;name=aarch64_golang-github-op-logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-op-logging-devel}"
SRC_URI[aarch64_golang-github-op-logging-devel.sha256sum] = "94f1ee264435a654d8a732cf6eeafbaabe5de4af3ef0e328829f4685c405ad13"

RDEPENDS:golang-github-op-logging-devel = " \
 go-filesystem \
 "
