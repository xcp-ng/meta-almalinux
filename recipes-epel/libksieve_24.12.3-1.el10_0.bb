# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksieve"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libksieve \
 libksieve-devel \
 libksieve-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksieve-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d0faf12359461b336d27a7d7182a4c5da651adcc6aba6a8d2e3aba41548bc90"

URI_x86_64_v2_libksieve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksieve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksieve}"
SRC_URI[x86_64_v2_libksieve.sha256sum] = "045281c592d4fe20201174191b939fa46e03d5fd366314942ae416d7ea163fd0"

URI_x86_64_v2_libksieve-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksieve-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksieve-devel}"
SRC_URI[x86_64_v2_libksieve-devel.sha256sum] = "e982e0771e705131cfaaff10346f69e7675243dd1a72f819f15b052c3f053080"

URI_x86_64_v2_libksieve-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libksieve-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksieve-doc}"
SRC_URI[x86_64_v2_libksieve-doc.sha256sum] = "72f3f5dcc9963cec13aee41e9c2685aa68dab8b0fa9fad09260a40a4cbd0b701"

URI_aarch64_libksieve = "${EPEL_MIRROR}/aarch64/Packages/l/libksieve-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libksieve;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksieve}"
SRC_URI[aarch64_libksieve.sha256sum] = "d71f62850064e7b77d0ed5b13a97234f593c019990f127bd01a37f10a2529b20"

URI_aarch64_libksieve-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksieve-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libksieve-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksieve-devel}"
SRC_URI[aarch64_libksieve-devel.sha256sum] = "a76f6b64f29d5672fb5810ff3cbc0fc0222324fea9f3d949c489ac6ec8f58724"

URI_aarch64_libksieve-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libksieve-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_libksieve-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksieve-doc}"
SRC_URI[aarch64_libksieve-doc.sha256sum] = "dcfa2036f7d72a7308813bc0e778288339a2261269110b326c266e8fdf3db0b9"

RDEPENDS:libksieve = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmime \
 ktextaddons-qt6 \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:libksieve-devel = " \
 cmake-filesystem \
 kf6-syntax-highlighting-devel \
 libksieve \
 "
RDEPENDS:libksieve-doc = " \
 "
