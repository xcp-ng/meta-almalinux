# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libwebsockets"
PV = "4.3.10"
PR = "1.el10_1"
PACKAGES = " \
 libwebsockets \
 libwebsockets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libwebsockets-4.3.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c21312671df82bdbf242928bd5f3ccc75b5167cbe1f9134b45e373a98302739"

URI_x86_64_v2_libwebsockets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwebsockets-4.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwebsockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebsockets}"
SRC_URI[x86_64_v2_libwebsockets.sha256sum] = "97d998e9730d902edf6583a34487ed1c55621f9ff0e0132d41a664c31af73a90"

URI_x86_64_v2_libwebsockets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwebsockets-devel-4.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwebsockets-devel}"
SRC_URI[x86_64_v2_libwebsockets-devel.sha256sum] = "3b3ef3cf95d48bb45f657513161c3506954307ea1b9aa6aa036079ad978be99f"

URI_aarch64_libwebsockets = "${EPEL_MIRROR}/aarch64/Packages/l/libwebsockets-4.3.10-1.el10_1.aarch64.rpm;name=aarch64_libwebsockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebsockets}"
SRC_URI[aarch64_libwebsockets.sha256sum] = "91e6d1e4e486719e14bdf33bc251c8b5a187746330261feb15fae7ae1823a2b6"

URI_aarch64_libwebsockets-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libwebsockets-devel-4.3.10-1.el10_1.aarch64.rpm;name=aarch64_libwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwebsockets-devel}"
SRC_URI[aarch64_libwebsockets-devel.sha256sum] = "4177161363a090782ea90a3df22da36029e242d1b7c4d0577a98eb4b5eddea39"

RDEPENDS:libwebsockets = " \
 glib2 \
 glibc \
 libev \
 libuv \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libwebsockets-devel = " \
 cmake-filesystem \
 libev-devel \
 libuv-devel \
 libwebsockets \
 openssl-devel \
 pkgconf-pkg-config \
 "
