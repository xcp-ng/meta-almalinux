# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-B-Keywords"
PV = "1.27"
PR = "1.el10_0"
PACKAGES = " \
 perl-B-Keywords \
 perl-B-Keywords-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-B-Keywords-1.27-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a84594b8daac56d3b3c299751d04390a7255cdec553ea418b2605e9fa170b53"

URI_x86_64_v2_perl-B-Keywords = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-B-Keywords-1.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-B-Keywords;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-B-Keywords}"
SRC_URI[x86_64_v2_perl-B-Keywords.sha256sum] = "917f937012503e93d4d6431d525ef5391d63c153ae0622c8b314bb4c944586bd"

URI_x86_64_v2_perl-B-Keywords-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-B-Keywords-tests-1.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-B-Keywords-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-B-Keywords-tests}"
SRC_URI[x86_64_v2_perl-B-Keywords-tests.sha256sum] = "a6bd6266c0eeefda51cd520e8d55ff739cf8cba08c67e765e79f2dfb768ab4cc"

URI_aarch64_perl-B-Keywords = "${EPEL_MIRROR}/aarch64/Packages/p/perl-B-Keywords-1.27-1.el10_0.noarch.rpm;name=aarch64_perl-B-Keywords;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-B-Keywords}"
SRC_URI[aarch64_perl-B-Keywords.sha256sum] = "e4c24b757e7c41642e6624e86d8aab09a518adf971590769bc18fe4fff96e01d"

URI_aarch64_perl-B-Keywords-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-B-Keywords-tests-1.27-1.el10_0.noarch.rpm;name=aarch64_perl-B-Keywords-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-B-Keywords-tests}"
SRC_URI[aarch64_perl-B-Keywords-tests.sha256sum] = "d686758da5ba0cdbe32567f92f629c454c4a7b9e9f5563b4deb2d3ce3f4b20a7"

RDEPENDS:perl-B-Keywords = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-B-Keywords-tests = " \
 bash \
 perl-B-Keywords \
 perl-PathTools \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-devel \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
