# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtserialbus"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtserialbus \
 qt6-qtserialbus-devel \
 qt6-qtserialbus-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtserialbus-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3262bc07b025432d55f9f5ef1f4d8f4d497332016e603bb6817a70bb83d13076"

URI_x86_64_v2_qt6-qtserialbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialbus-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialbus}"
SRC_URI[x86_64_v2_qt6-qtserialbus.sha256sum] = "3cedbc69aab7b5e7c2d154d56b415d41ce7d6eb313e918fbe6cd20e224b54a4b"

URI_x86_64_v2_qt6-qtserialbus-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtserialbus-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialbus-devel}"
SRC_URI[x86_64_v2_qt6-qtserialbus-devel.sha256sum] = "f5d9dde974085747af0a42e2a079f4f94c7e4ad48b42fb59721074c6fd94465f"

URI_x86_64_v2_qt6-qtserialbus-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtserialbus-examples-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtserialbus-examples}"
SRC_URI[x86_64_v2_qt6-qtserialbus-examples.sha256sum] = "e3a45435108e827e7a45df1392349b003d77e332686ad2ca17f1d175f9e3e699"

URI_aarch64_qt6-qtserialbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialbus-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialbus}"
SRC_URI[aarch64_qt6-qtserialbus.sha256sum] = "5b1271a2e9afa4b5ff37da123d26fe00d743e862200c76adef7604242b52d0b9"

URI_aarch64_qt6-qtserialbus-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtserialbus-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialbus-devel}"
SRC_URI[aarch64_qt6-qtserialbus-devel.sha256sum] = "3f8726f967cd4c5b5012db7476656e775f108d2fc58df2d4fe297d882b359ce5"

URI_aarch64_qt6-qtserialbus-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtserialbus-examples-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtserialbus-examples}"
SRC_URI[aarch64_qt6-qtserialbus-examples.sha256sum] = "13da1936a80b297e7820b50d2ee83771e67b15537e4d5509634827f19d2a9829"

RDEPENDS:qt6-qtserialbus = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtserialport \
 "
RDEPENDS:qt6-qtserialbus-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtserialbus \
 qt6-qtserialport-devel \
 "
RDEPENDS:qt6-qtserialbus-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtserialbus \
 qt6-qtserialport \
 "
