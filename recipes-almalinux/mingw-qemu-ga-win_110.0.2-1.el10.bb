# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-qemu-ga-win"
PV = "110.0.2"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 mingw-qemu-ga-win \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mingw-qemu-ga-win-110.0.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a38d46453a7d5a7ad887de98ef7a3feda166d3cd019027cc63f341b414027c2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mingw-qemu-ga-win-110.0.2-1.el10.noarch.rpm;name=x86_64_v2_mingw-qemu-ga-win;unpack=0"
SRC_URI[x86_64_v2_mingw-qemu-ga-win.sha256sum] = "aa053a038375f9af5bdd25cf1baf75fa685fb28f1946632b91c0cd9dced52029"

RDEPENDS:mingw-qemu-ga-win = " \
 systemd \
 "
