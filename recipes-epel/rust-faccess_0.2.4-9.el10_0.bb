# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-faccess"
PV = "0.2.4"
PR = "9.el10_0"
PACKAGES = " \
 rust-faccess+default-devel \
 rust-faccess-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-faccess-0.2.4-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db6f68f42f677c92b34fad8a6107fb478356aadc8125105a8b3b252aa2f2398e"

URI_x86_64_v2_rust-faccess+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faccess+default-devel-0.2.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faccess+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faccess+default-devel}"
SRC_URI[x86_64_v2_rust-faccess+default-devel.sha256sum] = "857a07adfa57994423fc8855b4bf90146d103feba99c0cd5ecc9171b093a3590"

URI_x86_64_v2_rust-faccess-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faccess-devel-0.2.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faccess-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faccess-devel}"
SRC_URI[x86_64_v2_rust-faccess-devel.sha256sum] = "0e73cd0a9136e5a0a79d08f0a98563113c894269c43e9ba800c1d6628588b2a9"

URI_aarch64_rust-faccess+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faccess+default-devel-0.2.4-9.el10_0.noarch.rpm;name=aarch64_rust-faccess+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faccess+default-devel}"
SRC_URI[aarch64_rust-faccess+default-devel.sha256sum] = "27b6df49e3da6157f1deecdf8b6eb287bca50637637383e5ede9991f3f44aab7"

URI_aarch64_rust-faccess-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faccess-devel-0.2.4-9.el10_0.noarch.rpm;name=aarch64_rust-faccess-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faccess-devel}"
SRC_URI[aarch64_rust-faccess-devel.sha256sum] = "f1e1d6733f6abef333057795e5537e2d1f5635d5de2789d345c2848be25a894b"

RDEPENDS:rust-faccess+default-devel = " \
 cargo \
 rust-faccess-devel \
 "
RDEPENDS:rust-faccess-devel = " \
 cargo \
 rust-bitflags1+default-devel \
 rust-libc+default-devel \
 "
