# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Proc-Daemon"
PV = "0.23"
PR = "29.el10_1"
PACKAGES = " \
 perl-Proc-Daemon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Proc-Daemon-0.23-29.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85e4a4c76378759e05a4dedd19899e63274aa38c188204171c23298adb11ec04"

URI_x86_64_v2_perl-Proc-Daemon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Proc-Daemon-0.23-29.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Proc-Daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Proc-Daemon}"
SRC_URI[x86_64_v2_perl-Proc-Daemon.sha256sum] = "300d8e93919f6ba6cca0b2e8c3196ecc008bba16f672cfa03c1bcb91cc16c3ba"

URI_aarch64_perl-Proc-Daemon = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Proc-Daemon-0.23-29.el10_1.noarch.rpm;name=aarch64_perl-Proc-Daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Proc-Daemon}"
SRC_URI[aarch64_perl-Proc-Daemon.sha256sum] = "28a247e748251454156e4e8fe75d088d0792008134bbcd8c766d319875f58d65"

RDEPENDS:perl-Proc-Daemon = " \
 perl-POSIX \
 perl-Proc-ProcessTable \
 perl-libs \
 "
