# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Locale-Maketext"
PV = "1.33"
PR = "512.el10"
PACKAGES = " \
 perl-Locale-Maketext \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Locale-Maketext-1.33-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a989af56d1ad92f9f248c117450811e6a7bc3369111ed40f634eb20853771e0e"

URI_x86_64_v2_perl-Locale-Maketext = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Locale-Maketext-1.33-512.el10.noarch.rpm;name=x86_64_v2_perl-Locale-Maketext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Locale-Maketext}"
SRC_URI[x86_64_v2_perl-Locale-Maketext.sha256sum] = "29ae938b0e5100d904d8762ef4fa21f3d6e1ee9c8afec19e01f9698fed8c9157"

URI_aarch64_perl-Locale-Maketext = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Locale-Maketext-1.33-512.el10.noarch.rpm;name=aarch64_perl-Locale-Maketext;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Locale-Maketext}"
SRC_URI[aarch64_perl-Locale-Maketext.sha256sum] = "29ae938b0e5100d904d8762ef4fa21f3d6e1ee9c8afec19e01f9698fed8c9157"

RDEPENDS:perl-Locale-Maketext = " \
 perl-Carp \
 perl-I18N-LangTags \
 perl-Locale-Maketext \
 perl-libs \
 "
