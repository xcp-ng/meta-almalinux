# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-version-compare"
PV = "0.2.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-version-compare+default-devel \
 rust-version-compare-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-version-compare-0.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1a920317b75b30ecd537918dc8c9c417fd850563abec195211962be8a1434f4"

URI_x86_64_v2_rust-version-compare+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-compare+default-devel-0.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-compare+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-compare+default-devel}"
SRC_URI[x86_64_v2_rust-version-compare+default-devel.sha256sum] = "9cf72baaa7520ad92984e5df5641b37d69cd865a837e8de75f180651fa47d11f"

URI_x86_64_v2_rust-version-compare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-compare-devel-0.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-compare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-compare-devel}"
SRC_URI[x86_64_v2_rust-version-compare-devel.sha256sum] = "714310216cbd75a5639782350782419bcf37272c4548474275a132726ba9c39b"

URI_aarch64_rust-version-compare+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-compare+default-devel-0.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-version-compare+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-compare+default-devel}"
SRC_URI[aarch64_rust-version-compare+default-devel.sha256sum] = "ff212b5c95e3484aee3df43ec126de4c80e93c2988d60376e0215dcd4e890f9e"

URI_aarch64_rust-version-compare-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-compare-devel-0.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-version-compare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-compare-devel}"
SRC_URI[aarch64_rust-version-compare-devel.sha256sum] = "6d54264c077ed57602e8a5e9cd3184a722ff4a47554e1ccf3dae7a40d0549e1b"

RDEPENDS:rust-version-compare+default-devel = " \
 cargo \
 rust-version-compare-devel \
 "
RDEPENDS:rust-version-compare-devel = " \
 cargo \
 rust \
 "
