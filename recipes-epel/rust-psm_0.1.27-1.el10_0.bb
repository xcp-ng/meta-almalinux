# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psm"
PV = "0.1.27"
PR = "1.el10_0"
PACKAGES = " \
 rust-psm+default-devel \
 rust-psm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-psm-0.1.27-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27e0147eb352cd73251f2d6816b03e824ea62342188455bf7b6e99f52c0acd02"

URI_x86_64_v2_rust-psm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psm+default-devel-0.1.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psm+default-devel}"
SRC_URI[x86_64_v2_rust-psm+default-devel.sha256sum] = "bc5f6c121d794af22fba029cc5aa9b09f618a83ed831ab06e89fd692f3453246"

URI_x86_64_v2_rust-psm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psm-devel-0.1.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psm-devel}"
SRC_URI[x86_64_v2_rust-psm-devel.sha256sum] = "d82b8ea29f700985a48f2fa5a91f85c5a1e6f570b89ee528184bec73f59d18a0"

URI_aarch64_rust-psm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psm+default-devel-0.1.27-1.el10_0.noarch.rpm;name=aarch64_rust-psm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psm+default-devel}"
SRC_URI[aarch64_rust-psm+default-devel.sha256sum] = "2f949bd94883508adce3638813bdebae0854591e68f6b8ae3f2f8d7574f8a1ea"

URI_aarch64_rust-psm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psm-devel-0.1.27-1.el10_0.noarch.rpm;name=aarch64_rust-psm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psm-devel}"
SRC_URI[aarch64_rust-psm-devel.sha256sum] = "e63b4180a6533d44e53cb4fcc8d204571595f478fae78981cfb88e97a2fc541e"

RDEPENDS:rust-psm+default-devel = " \
 cargo \
 rust-psm-devel \
 "
RDEPENDS:rust-psm-devel = " \
 cargo \
 rust-cc+default-devel \
 "
