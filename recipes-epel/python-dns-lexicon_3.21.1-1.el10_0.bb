# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dns-lexicon"
PV = "3.21.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-dns-lexicon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dns-lexicon-3.21.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77f489d037ca60f20fab8ff4ce6ec4f0648e1016f6b64a669e8e0f968654f3f5"

URI_x86_64_v2_python3-dns-lexicon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dns-lexicon-3.21.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dns-lexicon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dns-lexicon}"
SRC_URI[x86_64_v2_python3-dns-lexicon.sha256sum] = "905b7a3482d7b804559e041a8fb848f688e7a74507d79121db571334fda85fcf"

URI_aarch64_python3-dns-lexicon = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dns-lexicon-3.21.1-1.el10_0.noarch.rpm;name=aarch64_python3-dns-lexicon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dns-lexicon}"
SRC_URI[aarch64_python3-dns-lexicon.sha256sum] = "ef6fbba75a73e1a58c5564b9e60850ddfa0ad942e470b10ed1aba0ece4b54e6f"

RDEPENDS:python3-dns-lexicon = " \
 python3 \
 python3-beautifulsoup4 \
 python3-cryptography \
 python3-dns \
 python3-pyotp \
 python3-pyyaml \
 python3-requests \
 python3-tldextract \
 "
