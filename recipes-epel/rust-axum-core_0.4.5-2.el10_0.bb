# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum-core"
PV = "0.4.5"
PR = "2.el10_0"
PACKAGES = " \
 rust-axum-core+default-devel \
 rust-axum-core+tracing-devel \
 rust-axum-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-core-0.4.5-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21da599c0ef3da6ded3a8e790dbbcfc510b0afd5b63f67e42d986c90af801a73"

URI_x86_64_v2_rust-axum-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-core+default-devel-0.4.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-core+default-devel}"
SRC_URI[x86_64_v2_rust-axum-core+default-devel.sha256sum] = "154a8281f3ef2522fc23e5ba525c41a6299a3158564a675a5e0411c6bc73f7d2"

URI_x86_64_v2_rust-axum-core+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-core+tracing-devel-0.4.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-core+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-core+tracing-devel}"
SRC_URI[x86_64_v2_rust-axum-core+tracing-devel.sha256sum] = "d147ee8dbf127f25fb1f3f540feb19ae7fb385be577fe173f5f0214f3a650101"

URI_x86_64_v2_rust-axum-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-core-devel-0.4.5-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-core-devel}"
SRC_URI[x86_64_v2_rust-axum-core-devel.sha256sum] = "9bc682ef93597b8f4fc9bc73e0cd4728aaa6ee243b895f773a726f7e9ecc8cb6"

URI_aarch64_rust-axum-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-core+default-devel-0.4.5-2.el10_0.noarch.rpm;name=aarch64_rust-axum-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-core+default-devel}"
SRC_URI[aarch64_rust-axum-core+default-devel.sha256sum] = "4e9a975273a751b3f73e49939f632b067a4b608553a461fb546cf79de9704752"

URI_aarch64_rust-axum-core+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-core+tracing-devel-0.4.5-2.el10_0.noarch.rpm;name=aarch64_rust-axum-core+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-core+tracing-devel}"
SRC_URI[aarch64_rust-axum-core+tracing-devel.sha256sum] = "721e0fd8925cf465d547f0e854cf333703221a2afbfe3bdffad6fe5ff5cf407a"

URI_aarch64_rust-axum-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-core-devel-0.4.5-2.el10_0.noarch.rpm;name=aarch64_rust-axum-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-core-devel}"
SRC_URI[aarch64_rust-axum-core-devel.sha256sum] = "5dffc96b10041705ec00f071ee04a580732ffc99a26c42239b5268d2db06bfbb"

RDEPENDS:rust-axum-core+default-devel = " \
 cargo \
 rust-axum-core-devel \
 "
RDEPENDS:rust-axum-core+tracing-devel = " \
 cargo \
 rust-axum-core-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-axum-core-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-bytes+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-mime+default-devel \
 rust-pin-project-lite+default-devel \
 rust-rustversion+default-devel \
 rust-sync_wrapper+default-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
