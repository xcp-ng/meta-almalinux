# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-deprecated"
PV = "1.3.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-deprecated \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-deprecated-1.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6baf676eeba5ce01751ebad347c0472bf025c21dd5e43544d1559737fd89ee68"

URI_x86_64_v2_python3-deprecated = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-deprecated-1.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-deprecated;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-deprecated}"
SRC_URI[x86_64_v2_python3-deprecated.sha256sum] = "ecd3372db7ff89b32540c0347dfe128dfcdb52e045dbe0239c8b8fd03164717d"

URI_aarch64_python3-deprecated = "${EPEL_MIRROR}/aarch64/Packages/p/python3-deprecated-1.3.1-1.el10_1.noarch.rpm;name=aarch64_python3-deprecated;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-deprecated}"
SRC_URI[aarch64_python3-deprecated.sha256sum] = "8fb3578fe5775346d73c30015c875b1df31673a72a3de12207b88ecdea9f2fd3"

RDEPENDS:python3-deprecated = " \
 python3 \
 python3-wrapt \
 "
