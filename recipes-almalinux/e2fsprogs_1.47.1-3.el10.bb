# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "e2fsprogs"
PV = "1.47.1"
PR = "3.el10"
PACKAGES = " \
 e2fsprogs \
 e2fsprogs-devel \
 e2fsprogs-libs \
 libcom_err \
 libcom_err-devel \
 libss \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/e2fsprogs-1.47.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2679d07112522d4f444eb327393876eb968c997eac409398695bf40fcb37640a"

URI_x86_64_v2_e2fsprogs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/e2fsprogs-1.47.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_e2fsprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e2fsprogs}"
SRC_URI[x86_64_v2_e2fsprogs.sha256sum] = "c2b54eb8ca2686ff118b03eda3e0dfc2b86bf9792c42a6efa5c88744a88783dc"

URI_x86_64_v2_e2fsprogs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/e2fsprogs-devel-1.47.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_e2fsprogs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e2fsprogs-devel}"
SRC_URI[x86_64_v2_e2fsprogs-devel.sha256sum] = "cc4a4b86f5c4ef60f6f7f9c20f1aab51606cb969daf311ae82d386eaf2ec5cfc"

URI_x86_64_v2_e2fsprogs-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/e2fsprogs-libs-1.47.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_e2fsprogs-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e2fsprogs-libs}"
SRC_URI[x86_64_v2_e2fsprogs-libs.sha256sum] = "b61dd0426509b7591b6a4ab88754a29112d0178bc1fb12a1efc311308decbcea"

URI_x86_64_v2_libcom_err = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcom_err-1.47.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_libcom_err;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcom_err}"
SRC_URI[x86_64_v2_libcom_err.sha256sum] = "4989a4c3e49ede1a3618394c1d2757be545e1d81ffaac16bd58ab521dd554e27"

URI_x86_64_v2_libcom_err-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcom_err-devel-1.47.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_libcom_err-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcom_err-devel}"
SRC_URI[x86_64_v2_libcom_err-devel.sha256sum] = "15b104356e613df4a33363f2b6d32105c7fc3ce7a95b8404afdf40aa79a5eabf"

URI_x86_64_v2_libss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libss-1.47.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_libss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libss}"
SRC_URI[x86_64_v2_libss.sha256sum] = "26240c08977ff0e56c54d3f0b01047e25b0b9e6288a72e7fe35d9fb02676bd38"

URI_aarch64_e2fsprogs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/e2fsprogs-1.47.1-3.el10.aarch64.rpm;name=aarch64_e2fsprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_e2fsprogs}"
SRC_URI[aarch64_e2fsprogs.sha256sum] = "b729011fd5b3b69a939d105f5464b3a10a6d2f08cfe22771b2f89b07b9bf6b03"

URI_aarch64_e2fsprogs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/e2fsprogs-devel-1.47.1-3.el10.aarch64.rpm;name=aarch64_e2fsprogs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_e2fsprogs-devel}"
SRC_URI[aarch64_e2fsprogs-devel.sha256sum] = "2280d7c0d43426ae7c62651a0a62c01cafccda75532ca4dd6f8ddd8e28c999cb"

URI_aarch64_e2fsprogs-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/e2fsprogs-libs-1.47.1-3.el10.aarch64.rpm;name=aarch64_e2fsprogs-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_e2fsprogs-libs}"
SRC_URI[aarch64_e2fsprogs-libs.sha256sum] = "8ea6eb6d941569de18e59853a5192ecf941e9f5dbc64f8268d5a45c25976416a"

URI_aarch64_libcom_err = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcom_err-1.47.1-3.el10.aarch64.rpm;name=aarch64_libcom_err;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcom_err}"
SRC_URI[aarch64_libcom_err.sha256sum] = "6d0cb42866b6bd7459d32a49cc8410a0c552784c728ccfe04a2f2edb29183bf5"

URI_aarch64_libcom_err-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcom_err-devel-1.47.1-3.el10.aarch64.rpm;name=aarch64_libcom_err-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcom_err-devel}"
SRC_URI[aarch64_libcom_err-devel.sha256sum] = "0063e788e742553590d5ce228b762e9687d3b600e44d93cf5fd3382f654c2d56"

URI_aarch64_libss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libss-1.47.1-3.el10.aarch64.rpm;name=aarch64_libss;unpack=0"
SRC_URI:append = " ${URI_aarch64_libss}"
SRC_URI[aarch64_libss.sha256sum] = "0ba38d7a7916988b857d214512a5ccec9c6dce43228fde9cf7b357cf0176d089"

RDEPENDS:e2fsprogs = " \
 e2fsprogs-libs \
 fuse3-libs \
 glibc \
 libblkid \
 libcom_err \
 libss \
 libuuid \
 "
RDEPENDS:e2fsprogs-devel = " \
 e2fsprogs-libs \
 gawk \
 libcom_err-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:e2fsprogs-libs = " \
 glibc \
 libcom_err \
 "
RDEPENDS:libcom_err = " \
 glibc \
 "
RDEPENDS:libcom_err-devel = " \
 bash \
 libcom_err \
 pkgconf-pkg-config \
 "
RDEPENDS:libss = " \
 glibc \
 libcom_err \
 "
