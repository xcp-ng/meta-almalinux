# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkomparediff2"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libkomparediff2 \
 libkomparediff2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkomparediff2-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b725e01c0ca58a8b557d8c02fddaa144c26bf065ecb5e2131f75ce9046c91e0"

URI_x86_64_v2_libkomparediff2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkomparediff2-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkomparediff2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkomparediff2}"
SRC_URI[x86_64_v2_libkomparediff2.sha256sum] = "f709e2db492ee6e10f1acdfa37889c06101d042e6ca80997e9bb6d9b73cec3e4"

URI_x86_64_v2_libkomparediff2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkomparediff2-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkomparediff2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkomparediff2-devel}"
SRC_URI[x86_64_v2_libkomparediff2-devel.sha256sum] = "4d15b55158e6aa42973d5a9872118ec1b91a95b32c1d8e05b72cd06e296248e7"

URI_aarch64_libkomparediff2 = "${EPEL_MIRROR}/aarch64/Packages/l/libkomparediff2-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkomparediff2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkomparediff2}"
SRC_URI[aarch64_libkomparediff2.sha256sum] = "2595624bf0b60fdba0bbd84dd8f73afda602584aaecb0532ae270c8cd6b36fe4"

URI_aarch64_libkomparediff2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkomparediff2-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkomparediff2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkomparediff2-devel}"
SRC_URI[aarch64_libkomparediff2-devel.sha256sum] = "ee01acd7f87021eaa35acd43f9b71027dc6d0bd7df820b636be5c840054c70f3"

RDEPENDS:libkomparediff2 = " \
 diffutils \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkomparediff2-devel = " \
 cmake \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kxmlgui-devel \
 libkomparediff2 \
 qt6-qtbase-devel \
 "
