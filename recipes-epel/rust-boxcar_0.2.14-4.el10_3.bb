# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-boxcar"
PV = "0.2.14"
PR = "4.el10_3"
PACKAGES = " \
 rust-boxcar+default-devel \
 rust-boxcar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-boxcar-0.2.14-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7682a7335f8e645a38769a80fdd8a4bb66447de84c98c882510f653c6d55cf25"

URI_x86_64_v2_rust-boxcar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-boxcar+default-devel-0.2.14-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-boxcar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-boxcar+default-devel}"
SRC_URI[x86_64_v2_rust-boxcar+default-devel.sha256sum] = "e9452b5096c7083a6ef426c16d855a6cf76de809b6f372f171e48ab5062611a7"

URI_x86_64_v2_rust-boxcar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-boxcar-devel-0.2.14-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-boxcar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-boxcar-devel}"
SRC_URI[x86_64_v2_rust-boxcar-devel.sha256sum] = "62917b38ebd0d697379e056c4fcedfd87bbfe3f86b36a2870e1e0fa84a307af5"

URI_aarch64_rust-boxcar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-boxcar+default-devel-0.2.14-4.el10_3.noarch.rpm;name=aarch64_rust-boxcar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-boxcar+default-devel}"
SRC_URI[aarch64_rust-boxcar+default-devel.sha256sum] = "0829b9077d192bd38d85d529dfdb750deec3f3f6c6f21feb17c8d8d7950cf9d5"

URI_aarch64_rust-boxcar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-boxcar-devel-0.2.14-4.el10_3.noarch.rpm;name=aarch64_rust-boxcar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-boxcar-devel}"
SRC_URI[aarch64_rust-boxcar-devel.sha256sum] = "c097f6de4087fccc32d832743dbd4edf4e3055ddc061ad73913fe6a304c53df8"

RDEPENDS:rust-boxcar+default-devel = " \
 cargo \
 rust-boxcar-devel \
 "
RDEPENDS:rust-boxcar-devel = " \
 cargo \
 rust \
 "
