# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-ghc-lib-parser"
PV = "9.6.6.20240701"
PR = "1.el10_0"
PACKAGES = " \
 ghc-ghc-lib-parser \
 ghc-ghc-lib-parser-devel \
 ghc-ghc-lib-parser-doc \
 ghc-ghc-lib-parser-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-ghc-lib-parser-9.6.6.20240701-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4adc135c7b8cfebb09ff4630c86f5d5dc31ed38821883d327cb18ac8b8cdbb3"

URI_x86_64_v2_ghc-ghc-lib-parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-lib-parser-9.6.6.20240701-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-lib-parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-lib-parser}"
SRC_URI[x86_64_v2_ghc-ghc-lib-parser.sha256sum] = "9129b84d7c5e0754143a514c0234de555178683a65ec7c931fc241b4a173c4ef"

URI_x86_64_v2_ghc-ghc-lib-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-lib-parser-devel-9.6.6.20240701-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-lib-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-lib-parser-devel}"
SRC_URI[x86_64_v2_ghc-ghc-lib-parser-devel.sha256sum] = "6cdcd6bbdd4f3f9bb1c528642b6f7ccd9e3dd8ce10839b502a71c3edbac80c36"

URI_x86_64_v2_ghc-ghc-lib-parser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-lib-parser-doc-9.6.6.20240701-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ghc-lib-parser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-lib-parser-doc}"
SRC_URI[x86_64_v2_ghc-ghc-lib-parser-doc.sha256sum] = "69d18ba0a2fbf1d2823cd4f4e6e9b61dd52d1f8f13f2efda6afc9466614d4963"

URI_x86_64_v2_ghc-ghc-lib-parser-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghc-lib-parser-prof-9.6.6.20240701-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghc-lib-parser-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghc-lib-parser-prof}"
SRC_URI[x86_64_v2_ghc-ghc-lib-parser-prof.sha256sum] = "24ee49b898e0264ba32de5ce1fcf74960fdb9e961e1d2a56ab65128d1af46b5d"

URI_aarch64_ghc-ghc-lib-parser = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-lib-parser-9.6.6.20240701-1.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-lib-parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-lib-parser}"
SRC_URI[aarch64_ghc-ghc-lib-parser.sha256sum] = "23472fc86c0dd50b14f7763b010a078bf1f96945834becbce4382648588b920b"

URI_aarch64_ghc-ghc-lib-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-lib-parser-devel-9.6.6.20240701-1.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-lib-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-lib-parser-devel}"
SRC_URI[aarch64_ghc-ghc-lib-parser-devel.sha256sum] = "0aaa4977e1cdfd47060b12b36044bd72909b27ffe1dde5f2fc2b53a7cdc126c4"

URI_aarch64_ghc-ghc-lib-parser-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-lib-parser-doc-9.6.6.20240701-1.el10_0.noarch.rpm;name=aarch64_ghc-ghc-lib-parser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-lib-parser-doc}"
SRC_URI[aarch64_ghc-ghc-lib-parser-doc.sha256sum] = "551f04a8df4022674c1c07e703ccca8d59bc9407ab029839022c8380fe75138b"

URI_aarch64_ghc-ghc-lib-parser-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghc-lib-parser-prof-9.6.6.20240701-1.el10_0.aarch64.rpm;name=aarch64_ghc-ghc-lib-parser-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghc-lib-parser-prof}"
SRC_URI[aarch64_ghc-ghc-lib-parser-prof.sha256sum] = "fe224d1749cb127a79dc04f42ae7f50e7a531ecda865690a0a0a572a845ef1f2"

RDEPENDS:ghc-ghc-lib-parser = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ghc-lib-parser-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-ghc-lib-parser \
 ghc-parsec-devel \
 ghc-pretty-devel \
 ghc-process-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-ghc-lib-parser-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ghc-lib-parser-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-ghc-lib-parser-devel \
 ghc-parsec-prof \
 ghc-pretty-prof \
 ghc-process-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 "
