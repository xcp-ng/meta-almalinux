# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-typescript"
PV = "0.23.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-typescript+default-devel \
 rust-tree-sitter-typescript-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-typescript-0.23.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "957512b437b4668702ffdfae275d8f7f9b4176bb2d1f6a650c30583409fd1415"

URI_x86_64_v2_rust-tree-sitter-typescript+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-typescript+default-devel-0.23.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-typescript+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-typescript+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-typescript+default-devel.sha256sum] = "585628f0ed5d9ca52181c8c8bb6f4582c398fb843fb772fed379828b1ff25bbb"

URI_x86_64_v2_rust-tree-sitter-typescript-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-typescript-devel-0.23.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-typescript-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-typescript-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-typescript-devel.sha256sum] = "d9f16bcb667bfb649777f76777e8d9e6e673caa5011d85badabb54ba70dc2ba1"

URI_aarch64_rust-tree-sitter-typescript+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-typescript+default-devel-0.23.2-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-typescript+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-typescript+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-typescript+default-devel.sha256sum] = "cfc0c7b3e1223a58a8984cee304345e8fc6a3332f26d63b1c66a1e1f52da66b6"

URI_aarch64_rust-tree-sitter-typescript-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-typescript-devel-0.23.2-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-typescript-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-typescript-devel}"
SRC_URI[aarch64_rust-tree-sitter-typescript-devel.sha256sum] = "9513e8dcd006e3906f6ac11581ae629dc531b037c9900d08ebc9ec44b24cffc7"

RDEPENDS:rust-tree-sitter-typescript+default-devel = " \
 cargo \
 rust-tree-sitter-typescript-devel \
 "
RDEPENDS:rust-tree-sitter-typescript-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
