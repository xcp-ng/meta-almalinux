# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-css"
PV = "0.23.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-css+default-devel \
 rust-tree-sitter-css-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-css-0.23.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdfd753fc49b5f550c88590eef0a3686b19a0fef97a7543a3028c7287dc9214c"

URI_x86_64_v2_rust-tree-sitter-css+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-css+default-devel-0.23.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-css+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-css+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-css+default-devel.sha256sum] = "3f7ef25e495765d526db37fedf3e70b67939face3b4f82be5a02eddbbf4a30fc"

URI_x86_64_v2_rust-tree-sitter-css-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-css-devel-0.23.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-css-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-css-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-css-devel.sha256sum] = "7c40369cc0b88fd2ad3918c343ba5524ca8dfc73447261e35bb1b9899e89559d"

URI_aarch64_rust-tree-sitter-css+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-css+default-devel-0.23.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-css+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-css+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-css+default-devel.sha256sum] = "677a30715e56233545a830e40f6d9ce1acf85122af4bc6d56d287ea6f0ff13c6"

URI_aarch64_rust-tree-sitter-css-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-css-devel-0.23.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-css-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-css-devel}"
SRC_URI[aarch64_rust-tree-sitter-css-devel.sha256sum] = "6b61ad281672b9f691dd05e678857350831817caa4a191cff1e8848d312f42f9"

RDEPENDS:rust-tree-sitter-css+default-devel = " \
 cargo \
 rust-tree-sitter-css-devel \
 "
RDEPENDS:rust-tree-sitter-css-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
