# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-FDPass"
PV = "1.3"
PR = "8.el10_0"
PACKAGES = " \
 perl-IO-FDPass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-FDPass-1.3-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9686b9e03de12b647f06eacdddf5970c7e87ca9dc8f04953f9cbd2eb76c6eee"

URI_x86_64_v2_perl-IO-FDPass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-FDPass-1.3-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-IO-FDPass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-FDPass}"
SRC_URI[x86_64_v2_perl-IO-FDPass.sha256sum] = "a29cf2d1ff666850ee542d1aa023a3aa154a3f415c688dfd81565a775251a7c8"

URI_aarch64_perl-IO-FDPass = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-FDPass-1.3-8.el10_0.aarch64.rpm;name=aarch64_perl-IO-FDPass;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-FDPass}"
SRC_URI[aarch64_perl-IO-FDPass.sha256sum] = "9f5ad6ef90a039d5b8d783d0924f5668bc65fd29bd6f21e0a047a55b843fc717"

RDEPENDS:perl-IO-FDPass = " \
 glibc \
 perl-libs \
 "
