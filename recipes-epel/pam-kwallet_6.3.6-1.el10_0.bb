# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam-kwallet"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 pam-kwallet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam-kwallet-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23b08be87b906476c8ebb5430524ebbc20ea56f257ba3a706f85a59340d06606"

URI_x86_64_v2_pam-kwallet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam-kwallet-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam-kwallet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-kwallet}"
SRC_URI[x86_64_v2_pam-kwallet.sha256sum] = "74cd2e05cb0c8598d5389eddb956a3d1505e7b2c00148d6cc032cea21b98bb84"

URI_aarch64_pam-kwallet = "${EPEL_MIRROR}/aarch64/Packages/p/pam-kwallet-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_pam-kwallet;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-kwallet}"
SRC_URI[aarch64_pam-kwallet.sha256sum] = "e3c026aba9579e8aeb5cbca0f37c4db5c7a7cf2a1bb1e00989488c8bf1b849f6"

RDEPENDS:pam-kwallet = " \
 bash \
 glibc \
 kf6-kwallet \
 libgcrypt \
 pam-libs \
 socat \
 "
