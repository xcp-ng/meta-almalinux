# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "checksec"
PV = "2.7.1"
PR = "7.el10_3"
PACKAGES = " \
 checksec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/checksec-2.7.1-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2872ef9ff4881a5c8cf55835dae9902c60b06d3f2b62f44a74e3d44f508d2d38"

URI_x86_64_v2_checksec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/checksec-2.7.1-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_checksec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_checksec}"
SRC_URI[x86_64_v2_checksec.sha256sum] = "1884bec02b0d871f65f99445f2914fcbad709a3529fc3041aec3769d5bf6e556"

URI_aarch64_checksec = "${EPEL_MIRROR}/aarch64/Packages/c/checksec-2.7.1-7.el10_3.noarch.rpm;name=aarch64_checksec;unpack=0"
SRC_URI:append = " ${URI_aarch64_checksec}"
SRC_URI[aarch64_checksec.sha256sum] = "dfdb484b96e8c21750e950ba75b836429d2111e8889d3dac2052668f31459257"

RDEPENDS:checksec = " \
 bash \
 binutils \
 file \
 findutils \
 gawk \
 which \
 "
