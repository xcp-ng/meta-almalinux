# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lprint"
PV = "1.3.1"
PR = "8.el10"
PACKAGES = " \
 lprint \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lprint-1.3.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e032eaae031e772e93f9e40eddf2a9ced5999c57b04d93c9196d8a0ca917d249"

URI_x86_64_v2_lprint = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lprint-1.3.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_lprint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lprint}"
SRC_URI[x86_64_v2_lprint.sha256sum] = "5cf968982a6da97b0ab35b387e7596f055e066450e702c64936f01e89f408041"

URI_aarch64_lprint = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lprint-1.3.1-8.el10.aarch64.rpm;name=aarch64_lprint;unpack=0"
SRC_URI:append = " ${URI_aarch64_lprint}"
SRC_URI[aarch64_lprint.sha256sum] = "6f6abe4b8d96c334abfc9456f59a12ccc8ec33d017e7a724804d46196f1daac4"

RDEPENDS:lprint = " \
 avahi \
 bash \
 cups-libs \
 filesystem \
 glibc \
 pappl \
 "
