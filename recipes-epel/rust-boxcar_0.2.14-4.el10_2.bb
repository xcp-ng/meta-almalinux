# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-boxcar"
PV = "0.2.14"
PR = "4.el10_2"
PACKAGES = " \
 rust-boxcar+default-devel \
 rust-boxcar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-boxcar-0.2.14-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6993cdbd58cccb9880a8fcdb0f499edb2dcd3d83a5246c16af209464b4679f0e"

URI_x86_64_v2_rust-boxcar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-boxcar+default-devel-0.2.14-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-boxcar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-boxcar+default-devel}"
SRC_URI[x86_64_v2_rust-boxcar+default-devel.sha256sum] = "5ecaec6ee4f695b2da80ff12e8f4fa62216ccf06dd7bfff2a23d337c668853f6"

URI_x86_64_v2_rust-boxcar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-boxcar-devel-0.2.14-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-boxcar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-boxcar-devel}"
SRC_URI[x86_64_v2_rust-boxcar-devel.sha256sum] = "ed8538b1482a5ce3eea7d5039c6fc1e171ca3c25b253527d6acd42bb5172646e"

URI_aarch64_rust-boxcar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-boxcar+default-devel-0.2.14-4.el10_2.noarch.rpm;name=aarch64_rust-boxcar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-boxcar+default-devel}"
SRC_URI[aarch64_rust-boxcar+default-devel.sha256sum] = "7242e68e2cd8d40ede90a6d32006f8fa724157a93be2f5cb37890a83f6baa633"

URI_aarch64_rust-boxcar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-boxcar-devel-0.2.14-4.el10_2.noarch.rpm;name=aarch64_rust-boxcar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-boxcar-devel}"
SRC_URI[aarch64_rust-boxcar-devel.sha256sum] = "ad6393cb5c402bd5334343fb6fe712baac30e73d2283217739963987653ebe88"

RDEPENDS:rust-boxcar+default-devel = " \
 cargo \
 rust-boxcar-devel \
 "
RDEPENDS:rust-boxcar-devel = " \
 cargo \
 rust \
 "
