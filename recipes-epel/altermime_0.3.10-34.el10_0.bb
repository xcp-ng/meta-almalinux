# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "altermime"
PV = "0.3.10"
PR = "34.el10_0"
PACKAGES = " \
 altermime \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/altermime-0.3.10-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "32037da6aad936d66cb14810b0230454ab086c401bea7eb3976454e69ec4f988"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/altermime-0.3.10-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_altermime;unpack=0"
SRC_URI[x86_64_v2_altermime.sha256sum] = "bcc0c5e7025396705a25f88f24f08b8c280ba46314361e85d53c145cf6244200"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/altermime-0.3.10-34.el10_0.aarch64.rpm;name=aarch64_altermime;unpack=0"
SRC_URI[aarch64_altermime.sha256sum] = "d82463e254ad01ff302f7d498f27c07316c3f435bd2c78ac003488671bfd03ab"

RDEPENDS:altermime = " \
 glibc \
 "
