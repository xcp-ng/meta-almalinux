# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnbd"
PV = "1.24.1"
PR = "1.el10"
PACKAGES = " \
 libnbd \
 libnbd-bash-completion \
 libnbd-devel \
 nbdfuse \
 ocaml-libnbd \
 ocaml-libnbd-devel \
 python3-libnbd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnbd-1.24.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2b548388773ba99190225f3359eff852bd8277e43bcdf1151eb8d9ab8a36ffc"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ocaml-libnbd-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd-devel: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd-devel: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd-devel: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd-devel: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd-devel: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd-devel: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd-devel: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd-devel: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-libnbd-devel: ocamlx(Stdlib__Bigarray) = 2fb6f37865dd77a707635669254911e1
# - ocaml-libnbd-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libnbd-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libnbd: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - ocaml-libnbd-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd-devel: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd-devel: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd-devel: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd-devel: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd-devel: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd-devel: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd-devel: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd-devel: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-libnbd-devel: ocamlx(Stdlib__Bigarray) = 2fb6f37865dd77a707635669254911e1
# - ocaml-libnbd-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libnbd-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libnbd: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda

URI_x86_64_v2_libnbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnbd-1.24.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd}"
SRC_URI[x86_64_v2_libnbd.sha256sum] = "5f477f11776e3bac99d82c2c7d70f9c4c2a3c9904121e90ab588475879bb85b0"

URI_x86_64_v2_libnbd-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnbd-bash-completion-1.24.1-1.el10.noarch.rpm;name=x86_64_v2_libnbd-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd-bash-completion}"
SRC_URI[x86_64_v2_libnbd-bash-completion.sha256sum] = "802c063e311ba434177b428112f76350fafd41f68b2c5edde337bcbdf74181a5"

URI_x86_64_v2_libnbd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnbd-devel-1.24.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd-devel}"
SRC_URI[x86_64_v2_libnbd-devel.sha256sum] = "6a5d9d12eef63eb741bf3fbf9bbd5fa3214e518819b59b1a34f4e3baf03caeb0"

URI_x86_64_v2_nbdfuse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdfuse-1.24.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_nbdfuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdfuse}"
SRC_URI[x86_64_v2_nbdfuse.sha256sum] = "8b53ad8089f52458738997591546b7b450b137eb193d6559a63607650f0f56fd"

URI_x86_64_v2_ocaml-libnbd = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libnbd-1.24.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ocaml-libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libnbd}"
SRC_URI[x86_64_v2_ocaml-libnbd.sha256sum] = "08ef7402182c3486c7087c8664a0f5c81475945eca18374c426d58f9f5a65b39"

URI_x86_64_v2_ocaml-libnbd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libnbd-devel-1.24.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_ocaml-libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libnbd-devel}"
SRC_URI[x86_64_v2_ocaml-libnbd-devel.sha256sum] = "4c22137839524e53765aab46cc5a17cf4c31fa46e89cf8d0de5ebcdc2141e8f3"

URI_x86_64_v2_python3-libnbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnbd-1.24.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnbd}"
SRC_URI[x86_64_v2_python3-libnbd.sha256sum] = "c4ca490e4745acb8b02692f8d9bb04dc47a4c5a36ccd53c7b490411732f0987a"

URI_aarch64_libnbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnbd-1.24.1-1.el10.aarch64.rpm;name=aarch64_libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd}"
SRC_URI[aarch64_libnbd.sha256sum] = "28d350698a07fb3a703eab401a2a2aea30ed59dfe4ece5159950cd6f4608e75d"

URI_aarch64_libnbd-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnbd-bash-completion-1.24.1-1.el10.noarch.rpm;name=aarch64_libnbd-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd-bash-completion}"
SRC_URI[aarch64_libnbd-bash-completion.sha256sum] = "802c063e311ba434177b428112f76350fafd41f68b2c5edde337bcbdf74181a5"

URI_aarch64_libnbd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnbd-devel-1.24.1-1.el10.aarch64.rpm;name=aarch64_libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd-devel}"
SRC_URI[aarch64_libnbd-devel.sha256sum] = "c3f360e20b68f785cc65a589e351b237f214f5b13547f7d79588c234f64d9878"

URI_aarch64_nbdfuse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdfuse-1.24.1-1.el10.aarch64.rpm;name=aarch64_nbdfuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdfuse}"
SRC_URI[aarch64_nbdfuse.sha256sum] = "5f9043e8fbc72925190fabb3cac6f536b54cd21d080c0a92cab0343c96df10e9"

URI_aarch64_ocaml-libnbd = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libnbd-1.24.1-1.el10.aarch64.rpm;name=aarch64_ocaml-libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libnbd}"
SRC_URI[aarch64_ocaml-libnbd.sha256sum] = "fe208b5fae3bae7ca0de99c35ae8f89a2183b29906e018344737ad0d193f7c00"

URI_aarch64_ocaml-libnbd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libnbd-devel-1.24.1-1.el10.aarch64.rpm;name=aarch64_ocaml-libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libnbd-devel}"
SRC_URI[aarch64_ocaml-libnbd-devel.sha256sum] = "2fdf077fede2e1fa7c77656cea8a8b6234943fc903edf6af83f2c059a97712c5"

URI_aarch64_python3-libnbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnbd-1.24.1-1.el10.aarch64.rpm;name=aarch64_python3-libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnbd}"
SRC_URI[aarch64_python3-libnbd.sha256sum] = "34d7659c8d032e1afd46492218ad88718c6bc0e90ee394ff3dff1c4dfa0acb6e"

RDEPENDS:libnbd = " \
 glibc \
 gnutls \
 libxml2 \
 "
RDEPENDS:libnbd-bash-completion = " \
 bash-completion \
 libnbd \
 "
RDEPENDS:libnbd-devel = " \
 libnbd \
 pkgconf-pkg-config \
 "
RDEPENDS:nbdfuse = " \
 fuse3-libs \
 glibc \
 libnbd \
 "
RDEPENDS:ocaml-libnbd = " \
 glibc \
 libnbd \
 "
RDEPENDS:ocaml-libnbd-devel = " \
 ocaml-libnbd \
 "
RDEPENDS:python3-libnbd = " \
 bash \
 glibc \
 gnutls \
 libnbd \
 libxml2 \
 python3 \
 "
