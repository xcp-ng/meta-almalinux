# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_comm"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_comm+default-devel \
 rust-uu_comm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_comm-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adcd93287265f64e26cf30b29e4a65bf9f3da164cd22be3c110a9f63ef4c1d57"

URI_x86_64_v2_rust-uu_comm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_comm+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_comm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_comm+default-devel}"
SRC_URI[x86_64_v2_rust-uu_comm+default-devel.sha256sum] = "e96c1379a21f46450d2bca337a5202a017bdb4e7db5f5a0983326e809a22360c"

URI_x86_64_v2_rust-uu_comm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_comm-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_comm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_comm-devel}"
SRC_URI[x86_64_v2_rust-uu_comm-devel.sha256sum] = "9add616cf4d74c861d270040f0784026f1103ccb836a754d427803b4f0d75b4e"

URI_aarch64_rust-uu_comm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_comm+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_comm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_comm+default-devel}"
SRC_URI[aarch64_rust-uu_comm+default-devel.sha256sum] = "8073ada56a4f026b71ce3c0bb00b58fed284b376d91f8e85d36723b08242e391"

URI_aarch64_rust-uu_comm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_comm-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_comm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_comm-devel}"
SRC_URI[aarch64_rust-uu_comm-devel.sha256sum] = "e6e7d638c84e9cdc3dcb60a17c650ed012718a293f247825b6aecb727b0f9c20"

RDEPENDS:rust-uu_comm+default-devel = " \
 cargo \
 rust-uu_comm-devel \
 "
RDEPENDS:rust-uu_comm-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 "
