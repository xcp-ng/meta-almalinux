# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-debug-helper"
PV = "0.3.13"
PR = "3.el10_0"
PACKAGES = " \
 rust-debug-helper+default-devel \
 rust-debug-helper-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-debug-helper-0.3.13-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bbef6d8dd33997dc13e9b1854f9935d29bd42645004132b9391bfec7855cc1d"

URI_x86_64_v2_rust-debug-helper+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-debug-helper+default-devel-0.3.13-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-debug-helper+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-debug-helper+default-devel}"
SRC_URI[x86_64_v2_rust-debug-helper+default-devel.sha256sum] = "923ba79c0b3c3d5c98dca253d0fb2d1275805fd57afa21cd8f88307d79496f66"

URI_x86_64_v2_rust-debug-helper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-debug-helper-devel-0.3.13-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-debug-helper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-debug-helper-devel}"
SRC_URI[x86_64_v2_rust-debug-helper-devel.sha256sum] = "b223149add62473b265e6f6b10c5cd4b7b9c6487b8d01db3a0e9804a227a97d0"

URI_aarch64_rust-debug-helper+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-debug-helper+default-devel-0.3.13-3.el10_0.noarch.rpm;name=aarch64_rust-debug-helper+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-debug-helper+default-devel}"
SRC_URI[aarch64_rust-debug-helper+default-devel.sha256sum] = "08b6c2682e9e27304b0a27da0e2c7757e0e61f752386e30c438e298bb215f397"

URI_aarch64_rust-debug-helper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-debug-helper-devel-0.3.13-3.el10_0.noarch.rpm;name=aarch64_rust-debug-helper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-debug-helper-devel}"
SRC_URI[aarch64_rust-debug-helper-devel.sha256sum] = "6bd21708996f4d9b2477191a79f079d525b60dcfdd55e07cbbfc3bdccfc42823"

RDEPENDS:rust-debug-helper+default-devel = " \
 cargo \
 rust-debug-helper-devel \
 "
RDEPENDS:rust-debug-helper-devel = " \
 cargo \
 "
