# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "objfw"
PV = "1.5.7"
PR = "1.el10_2"
PACKAGES = " \
 libobjfw \
 libobjfw-devel \
 libobjfwhid \
 libobjfwhid-devel \
 libobjfwrt \
 libobjfwrt-devel \
 libobjfwtls \
 libobjfwtls-devel \
 objfw \
 objfw-doc \
 ofarc \
 ofdns \
 ofgctester \
 ofhash \
 ofhttp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/objfw-1.5.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a74214d356e7bbc58248773a6bf69737ce7a3f0c2736aa7d16dfffe6c2d8e608"

URI_x86_64_v2_libobjfw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfw-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfw}"
SRC_URI[x86_64_v2_libobjfw.sha256sum] = "4797a96aa5d70df8c10931991cadcfbb5a351cdfbe3912074974b6261085bbae"

URI_x86_64_v2_libobjfw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfw-devel-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfw-devel}"
SRC_URI[x86_64_v2_libobjfw-devel.sha256sum] = "f7821f3c0b31efb90a56040005bbf52455859cd393e7e4ba04a66622f00b93bf"

URI_x86_64_v2_libobjfwhid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwhid-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwhid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwhid}"
SRC_URI[x86_64_v2_libobjfwhid.sha256sum] = "e79971eaa67ebf339bca936c9a717dae6cdae47c560fcef90d1ecffd262a9517"

URI_x86_64_v2_libobjfwhid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwhid-devel-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwhid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwhid-devel}"
SRC_URI[x86_64_v2_libobjfwhid-devel.sha256sum] = "0f7c872e15e92ede29345f57055a13486aac95413f456ab43b76e60d8a6c31e2"

URI_x86_64_v2_libobjfwrt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwrt-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwrt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwrt}"
SRC_URI[x86_64_v2_libobjfwrt.sha256sum] = "70772071f01243edef48aca92be375e6a5a14b4c2f9d24fc1754b04650cb8a76"

URI_x86_64_v2_libobjfwrt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwrt-devel-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwrt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwrt-devel}"
SRC_URI[x86_64_v2_libobjfwrt-devel.sha256sum] = "d5ba7b439e4e4dff847766bc1685df01279cad716d92bee74a320f0f0a09eeed"

URI_x86_64_v2_libobjfwtls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwtls-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwtls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwtls}"
SRC_URI[x86_64_v2_libobjfwtls.sha256sum] = "5ed46b97e24729526bac624b1469904a7b63bd1c449b940a519f7476f39d9d3e"

URI_x86_64_v2_libobjfwtls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwtls-devel-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwtls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwtls-devel}"
SRC_URI[x86_64_v2_libobjfwtls-devel.sha256sum] = "0d326d54f8b20dfd839f5992677641542d9d74c0d7d516374ea3a679354c93c5"

URI_x86_64_v2_objfw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/objfw-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_objfw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objfw}"
SRC_URI[x86_64_v2_objfw.sha256sum] = "9a9012b9afbe1b6d3db6694a884b0c02e596334f7201423a24da71797a53f69a"

URI_x86_64_v2_objfw-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/objfw-doc-1.5.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_objfw-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objfw-doc}"
SRC_URI[x86_64_v2_objfw-doc.sha256sum] = "3a5d8c03f9f3e65bfb212258bcf702016a79eee267bfb0f8c77e27548ddfb769"

URI_x86_64_v2_ofarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofarc-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofarc}"
SRC_URI[x86_64_v2_ofarc.sha256sum] = "42244bad0d4c4b72e9806f8265a00b5b108843724ecdea2604b4cc7b6203088e"

URI_x86_64_v2_ofdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofdns-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofdns}"
SRC_URI[x86_64_v2_ofdns.sha256sum] = "2f30241bc93efe4887f54cf7877e70fcbb0d809b36e5ca6f3a7fb77ac525009c"

URI_x86_64_v2_ofgctester = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofgctester-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofgctester;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofgctester}"
SRC_URI[x86_64_v2_ofgctester.sha256sum] = "f74b65c3e27d1f5156d3daab9427f5c35447b720d49eca681b92239f5617be2c"

URI_x86_64_v2_ofhash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofhash-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofhash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofhash}"
SRC_URI[x86_64_v2_ofhash.sha256sum] = "2d69e02f87d885fc293856747ba4caa3d86022411949e94076896a253a50b52b"

URI_x86_64_v2_ofhttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofhttp-1.5.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofhttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofhttp}"
SRC_URI[x86_64_v2_ofhttp.sha256sum] = "f09ae17099f06fcd4afe4c42309186e0db41a75d3251c7db8ebf9780bc3e4eaf"

URI_aarch64_libobjfw = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfw-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_libobjfw;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfw}"
SRC_URI[aarch64_libobjfw.sha256sum] = "724d1f69b7d2cb10933b47ac04794c073bf9ae37b6a4d53a7415a575320b5adf"

URI_aarch64_libobjfw-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfw-devel-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_libobjfw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfw-devel}"
SRC_URI[aarch64_libobjfw-devel.sha256sum] = "4dbb2c2f89220d59b848e55eaec1d6086f3cf56a584d4f14ed1c84d26dd26663"

URI_aarch64_libobjfwhid = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwhid-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_libobjfwhid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwhid}"
SRC_URI[aarch64_libobjfwhid.sha256sum] = "267b26d2f48cad62c9ebec9b9335894e1a0ed72a0f59594c63084b22efe8e85e"

URI_aarch64_libobjfwhid-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwhid-devel-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_libobjfwhid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwhid-devel}"
SRC_URI[aarch64_libobjfwhid-devel.sha256sum] = "f0b217a0ac40b264b3f6598fffe9a8129bc2624c2df07aac6286aee1e8508d2c"

URI_aarch64_libobjfwrt = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwrt-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_libobjfwrt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwrt}"
SRC_URI[aarch64_libobjfwrt.sha256sum] = "c49080489847b29d81b557d792ec2e1fcf82520e3baa2e1db7c205dde458c6df"

URI_aarch64_libobjfwrt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwrt-devel-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_libobjfwrt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwrt-devel}"
SRC_URI[aarch64_libobjfwrt-devel.sha256sum] = "0268ee61286db79bdb57646afbbf2212d0b4a6f212a6d07786d2f13001b21e8a"

URI_aarch64_libobjfwtls = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwtls-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_libobjfwtls;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwtls}"
SRC_URI[aarch64_libobjfwtls.sha256sum] = "ad548de9cf2915302154f0ac22486e1baeb44da5d290343f9bb48d33e436bc88"

URI_aarch64_libobjfwtls-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwtls-devel-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_libobjfwtls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwtls-devel}"
SRC_URI[aarch64_libobjfwtls-devel.sha256sum] = "85dffcb22f979fa139b1836bb57ee4cb074697e8d61de4e40396a94ca809a1b3"

URI_aarch64_objfw = "${EPEL_MIRROR}/aarch64/Packages/o/objfw-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_objfw;unpack=0"
SRC_URI:append = " ${URI_aarch64_objfw}"
SRC_URI[aarch64_objfw.sha256sum] = "74bed8b94d06d8fc2c15d9057a39f6a140a1db120f81141de395797a26c9947b"

URI_aarch64_objfw-doc = "${EPEL_MIRROR}/aarch64/Packages/o/objfw-doc-1.5.7-1.el10_2.noarch.rpm;name=aarch64_objfw-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_objfw-doc}"
SRC_URI[aarch64_objfw-doc.sha256sum] = "19c173390e22cbf898dfc7661351c6de01b4ce5bd144bdef96506d8935ee1d60"

URI_aarch64_ofarc = "${EPEL_MIRROR}/aarch64/Packages/o/ofarc-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_ofarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofarc}"
SRC_URI[aarch64_ofarc.sha256sum] = "5051f0fc9584930af494bfe3e68a2e268882cb81e550932e554d0c967f3da1b7"

URI_aarch64_ofdns = "${EPEL_MIRROR}/aarch64/Packages/o/ofdns-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_ofdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofdns}"
SRC_URI[aarch64_ofdns.sha256sum] = "0f09a9533d38e285df09df79b5e6f3a032609c90e1ef5e4732a56d7b930be352"

URI_aarch64_ofgctester = "${EPEL_MIRROR}/aarch64/Packages/o/ofgctester-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_ofgctester;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofgctester}"
SRC_URI[aarch64_ofgctester.sha256sum] = "446c07b6b8fa6f9bf167a34419bb1e1e29515b83ff07e67e62c5c3d1b62470dc"

URI_aarch64_ofhash = "${EPEL_MIRROR}/aarch64/Packages/o/ofhash-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_ofhash;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofhash}"
SRC_URI[aarch64_ofhash.sha256sum] = "253aa51609c5fd700e01424668d96ff2b7bf95e33161c5d3e9d795ec7a4d8d58"

URI_aarch64_ofhttp = "${EPEL_MIRROR}/aarch64/Packages/o/ofhttp-1.5.7-1.el10_2.aarch64.rpm;name=aarch64_ofhttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofhttp}"
SRC_URI[aarch64_ofhttp.sha256sum] = "f43670098b374580ec8d5e174c8d363684e7b889fbab45c9e7e3475332699e53"

RDEPENDS:libobjfw = " \
 glibc \
 libgcc \
 libobjfwrt \
 "
RDEPENDS:libobjfw-devel = " \
 bash \
 clang \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwrt-devel \
 lksctp-tools-devel \
 "
RDEPENDS:libobjfwhid = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:libobjfwhid-devel = " \
 libobjfw-devel \
 libobjfwhid \
 libobjfwrt-devel \
 "
RDEPENDS:libobjfwrt = " \
 glibc \
 libgcc \
 "
RDEPENDS:libobjfwrt-devel = " \
 libobjfwrt \
 "
RDEPENDS:libobjfwtls = " \
 glibc \
 gnutls \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:libobjfwtls-devel = " \
 libobjfw-devel \
 libobjfwrt-devel \
 libobjfwtls \
 "
RDEPENDS:objfw = " \
 libobjfw \
 libobjfw-devel \
 libobjfwhid \
 libobjfwhid-devel \
 libobjfwrt \
 libobjfwrt-devel \
 libobjfwtls \
 libobjfwtls-devel \
 ofarc \
 ofdns \
 ofgctester \
 ofhash \
 ofhttp \
 "
RDEPENDS:objfw-doc = " \
 "
RDEPENDS:ofarc = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
RDEPENDS:ofdns = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:ofgctester = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwhid \
 libobjfwrt \
 "
RDEPENDS:ofhash = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
RDEPENDS:ofhttp = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
