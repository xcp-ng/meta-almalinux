# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s3fs-fuse"
PV = "1.97"
PR = "1.el10_2"
PACKAGES = " \
 s3fs-fuse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/s3fs-fuse-1.97-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e3b41f5fc36c67e2f047037c9a2198e0f593af8a03d8a8058436f7890382fb3"

URI_x86_64_v2_s3fs-fuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s3fs-fuse-1.97-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_s3fs-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s3fs-fuse}"
SRC_URI[x86_64_v2_s3fs-fuse.sha256sum] = "c24861a7dd774ba85f9bc6ab8e96e0530e2021caa7f4045d140375988a74181a"

URI_aarch64_s3fs-fuse = "${EPEL_MIRROR}/aarch64/Packages/s/s3fs-fuse-1.97-1.el10_2.aarch64.rpm;name=aarch64_s3fs-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_s3fs-fuse}"
SRC_URI[aarch64_s3fs-fuse.sha256sum] = "4bb84b1142d7ddeb0033cdc7d8610cc6f6c14231c7407e5844f0d64d48c06e94"

RDEPENDS:s3fs-fuse = " \
 fuse3 \
 fuse3-libs \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 mailcap \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
