# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-search"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 akonadi-search \
 akonadi-search-devel \
 akonadi-search-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-search-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39873c41b425c99b1ac385812497946b2b8961f8fa2ad5107cd09de431a13fd3"

URI_x86_64_v2_akonadi-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search}"
SRC_URI[x86_64_v2_akonadi-search.sha256sum] = "eaa2a00b8f8148c81834881ce26a2fac503a95435e508ddeba448adeed5ab32b"

URI_x86_64_v2_akonadi-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search-devel}"
SRC_URI[x86_64_v2_akonadi-search-devel.sha256sum] = "8934c7168625e43d08b5fb1cde2d811d623ad25c963ba23e5ee0e1b1a746fdae"

URI_x86_64_v2_akonadi-search-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-search-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search-doc}"
SRC_URI[x86_64_v2_akonadi-search-doc.sha256sum] = "5e3e7df60a6b78151442902f5688fc089f930b249a7b4670b446c73e4ff25f47"

URI_aarch64_akonadi-search = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search}"
SRC_URI[aarch64_akonadi-search.sha256sum] = "b600e612920720fce53948bc695ff5f2465fdda56b89e9c380bb89d26ef6dc98"

URI_aarch64_akonadi-search-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search-devel}"
SRC_URI[aarch64_akonadi-search-devel.sha256sum] = "ca6c5490593f8bce7378f7456856a73a8d5f6b494423ee7d4b4fe0d2ac99046b"

URI_aarch64_akonadi-search-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_akonadi-search-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search-doc}"
SRC_URI[aarch64_akonadi-search-doc.sha256sum] = "b37eaf208204483b4399ddce58d34f1fa121feb0b183677ce608398c19b5735d"

RDEPENDS:akonadi-search = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-krunner \
 kf6-kwidgetsaddons \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 xapian-core-libs \
 "
RDEPENDS:akonadi-search-devel = " \
 akonadi-mime-devel \
 akonadi-search \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kcoreaddons-devel \
 kmime-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:akonadi-search-doc = " \
 "
