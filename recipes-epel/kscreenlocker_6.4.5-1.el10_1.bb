# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kscreenlocker"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 kscreenlocker \
 kscreenlocker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kscreenlocker-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa11783d2af81438c762776646243adbe7d8cec1b205ce61f2da29a0c3335a28"

URI_x86_64_v2_kscreenlocker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreenlocker-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreenlocker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreenlocker}"
SRC_URI[x86_64_v2_kscreenlocker.sha256sum] = "1538e4a3920ae6c4bb875bcce43c4587d5c8b3437841f6f52b3c4881518b8685"

URI_x86_64_v2_kscreenlocker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreenlocker-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreenlocker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreenlocker-devel}"
SRC_URI[x86_64_v2_kscreenlocker-devel.sha256sum] = "204bdc3355f51a14bc2d1ffd066b4367444ff9e17ea1fb5d83e667efb6067ff9"

URI_aarch64_kscreenlocker = "${EPEL_MIRROR}/aarch64/Packages/k/kscreenlocker-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kscreenlocker;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreenlocker}"
SRC_URI[aarch64_kscreenlocker.sha256sum] = "a178016353b23c1ff1ae8b4aafedc299e950ec043f4ef0f981a51cd4c941cc2c"

URI_aarch64_kscreenlocker-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kscreenlocker-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kscreenlocker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreenlocker-devel}"
SRC_URI[aarch64_kscreenlocker-devel.sha256sum] = "cbc6ecdaedf61724ec8181f07f0e0601cd70613022e398ae7ef5377e94dc0658"

RDEPENDS:kscreenlocker = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 layer-shell-qt \
 libX11 \
 libXi \
 libkscreen \
 libplasma \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 libxcb \
 pam-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xcb-util-keysyms \
 "
RDEPENDS:kscreenlocker-devel = " \
 cmake-filesystem \
 kscreenlocker \
 "
