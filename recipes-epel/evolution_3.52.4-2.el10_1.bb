# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "evolution"
PV = "3.52.4"
PR = "2.el10_1"
PACKAGES = " \
 evolution \
 evolution-bogofilter \
 evolution-devel \
 evolution-devel-docs \
 evolution-help \
 evolution-langpacks \
 evolution-pst \
 evolution-spamassassin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/evolution-3.52.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b7ff7c31ccebd48c671b97182fdce36a72f657859628f57ef65301ea196d55a"

URI_x86_64_v2_evolution = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-3.52.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution}"
SRC_URI[x86_64_v2_evolution.sha256sum] = "d5cfa60b7dec9869341bcb77b0acb81169f287fd1cbd971756d705795f57346e"

URI_x86_64_v2_evolution-bogofilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-bogofilter-3.52.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution-bogofilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-bogofilter}"
SRC_URI[x86_64_v2_evolution-bogofilter.sha256sum] = "314f192094ecb20c379d392079df82d3cdad5d3362d142c4133d1b3bd9c39283"

URI_x86_64_v2_evolution-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-devel-3.52.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-devel}"
SRC_URI[x86_64_v2_evolution-devel.sha256sum] = "0a3eb7bc43f126950cb805a80b61b1dec5d67b42234a70ff7ac850de8b1c58e4"

URI_x86_64_v2_evolution-devel-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-devel-docs-3.52.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_evolution-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-devel-docs}"
SRC_URI[x86_64_v2_evolution-devel-docs.sha256sum] = "8f97b2327fc1005c46058b20743ad6fd41776f7d238ed843456040dee5fc40b0"

URI_x86_64_v2_evolution-help = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-help-3.52.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_evolution-help;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-help}"
SRC_URI[x86_64_v2_evolution-help.sha256sum] = "d8c2b769b48899ed31c4db870315511903c3cd35477b5a21882aeb985a54b164"

URI_x86_64_v2_evolution-langpacks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-langpacks-3.52.4-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_evolution-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-langpacks}"
SRC_URI[x86_64_v2_evolution-langpacks.sha256sum] = "e03e44187f80e6a11c6a812e656b1447b21262306544458a9e9c581165227b51"

URI_x86_64_v2_evolution-pst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-pst-3.52.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution-pst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-pst}"
SRC_URI[x86_64_v2_evolution-pst.sha256sum] = "2bd0877313d606a0eff0b138b27ebaf722ba727028fff5d67dffe323ec47c40c"

URI_x86_64_v2_evolution-spamassassin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-spamassassin-3.52.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution-spamassassin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-spamassassin}"
SRC_URI[x86_64_v2_evolution-spamassassin.sha256sum] = "f8cff67cf1bba7027f4f4ca62747c7eaecc3b6889007084f3acb24254de72620"

URI_aarch64_evolution = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-3.52.4-2.el10_1.aarch64.rpm;name=aarch64_evolution;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution}"
SRC_URI[aarch64_evolution.sha256sum] = "acc659ef6121c8a1db6afb99df63dd89e5e03ed77a6cf4e8c94e80d7ad3ca1f1"

URI_aarch64_evolution-bogofilter = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-bogofilter-3.52.4-2.el10_1.aarch64.rpm;name=aarch64_evolution-bogofilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-bogofilter}"
SRC_URI[aarch64_evolution-bogofilter.sha256sum] = "830cbcd3c7c344b3e11ff4c453269e83f74a73eac720127a2689ff644c871bf6"

URI_aarch64_evolution-devel = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-devel-3.52.4-2.el10_1.aarch64.rpm;name=aarch64_evolution-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-devel}"
SRC_URI[aarch64_evolution-devel.sha256sum] = "9dd16f02a724e7741945a9bc2eb32e70f949170aefba68851023df6c8c67e53d"

URI_aarch64_evolution-devel-docs = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-devel-docs-3.52.4-2.el10_1.noarch.rpm;name=aarch64_evolution-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-devel-docs}"
SRC_URI[aarch64_evolution-devel-docs.sha256sum] = "2bc0161d0516209b9d82a1e8f890998b218d2655e657177f1e732c7be3e12e38"

URI_aarch64_evolution-help = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-help-3.52.4-2.el10_1.noarch.rpm;name=aarch64_evolution-help;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-help}"
SRC_URI[aarch64_evolution-help.sha256sum] = "8840deee81dee274550f0d723ce03b75fcee676fec29eaec4823ce8b97934e31"

URI_aarch64_evolution-langpacks = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-langpacks-3.52.4-2.el10_1.noarch.rpm;name=aarch64_evolution-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-langpacks}"
SRC_URI[aarch64_evolution-langpacks.sha256sum] = "b42c306be9ee93adc4c5bbba17b07cd155897062f4840358b2c003fffd67d402"

URI_aarch64_evolution-pst = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-pst-3.52.4-2.el10_1.aarch64.rpm;name=aarch64_evolution-pst;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-pst}"
SRC_URI[aarch64_evolution-pst.sha256sum] = "5527e7820ee0e55e19fd388577addb29f6e64e228842d7ff68b41f20230820af"

URI_aarch64_evolution-spamassassin = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-spamassassin-3.52.4-2.el10_1.aarch64.rpm;name=aarch64_evolution-spamassassin;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-spamassassin}"
SRC_URI[aarch64_evolution-spamassassin.sha256sum] = "68d0c2ad471e83210dc0b46e4358f93a03ec3152a4061ae07fe73231d5efb3df"

RDEPENDS:evolution = " \
 atk \
 cairo \
 cairo-gobject \
 cmark-lib \
 enchant2 \
 evolution-data-server \
 evolution-langpacks \
 gdk-pixbuf2 \
 geocode-glib \
 glib2 \
 glibc \
 gnome-autoar \
 gnome-desktop3 \
 gspell \
 gtk3 \
 gvfs \
 highlight \
 javascriptcoregtk4.1 \
 libcanberra \
 libgweather \
 libical \
 libical-glib \
 libnotify \
 libsecret \
 libsoup3 \
 libxml2 \
 nspr \
 nss \
 openldap \
 pango \
 psmisc \
 sqlite-libs \
 webkit2gtk4.1 \
 "
RDEPENDS:evolution-bogofilter = " \
 bogofilter \
 evolution \
 evolution-data-server \
 glib2 \
 glibc \
 gtk3 \
 "
RDEPENDS:evolution-devel = " \
 enchant2-devel \
 evolution \
 evolution-data-server-devel \
 evolution-devel \
 glib2-devel \
 gnome-desktop3-devel \
 gspell-devel \
 gtk3-devel \
 libgweather-devel \
 libsoup3-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 webkit2gtk4.1-devel \
 "
RDEPENDS:evolution-devel-docs = " \
 devhelp \
 evolution-devel \
 "
RDEPENDS:evolution-help = " \
 evolution \
 yelp \
 "
RDEPENDS:evolution-langpacks = " \
 evolution \
 "
RDEPENDS:evolution-pst = " \
 evolution \
 evolution-data-server \
 glib2 \
 glibc \
 gtk3 \
 libical-glib \
 libpst-libs \
 "
RDEPENDS:evolution-spamassassin = " \
 evolution \
 evolution-data-server \
 glib2 \
 glibc \
 gtk3 \
 spamassassin \
 "
