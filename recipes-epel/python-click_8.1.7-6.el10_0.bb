# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-click"
PV = "8.1.7"
PR = "6.el10_0"
PACKAGES = " \
 python3-click \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-click-8.1.7-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ef129601f33819f7fde102e36ecad95fc83bfb4cf922932c13c265ccf66ebca"

URI_x86_64_v2_python3-click = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-click-8.1.7-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-click;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-click}"
SRC_URI[x86_64_v2_python3-click.sha256sum] = "a78f210607d99d825681cfa65b7c892873af3fb9a008ed3f43c3431e27223c65"

URI_aarch64_python3-click = "${EPEL_MIRROR}/aarch64/Packages/p/python3-click-8.1.7-6.el10_0.noarch.rpm;name=aarch64_python3-click;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-click}"
SRC_URI[aarch64_python3-click.sha256sum] = "c28b53be0a6f4e6977d4369f624d4cf5faea5a6056619f1a584efbe03eda460f"

RDEPENDS:python3-click = " \
 python3 \
 "
