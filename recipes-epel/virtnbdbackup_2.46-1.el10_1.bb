# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virtnbdbackup"
PV = "2.46"
PR = "1.el10_1"
PACKAGES = " \
 virtnbdbackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/virtnbdbackup-2.46-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d29081804e8fcf448d6a38ec177487527c8893effc1756e26d0a9926aed66e4c"

URI_x86_64_v2_virtnbdbackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/virtnbdbackup-2.46-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_virtnbdbackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virtnbdbackup}"
SRC_URI[x86_64_v2_virtnbdbackup.sha256sum] = "35e5ab139d1ab6f93b3d4789670d5ab52bcb1f0bca65cfd47ad19f3c0024693a"

URI_aarch64_virtnbdbackup = "${EPEL_MIRROR}/aarch64/Packages/v/virtnbdbackup-2.46-1.el10_1.noarch.rpm;name=aarch64_virtnbdbackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_virtnbdbackup}"
SRC_URI[aarch64_virtnbdbackup.sha256sum] = "832cffbeaea8881d57cf5c969d70fd53cc697b47938ad9c003a4252eda70fbe7"

RDEPENDS:virtnbdbackup = " \
 nbdkit-python-plugin \
 nbdkit-server \
 openssh-clients \
 python3 \
 python3-colorlog \
 python3-libnbd \
 python3-libvirt \
 python3-lxml \
 python3-lz4 \
 python3-paramiko \
 python3-tqdm \
 python3-typing-extensions \
 qemu-img \
 "
