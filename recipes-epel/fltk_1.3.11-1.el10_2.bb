# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fltk"
PV = "1.3.11"
PR = "1.el10_2"
PACKAGES = " \
 fltk \
 fltk-devel \
 fltk-fluid \
 fltk-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fltk-1.3.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "679ef2929950628abdbfa97cac8a5d70b44bce426ce998b06fe070a805882036"

URI_x86_64_v2_fltk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-1.3.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk}"
SRC_URI[x86_64_v2_fltk.sha256sum] = "1ce5ccbc42ee8fbd8db79e022b8ffb019d00c0c84c313a315efb4e4855523c60"

URI_x86_64_v2_fltk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-devel-1.3.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk-devel}"
SRC_URI[x86_64_v2_fltk-devel.sha256sum] = "01bd5168ce3214335461123f1539231ebc6b3cf042749bd47ea0c7a783d275b1"

URI_x86_64_v2_fltk-fluid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-fluid-1.3.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk-fluid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk-fluid}"
SRC_URI[x86_64_v2_fltk-fluid.sha256sum] = "6a8d3c8177bb7a9fc83cfa7b85003cf716298dd751021961c3c5b14b859f2f41"

URI_x86_64_v2_fltk-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-static-1.3.11-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk-static}"
SRC_URI[x86_64_v2_fltk-static.sha256sum] = "72ef78fecbf33e4f07da79c8e8a4a7255475312c15fa98dc154d5fcb5cf6ee7a"

URI_aarch64_fltk = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-1.3.11-1.el10_2.aarch64.rpm;name=aarch64_fltk;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk}"
SRC_URI[aarch64_fltk.sha256sum] = "1bd784c53686804fc25c236607c7f1dd7911e477f08551c575f5cb33106fca15"

URI_aarch64_fltk-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-devel-1.3.11-1.el10_2.aarch64.rpm;name=aarch64_fltk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk-devel}"
SRC_URI[aarch64_fltk-devel.sha256sum] = "111ef642a4ef369963672d0a6398218e951f179df07c68ca009132668520c1e1"

URI_aarch64_fltk-fluid = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-fluid-1.3.11-1.el10_2.aarch64.rpm;name=aarch64_fltk-fluid;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk-fluid}"
SRC_URI[aarch64_fltk-fluid.sha256sum] = "a410229b70b2eb10f93dff4c5489077118f2f7437eb2c6977c94d786ef007a08"

URI_aarch64_fltk-static = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-static-1.3.11-1.el10_2.aarch64.rpm;name=aarch64_fltk-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk-static}"
SRC_URI[aarch64_fltk-static.sha256sum] = "8f12feac05a1389dea49d175ea919ffce86e2b2b3577db7b960bd50f2757ead0"

RDEPENDS:fltk = " \
 fontconfig \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXft \
 libXinerama \
 libXrender \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 "
RDEPENDS:fltk-devel = " \
 bash \
 cmake-filesystem \
 fltk \
 fontconfig-devel \
 libICE-devel \
 libSM-devel \
 libX11-devel \
 libXft-devel \
 libXt-devel \
 libglvnd-devel \
 libjpeg-turbo-devel \
 libpng-devel \
 libstdc++-devel \
 mesa-libGLU-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:fltk-fluid = " \
 fltk \
 fltk-devel \
 fontconfig \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXft \
 libXinerama \
 libXrender \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 "
RDEPENDS:fltk-static = " \
 fltk-devel \
 "
