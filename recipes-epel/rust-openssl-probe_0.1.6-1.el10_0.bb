# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl-probe"
PV = "0.1.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-openssl-probe+default-devel \
 rust-openssl-probe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-probe-0.1.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afb893654d9efd5489a98c9517be4bb3ff4a83a73a73cf3d3c614a6c4fa7b5ac"

URI_x86_64_v2_rust-openssl-probe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-probe+default-devel-0.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-probe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-probe+default-devel}"
SRC_URI[x86_64_v2_rust-openssl-probe+default-devel.sha256sum] = "b33543adbc8b47be727b4e00dc6fe11516cb522f94ce3aa392286b9f7a6264e2"

URI_x86_64_v2_rust-openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-probe-devel-0.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-openssl-probe-devel.sha256sum] = "74a756839e0dda5db7cf8f49bdc8f2b906a9ee5558bb52122839c3f1f9fdfb23"

URI_aarch64_rust-openssl-probe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-probe+default-devel-0.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-openssl-probe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-probe+default-devel}"
SRC_URI[aarch64_rust-openssl-probe+default-devel.sha256sum] = "f9106de43ddef3e00ca0967b30107bfb336e15bdd0eb80113dfb795841fb33b8"

URI_aarch64_rust-openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-probe-devel-0.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-probe-devel}"
SRC_URI[aarch64_rust-openssl-probe-devel.sha256sum] = "c6b8f0097948dc5d59a2c67ac59382309e01d5f470e3d1620241dd9e2a9929bf"

RDEPENDS:rust-openssl-probe+default-devel = " \
 cargo \
 rust-openssl-probe-devel \
 "
RDEPENDS:rust-openssl-probe-devel = " \
 cargo \
 rust \
 "
