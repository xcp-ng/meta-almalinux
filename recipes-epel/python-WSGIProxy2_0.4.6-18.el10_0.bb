# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-WSGIProxy2"
PV = "0.4.6"
PR = "18.el10_0"
PACKAGES = " \
 python3-WSGIProxy2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-WSGIProxy2-0.4.6-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e568932b760c7ee0fdfd7c8dff9d73800a71d2061f54004385d61f18af5682a6"

URI_x86_64_v2_python3-WSGIProxy2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-WSGIProxy2-0.4.6-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-WSGIProxy2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-WSGIProxy2}"
SRC_URI[x86_64_v2_python3-WSGIProxy2.sha256sum] = "fa1e7bf39ab26ddad67693b0624b118a877abbf709447d5d98d5b00459ddd556"

URI_aarch64_python3-WSGIProxy2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-WSGIProxy2-0.4.6-18.el10_0.noarch.rpm;name=aarch64_python3-WSGIProxy2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-WSGIProxy2}"
SRC_URI[aarch64_python3-WSGIProxy2.sha256sum] = "676be03951354614bf11a3758ad9283c91248581e8b1e32a56502c888e9962d2"

RDEPENDS:python3-WSGIProxy2 = " \
 python3 \
 python3-six \
 python3-webob \
 "
