# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hash32"
PV = "0.3.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-hash32+default-devel \
 rust-hash32-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hash32-0.3.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a84752428050cc0160682fc4669d6951e60063764ccb509f1cc491ff824073b"

URI_x86_64_v2_rust-hash32+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hash32+default-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hash32+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hash32+default-devel}"
SRC_URI[x86_64_v2_rust-hash32+default-devel.sha256sum] = "5cc2bcb75def635867da165217162deab8adf015ded2df8b063692c391324522"

URI_x86_64_v2_rust-hash32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hash32-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hash32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hash32-devel}"
SRC_URI[x86_64_v2_rust-hash32-devel.sha256sum] = "01ffdedaabbfa9aa13e74bfa31d8b1a674a17fd8e489e0d841b5c4f2e9d39bba"

URI_aarch64_rust-hash32+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hash32+default-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-hash32+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hash32+default-devel}"
SRC_URI[aarch64_rust-hash32+default-devel.sha256sum] = "fc4e92b1da2944c386e194856756e54fee429c52f87337114200d314d165cf72"

URI_aarch64_rust-hash32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hash32-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-hash32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hash32-devel}"
SRC_URI[aarch64_rust-hash32-devel.sha256sum] = "4a806df08cb18140cb83d5d6e2d8ae34df0fa77a7c1ea46e2709846cd0279507"

RDEPENDS:rust-hash32+default-devel = " \
 cargo \
 rust-hash32-devel \
 "
RDEPENDS:rust-hash32-devel = " \
 cargo \
 rust-byteorder-devel \
 "
