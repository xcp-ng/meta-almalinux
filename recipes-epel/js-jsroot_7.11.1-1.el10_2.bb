# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "js-jsroot"
PV = "7.11.1"
PR = "1.el10_2"
PACKAGES = " \
 js-jsroot \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/js-jsroot-7.11.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "040caac7ed7dabac7b420b3e51332d1e3f607de3e773d2015336b88c2f37bb1a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-jsroot-7.11.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_js-jsroot;unpack=0"
SRC_URI[x86_64_v2_js-jsroot.sha256sum] = "c122936975f0ed114636c076aa7584a5f9e62c4f9d2d2b3922e8b081cde3f532"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/js-jsroot-7.11.1-1.el10_2.noarch.rpm;name=aarch64_js-jsroot;unpack=0"
SRC_URI[aarch64_js-jsroot.sha256sum] = "d6dd3efbc3a4422416cda5c5a4dbc18ef3590294c9fe93eb68e8c2646eab7372"

RDEPENDS:js-jsroot = " \
 mathjax3 \
 web-assets-filesystem \
 "
