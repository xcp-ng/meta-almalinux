# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipset"
PV = "7.22"
PR = "7.el10_0"
PACKAGES = " \
 ipset \
 ipset-devel \
 ipset-libs \
 ipset-service \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ipset-7.22-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3455bf1f909c1f8c2452cbd0d153fbe5db1b7b694ccc4fff712181ffbfa97b1"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ipset: (kernel-64k-debug-modules-extra if kernel-64k-debug-core)
# - ipset: (kernel-64k-modules-extra if kernel-64k-core)
# - ipset: (kernel-rt-64k-debug-modules-extra if kernel-rt-64k-debug-core)
# - ipset: (kernel-rt-64k-modules-extra if kernel-rt-64k-core)
# - ipset: (kernel-rt-debug-modules-extra if kernel-rt-debug-core)
# - ipset: (kernel-rt-modules-extra if kernel-rt-core)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - ipset: (kernel-rt-64k-debug-modules-extra if kernel-rt-64k-debug-core)
# - ipset: (kernel-rt-64k-modules-extra if kernel-rt-64k-core)
# - ipset: (kernel-rt-debug-modules-extra if kernel-rt-debug-core)
# - ipset: (kernel-rt-modules-extra if kernel-rt-core)

URI_x86_64_v2_ipset = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipset-7.22-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_ipset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset}"
SRC_URI[x86_64_v2_ipset.sha256sum] = "ca48af4eb285c897dab514f692aee76d9b0d093cf4284db51494fa5ae9ec5a8e"

URI_x86_64_v2_ipset-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ipset-devel-7.22-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_ipset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset-devel}"
SRC_URI[x86_64_v2_ipset-devel.sha256sum] = "45783c8f8f28a8174c46a0a2b28f51d136205c010474f798d75b540f2361503c"

URI_x86_64_v2_ipset-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipset-libs-7.22-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_ipset-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset-libs}"
SRC_URI[x86_64_v2_ipset-libs.sha256sum] = "ed6bdca66f44ea2af6a37a83a634f634291bacc0aac36c3c97494a14fbc1c8d2"

URI_x86_64_v2_ipset-service = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipset-service-7.22-7.el10_0.noarch.rpm;name=x86_64_v2_ipset-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset-service}"
SRC_URI[x86_64_v2_ipset-service.sha256sum] = "6ea6be083eda363053ffa2e884272af2410e9021f7890a228d550a7da88ffe39"

URI_aarch64_ipset = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipset-7.22-7.el10_0.aarch64.rpm;name=aarch64_ipset;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset}"
SRC_URI[aarch64_ipset.sha256sum] = "b473881ea0ea2a3f091203132ff7f110a79f3fe4eb50eff972abaedd94fb04f1"

URI_aarch64_ipset-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ipset-devel-7.22-7.el10_0.aarch64.rpm;name=aarch64_ipset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset-devel}"
SRC_URI[aarch64_ipset-devel.sha256sum] = "91e35460d12bebf4a6d399ad9ebb7d0af95c8dde5ce014a84f43b0df690ff063"

URI_aarch64_ipset-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipset-libs-7.22-7.el10_0.aarch64.rpm;name=aarch64_ipset-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset-libs}"
SRC_URI[aarch64_ipset-libs.sha256sum] = "0f3fa13018be476dd2f5531fc08cf48e51e21bbb2f83676eff11277f06cd4c7b"

URI_aarch64_ipset-service = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipset-service-7.22-7.el10_0.noarch.rpm;name=aarch64_ipset-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset-service}"
SRC_URI[aarch64_ipset-service.sha256sum] = "6ea6be083eda363053ffa2e884272af2410e9021f7890a228d550a7da88ffe39"

RDEPENDS:ipset:x86_64_v2 = " \
 bash \
 glibc \
 ipset-libs \
 kernel-debug-modules-extra \
 kernel-modules-extra \
"
RDEPENDS:ipset:aarch64 = " \
 bash \
 glibc \
 ipset-libs \
 kernel-64k-debug-modules-extra \
 kernel-64k-modules-extra \
 kernel-debug-modules-extra \
 kernel-modules-extra \
"
RDEPENDS:ipset-devel = " \
 ipset-libs \
 kernel-headers \
 libmnl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ipset-libs = " \
 glibc \
 libmnl \
 "
RDEPENDS:ipset-service = " \
 bash \
 ipset \
 iptables-nft-services \
 systemd \
 "
