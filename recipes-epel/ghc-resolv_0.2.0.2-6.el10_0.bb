# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-resolv"
PV = "0.2.0.2"
PR = "6.el10_0"
PACKAGES = " \
 ghc-resolv \
 ghc-resolv-devel \
 ghc-resolv-doc \
 ghc-resolv-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-resolv-0.2.0.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62fb0e728e586c1156a4afb3f303419c133066946ffd940fbb81dbb3e33c0a90"

URI_x86_64_v2_ghc-resolv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-resolv-0.2.0.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-resolv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-resolv}"
SRC_URI[x86_64_v2_ghc-resolv.sha256sum] = "5b14b3096f373b267dd24691479933664de78d4ff4b4bef757ebb03813e2540b"

URI_x86_64_v2_ghc-resolv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-resolv-devel-0.2.0.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-resolv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-resolv-devel}"
SRC_URI[x86_64_v2_ghc-resolv-devel.sha256sum] = "391cf07c4804716e4c386162546ebb4b756ef0a38aa575e1aa7069cc544bf906"

URI_x86_64_v2_ghc-resolv-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-resolv-doc-0.2.0.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-resolv-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-resolv-doc}"
SRC_URI[x86_64_v2_ghc-resolv-doc.sha256sum] = "19300d42e1677e15fb7eeadcaffa9d8cf02144cf44ecd7be343750b22f8a0b88"

URI_x86_64_v2_ghc-resolv-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-resolv-prof-0.2.0.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-resolv-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-resolv-prof}"
SRC_URI[x86_64_v2_ghc-resolv-prof.sha256sum] = "47e09c35f7213593ab371a6fef7c9c6fc655d9cec5948db1a2eda067ca3ac5f5"

URI_aarch64_ghc-resolv = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-resolv-0.2.0.2-6.el10_0.aarch64.rpm;name=aarch64_ghc-resolv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-resolv}"
SRC_URI[aarch64_ghc-resolv.sha256sum] = "3cf2914ae00408735a72e994c326b57c5ad0bc4177bdf42c5d3bf048748ad171"

URI_aarch64_ghc-resolv-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-resolv-devel-0.2.0.2-6.el10_0.aarch64.rpm;name=aarch64_ghc-resolv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-resolv-devel}"
SRC_URI[aarch64_ghc-resolv-devel.sha256sum] = "a03ed9120b7ca28029a39352bbe1e3732307f65d3908f7f89102640a522dbef5"

URI_aarch64_ghc-resolv-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-resolv-doc-0.2.0.2-6.el10_0.noarch.rpm;name=aarch64_ghc-resolv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-resolv-doc}"
SRC_URI[aarch64_ghc-resolv-doc.sha256sum] = "1e6ff13e00ba1ca781682522398d7cfc1fdc35fcb5dafb2fd6348944c251ee12"

URI_aarch64_ghc-resolv-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-resolv-prof-0.2.0.2-6.el10_0.aarch64.rpm;name=aarch64_ghc-resolv-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-resolv-prof}"
SRC_URI[aarch64_ghc-resolv-prof.sha256sum] = "8a7ae87930383bd83e9e25a1ee5890f87e0d9747c5d89057f36bb4a00736e230"

RDEPENDS:ghc-resolv = " \
 ghc-array \
 ghc-base \
 ghc-base16-bytestring \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-resolv-devel = " \
 ghc-base-devel \
 ghc-base16-bytestring-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-resolv \
 "
RDEPENDS:ghc-resolv-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-resolv-prof = " \
 ghc-base-prof \
 ghc-base16-bytestring-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-resolv-devel \
 "
