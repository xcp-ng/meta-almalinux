# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-neovim"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 python-neovim-doc \
 python3-neovim \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-neovim-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03ad68be14abb8e15e1f62bd73eac8d3743e9c5516df13569f5f67a7b30b4498"

URI_x86_64_v2_python-neovim-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-neovim-doc-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-neovim-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-neovim-doc}"
SRC_URI[x86_64_v2_python-neovim-doc.sha256sum] = "6d18341eb32a611b830dfb17a5cdfacb932620ebd5d50e8ff9973ab6504b4048"

URI_x86_64_v2_python3-neovim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-neovim-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-neovim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-neovim}"
SRC_URI[x86_64_v2_python3-neovim.sha256sum] = "843e0733d45ae735d3347eb5887844721bbf4c96e231fc33c396bd4b6cefe54b"

URI_aarch64_python-neovim-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-neovim-doc-0.6.0-1.el10_2.noarch.rpm;name=aarch64_python-neovim-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-neovim-doc}"
SRC_URI[aarch64_python-neovim-doc.sha256sum] = "176ac1727a8a2b01a072f1526ede144e3737e72727019870a986892994c2b34a"

URI_aarch64_python3-neovim = "${EPEL_MIRROR}/aarch64/Packages/p/python3-neovim-0.6.0-1.el10_2.noarch.rpm;name=aarch64_python3-neovim;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-neovim}"
SRC_URI[aarch64_python3-neovim.sha256sum] = "9fb1c8878262dc5026196b2533ac4650c4ad3bc8905f6019ae09ecd719725459"

RDEPENDS:python-neovim-doc = " \
 "
RDEPENDS:python3-neovim = " \
 neovim \
 python3 \
 python3-greenlet \
 python3-msgpack \
 "
