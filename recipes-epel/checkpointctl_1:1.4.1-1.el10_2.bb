# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "checkpointctl"
PE = "1"
PV = "1.4.1"
PR = "1.el10_2"
PACKAGES = " \
 checkpointctl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/checkpointctl-1.4.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3277bb09207735d3da37ffdc246d3a28414bf569be7da5116f0126be9d3fc2e6"

URI_x86_64_v2_checkpointctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/checkpointctl-1.4.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_checkpointctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_checkpointctl}"
SRC_URI[x86_64_v2_checkpointctl.sha256sum] = "dbe83bb1efe0551bbd098c71d74e477956e4584e9108fd880c4342e5a142c64b"

URI_aarch64_checkpointctl = "${EPEL_MIRROR}/aarch64/Packages/c/checkpointctl-1.4.1-1.el10_2.aarch64.rpm;name=aarch64_checkpointctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_checkpointctl}"
SRC_URI[aarch64_checkpointctl.sha256sum] = "af0f89c50bbfb8ea2dd58aa9d1b1087d9a4dee343662ba675c02a935cee92c47"

RDEPENDS:checkpointctl = " \
 glibc \
 "
