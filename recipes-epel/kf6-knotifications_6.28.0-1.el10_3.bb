# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knotifications"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-knotifications \
 kf6-knotifications-devel \
 kf6-knotifications-doc \
 kf6-knotifications-html \
 python3-kf6-knotifications \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knotifications-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cda580a78edcf3c9611dc5493621f941233aa35daa16f441bcfce9cceb3efbd1"

URI_x86_64_v2_kf6-knotifications = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications}"
SRC_URI[x86_64_v2_kf6-knotifications.sha256sum] = "bf5277f1897267d24fbf077ba6a22fca5b9c97fb75e89416ac34141da52fa237"

URI_x86_64_v2_kf6-knotifications-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifications-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-devel}"
SRC_URI[x86_64_v2_kf6-knotifications-devel.sha256sum] = "cddc8ec0ef27b2d23b74275f2129a619b859e3575306a23dc5089e7896248e24"

URI_x86_64_v2_kf6-knotifications-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifications-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-doc}"
SRC_URI[x86_64_v2_kf6-knotifications-doc.sha256sum] = "bb9af366cb285672e129ac997c36185e00482c4f807d6dd8390e5d23b4966bdf"

URI_x86_64_v2_kf6-knotifications-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifications-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-html}"
SRC_URI[x86_64_v2_kf6-knotifications-html.sha256sum] = "f87af5467e0fcaf0b07fba3936c0a43a0878daad0702d4621613062c8ecaf6db"

URI_x86_64_v2_python3-kf6-knotifications = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-knotifications-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-knotifications}"
SRC_URI[x86_64_v2_python3-kf6-knotifications.sha256sum] = "f360f75859c36aa0ee43f59bd0c59ce928c525e0883c00513799be10f3340101"

URI_aarch64_kf6-knotifications = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications}"
SRC_URI[aarch64_kf6-knotifications.sha256sum] = "e550948f6399ca4a9083659a29b89f1e36aa4021250f4ea85c787b25eed3c3eb"

URI_aarch64_kf6-knotifications-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knotifications-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-devel}"
SRC_URI[aarch64_kf6-knotifications-devel.sha256sum] = "ad34616b3deb547ca504d5e27f979a773db4ea3d91dca8e4b484da0d2e21db29"

URI_aarch64_kf6-knotifications-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knotifications-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-doc}"
SRC_URI[aarch64_kf6-knotifications-doc.sha256sum] = "0f297d2c2ce554656de10a76a5490e510ff585843f79cdc6e192856225f6d5fa"

URI_aarch64_kf6-knotifications-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knotifications-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-html}"
SRC_URI[aarch64_kf6-knotifications-html.sha256sum] = "e02e5245d62931e28de011cfd3e855077dfa26b9600e6cc79b7bb39a48ac13bb"

URI_aarch64_python3-kf6-knotifications = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-knotifications-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-knotifications}"
SRC_URI[aarch64_python3-kf6-knotifications.sha256sum] = "3fde4e6817bc6f947254127a8f4c3c5ab23d7a1a162dd35db11cc7ac86947942"

RDEPENDS:kf6-knotifications = " \
 glibc \
 kf6-kconfig \
 libcanberra \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-knotifications-devel = " \
 cmake-filesystem \
 kf6-knotifications \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-knotifications-doc = " \
 "
RDEPENDS:kf6-knotifications-html = " \
 "
RDEPENDS:python3-kf6-knotifications = " \
 glibc \
 kf6-knotifications \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
