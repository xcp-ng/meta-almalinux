# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-milou"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-milou \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-milou-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ec0378f8225dac7a1c4868bc49ba7f9ae24b0893905e157dfb3336ed26ddf73"

URI_x86_64_v2_plasma-milou = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-milou-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-milou;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-milou}"
SRC_URI[x86_64_v2_plasma-milou.sha256sum] = "5585d3a86c98cfdf1e52d56882a549018569f9eaecf7c1237a54d8a46ff5b9d3"

URI_aarch64_plasma-milou = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-milou-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-milou;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-milou}"
SRC_URI[aarch64_plasma-milou.sha256sum] = "34ddf581d8a8fbd6cefe6bb8f820ac7a9c9938d7fe0c9c8884ec28e29ec19b59"

RDEPENDS:plasma-milou = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-krunner \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
