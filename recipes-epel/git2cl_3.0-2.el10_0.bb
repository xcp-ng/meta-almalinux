# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git2cl"
PV = "3.0"
PR = "2.el10_0"
PACKAGES = " \
 git2cl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git2cl-3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b0b59f7f69a0f1764b76e534f125de6db724b005462140f4833cd4f00bd0db4"

URI_x86_64_v2_git2cl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git2cl-3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_git2cl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git2cl}"
SRC_URI[x86_64_v2_git2cl.sha256sum] = "835b6fd388c3494a298d96ebab5ac3490838320c3ab5f3ad1f31347a352b1d1a"

URI_aarch64_git2cl = "${EPEL_MIRROR}/aarch64/Packages/g/git2cl-3.0-2.el10_0.noarch.rpm;name=aarch64_git2cl;unpack=0"
SRC_URI:append = " ${URI_aarch64_git2cl}"
SRC_URI[aarch64_git2cl.sha256sum] = "1f8fa27f0e472115c1ca0fb8971d434f0886dc853f94de160c44d7ea5732616b"

RDEPENDS:git2cl = " \
 git \
 perl-FileHandle \
 perl-POSIX \
 perl-Text-Tabs+Wrap \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-open \
 "
