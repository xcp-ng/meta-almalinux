# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trybuild"
PV = "1.0.120"
PR = "1.el10_2"
PACKAGES = " \
 rust-trybuild+default-devel \
 rust-trybuild+diff-devel \
 rust-trybuild-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-trybuild-1.0.120-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eaa7a3c7437e24f852f4b66cd0f3b1ee468954e0714f63c13479a7daccac347f"

URI_x86_64_v2_rust-trybuild+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild+default-devel-1.0.120-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild+default-devel}"
SRC_URI[x86_64_v2_rust-trybuild+default-devel.sha256sum] = "5000bb4b01f222696b848966d48409a664b3fd726ded2f7ed980ffe3166f14bd"

URI_x86_64_v2_rust-trybuild+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild+diff-devel-1.0.120-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild+diff-devel}"
SRC_URI[x86_64_v2_rust-trybuild+diff-devel.sha256sum] = "4413c311a38f076f725a95c19cd51128f56ed68ddc484f9c29a0da10db8815a1"

URI_x86_64_v2_rust-trybuild-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild-devel-1.0.120-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild-devel}"
SRC_URI[x86_64_v2_rust-trybuild-devel.sha256sum] = "246a3279adada49afc8d31abcbe8a7eae9c2486f8250e9efed39354427314844"

URI_aarch64_rust-trybuild+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild+default-devel-1.0.120-1.el10_2.noarch.rpm;name=aarch64_rust-trybuild+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild+default-devel}"
SRC_URI[aarch64_rust-trybuild+default-devel.sha256sum] = "225d43df7d8e4bfd548b2c1133954b91fcfaea2061491f87b6ecccc857de260b"

URI_aarch64_rust-trybuild+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild+diff-devel-1.0.120-1.el10_2.noarch.rpm;name=aarch64_rust-trybuild+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild+diff-devel}"
SRC_URI[aarch64_rust-trybuild+diff-devel.sha256sum] = "7c81a4644c736bc712d7fb5b99cc7749c529c7df90c983120b091da6984b07e8"

URI_aarch64_rust-trybuild-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild-devel-1.0.120-1.el10_2.noarch.rpm;name=aarch64_rust-trybuild-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild-devel}"
SRC_URI[aarch64_rust-trybuild-devel.sha256sum] = "fec8fdb7e27b8beb9fda9748a495d68eb5c45811a8772aea6a22433eb337267e"

RDEPENDS:rust-trybuild+default-devel = " \
 cargo \
 rust-trybuild-devel \
 "
RDEPENDS:rust-trybuild+diff-devel = " \
 cargo \
 rust-dissimilar+default-devel \
 rust-trybuild-devel \
 "
RDEPENDS:rust-trybuild-devel = " \
 cargo \
 rust \
 rust-glob+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-target-triple+default-devel \
 rust-termcolor+default-devel \
 rust-toml+default-devel \
 "
