# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtconnectivity"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtconnectivity \
 qt5-qtconnectivity-devel \
 qt5-qtconnectivity-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtconnectivity-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a74b2dff6c234d3b2b20219f8f0ed79d635f2822c3258d430cc9ccdde68c856"

URI_x86_64_v2_qt5-qtconnectivity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconnectivity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity}"
SRC_URI[x86_64_v2_qt5-qtconnectivity.sha256sum] = "97242e6ea8dc5c8c87fa1f0cc0b876e84ff3e0955a353bfe7ba3e08b91b61fe6"

URI_x86_64_v2_qt5-qtconnectivity-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconnectivity-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity-devel}"
SRC_URI[x86_64_v2_qt5-qtconnectivity-devel.sha256sum] = "e9182a61fecc4029d5e8689ba267f08bea8177b5563e7fc01e030388cd9364a9"

URI_x86_64_v2_qt5-qtconnectivity-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtconnectivity-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtconnectivity-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtconnectivity-examples}"
SRC_URI[x86_64_v2_qt5-qtconnectivity-examples.sha256sum] = "838eb50ec228e2549b40888d84c2ca4477776627b4eab042592459c43afaa7bc"

URI_aarch64_qt5-qtconnectivity = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtconnectivity;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity}"
SRC_URI[aarch64_qt5-qtconnectivity.sha256sum] = "f8ce53f91e8acd41ee0e0953ad791ff5cff353aefec061665e217902348e1933"

URI_aarch64_qt5-qtconnectivity-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtconnectivity-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity-devel}"
SRC_URI[aarch64_qt5-qtconnectivity-devel.sha256sum] = "211c6fed328758af5750a69763c2394088ab05da76d151a63b8fad5c4344a2ef"

URI_aarch64_qt5-qtconnectivity-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtconnectivity-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtconnectivity-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtconnectivity-examples}"
SRC_URI[aarch64_qt5-qtconnectivity-examples.sha256sum] = "a1a08da65c8862cc21dd55216bbe2611541315fad60ec8680ccc5a220e476d1d"

RDEPENDS:qt5-qtconnectivity = " \
 bluez-libs \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtconnectivity-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtconnectivity \
 "
RDEPENDS:qt5-qtconnectivity-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtconnectivity \
 qt5-qtdeclarative \
 "
