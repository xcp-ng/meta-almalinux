# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awf-gtk2"
PV = "4.1.0"
PR = "1.el10_1"
PACKAGES = " \
 awf-gtk2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/awf-gtk2-4.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c34d3ce81c22151e0e85d949ff1a16523b5209ece1102d9819c7380335f8c3a"

URI_x86_64_v2_awf-gtk2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/awf-gtk2-4.1.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_awf-gtk2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awf-gtk2}"
SRC_URI[x86_64_v2_awf-gtk2.sha256sum] = "47379e18d46233c58bbbdab9143e62bd48abf0d799f71cff61921415abdd0edd"

URI_aarch64_awf-gtk2 = "${EPEL_MIRROR}/aarch64/Packages/a/awf-gtk2-4.1.0-1.el10_1.aarch64.rpm;name=aarch64_awf-gtk2;unpack=0"
SRC_URI:append = " ${URI_aarch64_awf-gtk2}"
SRC_URI[aarch64_awf-gtk2.sha256sum] = "7dc67c805d739c8b76afcaf4868fed7cfa7d7406d38c5bd71e452bcdf3bd5b83"

RDEPENDS:awf-gtk2 = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 hicolor-icon-theme \
 libnotify \
 pango \
 "
