# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netcat"
PV = "1.237"
PR = "1.el10_1"
PACKAGES = " \
 netcat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netcat-1.237-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "546bb2eaa33660147f277a95e50977b8b5e4d0c774679fc1510b2679cd4fcba9"

URI_x86_64_v2_netcat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcat-1.237-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcat}"
SRC_URI[x86_64_v2_netcat.sha256sum] = "3f0af85bbbb185675d6b4cae3885900c54bf2af457341028ac98bc995457ab6b"

URI_aarch64_netcat = "${EPEL_MIRROR}/aarch64/Packages/n/netcat-1.237-1.el10_1.aarch64.rpm;name=aarch64_netcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcat}"
SRC_URI[aarch64_netcat.sha256sum] = "e41b36df40a8d60108fb91916bf1d731a2324f73d14fbe7d0e92b0a9508ffbc0"

RDEPENDS:netcat = " \
 alternatives \
 bash \
 glibc \
 libbsd \
 libretls \
 "
