# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-attica"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-attica \
 kf6-attica-devel \
 kf6-attica-doc \
 kf6-attica-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-attica-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c6a3341e5e3bb817b6beffcee898721b3ef2cbe1ca46dad33327bc4b9d00efb"

URI_x86_64_v2_kf6-attica = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-attica;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica}"
SRC_URI[x86_64_v2_kf6-attica.sha256sum] = "517a1acad3d9c2a5f06d2d3c76f777701d51c499fba3e7a3efa0de388590e538"

URI_x86_64_v2_kf6-attica-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-attica-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-devel}"
SRC_URI[x86_64_v2_kf6-attica-devel.sha256sum] = "4a7fad3fffca1866f0444d4fade673923709bc3793f8f59d4f0949f33176637b"

URI_x86_64_v2_kf6-attica-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-attica-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-doc}"
SRC_URI[x86_64_v2_kf6-attica-doc.sha256sum] = "11a739cff1f33e8a0eda4a39f499650fccb03f3166991869702a89bef823cd79"

URI_x86_64_v2_kf6-attica-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-attica-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-attica-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-attica-html}"
SRC_URI[x86_64_v2_kf6-attica-html.sha256sum] = "0347f88043e83ccf0779a4091be4b9754f9c32d5f5a23af5646ff9b9dc48f1b6"

URI_aarch64_kf6-attica = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-attica;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica}"
SRC_URI[aarch64_kf6-attica.sha256sum] = "b3edd1aac34bbe2791859c6589b9607520d7ee3e67094a28296fd8e6fefe51b9"

URI_aarch64_kf6-attica-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-attica-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-devel}"
SRC_URI[aarch64_kf6-attica-devel.sha256sum] = "824a89ebbe521db37f1920e890a61c7ee61502621e70910c8bcfa2285663880c"

URI_aarch64_kf6-attica-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-attica-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-doc}"
SRC_URI[aarch64_kf6-attica-doc.sha256sum] = "0af5915cc5dc561f94c98c9acc815eec4c785956bfdb21c264a30e41093f92c1"

URI_aarch64_kf6-attica-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-attica-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-attica-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-attica-html}"
SRC_URI[aarch64_kf6-attica-html.sha256sum] = "6e32b0baab1b9f0ccf4121e6756ef4cf65788681a39c4b4ebe1fb341fcd79644"

RDEPENDS:kf6-attica = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-attica-devel = " \
 cmake-filesystem \
 kf6-attica \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-attica-doc = " \
 "
RDEPENDS:kf6-attica-html = " \
 "
