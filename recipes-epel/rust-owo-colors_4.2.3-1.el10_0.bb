# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-owo-colors"
PV = "4.2.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-owo-colors+alloc-devel \
 rust-owo-colors+default-devel \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors+supports-colors-devel \
 rust-owo-colors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-owo-colors-4.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "376819e926f6417a0bc14e8336405d78e8130bb401e789a184249ea45ecbf4c5"

URI_x86_64_v2_rust-owo-colors+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+alloc-devel-4.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+alloc-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+alloc-devel.sha256sum] = "232270cd4479b13acadde50095afe6278f215825d96e403338a7da723ded36e2"

URI_x86_64_v2_rust-owo-colors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+default-devel-4.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+default-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+default-devel.sha256sum] = "a08ce3c819e7559fec5a1d82c67d39ed17abfacb07759072cbc378fd37e5fcdd"

URI_x86_64_v2_rust-owo-colors+supports-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-color-devel-4.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+supports-color-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+supports-color-devel.sha256sum] = "ee338c500c4ec0ea775d741f9dbd01ff1238ff135b1b0265625ee215f80e8ccf"

URI_x86_64_v2_rust-owo-colors+supports-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-colors-devel-4.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+supports-colors-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+supports-colors-devel.sha256sum] = "d35b7588d2d915c7b87f5cbbe62134cdcee4cd60b9a5557530692e14917772c7"

URI_x86_64_v2_rust-owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors-devel-4.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors-devel}"
SRC_URI[x86_64_v2_rust-owo-colors-devel.sha256sum] = "4238eda6031ff9c93d398b1f9815c7c4899914cd8107516dcc4e4fa8919dfe21"
RPROVIDES:rust-owo-colors-devel:x86_64_v2 = "virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

URI_aarch64_rust-owo-colors+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+alloc-devel-4.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+alloc-devel}"
SRC_URI[aarch64_rust-owo-colors+alloc-devel.sha256sum] = "91423618bff317d1e53c184d79f019a3d99238d46fdb4c577bb15aaba55b7b8c"

URI_aarch64_rust-owo-colors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+default-devel-4.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-owo-colors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+default-devel}"
SRC_URI[aarch64_rust-owo-colors+default-devel.sha256sum] = "3f1de4c5c15ab7111b6df0fb4e6d48e33b8cd75539c8b04fc5040434bccd259d"

URI_aarch64_rust-owo-colors+supports-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-color-devel-4.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+supports-color-devel}"
SRC_URI[aarch64_rust-owo-colors+supports-color-devel.sha256sum] = "c2bd32c1a761e37ee89c8a426187ddc0adb145a9296a978f22ac8963a8438100"

URI_aarch64_rust-owo-colors+supports-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-colors-devel-4.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+supports-colors-devel}"
SRC_URI[aarch64_rust-owo-colors+supports-colors-devel.sha256sum] = "47d4ea1907cf5e372d608b9d5fc401bb6148006c262c009635ec8a645eceb207"

URI_aarch64_rust-owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors-devel-4.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors-devel}"
SRC_URI[aarch64_rust-owo-colors-devel.sha256sum] = "f546be52965d9462ad7e806b7e73b7d027c60e9aa31bc903de439f9b4adba403"
RPROVIDES:rust-owo-colors-devel:aarch64 = "virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

RDEPENDS:rust-owo-colors+alloc-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+default-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+supports-color-devel = " \
 cargo \
 rust-owo-colors-devel \
 rust-supports-color+default-devel \
 "
RDEPENDS:rust-owo-colors+supports-colors-devel = " \
 cargo \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors-devel \
 rust-supports-color2+default-devel \
 "
RDEPENDS:rust-owo-colors-devel = " \
 bash \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"
