# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-greenlet"
PV = "3.0.3"
PR = "5.el10"
PACKAGES = " \
 python3-greenlet \
 python3-greenlet-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-greenlet-3.0.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50fb28e565f9b43ee411681cf28b62f5be1a0b9e0c080829a6852022922bcc2e"

URI_x86_64_v2_python3-greenlet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-greenlet-3.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-greenlet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-greenlet}"
SRC_URI[x86_64_v2_python3-greenlet.sha256sum] = "0d0300ea363b6226c48918c63c837d40c65bdace2929545d68f391209984721f"

URI_x86_64_v2_python3-greenlet-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-greenlet-devel-3.0.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-greenlet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-greenlet-devel}"
SRC_URI[x86_64_v2_python3-greenlet-devel.sha256sum] = "a25f42e17050b0e5751089e0de567a92ddfc6e43c9a10da0633cf0bc1d605315"

URI_aarch64_python3-greenlet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-greenlet-3.0.3-5.el10.aarch64.rpm;name=aarch64_python3-greenlet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-greenlet}"
SRC_URI[aarch64_python3-greenlet.sha256sum] = "b3b78b18ae580b0f1830f4fdb4b8329f235194d1fa25e525411653f4fb258ffe"

URI_aarch64_python3-greenlet-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-greenlet-devel-3.0.3-5.el10.aarch64.rpm;name=aarch64_python3-greenlet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-greenlet-devel}"
SRC_URI[aarch64_python3-greenlet-devel.sha256sum] = "e5ebda1488f32ad3ff40646a1a659d691c67af01eb80e5f50e3577337814f905"

RDEPENDS:python3-greenlet = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:python3-greenlet-devel = " \
 python3-greenlet \
 "
