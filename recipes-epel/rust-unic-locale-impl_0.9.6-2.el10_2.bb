# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-locale-impl"
PV = "0.9.6"
PR = "2.el10_2"
PACKAGES = " \
 rust-unic-locale-impl+default-devel \
 rust-unic-locale-impl+likelysubtags-devel \
 rust-unic-locale-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-locale-impl-0.9.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3565cb56033a78bfc3f5ae3a54adfbcd883d24d647a968d73ba4b81b42549250"

URI_x86_64_v2_rust-unic-locale-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-locale-impl+default-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-locale-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-locale-impl+default-devel}"
SRC_URI[x86_64_v2_rust-unic-locale-impl+default-devel.sha256sum] = "4a3b2792b6498a4c112cfb79904354114abeed45d27eeeff4a6782ea91ec64f9"

URI_x86_64_v2_rust-unic-locale-impl+likelysubtags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-locale-impl+likelysubtags-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-locale-impl+likelysubtags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-locale-impl+likelysubtags-devel}"
SRC_URI[x86_64_v2_rust-unic-locale-impl+likelysubtags-devel.sha256sum] = "dadb11bb47699a40a59ea6dd1b0e2b3ebb5ed2d3a1afaa3d29c39ce2b6129134"

URI_x86_64_v2_rust-unic-locale-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-locale-impl-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-locale-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-locale-impl-devel}"
SRC_URI[x86_64_v2_rust-unic-locale-impl-devel.sha256sum] = "fc0646b4753153c058732b8a1a80bd97c6538a47516192c838c5f2b4fdaa5673"

URI_aarch64_rust-unic-locale-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-locale-impl+default-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-locale-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-locale-impl+default-devel}"
SRC_URI[aarch64_rust-unic-locale-impl+default-devel.sha256sum] = "af6a66c0dc73dbd76913b460ce3cbd38fc2edfce3884be4a3735259953b4b4b2"

URI_aarch64_rust-unic-locale-impl+likelysubtags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-locale-impl+likelysubtags-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-locale-impl+likelysubtags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-locale-impl+likelysubtags-devel}"
SRC_URI[aarch64_rust-unic-locale-impl+likelysubtags-devel.sha256sum] = "26cb32b01fa1eb1ff7c999f461e8dffe1d8af02dade5aabb05ad3f53dc6594d4"

URI_aarch64_rust-unic-locale-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-locale-impl-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-locale-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-locale-impl-devel}"
SRC_URI[aarch64_rust-unic-locale-impl-devel.sha256sum] = "43db19db182ea6400f91e8b8c8d4015a14eb0715cafce02987a62661b9dcd0a6"

RDEPENDS:rust-unic-locale-impl+default-devel = " \
 cargo \
 rust-unic-locale-impl-devel \
 "
RDEPENDS:rust-unic-locale-impl+likelysubtags-devel = " \
 cargo \
 rust-unic-langid-impl+likelysubtags-devel \
 rust-unic-locale-impl-devel \
 "
RDEPENDS:rust-unic-locale-impl-devel = " \
 cargo \
 rust-tinystr+default-devel \
 rust-unic-langid-impl+default-devel \
 "
