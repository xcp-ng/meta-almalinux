# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tenacity"
PV = "9.1.4"
PR = "1.el10_3"
PACKAGES = " \
 python3-tenacity \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-tenacity-9.1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b779baabe156d26f8582fb5dddd3b084d8410a3acf61e606fbe90e0abdc5f1d7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tenacity-9.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tenacity;unpack=0"
SRC_URI[x86_64_v2_python3-tenacity.sha256sum] = "444dca4954c05964f3e55f6abafaedf9e0ad17362aad87559a70b55520160881"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-tenacity-9.1.4-1.el10_3.noarch.rpm;name=aarch64_python3-tenacity;unpack=0"
SRC_URI[aarch64_python3-tenacity.sha256sum] = "7c442f5d36337ec2d5736ef71db3bfa310344d70b8e2568c59f3d09ed407eea7"

RDEPENDS:python3-tenacity = " \
 python3 \
 "
