# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jss"
PV = "5.6.0"
PR = "1.el10"
PACKAGES = " \
 idm-jss \
 idm-jss-tomcat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jss-5.6.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17314c402bca51ce3abc0e2f2a129593d5f735792fa2f0af8008c0f11ad2d508"

URI_x86_64_v2_idm-jss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-jss-5.6.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_idm-jss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-jss}"
SRC_URI[x86_64_v2_idm-jss.sha256sum] = "d35976595cf7c2c22e6a6509b28dab6397e8bf267bce6036d9e904565542a17f"

URI_x86_64_v2_idm-jss-tomcat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-jss-tomcat-5.6.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_idm-jss-tomcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-jss-tomcat}"
SRC_URI[x86_64_v2_idm-jss-tomcat.sha256sum] = "49d867fc08acafa98cb4d8d6474e7f912fd11b948eba6a9567c61289edd0677f"

URI_aarch64_idm-jss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-jss-5.6.0-1.el10.aarch64.rpm;name=aarch64_idm-jss;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-jss}"
SRC_URI[aarch64_idm-jss.sha256sum] = "7561336dffc83c349666146b1bf664ea4f82dfebe6b09b48f0768a46b1cee95d"

URI_aarch64_idm-jss-tomcat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-jss-tomcat-5.6.0-1.el10.aarch64.rpm;name=aarch64_idm-jss-tomcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-jss-tomcat}"
SRC_URI[aarch64_idm-jss-tomcat.sha256sum] = "1989723c1c05b60dd711c77e8d80f5f2793bf22e62a5b6db5d607256f07ddd45"

RDEPENDS:idm-jss = " \
 apache-commons-lang3 \
 glibc \
 java-21-openjdk-headless \
 javapackages-filesystem \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 slf4j \
 slf4j-jdk14 \
 "
RDEPENDS:idm-jss-tomcat = " \
 idm-jss \
 javapackages-filesystem \
 tomcat9 \
 virtual/mvn_org.apache.tomcat_tomcat-catalina_ \
 virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 \
 virtual/mvn_org.apache.tomcat_tomcat-coyote_ \
 virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 \
 virtual/mvn_org.apache.tomcat_tomcat-juli_ \
 virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62 \
 "
