# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freexl"
PV = "2.0.0"
PR = "11.el10_0"
PACKAGES = " \
 freexl \
 freexl-devel \
 freexl-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/freexl-2.0.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb28fef29d020135c852c9170f8b0c89f84a51ae89cf387fe3a9008c2070ca8e"

URI_x86_64_v2_freexl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freexl-2.0.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freexl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freexl}"
SRC_URI[x86_64_v2_freexl.sha256sum] = "57a18fc89da0675048b29b8966a66d5aa15ed6400a4eda05ca473ee371f87088"

URI_x86_64_v2_freexl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freexl-devel-2.0.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freexl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freexl-devel}"
SRC_URI[x86_64_v2_freexl-devel.sha256sum] = "a3d373264014c57c2663ad8e239e26a5f68ec8b73710ecb6378160b0ead202ef"

URI_x86_64_v2_freexl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freexl-doc-2.0.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_freexl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freexl-doc}"
SRC_URI[x86_64_v2_freexl-doc.sha256sum] = "e2d96da2a5096f3732503c515974ab177f2b8871c0e5ce8db99cc1396ecbed49"

URI_aarch64_freexl = "${EPEL_MIRROR}/aarch64/Packages/f/freexl-2.0.0-11.el10_0.aarch64.rpm;name=aarch64_freexl;unpack=0"
SRC_URI:append = " ${URI_aarch64_freexl}"
SRC_URI[aarch64_freexl.sha256sum] = "5202787b2db09c77635784451baf06c8070ebb629d8eead0e663e483a83e5d27"

URI_aarch64_freexl-devel = "${EPEL_MIRROR}/aarch64/Packages/f/freexl-devel-2.0.0-11.el10_0.aarch64.rpm;name=aarch64_freexl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freexl-devel}"
SRC_URI[aarch64_freexl-devel.sha256sum] = "ddd63de32d9505eb4beb5f7c821f5dfd70a1f4532162e0f5ca4464e01e0936df"

URI_aarch64_freexl-doc = "${EPEL_MIRROR}/aarch64/Packages/f/freexl-doc-2.0.0-11.el10_0.noarch.rpm;name=aarch64_freexl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_freexl-doc}"
SRC_URI[aarch64_freexl-doc.sha256sum] = "308ea6ec350aee70a43c16ce1cbd8c74a545c3312d9be68e9c9f3583b27c1fb9"

RDEPENDS:freexl = " \
 expat \
 glibc \
 minizip-ng-compat \
 "
RDEPENDS:freexl-devel = " \
 freexl \
 pkgconf-pkg-config \
 "
RDEPENDS:freexl-doc = " \
 "
