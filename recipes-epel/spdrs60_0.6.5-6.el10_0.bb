# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spdrs60"
PV = "0.6.5"
PR = "6.el10_0"
PACKAGES = " \
 spdrs60 \
 spdrs60-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spdrs60-0.6.5-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7236844eea516b812605eec32a662f726db47a075619867b603f6d99f356b6c"

URI_x86_64_v2_spdrs60 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spdrs60-0.6.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spdrs60;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spdrs60}"
SRC_URI[x86_64_v2_spdrs60.sha256sum] = "8b5760972c73012368f4e1d81c4cfb16b8b2c9b5d1f158560968914127fbb9fe"

URI_x86_64_v2_spdrs60-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spdrs60-doc-0.6.5-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_spdrs60-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spdrs60-doc}"
SRC_URI[x86_64_v2_spdrs60-doc.sha256sum] = "ca1883d90747479551f4e3d08620382160338fe91657ee2a6bb89ef4f3ffca47"

URI_aarch64_spdrs60 = "${EPEL_MIRROR}/aarch64/Packages/s/spdrs60-0.6.5-6.el10_0.aarch64.rpm;name=aarch64_spdrs60;unpack=0"
SRC_URI:append = " ${URI_aarch64_spdrs60}"
SRC_URI[aarch64_spdrs60.sha256sum] = "8477f8434cdbbf493a506f0c65021c8fa56931ffd5babb88cc7f7e12a52b4901"

URI_aarch64_spdrs60-doc = "${EPEL_MIRROR}/aarch64/Packages/s/spdrs60-doc-0.6.5-6.el10_0.noarch.rpm;name=aarch64_spdrs60-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_spdrs60-doc}"
SRC_URI[aarch64_spdrs60-doc.sha256sum] = "78745c113e634443637a3d67847939c83e7c8f37a1e6b1d8801d32a320aa13b9"

RDEPENDS:spdrs60 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:spdrs60-doc = " \
 spdrs60 \
 "
