# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xz"
PE = "1"
PV = "5.6.2"
PR = "5.el10"
PACKAGES = " \
 xz \
 xz-devel \
 xz-libs \
 xz-lzma-compat \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/xz-5.6.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f21419c0fce7069e8d65811f88b5d988d7b4c75264083dbd13c1d479d3195003"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xz-5.6.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_xz;unpack=0"
SRC_URI[x86_64_v2_xz.sha256sum] = "c2bb295eb751b97ad5ec911cae2b51133a40034b3a9633303e55563d9fb3b187"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xz-devel-5.6.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_xz-devel;unpack=0"
SRC_URI[x86_64_v2_xz-devel.sha256sum] = "d271e44c60791d792eecbed8074756ae702bc838d47c4763eb2529eb1787bd25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xz-libs-5.6.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_xz-libs;unpack=0"
SRC_URI[x86_64_v2_xz-libs.sha256sum] = "ee1212976b5fe79a82886d45ab7bff1c1f867937a4169e87c2a41042cf7cca86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xz-lzma-compat-5.6.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_xz-lzma-compat;unpack=0"
SRC_URI[x86_64_v2_xz-lzma-compat.sha256sum] = "f35332579218d51d57a00d8a02656e28eef29e7cbf491cbdc2f4f71e4f81248c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xz-5.6.2-5.el10.aarch64.rpm;name=aarch64_xz;unpack=0"
SRC_URI[aarch64_xz.sha256sum] = "2e0980930d75e17f1b31c40411f379662de37986ca7840d819f8993a36d1e302"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xz-devel-5.6.2-5.el10.aarch64.rpm;name=aarch64_xz-devel;unpack=0"
SRC_URI[aarch64_xz-devel.sha256sum] = "aa75b529894fad9a20ca036cde0d26ce81fde1da5ea02fdddd07a2bc3bf40fe7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xz-libs-5.6.2-5.el10.aarch64.rpm;name=aarch64_xz-libs;unpack=0"
SRC_URI[aarch64_xz-libs.sha256sum] = "cd5bfd219be6d7362031b7274aa678831c7c5a6a6c2f1deb7893d803c9578927"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xz-lzma-compat-5.6.2-5.el10.aarch64.rpm;name=aarch64_xz-lzma-compat;unpack=0"
SRC_URI[aarch64_xz-lzma-compat.sha256sum] = "1d555e112fa6f6be9262f63f948a3e003071491bc019a8881c45499b22eb777f"

RDEPENDS:xz = " \
 bash \
 glibc \
 grep \
 xz-libs \
 "
RDEPENDS:xz-devel = " \
 pkgconf-pkg-config \
 xz-libs \
 "
RDEPENDS:xz-libs = " \
 glibc \
 "
RDEPENDS:xz-lzma-compat = " \
 glibc \
 xz \
 xz-libs \
 "
