# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-kstring"
PV = "2.0.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-kstring+arc-devel \
 rust-kstring+default-devel \
 rust-kstring+document-features-devel \
 rust-kstring+max_inline-devel \
 rust-kstring+serde-devel \
 rust-kstring+std-devel \
 rust-kstring+unsafe-devel \
 rust-kstring+unstable_bench_subset-devel \
 rust-kstring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-kstring-2.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b2f834e8cc7ec3a9fad73f7903687bbf25f315c63441213b3409b724daef522"

URI_x86_64_v2_rust-kstring+arc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+arc-devel-2.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+arc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kstring+arc-devel}"
SRC_URI[x86_64_v2_rust-kstring+arc-devel.sha256sum] = "2d3ae907fb8b1193296dcacd2943ff5b2b0388510f3c0d828d4ef472ad5fa1de"

URI_x86_64_v2_rust-kstring+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+default-devel-2.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kstring+default-devel}"
SRC_URI[x86_64_v2_rust-kstring+default-devel.sha256sum] = "0d26a579e1b7f34f5ea663a317f57c9d92f21f8965b761bba192da2c3e12b202"

URI_x86_64_v2_rust-kstring+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+document-features-devel-2.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kstring+document-features-devel}"
SRC_URI[x86_64_v2_rust-kstring+document-features-devel.sha256sum] = "00294fc7beb8232d2d29fdd5d3524d6ada1cb1fd15fd4400dfe3bb34d0356486"

URI_x86_64_v2_rust-kstring+max_inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+max_inline-devel-2.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+max_inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kstring+max_inline-devel}"
SRC_URI[x86_64_v2_rust-kstring+max_inline-devel.sha256sum] = "8c4f0f07240c5f9b3210401fbd3a1f9c0136134ccdc745f13edb191c8eb867e5"

URI_x86_64_v2_rust-kstring+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+serde-devel-2.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kstring+serde-devel}"
SRC_URI[x86_64_v2_rust-kstring+serde-devel.sha256sum] = "5d5df013fe9949ce68799c52b14b0709f724da890e294b77767f33838a0a4bfe"

URI_x86_64_v2_rust-kstring+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+std-devel-2.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kstring+std-devel}"
SRC_URI[x86_64_v2_rust-kstring+std-devel.sha256sum] = "a4c25eeb771a2647936cd706a80a14dc2483a104da9cca7d9ffe4a46a7862b13"

URI_x86_64_v2_rust-kstring+unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+unsafe-devel-2.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kstring+unsafe-devel}"
SRC_URI[x86_64_v2_rust-kstring+unsafe-devel.sha256sum] = "def7195d6d9c2db932b8a5856ade07be64375fdbcbfa1165de050d715496ed72"

URI_x86_64_v2_rust-kstring+unstable_bench_subset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring+unstable_bench_subset-devel-2.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring+unstable_bench_subset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kstring+unstable_bench_subset-devel}"
SRC_URI[x86_64_v2_rust-kstring+unstable_bench_subset-devel.sha256sum] = "4780b554e4841aee8513606e95134dd5ecb5473d74b2a9f7784b61150eedf133"

URI_x86_64_v2_rust-kstring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kstring-devel-2.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kstring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kstring-devel}"
SRC_URI[x86_64_v2_rust-kstring-devel.sha256sum] = "90f021da47a11f4bd907631cf4e8ce9b7a79cfebe1c8a4ae3bdb75edf8b8ba9f"

URI_aarch64_rust-kstring+arc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+arc-devel-2.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-kstring+arc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kstring+arc-devel}"
SRC_URI[aarch64_rust-kstring+arc-devel.sha256sum] = "0f464319b5842048d0f79706826c69415e1e099b225e4d49ccc91b14858285df"

URI_aarch64_rust-kstring+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+default-devel-2.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-kstring+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kstring+default-devel}"
SRC_URI[aarch64_rust-kstring+default-devel.sha256sum] = "d6fe2324e69c6de70a115d5a858d94df57be45a838926f20ade75d0120bcb941"

URI_aarch64_rust-kstring+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+document-features-devel-2.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-kstring+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kstring+document-features-devel}"
SRC_URI[aarch64_rust-kstring+document-features-devel.sha256sum] = "3b1fc7dbe3770d481864bdbbd091556f44bb88060091bf26e76636b20de97cf6"

URI_aarch64_rust-kstring+max_inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+max_inline-devel-2.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-kstring+max_inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kstring+max_inline-devel}"
SRC_URI[aarch64_rust-kstring+max_inline-devel.sha256sum] = "baf378b7854f77ec4135eacd6cd55fc592636bcac57101480c55bde2af5483d2"

URI_aarch64_rust-kstring+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+serde-devel-2.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-kstring+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kstring+serde-devel}"
SRC_URI[aarch64_rust-kstring+serde-devel.sha256sum] = "441656ad761bc6465be9357c96bfbcd66869d1b60221bd6eef88e5e1c8bfd957"

URI_aarch64_rust-kstring+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+std-devel-2.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-kstring+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kstring+std-devel}"
SRC_URI[aarch64_rust-kstring+std-devel.sha256sum] = "b8c4aa95be54335ac27f5d039eae903b543f3116ef4b9897a47aa4ecd1306aac"

URI_aarch64_rust-kstring+unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+unsafe-devel-2.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-kstring+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kstring+unsafe-devel}"
SRC_URI[aarch64_rust-kstring+unsafe-devel.sha256sum] = "546d80791d22db921745a8a4bb96e34af99fdf45e3ec6225e42c69768bfc5413"

URI_aarch64_rust-kstring+unstable_bench_subset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring+unstable_bench_subset-devel-2.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-kstring+unstable_bench_subset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kstring+unstable_bench_subset-devel}"
SRC_URI[aarch64_rust-kstring+unstable_bench_subset-devel.sha256sum] = "a06cc8de6503c37d045dfa0eecdb90d1fca7971c809c9ede2cfab2a8fa741e9a"

URI_aarch64_rust-kstring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kstring-devel-2.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-kstring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kstring-devel}"
SRC_URI[aarch64_rust-kstring-devel.sha256sum] = "981d4c03c5439d93aa1191681a3f6400d4540f6db0216d10f6dfc1f05bc31370"

RDEPENDS:rust-kstring+arc-devel = " \
 cargo \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+default-devel = " \
 cargo \
 rust-kstring+std-devel \
 rust-kstring+unsafe-devel \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+max_inline-devel = " \
 cargo \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+serde-devel = " \
 cargo \
 rust-kstring-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-kstring+std-devel = " \
 cargo \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+unsafe-devel = " \
 cargo \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring+unstable_bench_subset-devel = " \
 cargo \
 rust-kstring-devel \
 "
RDEPENDS:rust-kstring-devel = " \
 cargo \
 rust \
 rust-static_assertions+default-devel \
 "
