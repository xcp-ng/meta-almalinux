# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-activities"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-activities \
 plasma-activities-devel \
 plasma-activities-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-activities-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bc2c4c9227d611365e979a0f292d9ad907d1242fdb667a72811bc49401b3076"

URI_x86_64_v2_plasma-activities = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities}"
SRC_URI[x86_64_v2_plasma-activities.sha256sum] = "12934194691fddeac4321f7ce531e9f661475df9fb389e277a3bb2e1932112f9"

URI_x86_64_v2_plasma-activities-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-devel}"
SRC_URI[x86_64_v2_plasma-activities-devel.sha256sum] = "b2695d0b82938627bfe885d54533b9010ad38628346cee7299357b854532c878"

URI_x86_64_v2_plasma-activities-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-doc-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-activities-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-doc}"
SRC_URI[x86_64_v2_plasma-activities-doc.sha256sum] = "fb2f99df65279c786e3d8a1e8d3dd40366875ab3849f6d8fded53b0b45af5672"

URI_aarch64_plasma-activities = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-activities;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities}"
SRC_URI[aarch64_plasma-activities.sha256sum] = "196763efdf843dfdd397c6b351dede0517a4e7f368e3d4c7f69a4517ff0e39be"

URI_aarch64_plasma-activities-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-activities-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-devel}"
SRC_URI[aarch64_plasma-activities-devel.sha256sum] = "e474bb7cf1403e274b204e6b358b86ee4fcf8cdfd4ced86d0a9e8021d73dcaa9"

URI_aarch64_plasma-activities-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-doc-6.3.6-1.el10_0.noarch.rpm;name=aarch64_plasma-activities-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-doc}"
SRC_URI[aarch64_plasma-activities-doc.sha256sum] = "df73eec6670e6fc831213d995e148a43de05a5d2fc79182f40dbc4f673178b43"

RDEPENDS:plasma-activities = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-activities-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plasma-activities \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma-activities-doc = " \
 "
