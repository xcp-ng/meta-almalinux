# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcolorscheme"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcolorscheme \
 kf6-kcolorscheme-devel \
 kf6-kcolorscheme-doc \
 kf6-kcolorscheme-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kcolorscheme-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "670cb43d456008b2ecc8e8a18ff8393c37aad4430be60456e38ff934f84e33c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcolorscheme;unpack=0"
SRC_URI[x86_64_v2_kf6-kcolorscheme.sha256sum] = "90f965b1a645f1d5c906e54761cf08a2d138e7afd9239e4158b94f954de83b5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcolorscheme-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kcolorscheme-devel.sha256sum] = "9a89a36a1e75adacc6b09c70323934b82ec5d4d40f4dff7b09036919c17ff0fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcolorscheme-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kcolorscheme-doc.sha256sum] = "51e06c1c82404e9112b41069dea24e08882ba178f8f9df099f1edd5094dfeccf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcolorscheme-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kcolorscheme-html.sha256sum] = "fc701fe66bd95f1dd45ece002d2ef9b28d2640b6120369ed947138bcccc99e2a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcolorscheme;unpack=0"
SRC_URI[aarch64_kf6-kcolorscheme.sha256sum] = "f6d66811dafb29661029ac5ec5512f29fff4557c9f47b6ae527fa4b8156dee84"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcolorscheme-devel;unpack=0"
SRC_URI[aarch64_kf6-kcolorscheme-devel.sha256sum] = "904fd703c5eeb51e048236c8c926a0b0b63ce234e9c5a1a03eaff1ff99621507"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcolorscheme-doc;unpack=0"
SRC_URI[aarch64_kf6-kcolorscheme-doc.sha256sum] = "de0dd6c86709b39f3e565499c6d18297a9051b88cad1a90b51d4e35a5d5b912b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcolorscheme-html;unpack=0"
SRC_URI[aarch64_kf6-kcolorscheme-html.sha256sum] = "453f2c65282b01aeae0706df6d0e11750195f0f53dd3b6eed8e0210c99995319"

RDEPENDS:kf6-kcolorscheme = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcolorscheme-devel = " \
 cmake-filesystem \
 kf6-kcolorscheme \
 "
RDEPENDS:kf6-kcolorscheme-doc = " \
 "
RDEPENDS:kf6-kcolorscheme-html = " \
 "
