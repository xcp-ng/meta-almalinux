# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbounce"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kbounce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbounce-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a4a5e6ffb79e16759ebf0dfcc6ee16baffd5abc468d8e52b00b380ada1c2ae9"

URI_x86_64_v2_kbounce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbounce-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbounce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbounce}"
SRC_URI[x86_64_v2_kbounce.sha256sum] = "5db3e167330185fdbee4a3cc12fb28c6bce396d6b1652f8f6788eea891748774"

URI_aarch64_kbounce = "${EPEL_MIRROR}/aarch64/Packages/k/kbounce-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kbounce;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbounce}"
SRC_URI[aarch64_kbounce.sha256sum] = "46990bc30e6b1bc951e6709bbdad5527c897920036420511eeb5f75d4b2076fe"

RDEPENDS:kbounce = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
