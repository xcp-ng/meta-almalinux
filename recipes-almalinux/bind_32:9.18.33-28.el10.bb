# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bind"
PE = "32"
PV = "9.18.33"
PR = "28.el10"
PACKAGES = " \
 bind \
 bind-chroot \
 bind-devel \
 bind-dnssec-utils \
 bind-doc \
 bind-libs \
 bind-license \
 bind-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bind-9.18.33-28.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f818df9331c7a8ce238a07239079d34b2cb6a72fd67fedf482c5e49cc59fcd3"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - bind-devel: libcap-devel(aarch-64)
# - bind: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-9.18.33-28.el10.x86_64_v2.rpm;name=x86_64_v2_bind;unpack=0"
SRC_URI[x86_64_v2_bind.sha256sum] = "00fc1df5117227ebd7507c1e7c69e6fb987831d1eb50ded213adcef99246ab3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-chroot-9.18.33-28.el10.x86_64_v2.rpm;name=x86_64_v2_bind-chroot;unpack=0"
SRC_URI[x86_64_v2_bind-chroot.sha256sum] = "d7b96f6edb390fffaf3c6e855c69a27d8aa07726378fedc8b7782ac6a3dfdf89"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-devel-9.18.33-28.el10.x86_64_v2.rpm;name=x86_64_v2_bind-devel;unpack=0"
SRC_URI[x86_64_v2_bind-devel.sha256sum] = "899fe5a2d62290fef09af1ac7bd446d5f1ac4f4433af433af31ba5dd0ab20f25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-dnssec-utils-9.18.33-28.el10.x86_64_v2.rpm;name=x86_64_v2_bind-dnssec-utils;unpack=0"
SRC_URI[x86_64_v2_bind-dnssec-utils.sha256sum] = "af7daf3bc140ed9ce468c5e0e3b0987a1d4adffb52e6f0a07a2848a809a7a07f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-doc-9.18.33-28.el10.noarch.rpm;name=x86_64_v2_bind-doc;unpack=0"
SRC_URI[x86_64_v2_bind-doc.sha256sum] = "f0cd07f0a64970820d85cb47065fdccae515743299f6d64095ddeeec918dea1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-libs-9.18.33-28.el10.x86_64_v2.rpm;name=x86_64_v2_bind-libs;unpack=0"
SRC_URI[x86_64_v2_bind-libs.sha256sum] = "dd0bea17486ba00c2ca1115a4df14363f3c1c7011b80ef17fd996785baebcd53"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-license-9.18.33-28.el10.noarch.rpm;name=x86_64_v2_bind-license;unpack=0"
SRC_URI[x86_64_v2_bind-license.sha256sum] = "5ac965ad45ee2bb65e00760aa890cbd29e76f1d3d5e67090b129ad0052236bd5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-utils-9.18.33-28.el10.x86_64_v2.rpm;name=x86_64_v2_bind-utils;unpack=0"
SRC_URI[x86_64_v2_bind-utils.sha256sum] = "2c5ce24256a52fb4da6cdb23b2100235d28ca6431fbf08ed132b7fb1870cb87c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-9.18.33-28.el10.aarch64.rpm;name=aarch64_bind;unpack=0"
SRC_URI[aarch64_bind.sha256sum] = "1f585079f5d35b3ddab986e792e7dfd2bc6d17e1a2413680b6a9270a020ad52e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-chroot-9.18.33-28.el10.aarch64.rpm;name=aarch64_bind-chroot;unpack=0"
SRC_URI[aarch64_bind-chroot.sha256sum] = "f60aa3fe963829372e037fe22133cde927d99e2c0657afe26b6781e6935a9bb5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-devel-9.18.33-28.el10.aarch64.rpm;name=aarch64_bind-devel;unpack=0"
SRC_URI[aarch64_bind-devel.sha256sum] = "c490cf0e0f1b2686975c43798e76e31f46ccdd5205592b732dd26ae17ef43b35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-dnssec-utils-9.18.33-28.el10.aarch64.rpm;name=aarch64_bind-dnssec-utils;unpack=0"
SRC_URI[aarch64_bind-dnssec-utils.sha256sum] = "7f2dbfbd744d069f3d939ddf489bfef38c0bf1088a03874850a65d80b809f83a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-doc-9.18.33-28.el10.noarch.rpm;name=aarch64_bind-doc;unpack=0"
SRC_URI[aarch64_bind-doc.sha256sum] = "f0cd07f0a64970820d85cb47065fdccae515743299f6d64095ddeeec918dea1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-libs-9.18.33-28.el10.aarch64.rpm;name=aarch64_bind-libs;unpack=0"
SRC_URI[aarch64_bind-libs.sha256sum] = "02bf6e47eb11fb50829419ff3761216483e840361a7127ce1c0abbba87150fc6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-license-9.18.33-28.el10.noarch.rpm;name=aarch64_bind-license;unpack=0"
SRC_URI[aarch64_bind-license.sha256sum] = "5ac965ad45ee2bb65e00760aa890cbd29e76f1d3d5e67090b129ad0052236bd5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-utils-9.18.33-28.el10.aarch64.rpm;name=aarch64_bind-utils;unpack=0"
SRC_URI[aarch64_bind-utils.sha256sum] = "4c4eaf8c3f213580ee7e639b5ce47ed27d2e339eed692ed884f951d398c6103c"

RDEPENDS:bind:x86_64_v2 = " \
 bash \
 bind-libs \
 fstrm \
 glibc \
 glibc-common \
 grep \
 json-c \
 libcap \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 shadow-utils \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:bind:aarch64 = " \
 bash \
 bind-libs \
 fstrm \
 glibc \
 glibc-common \
 grep \
 json-c \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 shadow-utils \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:bind-chroot = " \
 bash \
 bind \
 grep \
 "
RDEPENDS:bind-devel:x86_64_v2 = " \
 bind-libs \
 fstrm-devel \
 json-c-devel \
 krb5-devel \
 libcap-devel \
 libmaxminddb-devel \
 libxml2-devel \
 lmdb-devel \
 openssl-devel \
 protobuf-c-devel \
"
RDEPENDS:bind-devel:aarch64 = " \
 bind-libs \
 fstrm-devel \
 json-c-devel \
 krb5-devel \
 libmaxminddb-devel \
 libxml2-devel \
 lmdb-devel \
 openssl-devel \
 protobuf-c-devel \
"
RDEPENDS:bind-dnssec-utils = " \
 bind-libs \
 glibc \
 "
RDEPENDS:bind-doc = " \
 bind-license \
 python3-sphinx_rtd_theme \
 "
RDEPENDS:bind-libs = " \
 bind-license \
 fstrm \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 zlib-ng-compat \
 "
RDEPENDS:bind-license = " \
 "
RDEPENDS:bind-utils = " \
 bind-libs \
 glibc \
 krb5-libs \
 libidn2 \
 lmdb-libs \
 protobuf-c \
 "
