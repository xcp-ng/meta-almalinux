# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-loader"
PV = "1.4.304.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-loader \
 vulkan-loader-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-loader-1.4.304.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "497b51111af6df75730e861212e72f90854949cea2705952ac8fad6840c13ade"

URI_x86_64_v2_vulkan-loader = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-loader-1.4.304.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-loader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-loader}"
SRC_URI[x86_64_v2_vulkan-loader.sha256sum] = "bc6d3075ef91bc47819f150a6aa6ba136db7ddb52003a9b0f3d17725c73da50b"

URI_x86_64_v2_vulkan-loader-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-loader-devel-1.4.304.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-loader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-loader-devel}"
SRC_URI[x86_64_v2_vulkan-loader-devel.sha256sum] = "26a0b2416acc8a6ae4d64312f1ceb622ff1960de383bc560434936692be91a12"

URI_aarch64_vulkan-loader = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-loader-1.4.304.0-1.el10.aarch64.rpm;name=aarch64_vulkan-loader;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-loader}"
SRC_URI[aarch64_vulkan-loader.sha256sum] = "01a871263665db56a7155a24e7277d4dea32de279550f4bf18cec500e58f8c57"

URI_aarch64_vulkan-loader-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-loader-devel-1.4.304.0-1.el10.aarch64.rpm;name=aarch64_vulkan-loader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-loader-devel}"
SRC_URI[aarch64_vulkan-loader-devel.sha256sum] = "d7630c5ad75b5ac32cc01734189ad1bd76bcfcd4c2f9cf6d9b2558133e921b4d"

RDEPENDS:vulkan-loader:x86_64_v2 = " \
 glibc \
 mesa-vulkan-drivers \
"
RDEPENDS:vulkan-loader:aarch64 = " \
 glibc \
"
RDEPENDS:vulkan-loader-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 vulkan-headers \
 vulkan-loader \
 "
