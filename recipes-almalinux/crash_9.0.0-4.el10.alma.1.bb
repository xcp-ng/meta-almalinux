# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crash"
PV = "9.0.0"
PR = "4.el10.alma.1"
PACKAGES = " \
 crash \
 crash-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crash-9.0.0-4.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eac8b39780b6145dd14ff9c245cab1b4d83979c5e13ad1b32fe714fbc3c1606e"

URI_x86_64_v2_crash = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crash-9.0.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_crash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crash}"
SRC_URI[x86_64_v2_crash.sha256sum] = "9861ce8da1618cfe310e4a0f7ba276e34854bd62cbc9f6a59b550b75a62c7b95"

URI_x86_64_v2_crash-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/crash-devel-9.0.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_crash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crash-devel}"
SRC_URI[x86_64_v2_crash-devel.sha256sum] = "97e22bf7d791d3d996e28ce425664a0b32f6beb9ec8a6f143b99e663773f940c"

URI_aarch64_crash = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crash-9.0.0-4.el10.alma.1.aarch64.rpm;name=aarch64_crash;unpack=0"
SRC_URI:append = " ${URI_aarch64_crash}"
SRC_URI[aarch64_crash.sha256sum] = "bb2a182f5379e24d9460d914baa7cef08c00e58385c3e03a857d4d1ed9d793c7"

URI_aarch64_crash-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/crash-devel-9.0.0-4.el10.alma.1.aarch64.rpm;name=aarch64_crash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_crash-devel}"
SRC_URI[aarch64_crash-devel.sha256sum] = "47db680a7171282e0b010856054f0f0bf9b26211dd34652c8ae8972b6f74550f"

RDEPENDS:crash = " \
 binutils \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 libzstd \
 lzo \
 mpfr \
 ncurses-libs \
 snappy \
 "
RDEPENDS:crash-devel = " \
 crash \
 zlib-ng-compat-devel \
 "
