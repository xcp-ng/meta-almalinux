# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knotifications"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-knotifications \
 kf6-knotifications-devel \
 kf6-knotifications-doc \
 kf6-knotifications-html \
 python3-kf6-knotifications \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knotifications-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9863456176be8129374676154b00a856e277486c417e0e76e62334381a45252"

URI_x86_64_v2_kf6-knotifications = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications}"
SRC_URI[x86_64_v2_kf6-knotifications.sha256sum] = "f15f65d814621d64497e3162a1032b8152aa1f9590d9ee2d847cbf8e619375e4"

URI_x86_64_v2_kf6-knotifications-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifications-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-devel}"
SRC_URI[x86_64_v2_kf6-knotifications-devel.sha256sum] = "5ee7be93f5d835d3debaa8f8aa5cee638547edfc12e4d41b58af35c8ed33bd69"

URI_x86_64_v2_kf6-knotifications-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifications-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-doc}"
SRC_URI[x86_64_v2_kf6-knotifications-doc.sha256sum] = "0bf7b20f13af8aa6a0d932556013970e8d728533aa4f69b907f391ff287bfa27"

URI_x86_64_v2_kf6-knotifications-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifications-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-html}"
SRC_URI[x86_64_v2_kf6-knotifications-html.sha256sum] = "8cb8e7d68c0458cde03b9b1afe5725247fd91a767d2f75a22d4edd1f4522b754"

URI_x86_64_v2_python3-kf6-knotifications = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-knotifications-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-knotifications}"
SRC_URI[x86_64_v2_python3-kf6-knotifications.sha256sum] = "ca79615b1e8bc9c195d85c80a4bde7839728fad4ad5dd883aeb6ca28af8ad0c7"

URI_aarch64_kf6-knotifications = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications}"
SRC_URI[aarch64_kf6-knotifications.sha256sum] = "3cd71ff3a63f25e081dd3e8f38598fad3a00973073a0697977b30863ef895cf2"

URI_aarch64_kf6-knotifications-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-knotifications-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-devel}"
SRC_URI[aarch64_kf6-knotifications-devel.sha256sum] = "b74074e13a6655c494b294c0838b64a82015bd2dd407ada18f3226cbb1a2a48a"

URI_aarch64_kf6-knotifications-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-knotifications-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-doc}"
SRC_URI[aarch64_kf6-knotifications-doc.sha256sum] = "58b261eadda78437c7980a2bbe387c629aac01efbaad948ce3bd760a44361fb8"

URI_aarch64_kf6-knotifications-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-knotifications-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-html}"
SRC_URI[aarch64_kf6-knotifications-html.sha256sum] = "f0b6deff083b0355faaccbfeabc74aaf950f2318a63e250c2bcbcc7f80871fd2"

URI_aarch64_python3-kf6-knotifications = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-knotifications-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_python3-kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-knotifications}"
SRC_URI[aarch64_python3-kf6-knotifications.sha256sum] = "f25ecb7f2580bcf8911cac923e1a182f50f74f17cbb7f137204ae3c3d6498d87"

RDEPENDS:kf6-knotifications = " \
 glibc \
 kf6-kconfig \
 libcanberra \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-knotifications-devel = " \
 cmake-filesystem \
 kf6-knotifications \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-knotifications-doc = " \
 "
RDEPENDS:kf6-knotifications-html = " \
 "
RDEPENDS:python3-kf6-knotifications = " \
 glibc \
 kf6-knotifications \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
