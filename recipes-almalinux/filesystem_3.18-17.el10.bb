# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "filesystem"
PV = "3.18"
PR = "17.el10"
PACKAGES = " \
 filesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/filesystem-3.18-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e913100f5e5c7bff9c0e5290dc898c40c4b8cca122c61b161498258cbb8d4c6"

URI_x86_64_v2_filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/filesystem-3.18-17.el10.x86_64_v2.rpm;name=x86_64_v2_filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_filesystem}"
SRC_URI[x86_64_v2_filesystem.sha256sum] = "66e95a11d94cb3c6923ab4e8e14947af3fa81209b7072ec8546239c94fd78ac6"

URI_aarch64_filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/filesystem-3.18-17.el10.aarch64.rpm;name=aarch64_filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_filesystem}"
SRC_URI[aarch64_filesystem.sha256sum] = "f0d10228adfa06010c243d65cdc789aab25a994a72b984ace32a68be761fba38"

RDEPENDS:filesystem = " \
 setup \
 "
