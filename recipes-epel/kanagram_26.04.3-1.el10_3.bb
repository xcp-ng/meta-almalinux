# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kanagram"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kanagram \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kanagram-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f21a166d84d70ae58ca6bb99403fb863647de24864b5e2e4cd1e391309865ed1"

URI_x86_64_v2_kanagram = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kanagram-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kanagram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kanagram}"
SRC_URI[x86_64_v2_kanagram.sha256sum] = "ec2c971a2444fd208c9bd4c990c38813b622003747ad2a93e8e288025c50a6af"

URI_aarch64_kanagram = "${EPEL_MIRROR}/aarch64/Packages/k/kanagram-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kanagram;unpack=0"
SRC_URI:append = " ${URI_aarch64_kanagram}"
SRC_URI[aarch64_kanagram.sha256sum] = "24ae1a10b4e270a05411a648f01850c937db6165404e0bb47b4a10ba0aefd050"

RDEPENDS:kanagram = " \
 glibc \
 kdeedu-data \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
