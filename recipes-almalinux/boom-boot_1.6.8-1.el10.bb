# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "boom-boot"
PV = "1.6.8"
PR = "1.el10"
PACKAGES = " \
 boom-boot \
 boom-boot-conf \
 python3-boom \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/boom-boot-1.6.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00d69efc08850ddd9af8730061786f8e1ba323e192c9a43556b3d33b56558625"

URI_x86_64_v2_boom-boot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boom-boot-1.6.8-1.el10.noarch.rpm;name=x86_64_v2_boom-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boom-boot}"
SRC_URI[x86_64_v2_boom-boot.sha256sum] = "0fdfd6e5635a78180289acebd496802f10ca22bf2d3345c3987faac1878b58a7"

URI_x86_64_v2_boom-boot-conf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boom-boot-conf-1.6.8-1.el10.noarch.rpm;name=x86_64_v2_boom-boot-conf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boom-boot-conf}"
SRC_URI[x86_64_v2_boom-boot-conf.sha256sum] = "3d4688592d648482316f8e8dab9088b426008d2cad6e139855677df44a01ac36"

URI_x86_64_v2_python3-boom = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-boom-1.6.8-1.el10.noarch.rpm;name=x86_64_v2_python3-boom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-boom}"
SRC_URI[x86_64_v2_python3-boom.sha256sum] = "0e5bcbae96528b5a37e5034a01c9303eeba6d0ffe55ab62157305bc37744c983"

URI_aarch64_boom-boot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boom-boot-1.6.8-1.el10.noarch.rpm;name=aarch64_boom-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_boom-boot}"
SRC_URI[aarch64_boom-boot.sha256sum] = "0fdfd6e5635a78180289acebd496802f10ca22bf2d3345c3987faac1878b58a7"

URI_aarch64_boom-boot-conf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boom-boot-conf-1.6.8-1.el10.noarch.rpm;name=aarch64_boom-boot-conf;unpack=0"
SRC_URI:append = " ${URI_aarch64_boom-boot-conf}"
SRC_URI[aarch64_boom-boot-conf.sha256sum] = "3d4688592d648482316f8e8dab9088b426008d2cad6e139855677df44a01ac36"

URI_aarch64_python3-boom = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-boom-1.6.8-1.el10.noarch.rpm;name=aarch64_python3-boom;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-boom}"
SRC_URI[aarch64_python3-boom.sha256sum] = "0e5bcbae96528b5a37e5034a01c9303eeba6d0ffe55ab62157305bc37744c983"

RDEPENDS:boom-boot = " \
 boom-boot-conf \
 python3 \
 python3-boom \
 python3-dbus \
 systemd \
 "
RDEPENDS:boom-boot-conf = " \
 "
RDEPENDS:python3-boom = " \
 python3 \
 python3-dbus \
 "
