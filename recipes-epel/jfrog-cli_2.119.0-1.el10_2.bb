# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jfrog-cli"
PV = "2.119.0"
PR = "1.el10_2"
PACKAGES = " \
 jfrog-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jfrog-cli-2.119.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d031476d435aabb7c79f0f12627d6d84a45d875ad5deb68f6453b7e6f263ae9"

URI_x86_64_v2_jfrog-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jfrog-cli-2.119.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jfrog-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jfrog-cli}"
SRC_URI[x86_64_v2_jfrog-cli.sha256sum] = "aa2cbac7716cd785bda75c495d9b8883709f4a908f10104893ca1ddd148da04d"

URI_aarch64_jfrog-cli = "${EPEL_MIRROR}/aarch64/Packages/j/jfrog-cli-2.119.0-1.el10_2.aarch64.rpm;name=aarch64_jfrog-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_jfrog-cli}"
SRC_URI[aarch64_jfrog-cli.sha256sum] = "020dab7e4a4d52c6294076810d30964fee581a9161586cf2fdc16fb687e58cd7"

RDEPENDS:jfrog-cli = " \
 glibc \
 "
