# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-flate2"
PV = "1.1.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-flate2+any_c_zlib-devel \
 rust-flate2+any_impl-devel \
 rust-flate2+any_zlib-devel \
 rust-flate2+default-devel \
 rust-flate2+document-features-devel \
 rust-flate2+libz-ng-sys-devel \
 rust-flate2+libz-sys-devel \
 rust-flate2+miniz-sys-devel \
 rust-flate2+miniz_oxide-devel \
 rust-flate2+rust_backend-devel \
 rust-flate2+zlib-default-devel \
 rust-flate2+zlib-devel \
 rust-flate2+zlib-ng-devel \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-flate2-1.1.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91beb1b9f571074a0ab275ce7ad89f8828daea3d19d8d831b9591315821903d9"

URI_x86_64_v2_rust-flate2+any_c_zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+any_c_zlib-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+any_c_zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+any_c_zlib-devel}"
SRC_URI[x86_64_v2_rust-flate2+any_c_zlib-devel.sha256sum] = "f954e1c128db8df0b7eb991fe7f7692dfd047f8d385cf37f399519ec6b6654f4"

URI_x86_64_v2_rust-flate2+any_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+any_impl-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+any_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+any_impl-devel}"
SRC_URI[x86_64_v2_rust-flate2+any_impl-devel.sha256sum] = "228d843dd77df67b3422256715485c71b2503edeb0a9675e57471c1247e19e26"

URI_x86_64_v2_rust-flate2+any_zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+any_zlib-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+any_zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+any_zlib-devel}"
SRC_URI[x86_64_v2_rust-flate2+any_zlib-devel.sha256sum] = "d8187bfa8e93c6a3a3f0e8e897f92767d4e5fec5ca0d30a35a4d791e8a2406cb"

URI_x86_64_v2_rust-flate2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+default-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+default-devel}"
SRC_URI[x86_64_v2_rust-flate2+default-devel.sha256sum] = "cf131a72ce93a2ab8917df392dd14299774a59377964cd282e060207e77c8a4f"

URI_x86_64_v2_rust-flate2+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+document-features-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+document-features-devel}"
SRC_URI[x86_64_v2_rust-flate2+document-features-devel.sha256sum] = "310ffcd9493c28dcc2f3474f9520ba46e46f0073ea76f64b4cbcb4ed0aa8c682"

URI_x86_64_v2_rust-flate2+libz-ng-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+libz-ng-sys-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+libz-ng-sys-devel}"
SRC_URI[x86_64_v2_rust-flate2+libz-ng-sys-devel.sha256sum] = "03ac1cfc8be081c1adcd770c52f2b1e145bad0fae10c0c3900eff6aeb8208a53"

URI_x86_64_v2_rust-flate2+libz-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+libz-sys-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+libz-sys-devel}"
SRC_URI[x86_64_v2_rust-flate2+libz-sys-devel.sha256sum] = "e21eb5717085e7f14f5441d39686470d9192212214671e40ec30f6b1cad0f805"

URI_x86_64_v2_rust-flate2+miniz-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+miniz-sys-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+miniz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+miniz-sys-devel}"
SRC_URI[x86_64_v2_rust-flate2+miniz-sys-devel.sha256sum] = "37dcca74249311068c0243eb401f5ed887927a588f52a429cb71b0fd2c68ea92"

URI_x86_64_v2_rust-flate2+miniz_oxide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+miniz_oxide-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+miniz_oxide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+miniz_oxide-devel}"
SRC_URI[x86_64_v2_rust-flate2+miniz_oxide-devel.sha256sum] = "3b707b5d7779119240a7ad53415e6d11c55c26ced578d42e6714f404bb12dd6c"

URI_x86_64_v2_rust-flate2+rust_backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+rust_backend-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+rust_backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+rust_backend-devel}"
SRC_URI[x86_64_v2_rust-flate2+rust_backend-devel.sha256sum] = "fea2d806a731cb04df3a915bb83076f47ada2fc8e422be80a3a7b54eb66372a0"

URI_x86_64_v2_rust-flate2+zlib-default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-default-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-default-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-default-devel.sha256sum] = "d75cc48b9b7308439e12f871cdf9ee27f23947a9d8179014c5b995e82649298b"

URI_x86_64_v2_rust-flate2+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-devel.sha256sum] = "a3f5f5cdd7fc23dfd940b6767ed14632acb34a1acdad18ce5079e05a747a869c"

URI_x86_64_v2_rust-flate2+zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-ng-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-ng-devel.sha256sum] = "693b602cb7d5f31dad51fb7e120ae97b64d79732e5f218f67b807d3e1bc116e5"

URI_x86_64_v2_rust-flate2+zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-rs-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-rs-devel.sha256sum] = "5bf35e74f60f6a7c8401476946fab6a9d5f98e63a7a77ff4fbe59d5ff3085d0d"

URI_x86_64_v2_rust-flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2-devel-1.1.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2-devel}"
SRC_URI[x86_64_v2_rust-flate2-devel.sha256sum] = "9da4082a3d6e5aa491a894d4eb0161492128cf157e18a8611886676d7a017040"

URI_aarch64_rust-flate2+any_c_zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+any_c_zlib-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+any_c_zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+any_c_zlib-devel}"
SRC_URI[aarch64_rust-flate2+any_c_zlib-devel.sha256sum] = "bc301ab562921dc41c826cccf4b26694ad7db9e527a84d5d43e64036e998642f"

URI_aarch64_rust-flate2+any_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+any_impl-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+any_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+any_impl-devel}"
SRC_URI[aarch64_rust-flate2+any_impl-devel.sha256sum] = "eddc4865fac6db8ebc6c548fcb9046fd836c39894ed74dd4c78a9a643a5afa71"

URI_aarch64_rust-flate2+any_zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+any_zlib-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+any_zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+any_zlib-devel}"
SRC_URI[aarch64_rust-flate2+any_zlib-devel.sha256sum] = "afd02ac16a6f1a4ce4cd16ec187ced95dbe3917a7149f77b23c359d6126cde51"

URI_aarch64_rust-flate2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+default-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+default-devel}"
SRC_URI[aarch64_rust-flate2+default-devel.sha256sum] = "e3ac48ce47dac126cf98fa0959d9f2bfaeb90401707b3a6edbc709d2224a7393"

URI_aarch64_rust-flate2+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+document-features-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+document-features-devel}"
SRC_URI[aarch64_rust-flate2+document-features-devel.sha256sum] = "cbd106950d3b5e7bc636afbad930fc997140a33d9f6fbefc6c7d077d08f1e35f"

URI_aarch64_rust-flate2+libz-ng-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+libz-ng-sys-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+libz-ng-sys-devel}"
SRC_URI[aarch64_rust-flate2+libz-ng-sys-devel.sha256sum] = "b1a8cf71f9152bc53801cfab877b5305acbdb3ae1f2ef325845848b2215569d4"

URI_aarch64_rust-flate2+libz-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+libz-sys-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+libz-sys-devel}"
SRC_URI[aarch64_rust-flate2+libz-sys-devel.sha256sum] = "b17f2f7301cdc4ac906fa6238b737e98240b7e0f5b1f6a13cc2ab89dae9ef797"

URI_aarch64_rust-flate2+miniz-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+miniz-sys-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+miniz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+miniz-sys-devel}"
SRC_URI[aarch64_rust-flate2+miniz-sys-devel.sha256sum] = "32d7aaaa2f14b98baf5f475ebf428dfaeaa62e75f62a4da32fccd59abf74640b"

URI_aarch64_rust-flate2+miniz_oxide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+miniz_oxide-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+miniz_oxide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+miniz_oxide-devel}"
SRC_URI[aarch64_rust-flate2+miniz_oxide-devel.sha256sum] = "99c96946cf9736890a5634eb6d9bb25559c2b17f77cc85fb807f76fd57a165a6"

URI_aarch64_rust-flate2+rust_backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+rust_backend-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+rust_backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+rust_backend-devel}"
SRC_URI[aarch64_rust-flate2+rust_backend-devel.sha256sum] = "f97847b8616f35c0ca5598f5e466d9e79aa10cb268cf3df39b1c665f841154ce"

URI_aarch64_rust-flate2+zlib-default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-default-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+zlib-default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-default-devel}"
SRC_URI[aarch64_rust-flate2+zlib-default-devel.sha256sum] = "d67f5658f94278038a374083fd4462de0f39295ccf8146c6791e9b1fe9914077"

URI_aarch64_rust-flate2+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-devel}"
SRC_URI[aarch64_rust-flate2+zlib-devel.sha256sum] = "3d8e739b9fd6fa83b158beb58e1a402cd85118151af55fd5a669e20cdcac9cb0"

URI_aarch64_rust-flate2+zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-ng-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-ng-devel}"
SRC_URI[aarch64_rust-flate2+zlib-ng-devel.sha256sum] = "c34e5d2a47d2868832ad9c0662bf6c382d0d86da5a701217c498b635ab0561c8"

URI_aarch64_rust-flate2+zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-rs-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-rs-devel}"
SRC_URI[aarch64_rust-flate2+zlib-rs-devel.sha256sum] = "8bed14b5e6ac6b197dce936090aeaa05bf4762ac603a253b809a48b6a8eda34c"

URI_aarch64_rust-flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2-devel-1.1.9-1.el10_2.noarch.rpm;name=aarch64_rust-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2-devel}"
SRC_URI[aarch64_rust-flate2-devel.sha256sum] = "c3708ac920d954027813bac333c18886d67f09b435eaa250a164a5c835b6cb08"

RDEPENDS:rust-flate2+any_c_zlib-devel = " \
 cargo \
 rust-flate2+any_zlib-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+any_impl-devel = " \
 cargo \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+any_zlib-devel = " \
 cargo \
 rust-flate2+any_impl-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+default-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+libz-ng-sys-devel = " \
 cargo \
 rust-flate2-devel \
 rust-libz-ng-sys+default-devel \
 "
RDEPENDS:rust-flate2+libz-sys-devel = " \
 cargo \
 rust-flate2-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-flate2+miniz-sys-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+miniz_oxide-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-flate2+any_impl-devel \
 rust-flate2-devel \
 rust-miniz_oxide0.8+simd-devel \
 rust-miniz_oxide0.8+with-alloc-devel \
 rust-miniz_oxide0.8-devel \
 "
RDEPENDS:rust-flate2+rust_backend-devel = " \
 cargo \
 rust-flate2+any_impl-devel \
 rust-flate2+miniz_oxide-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+zlib-default-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-flate2+any_c_zlib-devel \
 rust-flate2-devel \
 rust-libz-sys+default-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-flate2+zlib-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-flate2+any_c_zlib-devel \
 rust-flate2+libz-sys-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+zlib-ng-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-flate2+any_c_zlib-devel \
 rust-flate2+libz-ng-sys-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+zlib-rs-devel = " \
 cargo \
 rust-flate2+any_zlib-devel \
 rust-flate2-devel \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-flate2-devel = " \
 cargo \
 rust \
 "
