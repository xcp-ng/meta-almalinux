# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pspg"
PV = "5.8.16"
PR = "1.el10_1"
PACKAGES = " \
 pspg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pspg-5.8.16-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c3222a1c9f7bf85e0a82579777c8fcff719820482745be2719125b2adb42742"

URI_x86_64_v2_pspg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pspg-5.8.16-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pspg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pspg}"
SRC_URI[x86_64_v2_pspg.sha256sum] = "b0f8dae808104cb955f9ad2a8310ee9497ea7359b9749b72950e0e98adaf7ff4"

URI_aarch64_pspg = "${EPEL_MIRROR}/aarch64/Packages/p/pspg-5.8.16-1.el10_1.aarch64.rpm;name=aarch64_pspg;unpack=0"
SRC_URI:append = " ${URI_aarch64_pspg}"
SRC_URI[aarch64_pspg.sha256sum] = "7326e65fc65bd805ea08857ff57d4fefa5fc083294a239a826caedbb62db99c3"

RDEPENDS:pspg = " \
 glibc \
 ncurses-libs \
 readline \
 "
