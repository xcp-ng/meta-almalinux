# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Archive-Peek"
PV = "0.37"
PR = "5.el10_2"
PACKAGES = " \
 perl-Archive-Peek \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Archive-Peek-0.37-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fcbcd586ce20ab2c6b2ae368b66c92c443018a2332f179e41da9555a0a7269a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Archive-Peek-0.37-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Archive-Peek;unpack=0"
SRC_URI[x86_64_v2_perl-Archive-Peek.sha256sum] = "e5f88b9f10bcbf0a58aa704362053be2107c9a3bbc10b6148e27a35999e5c310"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Archive-Peek-0.37-5.el10_2.noarch.rpm;name=aarch64_perl-Archive-Peek;unpack=0"
SRC_URI[aarch64_perl-Archive-Peek.sha256sum] = "508e5425bfa73b1b95e77adc73746ffb20c8c093e72e5b8fce9f368b8dc126aa"

RDEPENDS:perl-Archive-Peek = " \
 perl-Archive-Tar \
 perl-Archive-Zip \
 perl-Carp \
 perl-IO-Compress \
 perl-Moo \
 perl-Types-Path-Tiny \
 perl-libs \
 "
