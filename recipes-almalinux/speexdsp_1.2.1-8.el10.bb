# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "speexdsp"
PV = "1.2.1"
PR = "8.el10"
PACKAGES = " \
 speexdsp \
 speexdsp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/speexdsp-1.2.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37336065207169a18b68110f40f4aad7536cff198da5eb2b6e0e0e136ba95442"

URI_x86_64_v2_speexdsp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/speexdsp-1.2.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_speexdsp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_speexdsp}"
SRC_URI[x86_64_v2_speexdsp.sha256sum] = "9328ebbdc61a4af196a386e32b6eed1ddbb2715819cc91a2c8a6586d9a0a30d5"

URI_x86_64_v2_speexdsp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/speexdsp-devel-1.2.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_speexdsp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_speexdsp-devel}"
SRC_URI[x86_64_v2_speexdsp-devel.sha256sum] = "519560e85f8e2e9f448588da684a6f279c288db7f465e35780541e8c67e0b7b7"

URI_aarch64_speexdsp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/speexdsp-1.2.1-8.el10.aarch64.rpm;name=aarch64_speexdsp;unpack=0"
SRC_URI:append = " ${URI_aarch64_speexdsp}"
SRC_URI[aarch64_speexdsp.sha256sum] = "57df623db900723cc7b56219ac359202959dd49ba78a12ef99f41ceb6b6bf533"

URI_aarch64_speexdsp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/speexdsp-devel-1.2.1-8.el10.aarch64.rpm;name=aarch64_speexdsp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_speexdsp-devel}"
SRC_URI[aarch64_speexdsp-devel.sha256sum] = "3ab52dc80cecfa625781c7d047c1eb0581f88b40e47ef83350e00ed3290a6c47"

RDEPENDS:speexdsp = " \
 glibc \
 "
RDEPENDS:speexdsp-devel = " \
 pkgconf-pkg-config \
 speexdsp \
 "
