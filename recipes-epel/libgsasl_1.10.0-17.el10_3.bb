# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgsasl"
PV = "1.10.0"
PR = "17.el10_3"
PACKAGES = " \
 libgsasl \
 libgsasl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgsasl-1.10.0-17.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0865084fb6910bbad1fa8598273c28bf303601ab236f31abc74c4a35da84d30a"

URI_x86_64_v2_libgsasl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgsasl-1.10.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgsasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgsasl}"
SRC_URI[x86_64_v2_libgsasl.sha256sum] = "5e4234473b75a3db481f6f77f41616a63073a809cff608b346edda96d2ae1abe"

URI_x86_64_v2_libgsasl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgsasl-devel-1.10.0-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgsasl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgsasl-devel}"
SRC_URI[x86_64_v2_libgsasl-devel.sha256sum] = "cdd0c207b75063afdfb7c94333f0024910ec99620b1a8fd3550c99477d0d721d"

URI_aarch64_libgsasl = "${EPEL_MIRROR}/aarch64/Packages/l/libgsasl-1.10.0-17.el10_3.aarch64.rpm;name=aarch64_libgsasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgsasl}"
SRC_URI[aarch64_libgsasl.sha256sum] = "7306196af9c1fbe97ce6938f62e17f877ed7c6ee18743fe94edb6e1cfb49e4f4"

URI_aarch64_libgsasl-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgsasl-devel-1.10.0-17.el10_3.aarch64.rpm;name=aarch64_libgsasl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgsasl-devel}"
SRC_URI[aarch64_libgsasl-devel.sha256sum] = "97229b3e07ad121c4d0fa483b453c1a8f0e4bc3b23685b140005e8be199bb671"

RDEPENDS:libgsasl = " \
 glibc \
 krb5-libs \
 libcom_err \
 libidn \
 libntlm \
 "
RDEPENDS:libgsasl-devel = " \
 libgsasl \
 pkgconf-pkg-config \
 "
