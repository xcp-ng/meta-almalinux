# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qttools"
PV = "6.9.1"
PR = "1.el10"
PACKAGES = " \
 qt6-assistant \
 qt6-designer \
 qt6-doctools \
 qt6-linguist \
 qt6-qdbusviewer \
 qt6-qttools \
 qt6-qttools-common \
 qt6-qttools-devel \
 qt6-qttools-examples \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 qt6-qttools-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qttools-6.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b762ce63832914b57b1c5fff0e01cf0a83b206bffb4c7a5aeabd7fa37b7a74f"

URI_x86_64_v2_qt6-assistant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-assistant-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-assistant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-assistant}"
SRC_URI[x86_64_v2_qt6-assistant.sha256sum] = "fcc575ba50250ae3efa7e3cd0e5250825ec96c3126c960e677b78dbb9eb5fd3f"

URI_x86_64_v2_qt6-designer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-designer-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-designer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-designer}"
SRC_URI[x86_64_v2_qt6-designer.sha256sum] = "6d7ad5fc384428907a4e9bb4ce376aa05e101d5b85e4b825a2157a4eb47d2bd7"

URI_x86_64_v2_qt6-doctools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-doctools-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-doctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doctools}"
SRC_URI[x86_64_v2_qt6-doctools.sha256sum] = "abc256e1dbbc3c5eb06627deb009b465646b7a7152d988de38317ce0518f8b3b"

URI_x86_64_v2_qt6-linguist = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-linguist-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-linguist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-linguist}"
SRC_URI[x86_64_v2_qt6-linguist.sha256sum] = "f82c73c8eb1fcefa718fa2b7b8b76ae69e4deafdca158c39830d0f17aede41ed"

URI_x86_64_v2_qt6-qdbusviewer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qdbusviewer-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qdbusviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qdbusviewer}"
SRC_URI[x86_64_v2_qt6-qdbusviewer.sha256sum] = "8e47760f0bee5d727fe8c730124ac233e6f3a4e6340c387060bb8d205d4e6cac"

URI_x86_64_v2_qt6-qttools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools}"
SRC_URI[x86_64_v2_qt6-qttools.sha256sum] = "8ea49833024fae5c13151cd9553388a5bfa69a44c75717afe6446ca77a14d62c"

URI_x86_64_v2_qt6-qttools-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-common-6.9.1-1.el10.noarch.rpm;name=x86_64_v2_qt6-qttools-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-common}"
SRC_URI[x86_64_v2_qt6-qttools-common.sha256sum] = "24b9fc296c8b07bf96265ebecb4b24133858f67f83191fbf1e82dba01a80b4f9"

URI_x86_64_v2_qt6-qttools-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-devel-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-devel}"
SRC_URI[x86_64_v2_qt6-qttools-devel.sha256sum] = "e6845711380e2155b1fad3d5ec2afd278baf565492772ba16d71e2bb120b6d51"

URI_x86_64_v2_qt6-qttools-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qttools-examples-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-examples}"
SRC_URI[x86_64_v2_qt6-qttools-examples.sha256sum] = "7c9caa5b06221d669f163074226f605d7f71ff4465588954663bc64e536d5c95"

URI_x86_64_v2_qt6-qttools-libs-designer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-designer-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-libs-designer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-libs-designer}"
SRC_URI[x86_64_v2_qt6-qttools-libs-designer.sha256sum] = "00dafe8a6f19f4032c363e570bfc54c0b0e6b6d58ed364b5a90106ad4158ffe9"

URI_x86_64_v2_qt6-qttools-libs-designercomponents = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-designercomponents-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-libs-designercomponents;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-libs-designercomponents}"
SRC_URI[x86_64_v2_qt6-qttools-libs-designercomponents.sha256sum] = "a3eca2fd6c76a5c8a594ed56cb7d1d30eb3e65fe9d339da1d2235ae4d4511ad4"

URI_x86_64_v2_qt6-qttools-libs-help = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-help-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-libs-help;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-libs-help}"
SRC_URI[x86_64_v2_qt6-qttools-libs-help.sha256sum] = "6971f5210e14d63401c130bbf0fb814e1d07b34b498c2c98d0963d04654c7a3d"

URI_x86_64_v2_qt6-qttools-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qttools-static-6.9.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-static}"
SRC_URI[x86_64_v2_qt6-qttools-static.sha256sum] = "3431f95f099a7a80380fc377c96c7c3d2521aeb996534001e8a3814a22ae2376"

URI_aarch64_qt6-assistant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-assistant-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-assistant;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-assistant}"
SRC_URI[aarch64_qt6-assistant.sha256sum] = "0629869dbe7495f8e19368db8c9dd8ed3a3f584bf3f54650fd86edfc85a160b6"

URI_aarch64_qt6-designer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-designer-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-designer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-designer}"
SRC_URI[aarch64_qt6-designer.sha256sum] = "3e1ce2546a03bdf4c9dde609092f6064f22e2a60189aabf6b2b9ea5dc2619137"

URI_aarch64_qt6-doctools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-doctools-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-doctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doctools}"
SRC_URI[aarch64_qt6-doctools.sha256sum] = "a1ecae9047538e079b89c2fa81cbae5d3f5766a620391ca7e346d509d9be51cd"

URI_aarch64_qt6-linguist = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-linguist-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-linguist;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-linguist}"
SRC_URI[aarch64_qt6-linguist.sha256sum] = "0fc5770d6e42cfa18a3eddc696d007c2745989b7e56e5d4cbaa39e1c3fdcf21e"

URI_aarch64_qt6-qdbusviewer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qdbusviewer-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qdbusviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qdbusviewer}"
SRC_URI[aarch64_qt6-qdbusviewer.sha256sum] = "36680d94738f63f99d3e49a90af0ec170dd2ae183e099a15a8abc53646c848dd"

URI_aarch64_qt6-qttools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools}"
SRC_URI[aarch64_qt6-qttools.sha256sum] = "b33633c546f9f77924b5ffbc9bd8441d8078fb8cf409458915a383203e1bd422"

URI_aarch64_qt6-qttools-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-common-6.9.1-1.el10.noarch.rpm;name=aarch64_qt6-qttools-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-common}"
SRC_URI[aarch64_qt6-qttools-common.sha256sum] = "24b9fc296c8b07bf96265ebecb4b24133858f67f83191fbf1e82dba01a80b4f9"

URI_aarch64_qt6-qttools-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-devel-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qttools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-devel}"
SRC_URI[aarch64_qt6-qttools-devel.sha256sum] = "b4e6a27ffa03e65037b82c4fb1d83996eb5aedbf69f686975127f20c3517bb43"

URI_aarch64_qt6-qttools-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qttools-examples-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qttools-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-examples}"
SRC_URI[aarch64_qt6-qttools-examples.sha256sum] = "2c9cac27706a76cb4d1ed7f5b37b225f2a1a166a6614b90d2c8ae64db1ffaac8"

URI_aarch64_qt6-qttools-libs-designer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-libs-designer-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qttools-libs-designer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-libs-designer}"
SRC_URI[aarch64_qt6-qttools-libs-designer.sha256sum] = "a1029ef51094ca9eaf7624503e292b06b978c040506b59b01ec01cdab74824ae"

URI_aarch64_qt6-qttools-libs-designercomponents = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-libs-designercomponents-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qttools-libs-designercomponents;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-libs-designercomponents}"
SRC_URI[aarch64_qt6-qttools-libs-designercomponents.sha256sum] = "0d3a1d5f78b70e9ea39de55c7bea13cd0dc52bfb78eac46d36d2caf58f3ff61b"

URI_aarch64_qt6-qttools-libs-help = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-libs-help-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qttools-libs-help;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-libs-help}"
SRC_URI[aarch64_qt6-qttools-libs-help.sha256sum] = "0dd37a60d72f8885c59494bbbb89e248629f5413ee41b61df1586ada57aa2a69"

URI_aarch64_qt6-qttools-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qttools-static-6.9.1-1.el10.aarch64.rpm;name=aarch64_qt6-qttools-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-static}"
SRC_URI[aarch64_qt6-qttools-static.sha256sum] = "86d641814732f7305ecc723354a8fd460b5d32bec14bedf7b6ba26b3a80a262e"

RDEPENDS:qt6-assistant = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-designer = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 "
RDEPENDS:qt6-doctools = " \
 clang-libs \
 glibc \
 libstdc++ \
 llvm-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-linguist = " \
 clang-libs \
 glibc \
 libstdc++ \
 llvm-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qdbusviewer = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools-common = " \
 "
RDEPENDS:qt6-qttools-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-designer \
 qt6-doctools \
 qt6-linguist \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qttools \
 qt6-qttools-devel \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-qttools-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools \
 qt6-qttools-common \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-qttools-libs-designer = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools-libs-designercomponents = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 qt6-qttools-libs-designer \
 "
RDEPENDS:qt6-qttools-libs-help = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools-static = " \
 qt6-qttools-devel \
 "
