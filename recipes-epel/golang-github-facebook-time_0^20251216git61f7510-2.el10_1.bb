# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-facebook-time"
PV = "0^20251216git61f7510"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
 calnex \
 fbclock \
 golang-github-facebook-time-vendor-licenses \
 ntpcheck \
 ntpresponder \
 pshark \
 ptp4u \
 ptpcheck \
 sptp \
 ziffy \
"
PACKAGES:aarch64 = " \
 golang-github-facebook-time-vendor-licenses \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-facebook-time-0^20251216git61f7510-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f09eb902dae27ff9427a331d1fe75a36f35f5d381bfa852020d73c4fa5a1128f"

URI_x86_64_v2_calnex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calnex-0^20251216git61f7510-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calnex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calnex}"
SRC_URI[x86_64_v2_calnex.sha256sum] = "57c1472c63abec762e29681bc71d996782381a1a4dd6040335a0b840012c4bf5"

URI_x86_64_v2_fbclock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fbclock-0^20251216git61f7510-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fbclock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fbclock}"
SRC_URI[x86_64_v2_fbclock.sha256sum] = "913686031d04c784346ddfd8886bc41f4624465be1917f0e689a442b75230dd2"

URI_x86_64_v2_golang-github-facebook-time-vendor-licenses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-facebook-time-vendor-licenses-0^20251216git61f7510-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-facebook-time-vendor-licenses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-facebook-time-vendor-licenses}"
SRC_URI[x86_64_v2_golang-github-facebook-time-vendor-licenses.sha256sum] = "82c91fadf63afebfed65b877277d67ada25284866c23e19d7f8e90256886b3fd"

URI_x86_64_v2_ntpcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpcheck-0^20251216git61f7510-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpcheck}"
SRC_URI[x86_64_v2_ntpcheck.sha256sum] = "accd2ad16b47d2c909aafe39dfaae3387c7366639499d9acc46ac3baf2f2f9fa"

URI_x86_64_v2_ntpresponder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpresponder-0^20251216git61f7510-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpresponder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpresponder}"
SRC_URI[x86_64_v2_ntpresponder.sha256sum] = "8b870ce0579f76c73638ee934f1d0fc2524af4cbb8d0a3e4460521d9679593c2"

URI_x86_64_v2_pshark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pshark-0^20251216git61f7510-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pshark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pshark}"
SRC_URI[x86_64_v2_pshark.sha256sum] = "f4214834db5325ff069a6aecbac009c56acd185d8945529eb53a8ee750646313"

URI_x86_64_v2_ptp4u = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptp4u-0^20251216git61f7510-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptp4u;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptp4u}"
SRC_URI[x86_64_v2_ptp4u.sha256sum] = "54546f2bf7d053133f44c52ea99c26ab9aebea93bb4ff5b3607e28cfcf0eeac0"

URI_x86_64_v2_ptpcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptpcheck-0^20251216git61f7510-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptpcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptpcheck}"
SRC_URI[x86_64_v2_ptpcheck.sha256sum] = "a3be99e6ee51582fe01f96d4a09c1e9990adef99c52919ac3d511f9e67dccd2a"

URI_x86_64_v2_sptp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sptp-0^20251216git61f7510-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sptp}"
SRC_URI[x86_64_v2_sptp.sha256sum] = "217f94fd0d8eba728bb5cd179b9844be7413f9192e2a33c923b37bd62af5516e"

URI_x86_64_v2_ziffy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ziffy-0^20251216git61f7510-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ziffy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ziffy}"
SRC_URI[x86_64_v2_ziffy.sha256sum] = "a9167e8a5142734c710ed1eee67a6d7788e30ce4df3533359ddafc00c56bdbaf"

URI_aarch64_golang-github-facebook-time-vendor-licenses = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-facebook-time-vendor-licenses-0^20251216git61f7510-2.el10_1.noarch.rpm;name=aarch64_golang-github-facebook-time-vendor-licenses;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-facebook-time-vendor-licenses}"
SRC_URI[aarch64_golang-github-facebook-time-vendor-licenses.sha256sum] = "9c7fff3d749d467efc46ca1f8bc1767cc57a118144e91938000f792a6d55883e"

RDEPENDS:calnex = " \
 glibc \
 golang-github-facebook-time-vendor-licenses \
 "
RDEPENDS:fbclock = " \
 glibc \
 golang-github-facebook-time-vendor-licenses \
 "
RDEPENDS:golang-github-facebook-time-vendor-licenses = " \
 "
RDEPENDS:ntpcheck = " \
 glibc \
 golang-github-facebook-time-vendor-licenses \
 "
RDEPENDS:ntpresponder = " \
 glibc \
 golang-github-facebook-time-vendor-licenses \
 "
RDEPENDS:pshark = " \
 glibc \
 golang-github-facebook-time-vendor-licenses \
 "
RDEPENDS:ptp4u = " \
 glibc \
 golang-github-facebook-time-vendor-licenses \
 "
RDEPENDS:ptpcheck = " \
 glibc \
 golang-github-facebook-time-vendor-licenses \
 "
RDEPENDS:sptp = " \
 glibc \
 golang-github-facebook-time-vendor-licenses \
 "
RDEPENDS:ziffy = " \
 glibc \
 golang-github-facebook-time-vendor-licenses \
 libpcap \
 "
