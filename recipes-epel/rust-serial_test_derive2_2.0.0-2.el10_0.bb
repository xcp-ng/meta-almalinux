# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serial_test_derive2"
PV = "2.0.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-serial_test_derive2+async-devel \
 rust-serial_test_derive2+default-devel \
 rust-serial_test_derive2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serial_test_derive2-2.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32a766ba0de7011b05d2fcc2b88e944e405e3c28a5440cc60250792fc12204a2"

URI_x86_64_v2_rust-serial_test_derive2+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive2+async-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive2+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive2+async-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive2+async-devel.sha256sum] = "58082e5f4a7abdac98b25677566a53f770bc9dc130040f61e21d9f9e485ff3fa"

URI_x86_64_v2_rust-serial_test_derive2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive2+default-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive2+default-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive2+default-devel.sha256sum] = "69c7125b112288a124d95d94fcf47b4e6a6c15c8226c42806049ad9a11a13744"

URI_x86_64_v2_rust-serial_test_derive2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive2-devel-2.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive2-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive2-devel.sha256sum] = "7f87b0d4e558a6b8bed4a92cca903bf7f0aff3b0878b324bc37bd1649fcec9b9"

URI_aarch64_rust-serial_test_derive2+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive2+async-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test_derive2+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive2+async-devel}"
SRC_URI[aarch64_rust-serial_test_derive2+async-devel.sha256sum] = "46663e8593cc3fc783d516c0dd714ede7693f37fe786691ba82d1528c1694af7"

URI_aarch64_rust-serial_test_derive2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive2+default-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test_derive2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive2+default-devel}"
SRC_URI[aarch64_rust-serial_test_derive2+default-devel.sha256sum] = "1cc1a942a5e1277d3d2f0d056773cce7c3c4bde14de845c7ba30b55463ef0864"

URI_aarch64_rust-serial_test_derive2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive2-devel-2.0.0-2.el10_0.noarch.rpm;name=aarch64_rust-serial_test_derive2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive2-devel}"
SRC_URI[aarch64_rust-serial_test_derive2-devel.sha256sum] = "40be148d6b6acfcc547559fa178ae58cd730cb73805d742a59a924316c675417"

RDEPENDS:rust-serial_test_derive2+async-devel = " \
 cargo \
 rust-serial_test_derive2-devel \
 "
RDEPENDS:rust-serial_test_derive2+default-devel = " \
 cargo \
 rust-serial_test_derive2-devel \
 "
RDEPENDS:rust-serial_test_derive2-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
