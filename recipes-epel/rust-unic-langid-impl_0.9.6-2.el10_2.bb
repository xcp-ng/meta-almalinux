# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-langid-impl"
PV = "0.9.6"
PR = "2.el10_2"
PACKAGES = " \
 rust-unic-langid-impl+binary-devel \
 rust-unic-langid-impl+default-devel \
 rust-unic-langid-impl+likelysubtags-devel \
 rust-unic-langid-impl+serde-devel \
 rust-unic-langid-impl+serde_json-devel \
 rust-unic-langid-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-langid-impl-0.9.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "730c5d1bf47fe6f22b7c9e73a0fec2bb4d9021170eeacc06bf11d1a1a64e6875"

URI_x86_64_v2_rust-unic-langid-impl+binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-impl+binary-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-impl+binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-impl+binary-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-impl+binary-devel.sha256sum] = "01545747b9d65a3409808fd500104599937e023579d81ca946e7b3c52db69ae8"

URI_x86_64_v2_rust-unic-langid-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-impl+default-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-impl+default-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-impl+default-devel.sha256sum] = "680f4130d7f079616971b13ddad5766465c03b4b5ecf7d625c96b24913a822f3"

URI_x86_64_v2_rust-unic-langid-impl+likelysubtags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-impl+likelysubtags-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-impl+likelysubtags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-impl+likelysubtags-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-impl+likelysubtags-devel.sha256sum] = "a67a4465cf39cd3076e5dd533a9a9575a1ae3d67e875f9a5d58d1a32087c51c0"

URI_x86_64_v2_rust-unic-langid-impl+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-impl+serde-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-impl+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-impl+serde-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-impl+serde-devel.sha256sum] = "42628f1b14294bbd12ab09c87723673de86d024464cbdfe4978d4fb5f35bf403"

URI_x86_64_v2_rust-unic-langid-impl+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-impl+serde_json-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-impl+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-impl+serde_json-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-impl+serde_json-devel.sha256sum] = "9496392787c4a7d1f0a82ed818f5f9bd9f64ac2050bd898876e433c7f0d16905"

URI_x86_64_v2_rust-unic-langid-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-impl-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-impl-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-impl-devel.sha256sum] = "85c4fac7a85290a687788a2e65abba90b663c2d6455ca1c69bfd66fde248aca2"

URI_aarch64_rust-unic-langid-impl+binary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-impl+binary-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-impl+binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-impl+binary-devel}"
SRC_URI[aarch64_rust-unic-langid-impl+binary-devel.sha256sum] = "814e6a2798b7ce43797b15ff55843bbf2c7c7b27f1d83c805f258107eaa994f7"

URI_aarch64_rust-unic-langid-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-impl+default-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-impl+default-devel}"
SRC_URI[aarch64_rust-unic-langid-impl+default-devel.sha256sum] = "d3758e7f345a7bfcb181eb2acf0b21ea2723d0706f584fc467fe8a270bf5af22"

URI_aarch64_rust-unic-langid-impl+likelysubtags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-impl+likelysubtags-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-impl+likelysubtags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-impl+likelysubtags-devel}"
SRC_URI[aarch64_rust-unic-langid-impl+likelysubtags-devel.sha256sum] = "992c7e62d2ba22cf69bc90b9e7b1c714358ed62155da42a853441fb3554812bc"

URI_aarch64_rust-unic-langid-impl+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-impl+serde-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-impl+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-impl+serde-devel}"
SRC_URI[aarch64_rust-unic-langid-impl+serde-devel.sha256sum] = "b5338419e169b6f79cc3d4a743d6ae0e7beb4944760f7d6f20fd3e1416bee002"

URI_aarch64_rust-unic-langid-impl+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-impl+serde_json-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-impl+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-impl+serde_json-devel}"
SRC_URI[aarch64_rust-unic-langid-impl+serde_json-devel.sha256sum] = "beb084ebae8a27582afeabad47c76bb7ff21783124ce7943c0a09c09cbb8d9ce"

URI_aarch64_rust-unic-langid-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-impl-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-impl-devel}"
SRC_URI[aarch64_rust-unic-langid-impl-devel.sha256sum] = "f62b6d77601a761b01b6e4da4f3bdcf73bc8095767d01e3d3907dc79ea69d170"

RDEPENDS:rust-unic-langid-impl+binary-devel = " \
 cargo \
 rust-unic-langid-impl+serde-devel \
 rust-unic-langid-impl+serde_json-devel \
 rust-unic-langid-impl-devel \
 "
RDEPENDS:rust-unic-langid-impl+default-devel = " \
 cargo \
 rust-unic-langid-impl-devel \
 "
RDEPENDS:rust-unic-langid-impl+likelysubtags-devel = " \
 cargo \
 rust-unic-langid-impl-devel \
 "
RDEPENDS:rust-unic-langid-impl+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-unic-langid-impl-devel \
 "
RDEPENDS:rust-unic-langid-impl+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-unic-langid-impl-devel \
 "
RDEPENDS:rust-unic-langid-impl-devel = " \
 cargo \
 rust-tinystr+default-devel \
 "
