# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "milter-greylist"
PV = "4.6.4"
PR = "18.el10_2"
PACKAGES = " \
 milter-greylist \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/milter-greylist-4.6.4-18.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3af8d8fe2debe6a406bd8e3db089a83caf29d07df8d9739409df845dac1541fd"

URI_x86_64_v2_milter-greylist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/milter-greylist-4.6.4-18.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_milter-greylist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_milter-greylist}"
SRC_URI[x86_64_v2_milter-greylist.sha256sum] = "5c226134bb70db73e97e520c2e0ba18e6be95e94dddaa94aafc6692f1eb2f49a"

URI_aarch64_milter-greylist = "${EPEL_MIRROR}/aarch64/Packages/m/milter-greylist-4.6.4-18.el10_2.aarch64.rpm;name=aarch64_milter-greylist;unpack=0"
SRC_URI:append = " ${URI_aarch64_milter-greylist}"
SRC_URI[aarch64_milter-greylist.sha256sum] = "10f44db2e428a6c2f2d19d17a0bab8a5e2cb8e599bdd269bb24219e473432111"

RDEPENDS:milter-greylist = " \
 bash \
 glibc \
 libmaxminddb \
 libspf2 \
 sendmail-milter \
 shadow-utils \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
