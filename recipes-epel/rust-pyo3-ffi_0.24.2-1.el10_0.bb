# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi"
PV = "0.24.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-ffi+abi3-devel \
 rust-pyo3-ffi+abi3-py310-devel \
 rust-pyo3-ffi+abi3-py311-devel \
 rust-pyo3-ffi+abi3-py312-devel \
 rust-pyo3-ffi+abi3-py313-devel \
 rust-pyo3-ffi+abi3-py37-devel \
 rust-pyo3-ffi+abi3-py38-devel \
 rust-pyo3-ffi+abi3-py39-devel \
 rust-pyo3-ffi+default-devel \
 rust-pyo3-ffi+extension-module-devel \
 rust-pyo3-ffi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi-0.24.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdf8d0f9d296283c55e7ca97b778a1f618abdf8cbe79aa5562c94ce5a14e6b3e"

URI_x86_64_v2_rust-pyo3-ffi+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-devel.sha256sum] = "306b07d7ac83e1dd47543ac2e4723dfa05a790ab2f4c4b4ab8e58fdb78e9d61f"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py310-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py310-devel.sha256sum] = "92e8a43641886a77e483274aad069c77b1e6212e67ce33778b68e47efa514e28"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py311-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py311-devel.sha256sum] = "4e42e02d851062612ddc2d503edb23321562ccccc81d18bf8d344f017d96e74a"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py312-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py312-devel.sha256sum] = "fc5c1e56fb02fd7dbe29adab87e7c3a9086032ebd4b8b4d26bf8fe5a080bace1"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py313-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py313-devel.sha256sum] = "0be3de796a19f38b9343415b2e03356b8efc92b0ffa895610597d9c498fc8c7d"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py37-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py37-devel.sha256sum] = "c69bbcb2f009d7602265c8a6b0552339945949603825bb6c8cfdf3b377a73d6a"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py38-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py38-devel.sha256sum] = "97e7f9d431aab648a4b94928acdc6f138c425b45e7f059e46ae8f4082f8d7e59"

URI_x86_64_v2_rust-pyo3-ffi+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+abi3-py39-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+abi3-py39-devel.sha256sum] = "0fd2f1a10a8d872e69fa78381dbe46e392cc32930b8ae80b56705e8efd59f7ef"

URI_x86_64_v2_rust-pyo3-ffi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+default-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+default-devel.sha256sum] = "d21b7830484b2abd733dabf31a2d496308df48c10f00776ef5e94050d9fdf3a5"

URI_x86_64_v2_rust-pyo3-ffi+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi+extension-module-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi+extension-module-devel.sha256sum] = "13cba2895003ee4e78cb5678c768d06dbc85643b2ddf76cd0b986091fe18f143"

URI_x86_64_v2_rust-pyo3-ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi-devel.sha256sum] = "01cb8f00eb72551a3f42c58ecf57cee1e4dfa1f978cc479953549d36f27162fb"

URI_aarch64_rust-pyo3-ffi+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-devel.sha256sum] = "a45c734b6a86dc1a3cb8140454e70800a21eb24d1ffb25f25abafc325526d83e"

URI_aarch64_rust-pyo3-ffi+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py310-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py310-devel.sha256sum] = "057129aa06cfe8faaf42fa8fac31de3260536aeac912ff787d5bcf5970922e23"

URI_aarch64_rust-pyo3-ffi+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py311-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py311-devel.sha256sum] = "1ccd4bd94c0add1637d49af40e6358e3a4e9644fddf60ddb32351d930a157536"

URI_aarch64_rust-pyo3-ffi+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py312-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py312-devel.sha256sum] = "f33071b85f2c70012e356d76741ec98f7c3f7abb1b439de880078a0abbb74d8c"

URI_aarch64_rust-pyo3-ffi+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py313-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py313-devel.sha256sum] = "b7353af98ea41c3ccee1ebe7ac10750dd7d76f9e1abdc12a3dd827cb061727dd"

URI_aarch64_rust-pyo3-ffi+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py37-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py37-devel.sha256sum] = "824b49ac54f52a82987dcc318b92c5832280f8479334f1ca0c9bc7f0f3938899"

URI_aarch64_rust-pyo3-ffi+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py38-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py38-devel.sha256sum] = "3055599adce35dc0347e64b61e3c162a902feac4788239b8773a178308e416c6"

URI_aarch64_rust-pyo3-ffi+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+abi3-py39-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+abi3-py39-devel.sha256sum] = "5086a4796e09770562d0a02f109bc278d4837b1c798a835addff3e252ba429c1"

URI_aarch64_rust-pyo3-ffi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+default-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+default-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+default-devel.sha256sum] = "77cdb85ec2dda3c328fd9b72bfb2e755b962abc8a45143108188d9a9996699b7"

URI_aarch64_rust-pyo3-ffi+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi+extension-module-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-ffi+extension-module-devel.sha256sum] = "f29fc587197fa811e548a870b8eb8aa5b0b3851b88b017ce5d8348e6c390dc84"

URI_aarch64_rust-pyo3-ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi-devel}"
SRC_URI[aarch64_rust-pyo3-ffi-devel.sha256sum] = "d408ad0e3107f03ec69ae9bb7a59319484c8fc30fc38e82ffeaa1b8e59ab3582"

RDEPENDS:rust-pyo3-ffi+abi3-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py311-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py312-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py313-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py38-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py39-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi+abi3-py310-devel \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+default-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi-devel \
 "
RDEPENDS:rust-pyo3-ffi-devel = " \
 cargo \
 python3-devel \
 rust \
 rust-libc+default-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+resolve-config-devel \
 "
