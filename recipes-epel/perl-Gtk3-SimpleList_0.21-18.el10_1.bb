# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Gtk3-SimpleList"
PV = "0.21"
PR = "18.el10_1"
PACKAGES = " \
 perl-Gtk3-SimpleList \
 perl-Gtk3-SimpleList-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Gtk3-SimpleList-0.21-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ec2884a5794adf911b82df13cb42c97c69db9ac76a0df8deae57894c01316ae"

URI_x86_64_v2_perl-Gtk3-SimpleList = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-SimpleList-0.21-18.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-SimpleList;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-SimpleList}"
SRC_URI[x86_64_v2_perl-Gtk3-SimpleList.sha256sum] = "ae90deae0031b9c39ffda5f49cb2ee0f90167f30ccb861d33ba311fef3b88488"

URI_x86_64_v2_perl-Gtk3-SimpleList-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-SimpleList-tests-0.21-18.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-SimpleList-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-SimpleList-tests}"
SRC_URI[x86_64_v2_perl-Gtk3-SimpleList-tests.sha256sum] = "984a6e9e06324a82252e227a00331cd9ea62c48284f49c22b178a18f1a5e223a"

URI_aarch64_perl-Gtk3-SimpleList = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-SimpleList-0.21-18.el10_1.noarch.rpm;name=aarch64_perl-Gtk3-SimpleList;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-SimpleList}"
SRC_URI[aarch64_perl-Gtk3-SimpleList.sha256sum] = "274f6413cb4fd3844ee726b9ab5b8fe2f1f59b04c38c1aeddba3057203165a5d"

URI_aarch64_perl-Gtk3-SimpleList-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-SimpleList-tests-0.21-18.el10_1.noarch.rpm;name=aarch64_perl-Gtk3-SimpleList-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-SimpleList-tests}"
SRC_URI[aarch64_perl-Gtk3-SimpleList-tests.sha256sum] = "419b99939438459e020c02077c5a59f4e783c58965d475fef2b032b2f943ad59"

RDEPENDS:perl-Gtk3-SimpleList = " \
 perl-Carp \
 perl-Gtk3 \
 perl-libs \
 "
RDEPENDS:perl-Gtk3-SimpleList-tests = " \
 bash \
 perl-Gtk3-SimpleList \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 "
