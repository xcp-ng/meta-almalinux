# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fern"
PV = "0.7.1"
PR = "4.el10_2"
PACKAGES = " \
 rust-fern+chrono-devel \
 rust-fern+colored-devel \
 rust-fern+date-based-devel \
 rust-fern+default-devel \
 rust-fern+libc-devel \
 rust-fern+meta-logging-in-format-devel \
 rust-fern+syslog-6-devel \
 rust-fern+syslog6-devel \
 rust-fern-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-fern-0.7.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9812719c47fd7899b480f1a61fe478eacf1c8130ec5c61d9d801524908145596"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+chrono-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+chrono-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fern+chrono-devel.sha256sum] = "5a30c9d22e9da9be254bdb06e46b9818488b09b26aab0b4c252fd1ea8797522e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+colored-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+colored-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fern+colored-devel.sha256sum] = "008a9ced4134bf75c5b287f43b7906a857cc42f458ab646c3362a670cb2c4fcb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+date-based-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+date-based-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fern+date-based-devel.sha256sum] = "0111b7a7c9829256df5ea47e4ce875f6e7867514dbaf6fb17fd7c5854535a76c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+default-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fern+default-devel.sha256sum] = "37bd80243ae4b1744a69fd591ebaf622bd6543bf749d5f14b7aa0e7e074d29e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+libc-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+libc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fern+libc-devel.sha256sum] = "62afb67173b9eb3b38287029c29e765881ebc0ed5c6ca7f2226b32434e41dd3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+meta-logging-in-format-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+meta-logging-in-format-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fern+meta-logging-in-format-devel.sha256sum] = "9477580b07090fca218d7b7a2d93c57d65b840b5be6675482524737004c09a86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+syslog-6-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+syslog-6-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fern+syslog-6-devel.sha256sum] = "8c79600bc135ec5d3082ffc6cd15cbf92e273dd43b1c27002e3dd2ef8338d6e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+syslog6-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+syslog6-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fern+syslog6-devel.sha256sum] = "ed0d0940e191bca92d83a88a28f7f67280725eb42d9abab60d3db0a02a1ed640"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fern-devel.sha256sum] = "b7d9f14a3081e0b80c8a94aa8dcdfe25add80ecbe803ff2820ed52547eb88a61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+chrono-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-fern+chrono-devel;unpack=0"
SRC_URI[aarch64_rust-fern+chrono-devel.sha256sum] = "f75ecf81c31f604e5157192ab74dce3e2a2dd7872354f0a61615614a644c4f3f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+colored-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-fern+colored-devel;unpack=0"
SRC_URI[aarch64_rust-fern+colored-devel.sha256sum] = "9d3946d2248a5d548fcd8d3f9574fc071e7ab8d76c079af28e25894ff3c47837"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+date-based-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-fern+date-based-devel;unpack=0"
SRC_URI[aarch64_rust-fern+date-based-devel.sha256sum] = "5b71109174d9d431e608338066e9e781c0cacb6659e7578a76ac88d10fe96270"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+default-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-fern+default-devel;unpack=0"
SRC_URI[aarch64_rust-fern+default-devel.sha256sum] = "f70ccb1a48cceb724e182249ef4efee820df1e727fb96a84209eba134279828b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+libc-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-fern+libc-devel;unpack=0"
SRC_URI[aarch64_rust-fern+libc-devel.sha256sum] = "110a5ea7426f68ac509b10e25eb3dc39f38ebbccc5b12d03d5fad289960fd10c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+meta-logging-in-format-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-fern+meta-logging-in-format-devel;unpack=0"
SRC_URI[aarch64_rust-fern+meta-logging-in-format-devel.sha256sum] = "18119321c24c89dc7bc8c10ae820005532c3626037a6599ea3ecab9c4c29593b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+syslog-6-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-fern+syslog-6-devel;unpack=0"
SRC_URI[aarch64_rust-fern+syslog-6-devel.sha256sum] = "e89e9f9ffccf90e2cd509dbe8421548667058fd9fe8b63c4bf755871ec0327d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+syslog6-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-fern+syslog6-devel;unpack=0"
SRC_URI[aarch64_rust-fern+syslog6-devel.sha256sum] = "ad126406955706482d52734184eea3a1a012be131db233945a1aa7ee793ff657"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fern-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-fern-devel;unpack=0"
SRC_URI[aarch64_rust-fern-devel.sha256sum] = "a7d69cac219692491e8d635fa500255b8d3773e4107a7648ff92dcdf98670425"

RDEPENDS:rust-fern+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+colored-devel = " \
 cargo \
 rust-colored2+default-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+date-based-devel = " \
 cargo \
 rust-fern+chrono-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+default-devel = " \
 cargo \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+libc-devel = " \
 cargo \
 rust-fern-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-fern+meta-logging-in-format-devel = " \
 cargo \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+syslog-6-devel = " \
 cargo \
 rust-fern+syslog6-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+syslog6-devel = " \
 cargo \
 rust-fern-devel \
 rust-syslog+default-devel \
 "
RDEPENDS:rust-fern-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-log+std-devel \
 "
