# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-emojis"
PV = "0.9.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-emojis+default-devel \
 rust-emojis+serde-devel \
 rust-emojis-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-emojis-0.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2531d16761f8b761ce4ea97f096aac5ad4376abfd5422889b5e5dcba7803bc0a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-emojis+default-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-emojis+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-emojis+default-devel.sha256sum] = "3c4a53ed87411908d4b6b518ac9fee0ab3f5b4eae8f1de0dd6157aa62cf57b4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-emojis+serde-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-emojis+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-emojis+serde-devel.sha256sum] = "43e593ba8b21b5f81c7114d9c2dde693674bc39295cae687a7b6da955b326fef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-emojis-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-emojis-devel;unpack=0"
SRC_URI[x86_64_v2_rust-emojis-devel.sha256sum] = "578fd7ab7e0ca62701b420505c7ea312b85afc4835b35873c0cac7bfeed69086"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-emojis+default-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-emojis+default-devel;unpack=0"
SRC_URI[aarch64_rust-emojis+default-devel.sha256sum] = "2bd7409682455d47317e1fdfd660c2692b3babb6d4d38f5ce13bbe1299717852"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-emojis+serde-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-emojis+serde-devel;unpack=0"
SRC_URI[aarch64_rust-emojis+serde-devel.sha256sum] = "6f7016337603725224e9da29ba5f1d32f3384fd730e9680db7d63a71f9623fb1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-emojis-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-emojis-devel;unpack=0"
SRC_URI[aarch64_rust-emojis-devel.sha256sum] = "99a643229f7684720f226724177f5d1c7019c54a45d44ca563ca67aa0c08c736"

RDEPENDS:rust-emojis+default-devel = " \
 cargo \
 rust-emojis-devel \
 "
RDEPENDS:rust-emojis+serde-devel = " \
 cargo \
 rust-emojis-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-emojis-devel = " \
 cargo \
 rust \
 rust-phf-devel \
 "
