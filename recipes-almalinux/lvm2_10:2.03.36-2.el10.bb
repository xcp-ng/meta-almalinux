# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lvm2"
PE = "10"
PV = "2.03.36"
PR = "2.el10"
PACKAGES = " \
 device-mapper \
 device-mapper-devel \
 device-mapper-event \
 device-mapper-event-devel \
 device-mapper-event-libs \
 device-mapper-libs \
 lvm2 \
 lvm2-dbusd \
 lvm2-devel \
 lvm2-libs \
 lvm2-lockd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lvm2-2.03.36-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86d8bd2276934eb958d8d8f8009f7a135db6ea8fc1336be42644bba53931f9e6"

URI_x86_64_v2_device-mapper = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-1.02.210-2.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper}"
SRC_URI[x86_64_v2_device-mapper.sha256sum] = "1b96be591c9243ffc31ce2418de775c234042866a98e7f05d1bd1f5497386e5f"

URI_x86_64_v2_device-mapper-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-devel-1.02.210-2.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-devel}"
SRC_URI[x86_64_v2_device-mapper-devel.sha256sum] = "36552d5a3871116b508e69837f1bad412018777bc0117d6ae82c3a439513942e"

URI_x86_64_v2_device-mapper-event = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-event-1.02.210-2.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-event;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-event}"
SRC_URI[x86_64_v2_device-mapper-event.sha256sum] = "c5508e7c3271dda2d0c0a945125df36e16c5d6661c8e126628366e69bd4c1104"

URI_x86_64_v2_device-mapper-event-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-event-devel-1.02.210-2.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-event-devel}"
SRC_URI[x86_64_v2_device-mapper-event-devel.sha256sum] = "f3e9cf1ca0ade335a9650d0af5eb54ac7dce5d29e9342ab89cb58375d6eb302f"

URI_x86_64_v2_device-mapper-event-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-event-libs-1.02.210-2.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-event-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-event-libs}"
SRC_URI[x86_64_v2_device-mapper-event-libs.sha256sum] = "ba67586fa98523454fc61d9c15766c20f48d118cfef4c6c703d7cba4a5214f11"

URI_x86_64_v2_device-mapper-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-libs-1.02.210-2.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-libs}"
SRC_URI[x86_64_v2_device-mapper-libs.sha256sum] = "fdc4003fc75b59913a7cfa9d8dadeee22194e419240645ce8310c616313f1701"

URI_x86_64_v2_lvm2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lvm2-2.03.36-2.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2}"
SRC_URI[x86_64_v2_lvm2.sha256sum] = "347f2da73f9f497164ef3ed738c6a09bf831a65006d9e320aadfb79492961337"

URI_x86_64_v2_lvm2-dbusd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lvm2-dbusd-2.03.36-2.el10.noarch.rpm;name=x86_64_v2_lvm2-dbusd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-dbusd}"
SRC_URI[x86_64_v2_lvm2-dbusd.sha256sum] = "75b31a7bdd3c2f6557b9432f21f66cabfbc5aab5a26650ccbd971a5b2316feb5"

URI_x86_64_v2_lvm2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/lvm2-devel-2.03.36-2.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-devel}"
SRC_URI[x86_64_v2_lvm2-devel.sha256sum] = "a7e7c21b7985f9b0b40c162fb7085a5a483d5336a6fc2b4ed3b2c7a87ef50690"

URI_x86_64_v2_lvm2-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lvm2-libs-2.03.36-2.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-libs}"
SRC_URI[x86_64_v2_lvm2-libs.sha256sum] = "2d94be43124e6ec607b0d38eeda4376d49c1fc869496b5b21d3660e75097afdd"

URI_x86_64_v2_lvm2-lockd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lvm2-lockd-2.03.36-2.el10.x86_64_v2.rpm;name=x86_64_v2_lvm2-lockd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lvm2-lockd}"
SRC_URI[x86_64_v2_lvm2-lockd.sha256sum] = "e52017e48eef244ee244fd658eac877621162d1cf0e6b6ad50b56a6292d51493"

URI_aarch64_device-mapper = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-1.02.210-2.el10.aarch64.rpm;name=aarch64_device-mapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper}"
SRC_URI[aarch64_device-mapper.sha256sum] = "84bfe8d609e2da22a0bba47ce20a0e4480c144045f5b9a792436550ae0838638"

URI_aarch64_device-mapper-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-devel-1.02.210-2.el10.aarch64.rpm;name=aarch64_device-mapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-devel}"
SRC_URI[aarch64_device-mapper-devel.sha256sum] = "5ca99597b570f29ad62f0c3cbec14efe1b8c82b37e42e2579b34edcc81d82e4c"

URI_aarch64_device-mapper-event = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-event-1.02.210-2.el10.aarch64.rpm;name=aarch64_device-mapper-event;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-event}"
SRC_URI[aarch64_device-mapper-event.sha256sum] = "04ef0ec293f0a6802c683fd08d80f82d46101a9e5962eeeb2d283e1f50b2fdfb"

URI_aarch64_device-mapper-event-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-event-devel-1.02.210-2.el10.aarch64.rpm;name=aarch64_device-mapper-event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-event-devel}"
SRC_URI[aarch64_device-mapper-event-devel.sha256sum] = "43db4b9c978c9a36d638bc887d8fd74782f9541f4de678a5ac03b0889e52d681"

URI_aarch64_device-mapper-event-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-event-libs-1.02.210-2.el10.aarch64.rpm;name=aarch64_device-mapper-event-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-event-libs}"
SRC_URI[aarch64_device-mapper-event-libs.sha256sum] = "9a5a6d5405d549ac7bfb340571dfa19b4cf4ad2a57e1f653c94296d7b0b82110"

URI_aarch64_device-mapper-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-libs-1.02.210-2.el10.aarch64.rpm;name=aarch64_device-mapper-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-libs}"
SRC_URI[aarch64_device-mapper-libs.sha256sum] = "f755d2ea7287bad42a50c8038f2a494e7099c7d5f41eca5859db13a452f0da68"

URI_aarch64_lvm2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lvm2-2.03.36-2.el10.aarch64.rpm;name=aarch64_lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2}"
SRC_URI[aarch64_lvm2.sha256sum] = "fd4c8f7c61f04a95710f842dc146f775e93ae67d1da91d8fc2a35ad5410e0a1d"

URI_aarch64_lvm2-dbusd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lvm2-dbusd-2.03.36-2.el10.noarch.rpm;name=aarch64_lvm2-dbusd;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-dbusd}"
SRC_URI[aarch64_lvm2-dbusd.sha256sum] = "75b31a7bdd3c2f6557b9432f21f66cabfbc5aab5a26650ccbd971a5b2316feb5"

URI_aarch64_lvm2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/lvm2-devel-2.03.36-2.el10.aarch64.rpm;name=aarch64_lvm2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-devel}"
SRC_URI[aarch64_lvm2-devel.sha256sum] = "dea9a1e97dd42667db58adeb612335e4c0968542d30305a5b0c35706d2288024"

URI_aarch64_lvm2-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lvm2-libs-2.03.36-2.el10.aarch64.rpm;name=aarch64_lvm2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-libs}"
SRC_URI[aarch64_lvm2-libs.sha256sum] = "dd70aad1eee7f979d4d44f0a19cd81685516be3843c110fa141d8278ed3c454c"

URI_aarch64_lvm2-lockd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lvm2-lockd-2.03.36-2.el10.aarch64.rpm;name=aarch64_lvm2-lockd;unpack=0"
SRC_URI:append = " ${URI_aarch64_lvm2-lockd}"
SRC_URI[aarch64_lvm2-lockd.sha256sum] = "f20799325813261edb0162bae611c9b0d9be8dd6ab9fb7c17dae27cad9bc7efc"

RDEPENDS:device-mapper = " \
 bash \
 device-mapper-libs \
 glibc \
 systemd \
 util-linux-core \
 "
RDEPENDS:device-mapper-devel = " \
 device-mapper \
 device-mapper-libs \
 libselinux-devel \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:device-mapper-event = " \
 bash \
 device-mapper \
 device-mapper-event-libs \
 device-mapper-libs \
 glibc \
 libgcc \
 systemd \
 "
RDEPENDS:device-mapper-event-devel = " \
 device-mapper-event \
 device-mapper-event-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:device-mapper-event-libs = " \
 device-mapper-libs \
 glibc \
 "
RDEPENDS:device-mapper-libs = " \
 device-mapper \
 glibc \
 libselinux \
 systemd-libs \
 "
RDEPENDS:lvm2 = " \
 bash \
 device-mapper-event-libs \
 device-mapper-persistent-data \
 glibc \
 kmod \
 libaio \
 libblkid \
 libedit \
 libnvme \
 libselinux \
 lvm2-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:lvm2-dbusd = " \
 bash \
 dbus \
 lvm2 \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-pyudev \
 systemd \
 "
RDEPENDS:lvm2-devel = " \
 device-mapper-devel \
 device-mapper-event-devel \
 lvm2 \
 lvm2-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:lvm2-libs = " \
 device-mapper-event \
 device-mapper-event-libs \
 device-mapper-libs \
 glibc \
 libaio \
 libblkid \
 libnvme \
 libselinux \
 systemd-libs \
 "
RDEPENDS:lvm2-lockd = " \
 bash \
 glibc \
 libselinux \
 lvm2 \
 sanlock-lib \
 systemd \
 systemd-libs \
 "
