# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bstr"
PV = "1.13.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-bstr+alloc-devel \
 rust-bstr+default-devel \
 rust-bstr+serde-devel \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bstr-1.13.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62a784a53676389c01817ecd0d89bd73b38040819d58c241ce37157f30466108"

URI_x86_64_v2_rust-bstr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+alloc-devel-1.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+alloc-devel}"
SRC_URI[x86_64_v2_rust-bstr+alloc-devel.sha256sum] = "67bd2006f3e6db0a8b4acafe41d5fa8a3ed667aebda26d60dfcb396def36c461"

URI_x86_64_v2_rust-bstr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+default-devel-1.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+default-devel}"
SRC_URI[x86_64_v2_rust-bstr+default-devel.sha256sum] = "55eea19646da926598222e03fbff6480c3a888e18b37175b991676ca6ce118a0"

URI_x86_64_v2_rust-bstr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+serde-devel-1.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+serde-devel}"
SRC_URI[x86_64_v2_rust-bstr+serde-devel.sha256sum] = "ab60d028f608d84088389a0c93eb653110de931f3d4688e51f981d32a5b6c45c"

URI_x86_64_v2_rust-bstr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+std-devel-1.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+std-devel}"
SRC_URI[x86_64_v2_rust-bstr+std-devel.sha256sum] = "b0fc0643fc4a3f4470fda9cc5d848837ee69af2f440c311a0848958c0f2c0312"

URI_x86_64_v2_rust-bstr+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr+unicode-devel-1.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr+unicode-devel}"
SRC_URI[x86_64_v2_rust-bstr+unicode-devel.sha256sum] = "e3128e68b66b330050aa282b8d2e2e70067a48466786d0a1c56ec8c00ea9122b"

URI_x86_64_v2_rust-bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bstr-devel-1.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bstr-devel}"
SRC_URI[x86_64_v2_rust-bstr-devel.sha256sum] = "e3893b8fe792d1cb38436b913ca026418092a9981557d299cd21af4f9ea6ef30"

URI_aarch64_rust-bstr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+alloc-devel-1.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-bstr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+alloc-devel}"
SRC_URI[aarch64_rust-bstr+alloc-devel.sha256sum] = "26b7a7a338b4ccdf9ffe21f123d960d250cfa4f4cde9b389da71823cbc70c1bb"

URI_aarch64_rust-bstr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+default-devel-1.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-bstr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+default-devel}"
SRC_URI[aarch64_rust-bstr+default-devel.sha256sum] = "6f7693261d0430c138370e0d19dbd4a572cda507fa2e58e0093b2a65b83677ec"

URI_aarch64_rust-bstr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+serde-devel-1.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-bstr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+serde-devel}"
SRC_URI[aarch64_rust-bstr+serde-devel.sha256sum] = "2632188014b45f48e84451f71685c25049bb74c11e4fef81d3ee2c944360d872"

URI_aarch64_rust-bstr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+std-devel-1.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-bstr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+std-devel}"
SRC_URI[aarch64_rust-bstr+std-devel.sha256sum] = "589c42bcd35c48a7e6817eb8e01817eab3a12ce43e630ea623bb859bb678c11d"

URI_aarch64_rust-bstr+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr+unicode-devel-1.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-bstr+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr+unicode-devel}"
SRC_URI[aarch64_rust-bstr+unicode-devel.sha256sum] = "2f57537b89970c132d06885068a6474f72798f0bca068e96a4fef13992337234"

URI_aarch64_rust-bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bstr-devel-1.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bstr-devel}"
SRC_URI[aarch64_rust-bstr-devel.sha256sum] = "9233f65e6c46a1164e2be96c1933a2c349293a64db5c0efbba5abb94806122cb"

RDEPENDS:rust-bstr+alloc-devel = " \
 cargo \
 rust-bstr-devel \
 rust-memchr+alloc-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+default-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 "
RDEPENDS:rust-bstr+serde-devel = " \
 cargo \
 rust-bstr-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+std-devel = " \
 cargo \
 rust-bstr+alloc-devel \
 rust-bstr-devel \
 rust-memchr+std-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-bstr+unicode-devel = " \
 cargo \
 rust-bstr-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-bstr-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "
