# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert_matches"
PV = "1.5.0"
PR = "10.el10_0"
PACKAGES = " \
 rust-assert_matches+default-devel \
 rust-assert_matches-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert_matches-1.5.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63a5c95a433b54d4a4d068ae7184041ed2b1e963dddd4ec22fb9273d7975b8fe"

URI_x86_64_v2_rust-assert_matches+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_matches+default-devel-1.5.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_matches+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_matches+default-devel}"
SRC_URI[x86_64_v2_rust-assert_matches+default-devel.sha256sum] = "7309532fbcd25683953e773b657f2fc04f8ca0a24612d794b55bd283c7f45133"

URI_x86_64_v2_rust-assert_matches-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_matches-devel-1.5.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_matches-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_matches-devel}"
SRC_URI[x86_64_v2_rust-assert_matches-devel.sha256sum] = "341975e2b808e424f364c3f91406cc262b1a629225f138f515051118eb902717"

URI_aarch64_rust-assert_matches+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_matches+default-devel-1.5.0-10.el10_0.noarch.rpm;name=aarch64_rust-assert_matches+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_matches+default-devel}"
SRC_URI[aarch64_rust-assert_matches+default-devel.sha256sum] = "89e7500a08fc968a3e1aea8d0749d62d08fce5c649e3fd09e6ede02b1cdbdb84"

URI_aarch64_rust-assert_matches-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_matches-devel-1.5.0-10.el10_0.noarch.rpm;name=aarch64_rust-assert_matches-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_matches-devel}"
SRC_URI[aarch64_rust-assert_matches-devel.sha256sum] = "0f729a1aadb29e4b3030638fc59e0d50a9d33bb6e45a078e301173019657b403"

RDEPENDS:rust-assert_matches+default-devel = " \
 cargo \
 rust-assert_matches-devel \
 "
RDEPENDS:rust-assert_matches-devel = " \
 cargo \
 "
