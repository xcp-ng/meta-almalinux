# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konquest"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 konquest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konquest-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28b506746071fac95b64dccacad80c0aab130b177ffb7939fc3e9c063eb54b6c"

URI_x86_64_v2_konquest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konquest-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konquest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konquest}"
SRC_URI[x86_64_v2_konquest.sha256sum] = "160fe6e60e94860c225956918266a4ddc19f1bf01a40748dcb736505753f27b8"

URI_aarch64_konquest = "${EPEL_MIRROR}/aarch64/Packages/k/konquest-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_konquest;unpack=0"
SRC_URI:append = " ${URI_aarch64_konquest}"
SRC_URI[aarch64_konquest.sha256sum] = "f0fe09dc3987d2c2c10a5b9cdaaa62fba7c95235da9fff0eb2bb11eeffcc49fc"

RDEPENDS:konquest = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtscxml \
 qt6-qtsvg \
 "
