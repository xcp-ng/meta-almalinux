# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-C3-Componentised"
PV = "1.001002"
PR = "25.el10_2"
PACKAGES = " \
 perl-Class-C3-Componentised \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-C3-Componentised-1.001002-25.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6618581342711d342950e95b90ae2087349360bbe3ac7dfea38aba4010a5d50"

URI_x86_64_v2_perl-Class-C3-Componentised = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-C3-Componentised-1.001002-25.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-C3-Componentised;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-C3-Componentised}"
SRC_URI[x86_64_v2_perl-Class-C3-Componentised.sha256sum] = "7a0e89da4846f0e9fbf6f0e9129c6fffba3c79a3c8494e2775d57dba7c018fc6"

URI_aarch64_perl-Class-C3-Componentised = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-C3-Componentised-1.001002-25.el10_2.noarch.rpm;name=aarch64_perl-Class-C3-Componentised;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-C3-Componentised}"
SRC_URI[aarch64_perl-Class-C3-Componentised.sha256sum] = "1870d3b1c9318947585d27d8dfc230636d1e41e350c9f33b73333d2604e9bca3"

RDEPENDS:perl-Class-C3-Componentised = " \
 perl-Carp \
 perl-Class-C3 \
 perl-Class-Inspector \
 perl-MRO-Compat \
 perl-Scalar-List-Utils \
 perl-libs \
 "
