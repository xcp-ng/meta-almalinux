# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jpeg-decoder"
PV = "0.3.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-jpeg-decoder+default-devel \
 rust-jpeg-decoder+nightly_aarch64_neon-devel \
 rust-jpeg-decoder+platform_independent-devel \
 rust-jpeg-decoder+rayon-devel \
 rust-jpeg-decoder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jpeg-decoder-0.3.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed089a6e00984e7c78eae738e9cb514aec9391a80fb631dd577e5a79ca778938"

URI_x86_64_v2_rust-jpeg-decoder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jpeg-decoder+default-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jpeg-decoder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jpeg-decoder+default-devel}"
SRC_URI[x86_64_v2_rust-jpeg-decoder+default-devel.sha256sum] = "42308b1de4b73485b59deb74f832e70b12f6c405d4894abb20e705df9f77a762"

URI_x86_64_v2_rust-jpeg-decoder+nightly_aarch64_neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jpeg-decoder+nightly_aarch64_neon-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jpeg-decoder+nightly_aarch64_neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jpeg-decoder+nightly_aarch64_neon-devel}"
SRC_URI[x86_64_v2_rust-jpeg-decoder+nightly_aarch64_neon-devel.sha256sum] = "60a2004586b891558baa91e1cbc42660955673805943ef659a274a7bca1b6ca3"

URI_x86_64_v2_rust-jpeg-decoder+platform_independent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jpeg-decoder+platform_independent-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jpeg-decoder+platform_independent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jpeg-decoder+platform_independent-devel}"
SRC_URI[x86_64_v2_rust-jpeg-decoder+platform_independent-devel.sha256sum] = "54e7765c3673c747f08b9eb6f13f7c4200368dda6f8bf7e717c287e2f6bcf0a6"

URI_x86_64_v2_rust-jpeg-decoder+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jpeg-decoder+rayon-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jpeg-decoder+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jpeg-decoder+rayon-devel}"
SRC_URI[x86_64_v2_rust-jpeg-decoder+rayon-devel.sha256sum] = "653c528711d5b3e0f69bfd1b71a1e55c37378a434c5a7408d84e7b83b67fa23c"

URI_x86_64_v2_rust-jpeg-decoder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jpeg-decoder-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jpeg-decoder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jpeg-decoder-devel}"
SRC_URI[x86_64_v2_rust-jpeg-decoder-devel.sha256sum] = "e5506e704d3e2f4004128badec4ee474ccefb5b2d35e3875ac7c5a51f4fa683e"

URI_aarch64_rust-jpeg-decoder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jpeg-decoder+default-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-jpeg-decoder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jpeg-decoder+default-devel}"
SRC_URI[aarch64_rust-jpeg-decoder+default-devel.sha256sum] = "2a4645dd39a45f557eb6c83711aa1487d0d2f61c083c63a0c5626047c7505496"

URI_aarch64_rust-jpeg-decoder+nightly_aarch64_neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jpeg-decoder+nightly_aarch64_neon-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-jpeg-decoder+nightly_aarch64_neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jpeg-decoder+nightly_aarch64_neon-devel}"
SRC_URI[aarch64_rust-jpeg-decoder+nightly_aarch64_neon-devel.sha256sum] = "9c943ad347b2cb3215f92e7ec19a26d80f8d9a6488df1a8934657692f52a0bce"

URI_aarch64_rust-jpeg-decoder+platform_independent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jpeg-decoder+platform_independent-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-jpeg-decoder+platform_independent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jpeg-decoder+platform_independent-devel}"
SRC_URI[aarch64_rust-jpeg-decoder+platform_independent-devel.sha256sum] = "2a1a7110bb93eccb5c412188a5f3b02ecaaa46cff7cce83080dfaaa1de2ba90b"

URI_aarch64_rust-jpeg-decoder+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jpeg-decoder+rayon-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-jpeg-decoder+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jpeg-decoder+rayon-devel}"
SRC_URI[aarch64_rust-jpeg-decoder+rayon-devel.sha256sum] = "45d99fab171ae7fd642e97c1d1071a5b879233b7951a1487549f7703f0ea0aea"

URI_aarch64_rust-jpeg-decoder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jpeg-decoder-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-jpeg-decoder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jpeg-decoder-devel}"
SRC_URI[aarch64_rust-jpeg-decoder-devel.sha256sum] = "5a8d3af55f217b30458adc787e3883722abf4514c160c50f0bd3ef1603b88bd8"

RDEPENDS:rust-jpeg-decoder+default-devel = " \
 cargo \
 rust-jpeg-decoder+rayon-devel \
 rust-jpeg-decoder-devel \
 "
RDEPENDS:rust-jpeg-decoder+nightly_aarch64_neon-devel = " \
 cargo \
 rust-jpeg-decoder-devel \
 "
RDEPENDS:rust-jpeg-decoder+platform_independent-devel = " \
 cargo \
 rust-jpeg-decoder-devel \
 "
RDEPENDS:rust-jpeg-decoder+rayon-devel = " \
 cargo \
 rust-jpeg-decoder-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-jpeg-decoder-devel = " \
 cargo \
 rust \
 "
