# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-edit-distance"
PV = "2.2.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-edit-distance+default-devel \
 rust-edit-distance-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-edit-distance-2.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "222dfb960392ddaa8987fffdcf1dc1f870554b53a094c328b4ca740ee4b4276e"

URI_x86_64_v2_rust-edit-distance+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-edit-distance+default-devel-2.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-edit-distance+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-edit-distance+default-devel}"
SRC_URI[x86_64_v2_rust-edit-distance+default-devel.sha256sum] = "eac3512d866660809953ed3e77aac9f728f33410669773abe0d85d492d0ab7f6"

URI_x86_64_v2_rust-edit-distance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-edit-distance-devel-2.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-edit-distance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-edit-distance-devel}"
SRC_URI[x86_64_v2_rust-edit-distance-devel.sha256sum] = "27f160c10f6d998425d2bc675a9b8301409d865d081fbdf3081fc1cd3d2add6f"

URI_aarch64_rust-edit-distance+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-edit-distance+default-devel-2.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-edit-distance+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-edit-distance+default-devel}"
SRC_URI[aarch64_rust-edit-distance+default-devel.sha256sum] = "325383961421f7c8916a464fe5906617e2acba839a5b3999bb13d5d07f876cbd"

URI_aarch64_rust-edit-distance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-edit-distance-devel-2.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-edit-distance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-edit-distance-devel}"
SRC_URI[aarch64_rust-edit-distance-devel.sha256sum] = "1fca129781be20763eaab03a5231c56bd73dd082f7d662f2b2bab8bf88cb78e8"

RDEPENDS:rust-edit-distance+default-devel = " \
 cargo \
 rust-edit-distance-devel \
 "
RDEPENDS:rust-edit-distance-devel = " \
 cargo \
 rust \
 "
