# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc_version"
PV = "0.4.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustc_version+default-devel \
 rust-rustc_version-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc_version-0.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f67542c6498b0b77b0ebf3577aa1b77719b0dc851e50f0855f0c311ae0b3075d"

URI_x86_64_v2_rust-rustc_version+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc_version+default-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc_version+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc_version+default-devel}"
SRC_URI[x86_64_v2_rust-rustc_version+default-devel.sha256sum] = "80cfad4afd1664209fc85b1ba9048eb54ab3e273171a8c60ed75359052cac07b"

URI_x86_64_v2_rust-rustc_version-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc_version-devel-0.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc_version-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc_version-devel}"
SRC_URI[x86_64_v2_rust-rustc_version-devel.sha256sum] = "d867f85e1946bd94e5c9e45c8786f13c7ab6eda1d3a62633df704a6410d2e81d"

URI_aarch64_rust-rustc_version+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc_version+default-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-rustc_version+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc_version+default-devel}"
SRC_URI[aarch64_rust-rustc_version+default-devel.sha256sum] = "068b03a38316a45d8ee7d0ad7f564b0a77f52d2a49b871d28c2f66202658a90d"

URI_aarch64_rust-rustc_version-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc_version-devel-0.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-rustc_version-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc_version-devel}"
SRC_URI[aarch64_rust-rustc_version-devel.sha256sum] = "c368e9e558f53d62134008503f7e66675e099ffdf7664c1b82a7656b14c09c1c"

RDEPENDS:rust-rustc_version+default-devel = " \
 cargo \
 rust-rustc_version-devel \
 "
RDEPENDS:rust-rustc_version-devel = " \
 cargo \
 rust \
 rust-semver+default-devel \
 "
