# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeipmi"
PV = "1.6.18"
PR = "1.el10_2"
PACKAGES = " \
 freeipmi \
 freeipmi-bmc-watchdog \
 freeipmi-devel \
 freeipmi-ipmidetectd \
 freeipmi-ipmiseld \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freeipmi-1.6.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e663c39cca2ce87fe9d26ec57c2fe043d4fd03be98886bb2fceaaf4b43523914"

URI_x86_64_v2_freeipmi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-1.6.18-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_freeipmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi}"
SRC_URI[x86_64_v2_freeipmi.sha256sum] = "a472509ddc73e884f166a578c995de080001a79248e7678e61578e9ac508c259"

URI_x86_64_v2_freeipmi-bmc-watchdog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-bmc-watchdog-1.6.18-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_freeipmi-bmc-watchdog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-bmc-watchdog}"
SRC_URI[x86_64_v2_freeipmi-bmc-watchdog.sha256sum] = "33e419f4aa178b05e4ac57bca07890db2a6690915788350e39fe4ba5270cb475"

URI_x86_64_v2_freeipmi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeipmi-devel-1.6.18-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_freeipmi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-devel}"
SRC_URI[x86_64_v2_freeipmi-devel.sha256sum] = "6f7d615fdbaf572727aa548b98bf0e7954a52e37c0a62adb50c5828f94f48636"

URI_x86_64_v2_freeipmi-ipmidetectd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-ipmidetectd-1.6.18-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_freeipmi-ipmidetectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-ipmidetectd}"
SRC_URI[x86_64_v2_freeipmi-ipmidetectd.sha256sum] = "c39dfeec3a49030afc0b90db72fe28b9335eb1d0d093043c2eb8894e945d4986"

URI_x86_64_v2_freeipmi-ipmiseld = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeipmi-ipmiseld-1.6.18-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_freeipmi-ipmiseld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeipmi-ipmiseld}"
SRC_URI[x86_64_v2_freeipmi-ipmiseld.sha256sum] = "402eed286a212a26f0d56df3767b3dc062e42ba79330128fffefb9794d34b401"

URI_aarch64_freeipmi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-1.6.18-1.el10_2.aarch64.rpm;name=aarch64_freeipmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi}"
SRC_URI[aarch64_freeipmi.sha256sum] = "42e1c3f29d5d7f151f1329e1d7ecf412a4833ec5a191c733baa6674ccbb1bd9a"

URI_aarch64_freeipmi-bmc-watchdog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-bmc-watchdog-1.6.18-1.el10_2.aarch64.rpm;name=aarch64_freeipmi-bmc-watchdog;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-bmc-watchdog}"
SRC_URI[aarch64_freeipmi-bmc-watchdog.sha256sum] = "a509e8f0e78e6c75aff46f7201faaf02502326f737b4f186587e6841fa2ba3e2"

URI_aarch64_freeipmi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeipmi-devel-1.6.18-1.el10_2.aarch64.rpm;name=aarch64_freeipmi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-devel}"
SRC_URI[aarch64_freeipmi-devel.sha256sum] = "9ba59aede8b350c5e35f805773f7c448f587a9ad4e571cc9a27e1a9080313330"

URI_aarch64_freeipmi-ipmidetectd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-ipmidetectd-1.6.18-1.el10_2.aarch64.rpm;name=aarch64_freeipmi-ipmidetectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-ipmidetectd}"
SRC_URI[aarch64_freeipmi-ipmidetectd.sha256sum] = "806db92dc10b41584d54df1fd54f7e5bdb74dbc8bdbdeee037da313fe4f983e6"

URI_aarch64_freeipmi-ipmiseld = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeipmi-ipmiseld-1.6.18-1.el10_2.aarch64.rpm;name=aarch64_freeipmi-ipmiseld;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeipmi-ipmiseld}"
SRC_URI[aarch64_freeipmi-ipmiseld.sha256sum] = "3fa0a90345442bd34c306adb15732042726097460d944b7cfc31817a47671bfb"

RDEPENDS:freeipmi = " \
 bash \
 glibc \
 libgcrypt \
 systemd \
 "
RDEPENDS:freeipmi-bmc-watchdog = " \
 bash \
 freeipmi \
 glibc \
 "
RDEPENDS:freeipmi-devel = " \
 freeipmi \
 pkgconf-pkg-config \
 "
RDEPENDS:freeipmi-ipmidetectd = " \
 bash \
 freeipmi \
 glibc \
 "
RDEPENDS:freeipmi-ipmiseld = " \
 bash \
 freeipmi \
 glibc \
 "
