# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-fancyindex"
PV = "0.5.2"
PR = "10.el10_0"
PACKAGES = " \
 nginx-mod-fancyindex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-fancyindex-0.5.2-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c7422c436566b6790421ef7138efb4ece290ee04d9b6712f7a7b5712e3dd1ac"

URI_x86_64_v2_nginx-mod-fancyindex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-fancyindex-0.5.2-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-fancyindex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-fancyindex}"
SRC_URI[x86_64_v2_nginx-mod-fancyindex.sha256sum] = "97fa73b588ed1f34ceda113e205f7e3d74a9b0956fd34b7837c875517c51ec53"

URI_aarch64_nginx-mod-fancyindex = "${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-fancyindex-0.5.2-10.el10_0.aarch64.rpm;name=aarch64_nginx-mod-fancyindex;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-fancyindex}"
SRC_URI[aarch64_nginx-mod-fancyindex.sha256sum] = "2f7c9d1d87aa8e7e048e0f7e109812e4bd4925a56dee6b4d357c960d083dfad6"

RDEPENDS:nginx-mod-fancyindex = " \
 glibc \
 nginx \
 "
