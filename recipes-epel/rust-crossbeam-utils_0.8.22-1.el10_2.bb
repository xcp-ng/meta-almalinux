# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-utils"
PV = "0.8.22"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam-utils+default-devel \
 rust-crossbeam-utils+nightly-devel \
 rust-crossbeam-utils+std-devel \
 rust-crossbeam-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-utils-0.8.22-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "650bee61591f5c8a9b25f3dffe5c32c730292877f4d368ae62619e989eb23423"

URI_x86_64_v2_rust-crossbeam-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+default-devel-0.8.22-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils+default-devel.sha256sum] = "1b79c06c75a518b8b3dd61d83f5542f57ee4844626965da91c3a89c06e9c188c"

URI_x86_64_v2_rust-crossbeam-utils+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+nightly-devel-0.8.22-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils+nightly-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils+nightly-devel.sha256sum] = "4ce8ab38343dc346db368ed5077b1126749ac71d8a89bc353051b5c9eb7614ab"

URI_x86_64_v2_rust-crossbeam-utils+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils+std-devel-0.8.22-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils+std-devel.sha256sum] = "6e1c42f99240646c862d3f3eef28f5927cd9d72cd823b9a955109760c29c2136"

URI_x86_64_v2_rust-crossbeam-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-utils-devel-0.8.22-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-utils-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-utils-devel.sha256sum] = "2d75130fb09526c7a6e0648f149538ec79fada5ba11d80a6b6b3da7f6a55beca"

URI_aarch64_rust-crossbeam-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+default-devel-0.8.22-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils+default-devel}"
SRC_URI[aarch64_rust-crossbeam-utils+default-devel.sha256sum] = "8041b1076446de0b84dda4665e38077c057245e54c64a2384c20b09c92bb9dc5"

URI_aarch64_rust-crossbeam-utils+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+nightly-devel-0.8.22-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-utils+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils+nightly-devel}"
SRC_URI[aarch64_rust-crossbeam-utils+nightly-devel.sha256sum] = "ea77c5f560097138a8520d53f8cbff2f421c3090c7c9d3fbecaf6bd50a7fbce7"

URI_aarch64_rust-crossbeam-utils+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils+std-devel-0.8.22-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-utils+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils+std-devel}"
SRC_URI[aarch64_rust-crossbeam-utils+std-devel.sha256sum] = "9abb612e740776ca07f0711c7c0d418ad19dac274291fe28d6bb6e9f3d75a92f"

URI_aarch64_rust-crossbeam-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-utils-devel-0.8.22-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-utils-devel}"
SRC_URI[aarch64_rust-crossbeam-utils-devel.sha256sum] = "0b751b76b69abe6008c82c6c56f50e58d05ea53548f1a38b714c42744c3145fd"

RDEPENDS:rust-crossbeam-utils+default-devel = " \
 cargo \
 rust-crossbeam-utils+std-devel \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils+nightly-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils+std-devel = " \
 cargo \
 rust-crossbeam-utils-devel \
 "
RDEPENDS:rust-crossbeam-utils-devel = " \
 cargo \
 rust \
 "
