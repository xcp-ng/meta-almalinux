# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit"
PV = "125"
PR = "6.el10"
PACKAGES = " \
 polkit \
 polkit-devel \
 polkit-docs \
 polkit-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/polkit-125-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73f0035338848a02bf53a68b5bb1fedaa76985e7a0a863feaeb42a971b598b24"

URI_x86_64_v2_polkit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/polkit-125-6.el10.x86_64_v2.rpm;name=x86_64_v2_polkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit}"
SRC_URI[x86_64_v2_polkit.sha256sum] = "9a0e67afc6bd53ff2913a39eb2165034f0facb23438e1b3581e4aae24b125091"

URI_x86_64_v2_polkit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/polkit-devel-125-6.el10.x86_64_v2.rpm;name=x86_64_v2_polkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-devel}"
SRC_URI[x86_64_v2_polkit-devel.sha256sum] = "66e1ffb77d9a1eb1b417ace7fa45cfa0cb7bb4b1a3a18ad3961ab535a90b6093"

URI_x86_64_v2_polkit-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/polkit-docs-125-6.el10.noarch.rpm;name=x86_64_v2_polkit-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-docs}"
SRC_URI[x86_64_v2_polkit-docs.sha256sum] = "d90e1fbf595dea59577281433d5a84cf9479d2fe390821431eae221fbbd00f8a"

URI_x86_64_v2_polkit-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/polkit-libs-125-6.el10.x86_64_v2.rpm;name=x86_64_v2_polkit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-libs}"
SRC_URI[x86_64_v2_polkit-libs.sha256sum] = "56b4a75950fe2405752fbfb7a0e59610079460ab44c22d1f5ed62af7a3ee94b6"

URI_aarch64_polkit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/polkit-125-6.el10.aarch64.rpm;name=aarch64_polkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit}"
SRC_URI[aarch64_polkit.sha256sum] = "7d446df346bd235803e266bb6e9e24963b09eaf1de3d4ca9858c898b532d42f3"

URI_aarch64_polkit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/polkit-devel-125-6.el10.aarch64.rpm;name=aarch64_polkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-devel}"
SRC_URI[aarch64_polkit-devel.sha256sum] = "b8ee26fd83588079adb9de6069e3569400f7fd6ca51a43dd7cf21c7e9fc2c323"

URI_aarch64_polkit-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/polkit-docs-125-6.el10.noarch.rpm;name=aarch64_polkit-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-docs}"
SRC_URI[aarch64_polkit-docs.sha256sum] = "d90e1fbf595dea59577281433d5a84cf9479d2fe390821431eae221fbbd00f8a"

URI_aarch64_polkit-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/polkit-libs-125-6.el10.aarch64.rpm;name=aarch64_polkit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-libs}"
SRC_URI[aarch64_polkit-libs.sha256sum] = "6c6015b6d209d91e3fc5a187569e7752cca0e50c55df435c5327755b1e6bfd9f"

RDEPENDS:polkit = " \
 bash \
 dbus \
 duktape \
 expat \
 glib2 \
 glibc \
 pam-libs \
 polkit-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:polkit-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 polkit-devel \
 polkit-docs \
 polkit-libs \
 "
RDEPENDS:polkit-docs = " \
 polkit-devel \
 "
RDEPENDS:polkit-libs = " \
 glib2 \
 glibc \
 systemd-libs \
 "
