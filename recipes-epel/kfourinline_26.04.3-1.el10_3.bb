# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kfourinline"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kfourinline \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kfourinline-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cd6de2b219b75f9259ce861a161762bdf104351761e69dc2a09e07dda332f73"

URI_x86_64_v2_kfourinline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfourinline-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfourinline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kfourinline}"
SRC_URI[x86_64_v2_kfourinline.sha256sum] = "01c64928892779025f7611f9ef5c0f4fa1baa44c4f56d0ba79fa5525f845ea2a"

URI_aarch64_kfourinline = "${EPEL_MIRROR}/aarch64/Packages/k/kfourinline-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kfourinline;unpack=0"
SRC_URI:append = " ${URI_aarch64_kfourinline}"
SRC_URI[aarch64_kfourinline.sha256sum] = "74a195b9286121e75dc6aa806e422df82276d5f5a771414fe34c3603f99da689"

RDEPENDS:kfourinline = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
