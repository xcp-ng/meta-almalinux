# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcoreaddons"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcoreaddons \
 kf6-kcoreaddons-devel \
 kf6-kcoreaddons-doc \
 kf6-kcoreaddons-html \
 python3-kf6-kcoreaddons \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kcoreaddons-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2cf3790b962f1f0b10119af874e12840e8880a494044ac4bbd2a96d7b24148a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcoreaddons;unpack=0"
SRC_URI[x86_64_v2_kf6-kcoreaddons.sha256sum] = "2ba8012c3cfa649b9a220db047cc6f3dc44eca0a9d04d44f56f01121b4913368"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcoreaddons-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kcoreaddons-devel.sha256sum] = "94e412441ec8d02af8a5e7c7169f1e5d60154ba385972bc979dcb15ee1314722"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcoreaddons-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kcoreaddons-doc.sha256sum] = "930a8c63a7a197a98f3017af7434ef60ea324b2a41625b0d6eed8d6f724bc964"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcoreaddons-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kcoreaddons-html.sha256sum] = "2f9aad184ee411a23be1a2f28dd84b4bb9883b1a519ce575e2bf57b40dde4335"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kcoreaddons-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kcoreaddons;unpack=0"
SRC_URI[x86_64_v2_python3-kf6-kcoreaddons.sha256sum] = "113c966348a7e5d37b29e1c930fc324dc178c72400ebdae950653c0ba98e9565"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcoreaddons;unpack=0"
SRC_URI[aarch64_kf6-kcoreaddons.sha256sum] = "2972e48e2d2752c864d6b90a41c3869f74d58f0a860032a490d4584de5390ac0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcoreaddons-devel;unpack=0"
SRC_URI[aarch64_kf6-kcoreaddons-devel.sha256sum] = "4bc75387fdc5c3c9d3e651b2f7bbee839878ce7cb05f9820faea51df1d7b2e33"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcoreaddons-doc;unpack=0"
SRC_URI[aarch64_kf6-kcoreaddons-doc.sha256sum] = "66e57107c9c13ca7275c9f808a20e88a9196fe1eaf0ae76ab6cacb738af6922d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcoreaddons-html;unpack=0"
SRC_URI[aarch64_kf6-kcoreaddons-html.sha256sum] = "7f5216a3d519a09c89e3b27822f91184140207f8850164734c350fa219fa4128"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kcoreaddons-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kcoreaddons;unpack=0"
SRC_URI[aarch64_python3-kf6-kcoreaddons.sha256sum] = "6a38955b10b5b5d7fea12c39e6db4416b734ba912ef5fedfea732efcc28a5625"

RDEPENDS:kf6-kcoreaddons = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libmount \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 systemd-libs \
 "
RDEPENDS:kf6-kcoreaddons-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcoreaddons-doc = " \
 "
RDEPENDS:kf6-kcoreaddons-html = " \
 "
RDEPENDS:python3-kf6-kcoreaddons = " \
 glibc \
 kf6-kcoreaddons \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
