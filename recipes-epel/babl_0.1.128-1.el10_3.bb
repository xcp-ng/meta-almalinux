# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "babl"
PV = "0.1.128"
PR = "1.el10_3"
PACKAGES = " \
 babl \
 babl-devel \
 babl-devel-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/babl-0.1.128-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6ea2564a6fcf1ae1fc4140b82c2163add4a760a456ad869b3d868c17db2f352"

URI_x86_64_v2_babl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/babl-0.1.128-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_babl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_babl}"
SRC_URI[x86_64_v2_babl.sha256sum] = "a2ed5d035c44ca572f2830009705eb0ce272dd1098a240125befa96a4ac4d5f2"

URI_x86_64_v2_babl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/babl-devel-0.1.128-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_babl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_babl-devel}"
SRC_URI[x86_64_v2_babl-devel.sha256sum] = "54a61ab1e7d2b6b82b924b222701c708580c5885d751f06b3952f5710ad87ca3"

URI_x86_64_v2_babl-devel-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/babl-devel-docs-0.1.128-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_babl-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_babl-devel-docs}"
SRC_URI[x86_64_v2_babl-devel-docs.sha256sum] = "9a421e0a21e3a0aca645a6ced5b950eafc7cd232a46849fb1ff8ae7f215a572d"

URI_aarch64_babl = "${EPEL_MIRROR}/aarch64/Packages/b/babl-0.1.128-1.el10_3.aarch64.rpm;name=aarch64_babl;unpack=0"
SRC_URI:append = " ${URI_aarch64_babl}"
SRC_URI[aarch64_babl.sha256sum] = "e578b23769b6967415f41548f93740a3c0fa5d473598e3a3c6cb095a2283d187"

URI_aarch64_babl-devel = "${EPEL_MIRROR}/aarch64/Packages/b/babl-devel-0.1.128-1.el10_3.aarch64.rpm;name=aarch64_babl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_babl-devel}"
SRC_URI[aarch64_babl-devel.sha256sum] = "c714840394e7bc4d20c255b701a5e9dc0247441c876dae02f678d56deea2cb88"

URI_aarch64_babl-devel-docs = "${EPEL_MIRROR}/aarch64/Packages/b/babl-devel-docs-0.1.128-1.el10_3.noarch.rpm;name=aarch64_babl-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_babl-devel-docs}"
SRC_URI[aarch64_babl-devel-docs.sha256sum] = "bf55ff019295b2925d430f7194e0e1fc0ce210779b290f862d524f9ae4c92ceb"

RDEPENDS:babl = " \
 glibc \
 lcms2 \
 "
RDEPENDS:babl-devel = " \
 babl \
 lcms2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:babl-devel-docs = " \
 babl-devel \
 "
