# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-yac"
PV = "2.4.2"
PR = "1.el10_3"
PACKAGES = " \
 php-pecl-yac \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-yac-2.4.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "32c9f0c41b23fdbf7585228ce66322a5955aa544a62d5445a050060c74ea5110"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-yac-2.4.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-yac;unpack=0"
SRC_URI[x86_64_v2_php-pecl-yac.sha256sum] = "2c43adaa463d0bb27d13e1ac69c34eb76564b9875df359fb1518a522c3ea25fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-yac-2.4.2-1.el10_3.aarch64.rpm;name=aarch64_php-pecl-yac;unpack=0"
SRC_URI[aarch64_php-pecl-yac.sha256sum] = "e47f6f59be1bdd6feae9fb8ba7bdcbe80ebdce2ce3ec5e91dd6d2189c68460f8"

RDEPENDS:php-pecl-yac = " \
 glibc \
 lz4-libs \
 php-common \
 php-pecl-igbinary \
 php-pecl-msgpack \
 "
