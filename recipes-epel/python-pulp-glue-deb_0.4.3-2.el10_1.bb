# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pulp-glue-deb"
PV = "0.4.3"
PR = "2.el10_1"
PACKAGES = " \
 python3-pulp-glue-deb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pulp-glue-deb-0.4.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c558833e4df5c1ded51271152b0cf2cb59afea3d403193782cc4f7351e1e3755"

URI_x86_64_v2_python3-pulp-glue-deb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pulp-glue-deb-0.4.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pulp-glue-deb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pulp-glue-deb}"
SRC_URI[x86_64_v2_python3-pulp-glue-deb.sha256sum] = "37eeba956468b16b2b8d5eb159a36b76b3551c467926b4abe88784cd1afccf21"

URI_aarch64_python3-pulp-glue-deb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pulp-glue-deb-0.4.3-2.el10_1.noarch.rpm;name=aarch64_python3-pulp-glue-deb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pulp-glue-deb}"
SRC_URI[aarch64_python3-pulp-glue-deb.sha256sum] = "448eb7849966436d585128eabd7265400c187cd271094631cb288c119b52fb07"

RDEPENDS:python3-pulp-glue-deb = " \
 python3 \
 python3-pulp-glue \
 "
