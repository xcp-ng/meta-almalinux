# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpgverify"
PV = "1"
PR = "1.el10_0"
PACKAGES = " \
 gpgverify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpgverify-1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5301d973ca1ad9977e2a4599c5213af20e4f308a03b45ad68067d939480bd8b3"

URI_x86_64_v2_gpgverify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpgverify-1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gpgverify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpgverify}"
SRC_URI[x86_64_v2_gpgverify.sha256sum] = "f49648e7599f58baf54e2bc2c0696f684502d369c492bae06b834c7f406beb46"

URI_aarch64_gpgverify = "${EPEL_MIRROR}/aarch64/Packages/g/gpgverify-1-1.el10_0.noarch.rpm;name=aarch64_gpgverify;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpgverify}"
SRC_URI[aarch64_gpgverify.sha256sum] = "d0fad43c3bb1cf50ad69961b6824b21fdffd343c4c272436e78be1c8d92c520b"

RDEPENDS:gpgverify = " \
 gnupg2 \
 redhat-rpm-config \
 "
