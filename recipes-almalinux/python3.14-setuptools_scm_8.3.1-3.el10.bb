# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-setuptools_scm"
PV = "8.3.1"
PR = "3.el10"
PACKAGES = " \
 python3.14-setuptools_scm \
 python3.14-setuptools_scm+toml \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-setuptools_scm-8.3.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fa150f50c5fcd996e0683efc49ba0f75cb9017672e50d40df9bc2bca3df60cc4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-setuptools_scm-8.3.1-3.el10.noarch.rpm;name=x86_64_v2_python3.14-setuptools_scm;unpack=0"
SRC_URI[x86_64_v2_python3.14-setuptools_scm.sha256sum] = "ad4ab8f8aa3c7487ef5c8a7b4a34ab0c959cd2bc64d533700b1a8ce925adef26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-setuptools_scm+toml-8.3.1-3.el10.noarch.rpm;name=x86_64_v2_python3.14-setuptools_scm+toml;unpack=0"
SRC_URI[x86_64_v2_python3.14-setuptools_scm+toml.sha256sum] = "6d4ac858765971706f63a84aaf8d32f3c51e548dc9c099d1c0d22798f7196d8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-setuptools_scm-8.3.1-3.el10.noarch.rpm;name=aarch64_python3.14-setuptools_scm;unpack=0"
SRC_URI[aarch64_python3.14-setuptools_scm.sha256sum] = "ad4ab8f8aa3c7487ef5c8a7b4a34ab0c959cd2bc64d533700b1a8ce925adef26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-setuptools_scm+toml-8.3.1-3.el10.noarch.rpm;name=aarch64_python3.14-setuptools_scm+toml;unpack=0"
SRC_URI[aarch64_python3.14-setuptools_scm+toml.sha256sum] = "6d4ac858765971706f63a84aaf8d32f3c51e548dc9c099d1c0d22798f7196d8d"

RDEPENDS:python3.14-setuptools_scm = " \
 python3.14 \
 python3.14-packaging \
 python3.14-setuptools \
 "
RDEPENDS:python3.14-setuptools_scm+toml = " \
 python3.14 \
 python3.14-setuptools_scm \
 "
