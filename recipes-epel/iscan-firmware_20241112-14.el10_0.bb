# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iscan-firmware"
PV = "20241112"
PR = "14.el10_0"
PACKAGES = " \
 iscan-firmware \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/iscan-firmware-20241112-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f341da0142dc4a51bdcd1579da4f09f1a72fa5b6efb31f9dfe39c6b13cb985b"

URI_x86_64_v2_iscan-firmware = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iscan-firmware-20241112-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_iscan-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iscan-firmware}"
SRC_URI[x86_64_v2_iscan-firmware.sha256sum] = "54ded9d7a879705761d64c627fd8cb6f8d14ca3c7116ff1feb6a891866765550"

URI_aarch64_iscan-firmware = "${EPEL_MIRROR}/aarch64/Packages/i/iscan-firmware-20241112-14.el10_0.noarch.rpm;name=aarch64_iscan-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_iscan-firmware}"
SRC_URI[aarch64_iscan-firmware.sha256sum] = "3d978b485b9d0c00cee41b28a93651c575e49b08bc13dd8d9d649788e3948597"

RDEPENDS:iscan-firmware = " \
 linux-firmware \
 "
