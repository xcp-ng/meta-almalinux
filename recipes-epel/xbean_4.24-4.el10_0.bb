# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xbean"
PV = "4.24"
PR = "4.el10_0"
PACKAGES = " \
 xbean \
 xbean-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xbean-4.24-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f231b2025871a8a9059209eb772da1c0022bdbb290963e7fde1346608e0b7bbd"

URI_x86_64_v2_xbean = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xbean-4.24-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xbean;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xbean}"
SRC_URI[x86_64_v2_xbean.sha256sum] = "8c1c42bc796049a90e7a47f6fa80b17c27c5dd98a4b29a694e08a5d2e7e63c83"

URI_x86_64_v2_xbean-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xbean-javadoc-4.24-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xbean-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xbean-javadoc}"
SRC_URI[x86_64_v2_xbean-javadoc.sha256sum] = "1e1f87a4df6a21a7cb5aaaccb9979e725393b414723eea87de10fc680ecb5a77"

URI_aarch64_xbean = "${EPEL_MIRROR}/aarch64/Packages/x/xbean-4.24-4.el10_0.noarch.rpm;name=aarch64_xbean;unpack=0"
SRC_URI:append = " ${URI_aarch64_xbean}"
SRC_URI[aarch64_xbean.sha256sum] = "038ecb979d9e64a9f2010d8c69c6f002d049c1221b4d1853854db5656c72231c"

URI_aarch64_xbean-javadoc = "${EPEL_MIRROR}/aarch64/Packages/x/xbean-javadoc-4.24-4.el10_0.noarch.rpm;name=aarch64_xbean-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xbean-javadoc}"
SRC_URI[aarch64_xbean-javadoc.sha256sum] = "140955328e7f112e6b9f1cf4edf03c7c8bb1c14da3dfcb65dc72fc4298466880"

RDEPENDS:xbean = " \
 javapackages-filesystem \
 slf4j \
 "
RDEPENDS:xbean-javadoc = " \
 javapackages-filesystem \
 "
