# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hledger-lib"
PV = "1.32.3"
PR = "18.el10_0"
PACKAGES = " \
 ghc-breakpoint \
 ghc-breakpoint-devel \
 ghc-breakpoint-doc \
 ghc-breakpoint-prof \
 ghc-cassava-megaparsec \
 ghc-cassava-megaparsec-devel \
 ghc-cassava-megaparsec-doc \
 ghc-cassava-megaparsec-prof \
 ghc-deferred-folds \
 ghc-deferred-folds-devel \
 ghc-deferred-folds-doc \
 ghc-deferred-folds-prof \
 ghc-hledger-lib \
 ghc-hledger-lib-devel \
 ghc-hledger-lib-doc \
 ghc-hledger-lib-prof \
 ghc-isomorphism-class \
 ghc-isomorphism-class-devel \
 ghc-isomorphism-class-doc \
 ghc-isomorphism-class-prof \
 ghc-pager \
 ghc-pager-devel \
 ghc-pager-doc \
 ghc-pager-prof \
 ghc-quickcheck-instances \
 ghc-quickcheck-instances-devel \
 ghc-quickcheck-instances-doc \
 ghc-quickcheck-instances-prof \
 ghc-quote-quot \
 ghc-quote-quot-devel \
 ghc-quote-quot-doc \
 ghc-quote-quot-prof \
 ghc-text-ansi \
 ghc-text-ansi-devel \
 ghc-text-ansi-doc \
 ghc-text-ansi-prof \
 ghc-text-builder \
 ghc-text-builder-dev \
 ghc-text-builder-dev-devel \
 ghc-text-builder-dev-doc \
 ghc-text-builder-dev-prof \
 ghc-text-builder-devel \
 ghc-text-builder-doc \
 ghc-text-builder-linear \
 ghc-text-builder-linear-devel \
 ghc-text-builder-linear-doc \
 ghc-text-builder-linear-prof \
 ghc-text-builder-prof \
 ghc-timeit \
 ghc-timeit-devel \
 ghc-timeit-doc \
 ghc-timeit-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hledger-lib-1.32.3-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0722e6e33f79dff9ea0229e2cc19d72f4321347b93e74d5343ba21ad6069b316"

URI_x86_64_v2_ghc-breakpoint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-breakpoint-0.1.4.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-breakpoint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-breakpoint}"
SRC_URI[x86_64_v2_ghc-breakpoint.sha256sum] = "dc479a1c8dbe844870b23d9f1810c913494d1b690fffe31ab205dcbdad5b3118"

URI_x86_64_v2_ghc-breakpoint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-breakpoint-devel-0.1.4.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-breakpoint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-breakpoint-devel}"
SRC_URI[x86_64_v2_ghc-breakpoint-devel.sha256sum] = "25c09ec7daa96c84c1f97f44f510aa9c2b23c3456d2d6066f1d6a94e1f37d56d"

URI_x86_64_v2_ghc-breakpoint-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-breakpoint-doc-0.1.4.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-breakpoint-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-breakpoint-doc}"
SRC_URI[x86_64_v2_ghc-breakpoint-doc.sha256sum] = "0af17da72c78fe87eb60f81a1fa2918098befd4954fd3b258559bed9d7e82295"

URI_x86_64_v2_ghc-breakpoint-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-breakpoint-prof-0.1.4.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-breakpoint-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-breakpoint-prof}"
SRC_URI[x86_64_v2_ghc-breakpoint-prof.sha256sum] = "744f7085990669642556375ca739330e354ea84a795c4eabdc5a904f304cc78d"

URI_x86_64_v2_ghc-cassava-megaparsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cassava-megaparsec-2.0.4-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cassava-megaparsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cassava-megaparsec}"
SRC_URI[x86_64_v2_ghc-cassava-megaparsec.sha256sum] = "f9d47bb175ec2a64efca5bde98c04cec3334b4e03ad2a060b148761ad15ed6e5"

URI_x86_64_v2_ghc-cassava-megaparsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cassava-megaparsec-devel-2.0.4-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cassava-megaparsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cassava-megaparsec-devel}"
SRC_URI[x86_64_v2_ghc-cassava-megaparsec-devel.sha256sum] = "8cb97b5fe375369e19b57cd438199595e6713a8261f7934a72b4dcf5db9b50e8"

URI_x86_64_v2_ghc-cassava-megaparsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cassava-megaparsec-doc-2.0.4-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cassava-megaparsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cassava-megaparsec-doc}"
SRC_URI[x86_64_v2_ghc-cassava-megaparsec-doc.sha256sum] = "57a83eea7170039a32dab3413d5545b0c4c84567eb6967baee1429c78180939d"

URI_x86_64_v2_ghc-cassava-megaparsec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cassava-megaparsec-prof-2.0.4-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cassava-megaparsec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cassava-megaparsec-prof}"
SRC_URI[x86_64_v2_ghc-cassava-megaparsec-prof.sha256sum] = "97ad1323c030f406a5584410007aa9c0cf4791ec0d2242aac26badd5ed034c76"

URI_x86_64_v2_ghc-deferred-folds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deferred-folds-0.9.18.6-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deferred-folds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deferred-folds}"
SRC_URI[x86_64_v2_ghc-deferred-folds.sha256sum] = "c57e3c25b1c2311f6d93eee25c321a0395fb1469ff8da936700b8d46eac8ebf7"

URI_x86_64_v2_ghc-deferred-folds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deferred-folds-devel-0.9.18.6-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deferred-folds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deferred-folds-devel}"
SRC_URI[x86_64_v2_ghc-deferred-folds-devel.sha256sum] = "7c2753c516d0c5291ff2a41361abcbd86216f66b221d18361aabc69ac9b2a7d5"

URI_x86_64_v2_ghc-deferred-folds-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deferred-folds-doc-0.9.18.6-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-deferred-folds-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deferred-folds-doc}"
SRC_URI[x86_64_v2_ghc-deferred-folds-doc.sha256sum] = "bb5f93fc9af55e341a04307eeeaab4e021da75b17c3010ffe49efbe3ad036b4b"

URI_x86_64_v2_ghc-deferred-folds-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-deferred-folds-prof-0.9.18.6-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-deferred-folds-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-deferred-folds-prof}"
SRC_URI[x86_64_v2_ghc-deferred-folds-prof.sha256sum] = "c6963a7090c897e6961a12fd25b4827b191092e70843a8aea2788c0346cb27c1"

URI_x86_64_v2_ghc-hledger-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hledger-lib-1.32.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hledger-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hledger-lib}"
SRC_URI[x86_64_v2_ghc-hledger-lib.sha256sum] = "02c1cd2d0951a166c6f66415cab43ac2dbb1bb072b805b0d351495c10b7b481e"

URI_x86_64_v2_ghc-hledger-lib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hledger-lib-devel-1.32.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hledger-lib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hledger-lib-devel}"
SRC_URI[x86_64_v2_ghc-hledger-lib-devel.sha256sum] = "a3f35ab282ebaf66edbb123ca3b2b245e8c9a5b54f0ccb68fb5cc1b8fe206a48"

URI_x86_64_v2_ghc-hledger-lib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hledger-lib-doc-1.32.3-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hledger-lib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hledger-lib-doc}"
SRC_URI[x86_64_v2_ghc-hledger-lib-doc.sha256sum] = "ee15afe264cf82846432e8bcc426b2b7d81e69fa3e67a32d2520ebeb221021db"

URI_x86_64_v2_ghc-hledger-lib-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hledger-lib-prof-1.32.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hledger-lib-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hledger-lib-prof}"
SRC_URI[x86_64_v2_ghc-hledger-lib-prof.sha256sum] = "3177e8a6c576ea8e6c4a5b8f3351063021071261bb9309f31e4a9385a5672391"

URI_x86_64_v2_ghc-isomorphism-class = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-isomorphism-class-0.1.0.12-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-isomorphism-class;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-isomorphism-class}"
SRC_URI[x86_64_v2_ghc-isomorphism-class.sha256sum] = "46a78de50f1bfec78cd30eeeb53becad31695ffcfef0b1ffcbb50f422cd1fab3"

URI_x86_64_v2_ghc-isomorphism-class-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-isomorphism-class-devel-0.1.0.12-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-isomorphism-class-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-isomorphism-class-devel}"
SRC_URI[x86_64_v2_ghc-isomorphism-class-devel.sha256sum] = "87e9971c9d249f4feb272e14b3682260353ce98891e6bf215b15579d06c61a56"

URI_x86_64_v2_ghc-isomorphism-class-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-isomorphism-class-doc-0.1.0.12-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-isomorphism-class-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-isomorphism-class-doc}"
SRC_URI[x86_64_v2_ghc-isomorphism-class-doc.sha256sum] = "bf4af60ab365052c8a931d55fdc45439e177925abc35d823b6f239414019e4b9"

URI_x86_64_v2_ghc-isomorphism-class-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-isomorphism-class-prof-0.1.0.12-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-isomorphism-class-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-isomorphism-class-prof}"
SRC_URI[x86_64_v2_ghc-isomorphism-class-prof.sha256sum] = "cbcebac4ac32454ddfa2a14ab8554152c83827d05d2db8148a85206013ce88bc"

URI_x86_64_v2_ghc-pager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pager-0.1.1.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pager}"
SRC_URI[x86_64_v2_ghc-pager.sha256sum] = "90a47395ffc823fa208578aebe733cbdf7d88bddee429efdb8c583c0f11105a2"

URI_x86_64_v2_ghc-pager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pager-devel-0.1.1.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pager-devel}"
SRC_URI[x86_64_v2_ghc-pager-devel.sha256sum] = "29de1ef9b3ee378005730abe3bfb062cd70247f79295d279addc3be54a58649c"

URI_x86_64_v2_ghc-pager-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pager-doc-0.1.1.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pager-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pager-doc}"
SRC_URI[x86_64_v2_ghc-pager-doc.sha256sum] = "8d659d4ce9ce0ead703221f23a6281d300f0ccc9a4fdd8fd65af85954477ccab"

URI_x86_64_v2_ghc-pager-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pager-prof-0.1.1.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pager-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pager-prof}"
SRC_URI[x86_64_v2_ghc-pager-prof.sha256sum] = "7556c7999d27da8ff1c81eca8c8b96118612a7bab4479ce48d67b81d5fdebd2e"

URI_x86_64_v2_ghc-quickcheck-instances = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quickcheck-instances-0.3.30-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-quickcheck-instances;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quickcheck-instances}"
SRC_URI[x86_64_v2_ghc-quickcheck-instances.sha256sum] = "53f6efbd90ec0fb2d9aff48707e2d94202bc5a64cd727f4b3da1d75a12462823"

URI_x86_64_v2_ghc-quickcheck-instances-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quickcheck-instances-devel-0.3.30-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-quickcheck-instances-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quickcheck-instances-devel}"
SRC_URI[x86_64_v2_ghc-quickcheck-instances-devel.sha256sum] = "8ed418b0716eaf227548d79d2ce58c482e6049a936f66aa74e4d226f58fcd703"

URI_x86_64_v2_ghc-quickcheck-instances-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quickcheck-instances-doc-0.3.30-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-quickcheck-instances-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quickcheck-instances-doc}"
SRC_URI[x86_64_v2_ghc-quickcheck-instances-doc.sha256sum] = "50f694fe6029ffb4bc5155a05152bbfa23af29291220b6cca038e90bf016d42f"

URI_x86_64_v2_ghc-quickcheck-instances-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quickcheck-instances-prof-0.3.30-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-quickcheck-instances-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quickcheck-instances-prof}"
SRC_URI[x86_64_v2_ghc-quickcheck-instances-prof.sha256sum] = "fe9b51ccc8e225d8ad36aa3bc51affd8f82d9b78e015f5891af2275097a8d1c5"

URI_x86_64_v2_ghc-quote-quot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quote-quot-0.2.1.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-quote-quot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quote-quot}"
SRC_URI[x86_64_v2_ghc-quote-quot.sha256sum] = "80c66584dd07d0ed2351bfe8fff513ae4b28e0c3aa03f1830e1939ea12adab15"

URI_x86_64_v2_ghc-quote-quot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quote-quot-devel-0.2.1.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-quote-quot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quote-quot-devel}"
SRC_URI[x86_64_v2_ghc-quote-quot-devel.sha256sum] = "3ef41298f19e1af5637e8ee2ae8f684975495bd3d0a5506d9f1e1a4014e5e3ea"

URI_x86_64_v2_ghc-quote-quot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quote-quot-doc-0.2.1.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-quote-quot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quote-quot-doc}"
SRC_URI[x86_64_v2_ghc-quote-quot-doc.sha256sum] = "91e72d4ae15c961ff23009131d3ec75d8869e2d2e19a907044bdb025a7649d00"

URI_x86_64_v2_ghc-quote-quot-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-quote-quot-prof-0.2.1.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-quote-quot-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-quote-quot-prof}"
SRC_URI[x86_64_v2_ghc-quote-quot-prof.sha256sum] = "f2ef2b5aa3263b0c23361f666e074c2b613f8c94b571eadd5aca04a4b25ebc7a"

URI_x86_64_v2_ghc-text-ansi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-ansi-0.3.0.1-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-ansi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-ansi}"
SRC_URI[x86_64_v2_ghc-text-ansi.sha256sum] = "e05d9fb4b0eabe7f365170c3952a62c3d46d901bbe3839c5b4824748b7ebb266"

URI_x86_64_v2_ghc-text-ansi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-ansi-devel-0.3.0.1-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-ansi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-ansi-devel}"
SRC_URI[x86_64_v2_ghc-text-ansi-devel.sha256sum] = "700b9faf6833ed1f061ecc81db8dea3e530e1ff10ece504ce3104127607bc257"

URI_x86_64_v2_ghc-text-ansi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-ansi-doc-0.3.0.1-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-text-ansi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-ansi-doc}"
SRC_URI[x86_64_v2_ghc-text-ansi-doc.sha256sum] = "2a4c1ff2439355db83b9514253f5ba70a5805ce2bdd2f071c4cc39124341fdb6"

URI_x86_64_v2_ghc-text-ansi-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-ansi-prof-0.3.0.1-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-ansi-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-ansi-prof}"
SRC_URI[x86_64_v2_ghc-text-ansi-prof.sha256sum] = "63a4cc352021134f35220d10fe0fcb6e2a948c7f4e01d59c9587d71898420c03"

URI_x86_64_v2_ghc-text-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-0.6.7.2-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder}"
SRC_URI[x86_64_v2_ghc-text-builder.sha256sum] = "2e6b5cb8eedcb897e7c845f24c02d636b1beb135503ea5826436e5e759e02bef"

URI_x86_64_v2_ghc-text-builder-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-dev-0.3.4.4-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-builder-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-dev}"
SRC_URI[x86_64_v2_ghc-text-builder-dev.sha256sum] = "89299c63dd0dd12dec88e4fce1853caef705d6f5e5b929262bdb2831435402bd"

URI_x86_64_v2_ghc-text-builder-dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-dev-devel-0.3.4.4-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-builder-dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-dev-devel}"
SRC_URI[x86_64_v2_ghc-text-builder-dev-devel.sha256sum] = "1fe28e01167ea5a2aa08d5a27783cec269c37922349211a7c2f355ecafcd0000"

URI_x86_64_v2_ghc-text-builder-dev-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-dev-doc-0.3.4.4-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-text-builder-dev-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-dev-doc}"
SRC_URI[x86_64_v2_ghc-text-builder-dev-doc.sha256sum] = "2e886c60058e9a9c6947848d47e0441b37311253486477ea7842e0a895e3ea8d"

URI_x86_64_v2_ghc-text-builder-dev-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-dev-prof-0.3.4.4-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-builder-dev-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-dev-prof}"
SRC_URI[x86_64_v2_ghc-text-builder-dev-prof.sha256sum] = "97da4bbdcc365dea279f8cab243a329a4e63e181b91ca16f0a853ae628f4a11f"

URI_x86_64_v2_ghc-text-builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-devel-0.6.7.2-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-devel}"
SRC_URI[x86_64_v2_ghc-text-builder-devel.sha256sum] = "03a6276f42581c5809f0562a8c9e58be540ea3ed188f7490fea78d48672260d8"

URI_x86_64_v2_ghc-text-builder-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-doc-0.6.7.2-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-text-builder-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-doc}"
SRC_URI[x86_64_v2_ghc-text-builder-doc.sha256sum] = "c9e69df861b59edd3735ae19e981998f9692ad010fa8dc9ad7238b5085ab1317"

URI_x86_64_v2_ghc-text-builder-linear = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-linear-0.1.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-builder-linear;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-linear}"
SRC_URI[x86_64_v2_ghc-text-builder-linear.sha256sum] = "f7b2fd272164190ddedbda536034918b1bdee02e7bf445665ccc9995eb382340"

URI_x86_64_v2_ghc-text-builder-linear-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-linear-devel-0.1.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-builder-linear-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-linear-devel}"
SRC_URI[x86_64_v2_ghc-text-builder-linear-devel.sha256sum] = "e32882805d8a241bfa47acb5cde2cc390d4532c21601a9d91dad9e8eb5433214"

URI_x86_64_v2_ghc-text-builder-linear-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-linear-doc-0.1.3-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-text-builder-linear-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-linear-doc}"
SRC_URI[x86_64_v2_ghc-text-builder-linear-doc.sha256sum] = "2ff7146150b60cfd1c2f7ed653f9206a7c83bddbb54526c834249618db21589e"

URI_x86_64_v2_ghc-text-builder-linear-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-linear-prof-0.1.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-builder-linear-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-linear-prof}"
SRC_URI[x86_64_v2_ghc-text-builder-linear-prof.sha256sum] = "0a792f002e15745721da3b54867e49a70c08d798c1c257c979cc4535fd7af6df"

URI_x86_64_v2_ghc-text-builder-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-builder-prof-0.6.7.2-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-builder-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-builder-prof}"
SRC_URI[x86_64_v2_ghc-text-builder-prof.sha256sum] = "05329b5cabec08f3053f59dd999e56db2a0f899a0ad3de8af14887355c9370c5"

URI_x86_64_v2_ghc-timeit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-timeit-2.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-timeit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-timeit}"
SRC_URI[x86_64_v2_ghc-timeit.sha256sum] = "e424470b38dcb4e23c766e7d42c3c56f2f3eeaf3f01d7dad100d1372c2599b42"

URI_x86_64_v2_ghc-timeit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-timeit-devel-2.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-timeit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-timeit-devel}"
SRC_URI[x86_64_v2_ghc-timeit-devel.sha256sum] = "35eadee3bd9546c71e6bc00cd5716b822405efeee53e54bb247fe0c602bc9331"

URI_x86_64_v2_ghc-timeit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-timeit-doc-2.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-timeit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-timeit-doc}"
SRC_URI[x86_64_v2_ghc-timeit-doc.sha256sum] = "d50099f31dbfe1d347dff142d478840279ce96a3bc3b2dfc0676fc12d34511a9"

URI_x86_64_v2_ghc-timeit-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-timeit-prof-2.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-timeit-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-timeit-prof}"
SRC_URI[x86_64_v2_ghc-timeit-prof.sha256sum] = "60c348b0c81dd2022d8065e644ca711724c6ab2b0880e77ad4fc21cb62fe1796"

URI_aarch64_ghc-breakpoint = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-breakpoint-0.1.4.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-breakpoint;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-breakpoint}"
SRC_URI[aarch64_ghc-breakpoint.sha256sum] = "dbed97623296c8b76cabe805029f4cef03d6f176815d95ed5c9c3c1750780da9"

URI_aarch64_ghc-breakpoint-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-breakpoint-devel-0.1.4.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-breakpoint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-breakpoint-devel}"
SRC_URI[aarch64_ghc-breakpoint-devel.sha256sum] = "233e6dc68ad3a082b3db75d31850aaee2999d054a40d1e45ba64880817945048"

URI_aarch64_ghc-breakpoint-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-breakpoint-doc-0.1.4.0-18.el10_0.noarch.rpm;name=aarch64_ghc-breakpoint-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-breakpoint-doc}"
SRC_URI[aarch64_ghc-breakpoint-doc.sha256sum] = "a932d1783b63186db01e03b769f48ce7b1ba76fb46184b25e68fd505d90d22f6"

URI_aarch64_ghc-breakpoint-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-breakpoint-prof-0.1.4.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-breakpoint-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-breakpoint-prof}"
SRC_URI[aarch64_ghc-breakpoint-prof.sha256sum] = "29a5c74030266062571ddaed01df599b299dfcd9ef282c163b6975d36e192960"

URI_aarch64_ghc-cassava-megaparsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cassava-megaparsec-2.0.4-18.el10_0.aarch64.rpm;name=aarch64_ghc-cassava-megaparsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cassava-megaparsec}"
SRC_URI[aarch64_ghc-cassava-megaparsec.sha256sum] = "97c8e2c65476d7febd1bc64bb63411eb55ef3ad4153af652355c5860ff87f095"

URI_aarch64_ghc-cassava-megaparsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cassava-megaparsec-devel-2.0.4-18.el10_0.aarch64.rpm;name=aarch64_ghc-cassava-megaparsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cassava-megaparsec-devel}"
SRC_URI[aarch64_ghc-cassava-megaparsec-devel.sha256sum] = "f00a0dd53ffa0831b7fbd4f897d6148dabcc042cc9577becd5159610af813262"

URI_aarch64_ghc-cassava-megaparsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cassava-megaparsec-doc-2.0.4-18.el10_0.noarch.rpm;name=aarch64_ghc-cassava-megaparsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cassava-megaparsec-doc}"
SRC_URI[aarch64_ghc-cassava-megaparsec-doc.sha256sum] = "25f7da185943d64f4d1a9463a3e50ca7b9df4f3c6f39183315aaf78250269832"

URI_aarch64_ghc-cassava-megaparsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cassava-megaparsec-prof-2.0.4-18.el10_0.aarch64.rpm;name=aarch64_ghc-cassava-megaparsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cassava-megaparsec-prof}"
SRC_URI[aarch64_ghc-cassava-megaparsec-prof.sha256sum] = "556bcc6c808533424760dee6ea4865a505ba963088e4ac481ae7015cf3ec61da"

URI_aarch64_ghc-deferred-folds = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deferred-folds-0.9.18.6-18.el10_0.aarch64.rpm;name=aarch64_ghc-deferred-folds;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deferred-folds}"
SRC_URI[aarch64_ghc-deferred-folds.sha256sum] = "df4eb5b76fffe44735ae503f7ef9dbd3ed6aec1b7a692c3e7ebdb1fd1e0b0363"

URI_aarch64_ghc-deferred-folds-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deferred-folds-devel-0.9.18.6-18.el10_0.aarch64.rpm;name=aarch64_ghc-deferred-folds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deferred-folds-devel}"
SRC_URI[aarch64_ghc-deferred-folds-devel.sha256sum] = "2a7236b5c27bbb4b7b053323831bf048723329b8ee347615d2b8a01e32476370"

URI_aarch64_ghc-deferred-folds-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deferred-folds-doc-0.9.18.6-18.el10_0.noarch.rpm;name=aarch64_ghc-deferred-folds-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deferred-folds-doc}"
SRC_URI[aarch64_ghc-deferred-folds-doc.sha256sum] = "0186e66f652b8fd0ccb67104f452e543b38bc5fbbe6453a8c251e76f55cc98c7"

URI_aarch64_ghc-deferred-folds-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-deferred-folds-prof-0.9.18.6-18.el10_0.aarch64.rpm;name=aarch64_ghc-deferred-folds-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-deferred-folds-prof}"
SRC_URI[aarch64_ghc-deferred-folds-prof.sha256sum] = "8cac45739eef0096c185420a429502b8c005245ecdfd6962cd503d03b71ebe7a"

URI_aarch64_ghc-hledger-lib = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hledger-lib-1.32.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-hledger-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hledger-lib}"
SRC_URI[aarch64_ghc-hledger-lib.sha256sum] = "78ac378a668702fcbd53bace3cabaf317030471060315d20b3ae4d54372eb184"

URI_aarch64_ghc-hledger-lib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hledger-lib-devel-1.32.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-hledger-lib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hledger-lib-devel}"
SRC_URI[aarch64_ghc-hledger-lib-devel.sha256sum] = "19b14e2c32866d68738600155cac454d7c389ffed04d0b8f6052609d374badb0"

URI_aarch64_ghc-hledger-lib-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hledger-lib-doc-1.32.3-18.el10_0.noarch.rpm;name=aarch64_ghc-hledger-lib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hledger-lib-doc}"
SRC_URI[aarch64_ghc-hledger-lib-doc.sha256sum] = "0bdc460a52f3c7c5f8e686672f2d8b9f4b787219fc4c6c4dfae9ee369f63d04c"

URI_aarch64_ghc-hledger-lib-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hledger-lib-prof-1.32.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-hledger-lib-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hledger-lib-prof}"
SRC_URI[aarch64_ghc-hledger-lib-prof.sha256sum] = "596dcb46e5616fc0db3cdd6c3c8e22986d6157159fd5c76ce768876cb32dc8a7"

URI_aarch64_ghc-isomorphism-class = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-isomorphism-class-0.1.0.12-18.el10_0.aarch64.rpm;name=aarch64_ghc-isomorphism-class;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-isomorphism-class}"
SRC_URI[aarch64_ghc-isomorphism-class.sha256sum] = "94a2da20fed7d2c9e5a1315f94162d562389fe082f6528b5c87f862e4cde0ec0"

URI_aarch64_ghc-isomorphism-class-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-isomorphism-class-devel-0.1.0.12-18.el10_0.aarch64.rpm;name=aarch64_ghc-isomorphism-class-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-isomorphism-class-devel}"
SRC_URI[aarch64_ghc-isomorphism-class-devel.sha256sum] = "58b50da42d62b5cf1a896e419b52c853f7ff17ccc932056b727e66bdbe723bda"

URI_aarch64_ghc-isomorphism-class-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-isomorphism-class-doc-0.1.0.12-18.el10_0.noarch.rpm;name=aarch64_ghc-isomorphism-class-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-isomorphism-class-doc}"
SRC_URI[aarch64_ghc-isomorphism-class-doc.sha256sum] = "52d0bdf88f762af993170141f7c0e6e45104ed7b0c9842331de72e4ec9204126"

URI_aarch64_ghc-isomorphism-class-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-isomorphism-class-prof-0.1.0.12-18.el10_0.aarch64.rpm;name=aarch64_ghc-isomorphism-class-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-isomorphism-class-prof}"
SRC_URI[aarch64_ghc-isomorphism-class-prof.sha256sum] = "575bf82986220a1bdf583c5d78b5c766150250657944621f52d9f811f3eaf9c4"

URI_aarch64_ghc-pager = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pager-0.1.1.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-pager;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pager}"
SRC_URI[aarch64_ghc-pager.sha256sum] = "25c0ebe870f8bac0fc60a68c314195cd058df448e4828ac4674e08a90a3880cb"

URI_aarch64_ghc-pager-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pager-devel-0.1.1.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-pager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pager-devel}"
SRC_URI[aarch64_ghc-pager-devel.sha256sum] = "06d0b8f6d99ef7626366c490110a768eb62c494c1b0cdc2b4b950a755c1ffedb"

URI_aarch64_ghc-pager-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pager-doc-0.1.1.0-18.el10_0.noarch.rpm;name=aarch64_ghc-pager-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pager-doc}"
SRC_URI[aarch64_ghc-pager-doc.sha256sum] = "a71d8eada91032e94a815c0f113d3e2f62370c782836e6c930982cc39c3f3fcd"

URI_aarch64_ghc-pager-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pager-prof-0.1.1.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-pager-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pager-prof}"
SRC_URI[aarch64_ghc-pager-prof.sha256sum] = "d4670830e365e0ec8f6bbde28d9a9f2db45280ac8f0674bc5b9ee0fd9193a498"

URI_aarch64_ghc-quickcheck-instances = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quickcheck-instances-0.3.30-18.el10_0.aarch64.rpm;name=aarch64_ghc-quickcheck-instances;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quickcheck-instances}"
SRC_URI[aarch64_ghc-quickcheck-instances.sha256sum] = "e75a763b02a471515f63bb56e4bab77ddfa0dbfc1b8fe0e1a4df9e67b31d058d"

URI_aarch64_ghc-quickcheck-instances-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quickcheck-instances-devel-0.3.30-18.el10_0.aarch64.rpm;name=aarch64_ghc-quickcheck-instances-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quickcheck-instances-devel}"
SRC_URI[aarch64_ghc-quickcheck-instances-devel.sha256sum] = "22cce5a1a203d3f6d2025e30e72de7a7f8d1ef66fb9da61ba06a422fa707a36d"

URI_aarch64_ghc-quickcheck-instances-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quickcheck-instances-doc-0.3.30-18.el10_0.noarch.rpm;name=aarch64_ghc-quickcheck-instances-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quickcheck-instances-doc}"
SRC_URI[aarch64_ghc-quickcheck-instances-doc.sha256sum] = "3f7e63724bd53a4ef4221e1663deb462d453d163efd28bfc6d2e1e1c0465dbaf"

URI_aarch64_ghc-quickcheck-instances-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quickcheck-instances-prof-0.3.30-18.el10_0.aarch64.rpm;name=aarch64_ghc-quickcheck-instances-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quickcheck-instances-prof}"
SRC_URI[aarch64_ghc-quickcheck-instances-prof.sha256sum] = "c934d5dec2916dca559d4a5bf369fa628283cc98e4f5ae7a069bc94a05e307e0"

URI_aarch64_ghc-quote-quot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quote-quot-0.2.1.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-quote-quot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quote-quot}"
SRC_URI[aarch64_ghc-quote-quot.sha256sum] = "4cf97e02d9405563f899d3c841390658562ed8e289b6757816c7a704b2ac194d"

URI_aarch64_ghc-quote-quot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quote-quot-devel-0.2.1.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-quote-quot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quote-quot-devel}"
SRC_URI[aarch64_ghc-quote-quot-devel.sha256sum] = "a5bc7eca2c2586d603072b4f75586d1991345978fc1fe9d7ebd9edcea1d7d62c"

URI_aarch64_ghc-quote-quot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quote-quot-doc-0.2.1.0-18.el10_0.noarch.rpm;name=aarch64_ghc-quote-quot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quote-quot-doc}"
SRC_URI[aarch64_ghc-quote-quot-doc.sha256sum] = "9004639c93913aa37dc6cd126453bc7e02536be35b90405e9ac7e18121c5a681"

URI_aarch64_ghc-quote-quot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-quote-quot-prof-0.2.1.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-quote-quot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-quote-quot-prof}"
SRC_URI[aarch64_ghc-quote-quot-prof.sha256sum] = "4004b309dbf2f94c3a87a857166fd466061a7828ff6fc5c31a953e33edf69ae8"

URI_aarch64_ghc-text-ansi = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-ansi-0.3.0.1-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-ansi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-ansi}"
SRC_URI[aarch64_ghc-text-ansi.sha256sum] = "951d42c1c945dc56ddfb7a53e83104d886be8dae1ed83470b9537d9fb328ad44"

URI_aarch64_ghc-text-ansi-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-ansi-devel-0.3.0.1-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-ansi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-ansi-devel}"
SRC_URI[aarch64_ghc-text-ansi-devel.sha256sum] = "24d862ce64b178360a9bf2f5e18377b9480bd288047a502b9b494f7bb5af14c9"

URI_aarch64_ghc-text-ansi-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-ansi-doc-0.3.0.1-18.el10_0.noarch.rpm;name=aarch64_ghc-text-ansi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-ansi-doc}"
SRC_URI[aarch64_ghc-text-ansi-doc.sha256sum] = "8276a8babba45d50299e11ef07537576f5a594a6503b6afeb713812bd84f8f28"

URI_aarch64_ghc-text-ansi-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-ansi-prof-0.3.0.1-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-ansi-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-ansi-prof}"
SRC_URI[aarch64_ghc-text-ansi-prof.sha256sum] = "2f91b498f2e3e89b57cc4c207cdaa46affe865da8b4dbefbb9957d5cf26785dd"

URI_aarch64_ghc-text-builder = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-0.6.7.2-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder}"
SRC_URI[aarch64_ghc-text-builder.sha256sum] = "3b19fc87a75210b4b615e532a408daa11186deec0f8deb17d9a9995856cdb03b"

URI_aarch64_ghc-text-builder-dev = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-dev-0.3.4.4-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-builder-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-dev}"
SRC_URI[aarch64_ghc-text-builder-dev.sha256sum] = "505b9e92464f2a7461b9b44d0525bca9779e71aa910e7c157603cc64bae1947e"

URI_aarch64_ghc-text-builder-dev-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-dev-devel-0.3.4.4-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-builder-dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-dev-devel}"
SRC_URI[aarch64_ghc-text-builder-dev-devel.sha256sum] = "5de80d844a18f54e91c9f1c5bc319eabd589deabe6f8cbad084f482591f8ccc1"

URI_aarch64_ghc-text-builder-dev-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-dev-doc-0.3.4.4-18.el10_0.noarch.rpm;name=aarch64_ghc-text-builder-dev-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-dev-doc}"
SRC_URI[aarch64_ghc-text-builder-dev-doc.sha256sum] = "18d2e49cd23746e77bf2c0b4759c5bc2e21a5dd76fb4a5887fe6390fce57b5af"

URI_aarch64_ghc-text-builder-dev-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-dev-prof-0.3.4.4-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-builder-dev-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-dev-prof}"
SRC_URI[aarch64_ghc-text-builder-dev-prof.sha256sum] = "8c7a45ef11e9c22f3ce49a2173ef1d636a30d13820272b4efa8653d848dd0abb"

URI_aarch64_ghc-text-builder-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-devel-0.6.7.2-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-devel}"
SRC_URI[aarch64_ghc-text-builder-devel.sha256sum] = "3abd3225b55d568f5161971e0ed386c2e8f6053873191dc4e1ddfcc1796043d0"

URI_aarch64_ghc-text-builder-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-doc-0.6.7.2-18.el10_0.noarch.rpm;name=aarch64_ghc-text-builder-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-doc}"
SRC_URI[aarch64_ghc-text-builder-doc.sha256sum] = "54144b75175724aee3631261a7a1126ef73a7a8f645a37d41964a805c5c2022b"

URI_aarch64_ghc-text-builder-linear = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-linear-0.1.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-builder-linear;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-linear}"
SRC_URI[aarch64_ghc-text-builder-linear.sha256sum] = "91141d5a730270ea7f2bd2b93b4454e5cc26ebd91de69adebd0b2f11bafe1820"

URI_aarch64_ghc-text-builder-linear-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-linear-devel-0.1.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-builder-linear-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-linear-devel}"
SRC_URI[aarch64_ghc-text-builder-linear-devel.sha256sum] = "9b3e56bf9412f1fd7d7397c0a87e8f6e1434e6ebd92ce8b7fabe3df1a9f9ce04"

URI_aarch64_ghc-text-builder-linear-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-linear-doc-0.1.3-18.el10_0.noarch.rpm;name=aarch64_ghc-text-builder-linear-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-linear-doc}"
SRC_URI[aarch64_ghc-text-builder-linear-doc.sha256sum] = "9bb1081af6a5a353cb4cb3387a584b09830a7d1e5e9029704ec62a3f3fab6baa"

URI_aarch64_ghc-text-builder-linear-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-linear-prof-0.1.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-builder-linear-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-linear-prof}"
SRC_URI[aarch64_ghc-text-builder-linear-prof.sha256sum] = "1326ac751330b5304ad55575dd59c82581fb044e1a26c9002333bd34daedf505"

URI_aarch64_ghc-text-builder-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-builder-prof-0.6.7.2-18.el10_0.aarch64.rpm;name=aarch64_ghc-text-builder-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-builder-prof}"
SRC_URI[aarch64_ghc-text-builder-prof.sha256sum] = "fabd0960ba852dbc95ad0bbe286b116cf42751c6c79bb1e801edf769ff2c8b6f"

URI_aarch64_ghc-timeit = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-timeit-2.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-timeit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-timeit}"
SRC_URI[aarch64_ghc-timeit.sha256sum] = "c31a09db3275381ee46889af55482b9ae1549f08dcb97961a91d98271f3561c2"

URI_aarch64_ghc-timeit-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-timeit-devel-2.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-timeit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-timeit-devel}"
SRC_URI[aarch64_ghc-timeit-devel.sha256sum] = "ddfac344aeaae952d824556d4507399db877c060737d6f28f7a0eb601eee30c0"

URI_aarch64_ghc-timeit-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-timeit-doc-2.0-18.el10_0.noarch.rpm;name=aarch64_ghc-timeit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-timeit-doc}"
SRC_URI[aarch64_ghc-timeit-doc.sha256sum] = "7e85a206baa6cbbbea42ff05977a8bc89a2382b8cfbed10e677139073094ef11"

URI_aarch64_ghc-timeit-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-timeit-prof-2.0-18.el10_0.aarch64.rpm;name=aarch64_ghc-timeit-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-timeit-prof}"
SRC_URI[aarch64_ghc-timeit-prof.sha256sum] = "17368e3d6fe4800a4c8941921cc9778a9fa439cd25a0410c701b4a40bdc4a6ef"

RDEPENDS:ghc-breakpoint = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc \
 ghc-ghc-bignum \
 ghc-ghc-boot \
 ghc-ghc-boot-th \
 ghc-ghc-heap \
 ghc-ghci \
 ghc-haskeline \
 ghc-hpc \
 ghc-mtl \
 ghc-pretty \
 ghc-pretty-simple \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-terminfo \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc-breakpoint-devel = " \
 ghc-ansi-terminal-devel \
 ghc-base-devel \
 ghc-breakpoint \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-ghc-devel \
 ghc-haskeline-devel \
 ghc-mtl-devel \
 ghc-pretty-simple-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-breakpoint-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-breakpoint-prof = " \
 ghc-ansi-terminal-prof \
 ghc-base-prof \
 ghc-breakpoint-devel \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-ghc-prof \
 ghc-haskeline-prof \
 ghc-mtl-prof \
 ghc-pretty-simple-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
RDEPENDS:ghc-cassava-megaparsec = " \
 ghc-Only \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cassava \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-megaparsec \
 ghc-mtl \
 ghc-os-string \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-transformers \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cassava-megaparsec-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cassava-devel \
 ghc-cassava-megaparsec \
 ghc-compiler \
 ghc-megaparsec-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-cassava-megaparsec-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cassava-megaparsec-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cassava-megaparsec-devel \
 ghc-cassava-prof \
 ghc-megaparsec-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
RDEPENDS:ghc-deferred-folds = " \
 ghc-StateVar \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-deepseq \
 ghc-distributive \
 ghc-exceptions \
 ghc-filepath \
 ghc-foldl \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-profunctors \
 ghc-random \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-th-abstraction \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-deferred-folds-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deferred-folds \
 ghc-foldl-devel \
 ghc-hashable-devel \
 ghc-primitive-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-deferred-folds-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-deferred-folds-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deferred-folds-devel \
 ghc-foldl-prof \
 ghc-hashable-prof \
 ghc-primitive-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
RDEPENDS:ghc-hledger-lib = " \
 ghc-Decimal \
 ghc-Glob \
 ghc-OneTuple \
 ghc-Only \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-aeson-pretty \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-cassava \
 ghc-cassava-megaparsec \
 ghc-clock \
 ghc-cmdargs \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-csv \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-doclayout \
 ghc-emojis \
 ghc-exceptions \
 ghc-extra \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hashtables \
 ghc-html \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-megaparsec \
 ghc-microlens \
 ghc-microlens-th \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-old-locale \
 ghc-optparse-applicative \
 ghc-os-string \
 ghc-pager \
 ghc-parsec \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-pretty-simple \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-primitive \
 ghc-process \
 ghc-quote-quot \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tabular \
 ghc-tagged \
 ghc-tasty \
 ghc-tasty-hunit \
 ghc-template-haskell \
 ghc-terminal-size \
 ghc-terminfo \
 ghc-text \
 ghc-text-ansi \
 ghc-text-builder-linear \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-timeit \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-uglymemo \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-hledger-lib-devel = " \
 ghc-Decimal-devel \
 ghc-Glob-devel \
 ghc-aeson-devel \
 ghc-aeson-pretty-devel \
 ghc-ansi-terminal-devel \
 ghc-array-devel \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-blaze-markup-devel \
 ghc-bytestring-devel \
 ghc-call-stack-devel \
 ghc-cassava-devel \
 ghc-cassava-megaparsec-devel \
 ghc-cmdargs-devel \
 ghc-colour-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-default-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-doclayout-devel \
 ghc-extra-devel \
 ghc-file-embed-devel \
 ghc-filepath-devel \
 ghc-hashtables-devel \
 ghc-hledger-lib \
 ghc-megaparsec-devel \
 ghc-microlens-devel \
 ghc-microlens-th-devel \
 ghc-mtl-devel \
 ghc-pager-devel \
 ghc-parser-combinators-devel \
 ghc-pretty-simple-devel \
 ghc-regex-tdfa-devel \
 ghc-safe-devel \
 ghc-tabular-devel \
 ghc-tasty-devel \
 ghc-tasty-hunit-devel \
 ghc-template-haskell-devel \
 ghc-terminal-size-devel \
 ghc-text-ansi-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-timeit-devel \
 ghc-transformers-devel \
 ghc-uglymemo-devel \
 ghc-unordered-containers-devel \
 ghc-utf8-string-devel \
 "
RDEPENDS:ghc-hledger-lib-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hledger-lib-prof = " \
 ghc-Decimal-prof \
 ghc-Glob-prof \
 ghc-aeson-pretty-prof \
 ghc-aeson-prof \
 ghc-ansi-terminal-prof \
 ghc-array-prof \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-blaze-markup-prof \
 ghc-bytestring-prof \
 ghc-call-stack-prof \
 ghc-cassava-megaparsec-prof \
 ghc-cassava-prof \
 ghc-cmdargs-prof \
 ghc-colour-prof \
 ghc-containers-prof \
 ghc-data-default-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-doclayout-prof \
 ghc-extra-prof \
 ghc-file-embed-prof \
 ghc-filepath-prof \
 ghc-hashtables-prof \
 ghc-hledger-lib-devel \
 ghc-megaparsec-prof \
 ghc-microlens-prof \
 ghc-microlens-th-prof \
 ghc-mtl-prof \
 ghc-pager-prof \
 ghc-parser-combinators-prof \
 ghc-pretty-simple-prof \
 ghc-regex-tdfa-prof \
 ghc-safe-prof \
 ghc-tabular-prof \
 ghc-tasty-hunit-prof \
 ghc-tasty-prof \
 ghc-template-haskell-prof \
 ghc-terminal-size-prof \
 ghc-text-ansi-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-timeit-prof \
 ghc-transformers-prof \
 ghc-uglymemo-prof \
 ghc-unordered-containers-prof \
 ghc-utf8-string-prof \
 "
RDEPENDS:ghc-isomorphism-class = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-isomorphism-class-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-hashable-devel \
 ghc-isomorphism-class \
 ghc-primitive-devel \
 ghc-text-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-isomorphism-class-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-isomorphism-class-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-hashable-prof \
 ghc-isomorphism-class-devel \
 ghc-primitive-prof \
 ghc-text-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
RDEPENDS:ghc-pager = " \
 ghc-array \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bitvec \
 ghc-bytestring \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-terminfo \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-zlib \
 glibc \
 gmp \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-pager-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-conduit-extra-devel \
 ghc-directory-devel \
 ghc-pager \
 ghc-process-devel \
 ghc-resourcet-devel \
 ghc-safe-devel \
 ghc-terminfo-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-pager-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pager-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-conduit-extra-prof \
 ghc-conduit-prof \
 ghc-directory-prof \
 ghc-pager-devel \
 ghc-process-prof \
 ghc-resourcet-prof \
 ghc-safe-prof \
 ghc-terminfo-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-quickcheck-instances = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-base-orphans \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-containers \
 ghc-data-fix \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-quickcheck-instances-devel = " \
 ghc-OneTuple-devel \
 ghc-QuickCheck-devel \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-fix-devel \
 ghc-hashable-devel \
 ghc-integer-logarithms-devel \
 ghc-old-time-devel \
 ghc-primitive-devel \
 ghc-quickcheck-instances \
 ghc-scientific-devel \
 ghc-splitmix-devel \
 ghc-strict-devel \
 ghc-tagged-devel \
 ghc-text-devel \
 ghc-text-short-devel \
 ghc-these-devel \
 ghc-time-compat-devel \
 ghc-time-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 ghc-unordered-containers-devel \
 ghc-uuid-types-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-quickcheck-instances-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-quickcheck-instances-prof = " \
 ghc-OneTuple-prof \
 ghc-QuickCheck-prof \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-containers-prof \
 ghc-data-fix-prof \
 ghc-hashable-prof \
 ghc-integer-logarithms-prof \
 ghc-old-time-prof \
 ghc-primitive-prof \
 ghc-quickcheck-instances-devel \
 ghc-scientific-prof \
 ghc-splitmix-prof \
 ghc-strict-prof \
 ghc-tagged-prof \
 ghc-text-prof \
 ghc-text-short-prof \
 ghc-these-prof \
 ghc-time-compat-prof \
 ghc-time-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 ghc-unordered-containers-prof \
 ghc-uuid-types-prof \
 ghc-vector-prof \
 "
RDEPENDS:ghc-quote-quot = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-quote-quot-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-quote-quot \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-quote-quot-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-quote-quot-prof = " \
 ghc-base-prof \
 ghc-quote-quot-devel \
 ghc-template-haskell-prof \
 "
RDEPENDS:ghc-text-ansi = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-quote-quot \
 ghc-template-haskell \
 ghc-text \
 ghc-text-builder-linear \
 glibc \
 gmp \
 "
RDEPENDS:ghc-text-ansi-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-text-ansi \
 ghc-text-builder-linear-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-text-ansi-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-text-ansi-prof = " \
 ghc-base-prof \
 ghc-text-ansi-devel \
 ghc-text-builder-linear-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-text-builder = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-deferred-folds \
 ghc-distributive \
 ghc-exceptions \
 ghc-filepath \
 ghc-foldl \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-integer-logarithms \
 ghc-isomorphism-class \
 ghc-mtl \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-profunctors \
 ghc-quickcheck-instances \
 ghc-random \
 ghc-scientific \
 ghc-semigroupoids \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-builder-dev \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-text-builder-dev = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-deferred-folds \
 ghc-distributive \
 ghc-exceptions \
 ghc-filepath \
 ghc-foldl \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-integer-logarithms \
 ghc-isomorphism-class \
 ghc-mtl \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-profunctors \
 ghc-quickcheck-instances \
 ghc-random \
 ghc-scientific \
 ghc-semigroupoids \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-text-builder-dev-devel = " \
 ghc-QuickCheck-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deferred-folds-devel \
 ghc-isomorphism-class-devel \
 ghc-quickcheck-instances-devel \
 ghc-split-devel \
 ghc-text-builder-dev \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-text-builder-dev-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-text-builder-dev-prof = " \
 ghc-QuickCheck-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-deferred-folds-prof \
 ghc-isomorphism-class-prof \
 ghc-quickcheck-instances-prof \
 ghc-split-prof \
 ghc-text-builder-dev-devel \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 "
RDEPENDS:ghc-text-builder-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-text-builder \
 ghc-text-builder-dev-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-text-builder-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-text-builder-linear = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-quote-quot \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-text-builder-linear-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-ghc-bignum-devel \
 ghc-quote-quot-devel \
 ghc-text-builder-linear \
 ghc-text-devel \
 "
RDEPENDS:ghc-text-builder-linear-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-text-builder-linear-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-ghc-bignum-prof \
 ghc-quote-quot-prof \
 ghc-text-builder-linear-devel \
 ghc-text-prof \
 "
RDEPENDS:ghc-text-builder-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-text-builder-dev-prof \
 ghc-text-builder-devel \
 ghc-text-prof \
 "
RDEPENDS:ghc-timeit = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-timeit-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-timeit \
 "
RDEPENDS:ghc-timeit-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-timeit-prof = " \
 ghc-base-prof \
 ghc-timeit-devel \
 "
