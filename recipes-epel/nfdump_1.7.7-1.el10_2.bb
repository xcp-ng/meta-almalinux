# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfdump"
PV = "1.7.7"
PR = "1.el10_2"
PACKAGES = " \
 nfdump \
 nfdump-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nfdump-1.7.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8877694e3af2004b8351b67165a38f63b093c2e08f5a728b8b714b15e829a3f"

URI_x86_64_v2_nfdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nfdump-1.7.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nfdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfdump}"
SRC_URI[x86_64_v2_nfdump.sha256sum] = "2059b18ef57f4409da1be4311462ff8601e0d60a26236a6d1f2bee984290193a"

URI_x86_64_v2_nfdump-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nfdump-libs-1.7.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nfdump-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfdump-libs}"
SRC_URI[x86_64_v2_nfdump-libs.sha256sum] = "a97f10741505a355cbd0d80a791097aa69920d520171b23ea95063c82c10707f"

URI_aarch64_nfdump = "${EPEL_MIRROR}/aarch64/Packages/n/nfdump-1.7.7-1.el10_2.aarch64.rpm;name=aarch64_nfdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfdump}"
SRC_URI[aarch64_nfdump.sha256sum] = "ede7aad3add8fe2b3519f19724e682511808f08436d10bd2a983e4309bc6c492"

URI_aarch64_nfdump-libs = "${EPEL_MIRROR}/aarch64/Packages/n/nfdump-libs-1.7.7-1.el10_2.aarch64.rpm;name=aarch64_nfdump-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfdump-libs}"
SRC_URI[aarch64_nfdump-libs.sha256sum] = "e285b9099fe01a9590a976abc7203c91e296ffeb8678c18d8413a6e01d2db52d"

RDEPENDS:nfdump = " \
 glibc \
 libpcap \
 nfdump-libs \
 rrdtool \
 "
RDEPENDS:nfdump-libs:x86_64_v2 = " \
 bzip2-libs \
 glibc \
 libzstd \
 rrdtool \
"
RDEPENDS:nfdump-libs:aarch64 = " \
 bzip2-libs \
 glibc \
 libatomic \
 libzstd \
 rrdtool \
"
