# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "adobe-source-code-pro-fonts"
PV = "2.042.1.062.1.026"
PR = "5.el10_0"
PACKAGES = " \
 adobe-source-code-pro-fonts \
 adobe-source-code-vf-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/adobe-source-code-pro-fonts-2.042.1.062.1.026-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0a1d0be20cbc64ac08a129871811a963ae2c77c2c837f0c3145a4a08de1656d"

URI_x86_64_v2_adobe-source-code-pro-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/adobe-source-code-pro-fonts-2.042.1.062.1.026-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_adobe-source-code-pro-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adobe-source-code-pro-fonts}"
SRC_URI[x86_64_v2_adobe-source-code-pro-fonts.sha256sum] = "5c9ffc096fdf9b3579cb4a97803be3a9b32fbf6d87570200e5e39894380ad3d9"

URI_x86_64_v2_adobe-source-code-vf-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/adobe-source-code-vf-fonts-2.042.1.062.1.026-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_adobe-source-code-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_adobe-source-code-vf-fonts}"
SRC_URI[x86_64_v2_adobe-source-code-vf-fonts.sha256sum] = "422a8d8673dbc9d29bc26083a855f5b0dec3ab2b1903e26ed4e1b8c292a2281e"

URI_aarch64_adobe-source-code-pro-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/adobe-source-code-pro-fonts-2.042.1.062.1.026-5.el10_0.noarch.rpm;name=aarch64_adobe-source-code-pro-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_adobe-source-code-pro-fonts}"
SRC_URI[aarch64_adobe-source-code-pro-fonts.sha256sum] = "b48ff5b69b9d8908e74630f78ebaec3aac5ed76f17ba03424f482eaddad913bf"

URI_aarch64_adobe-source-code-vf-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/adobe-source-code-vf-fonts-2.042.1.062.1.026-5.el10_0.noarch.rpm;name=aarch64_adobe-source-code-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_adobe-source-code-vf-fonts}"
SRC_URI[aarch64_adobe-source-code-vf-fonts.sha256sum] = "f9722bd776727aa30c93f7e6e475f16b399b2e1df3eaba20ad1bf65c7bd2ba7c"

RDEPENDS:adobe-source-code-pro-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:adobe-source-code-vf-fonts = " \
 fonts-filesystem \
 "
