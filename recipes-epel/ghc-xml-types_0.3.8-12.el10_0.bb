# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-xml-types"
PV = "0.3.8"
PR = "12.el10_0"
PACKAGES = " \
 ghc-xml-types \
 ghc-xml-types-devel \
 ghc-xml-types-doc \
 ghc-xml-types-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-xml-types-0.3.8-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf0f67dc37591a22d5c938cbf924d65bf280d734c83f67bbb23cf5b8a4d394bf"

URI_x86_64_v2_ghc-xml-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-types-0.3.8-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-types}"
SRC_URI[x86_64_v2_ghc-xml-types.sha256sum] = "5e19ccae307e91855d419cc948d8213aef3b973e9f1f00add8a7397891392f4b"

URI_x86_64_v2_ghc-xml-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-types-devel-0.3.8-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-types-devel}"
SRC_URI[x86_64_v2_ghc-xml-types-devel.sha256sum] = "f091c7f07181a9c44bf9af13366a7c224989290a125c8efc5a43e86d60a9503f"

URI_x86_64_v2_ghc-xml-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-types-doc-0.3.8-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-xml-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-types-doc}"
SRC_URI[x86_64_v2_ghc-xml-types-doc.sha256sum] = "c796a5643942d64821e9bbd8cc826827f9eb4e4ff5f6b985f42291b88c4c9d7d"

URI_x86_64_v2_ghc-xml-types-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-types-prof-0.3.8-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-types-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-types-prof}"
SRC_URI[x86_64_v2_ghc-xml-types-prof.sha256sum] = "f81248410f997e82fb6aca4b3f3cabddec394e6d4a5c51143c199f490388db01"

URI_aarch64_ghc-xml-types = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-types-0.3.8-12.el10_0.aarch64.rpm;name=aarch64_ghc-xml-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-types}"
SRC_URI[aarch64_ghc-xml-types.sha256sum] = "c500eb213e2a30dda6481ac0020c056a8d0fa9ca5d2cb235b3d75bf17dfc4ab7"

URI_aarch64_ghc-xml-types-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-types-devel-0.3.8-12.el10_0.aarch64.rpm;name=aarch64_ghc-xml-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-types-devel}"
SRC_URI[aarch64_ghc-xml-types-devel.sha256sum] = "01a3eb28efc8f205417222e2c9ccf895e73b2284cd53dd30abeb378e55af73e0"

URI_aarch64_ghc-xml-types-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-types-doc-0.3.8-12.el10_0.noarch.rpm;name=aarch64_ghc-xml-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-types-doc}"
SRC_URI[aarch64_ghc-xml-types-doc.sha256sum] = "947b5070d1931cd21496b56135980ad9e5243eae9691a22962dce82e6699b7ac"

URI_aarch64_ghc-xml-types-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-types-prof-0.3.8-12.el10_0.aarch64.rpm;name=aarch64_ghc-xml-types-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-types-prof}"
SRC_URI[aarch64_ghc-xml-types-prof.sha256sum] = "ef05e529c9c14f984c2307702096cd24b4d517553561e9633b97bc9f46f2cafe"

RDEPENDS:ghc-xml-types = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-xml-types-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-text-devel \
 ghc-xml-types \
 "
RDEPENDS:ghc-xml-types-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-xml-types-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-text-prof \
 ghc-xml-types-devel \
 "
