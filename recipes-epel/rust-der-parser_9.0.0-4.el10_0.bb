# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der-parser"
PV = "9.0.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-der-parser+bigint-devel \
 rust-der-parser+cookie-factory-devel \
 rust-der-parser+default-devel \
 rust-der-parser+num-bigint-devel \
 rust-der-parser+serialize-devel \
 rust-der-parser+std-devel \
 rust-der-parser+unstable-devel \
 rust-der-parser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der-parser-9.0.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f09dc92ac45a6db4e38d93174ef1bb8108124243c9d7078e707c11b03b5cfae9"

URI_x86_64_v2_rust-der-parser+bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+bigint-devel-9.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+bigint-devel}"
SRC_URI[x86_64_v2_rust-der-parser+bigint-devel.sha256sum] = "0775fdbfb4a9e6eb68176fe1d393aea953d33cf92c8e39434293930154180622"

URI_x86_64_v2_rust-der-parser+cookie-factory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+cookie-factory-devel-9.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+cookie-factory-devel}"
SRC_URI[x86_64_v2_rust-der-parser+cookie-factory-devel.sha256sum] = "820f4f1292de634be2085ca6f509aee905bd2b3eeaa19263b237bb96d50c3126"

URI_x86_64_v2_rust-der-parser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+default-devel-9.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+default-devel}"
SRC_URI[x86_64_v2_rust-der-parser+default-devel.sha256sum] = "5e32eebb03a56a71292d46a1f61ce17b31a1fe93dee2e4b9f2874c9b22aea0ee"

URI_x86_64_v2_rust-der-parser+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+num-bigint-devel-9.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-der-parser+num-bigint-devel.sha256sum] = "c58ff12fd91d020e842a41a11e853b7a97cd8ddde6c46d9d95651edb40182f15"

URI_x86_64_v2_rust-der-parser+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+serialize-devel-9.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+serialize-devel}"
SRC_URI[x86_64_v2_rust-der-parser+serialize-devel.sha256sum] = "cd27b3dcadce490400310735542bf7015ff63fa0b5692d4e1d514db74f0d5934"

URI_x86_64_v2_rust-der-parser+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+std-devel-9.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+std-devel}"
SRC_URI[x86_64_v2_rust-der-parser+std-devel.sha256sum] = "f220db3a7ab579ed9f96208dc501a1ba0f029ae152f69150b012718d677eb07e"

URI_x86_64_v2_rust-der-parser+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+unstable-devel-9.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+unstable-devel}"
SRC_URI[x86_64_v2_rust-der-parser+unstable-devel.sha256sum] = "ef4ddb54b6889d627879c9fdca526fcd5265b5509ce04d0bd39a88ae61519d0a"

URI_x86_64_v2_rust-der-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser-devel-9.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser-devel}"
SRC_URI[x86_64_v2_rust-der-parser-devel.sha256sum] = "41a28141e1b1fe152598fbe1000d3cd1fa303729c88dac9fcdeaa93ad1735c9e"

URI_aarch64_rust-der-parser+bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+bigint-devel-9.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-der-parser+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+bigint-devel}"
SRC_URI[aarch64_rust-der-parser+bigint-devel.sha256sum] = "8a3b8ed231f21dff53825b2f8439a861fb5ab5a2cbabc5b6a53d9407ce7eabde"

URI_aarch64_rust-der-parser+cookie-factory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+cookie-factory-devel-9.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-der-parser+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+cookie-factory-devel}"
SRC_URI[aarch64_rust-der-parser+cookie-factory-devel.sha256sum] = "562666c10e8bb148ef0c64b49bdea4e4e8ee3d06596b8a1e8ba91b017a90a52c"

URI_aarch64_rust-der-parser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+default-devel-9.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-der-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+default-devel}"
SRC_URI[aarch64_rust-der-parser+default-devel.sha256sum] = "18c35c229fdacf9e24e96009c42fc6d143d7ae0f78526a058bf415377fd31575"

URI_aarch64_rust-der-parser+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+num-bigint-devel-9.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-der-parser+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+num-bigint-devel}"
SRC_URI[aarch64_rust-der-parser+num-bigint-devel.sha256sum] = "26c71ec7403341cc68a0b0fba60ae0152ee6f763ed1a6eaec9b9c7316ff06c11"

URI_aarch64_rust-der-parser+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+serialize-devel-9.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-der-parser+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+serialize-devel}"
SRC_URI[aarch64_rust-der-parser+serialize-devel.sha256sum] = "c24ef9b884550c0c4049df2d03003453d8390fce6107187b8193da2c233280e0"

URI_aarch64_rust-der-parser+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+std-devel-9.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-der-parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+std-devel}"
SRC_URI[aarch64_rust-der-parser+std-devel.sha256sum] = "7884912ec8eecb0d9a621fc95cdc9798afd222a4fbbcc95e0f23783afce65c5b"

URI_aarch64_rust-der-parser+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+unstable-devel-9.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-der-parser+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+unstable-devel}"
SRC_URI[aarch64_rust-der-parser+unstable-devel.sha256sum] = "ed22c756ea014dabae8e77c24666b41ac02c60f036f7e9eccadcbb84f674df9c"

URI_aarch64_rust-der-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser-devel-9.0.0-4.el10_0.noarch.rpm;name=aarch64_rust-der-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser-devel}"
SRC_URI[aarch64_rust-der-parser-devel.sha256sum] = "0a4b404afc32694fe2c45f970c6369c20b1e06aa0dd7c7dd8425c4541ed10b56"

RDEPENDS:rust-der-parser+bigint-devel = " \
 cargo \
 rust-der-parser+num-bigint-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+cookie-factory-devel = " \
 cargo \
 rust-cookie-factory+default-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+default-devel = " \
 cargo \
 rust-der-parser+std-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+num-bigint-devel = " \
 cargo \
 rust-der-parser-devel \
 rust-num-bigint+default-devel \
 "
RDEPENDS:rust-der-parser+serialize-devel = " \
 cargo \
 rust-der-parser+cookie-factory-devel \
 rust-der-parser+std-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+std-devel = " \
 cargo \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+unstable-devel = " \
 cargo \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser-devel = " \
 cargo \
 rust \
 rust-asn1-rs+default-devel \
 rust-displaydoc-devel \
 rust-nom+default-devel \
 rust-num-traits+default-devel \
 rust-rusticata-macros+default-devel \
 "
