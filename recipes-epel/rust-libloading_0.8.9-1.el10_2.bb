# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libloading"
PV = "0.8.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-libloading+default-devel \
 rust-libloading-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libloading-0.8.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4d6bad3fabd51d45cc9bead5deb0b461e95c4a65c42f6c94bb7c873eabeef784"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libloading+default-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libloading+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libloading+default-devel.sha256sum] = "31314e70900823e61c1c09e582132e61cf26cdcca8639aab9a7ff7c4eaeecc94"
RPROVIDES:rust-libloading+default-devel:append:x86_64_v2 = " virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libloading-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libloading-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libloading-devel.sha256sum] = "48f0b8c44dbe65bdf46538379b1c56a818f7e122b2b60aeaa74f3c9d52381821"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libloading+default-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-libloading+default-devel;unpack=0"
SRC_URI[aarch64_rust-libloading+default-devel.sha256sum] = "69a4f03d29cadce0776f0d93c8c65f1c5d9d45a7610fd1c04bdab4af901133e0"
RPROVIDES:rust-libloading+default-devel:append:aarch64 = " virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libloading-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-libloading-devel;unpack=0"
SRC_URI[aarch64_rust-libloading-devel.sha256sum] = "a4f0f7ecc30673eb4a2ac3db16d28b5a04fdb67de4c22b36e52c08cdc74681a4"

RDEPENDS:rust-libloading+default-devel = " \
 cargo \
 rust-libloading-devel \
 "
RDEPENDS:rust-libloading-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
