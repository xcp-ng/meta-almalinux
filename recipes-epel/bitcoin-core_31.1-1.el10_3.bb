# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bitcoin-core"
PV = "31.1"
PR = "1.el10_3"
PACKAGES = " \
 bitcoin-core \
 bitcoin-core-desktop \
 bitcoin-core-server \
 bitcoin-core-utils \
 libbitcoinkernel \
 libbitcoinkernel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bitcoin-core-31.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d507684657095c4f87e08dcac993534127d3ddb4e83442f4f302439dad1f44aa"

URI_x86_64_v2_bitcoin-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-31.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core}"
SRC_URI[x86_64_v2_bitcoin-core.sha256sum] = "205cc9787f56ff9334e3eac9af4242668e5a9c60a9857c59da22e0c435bbd3f3"

URI_x86_64_v2_bitcoin-core-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-desktop-31.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-desktop}"
SRC_URI[x86_64_v2_bitcoin-core-desktop.sha256sum] = "047a294fe47629d34024fa6e1202a6cf53463a544808f99e2a3209590971e4ee"

URI_x86_64_v2_bitcoin-core-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-server-31.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-server}"
SRC_URI[x86_64_v2_bitcoin-core-server.sha256sum] = "acc96be403f4ca076825c8e4bebf92b4490fc6c6a33134dff9d15cc3d534d746"

URI_x86_64_v2_bitcoin-core-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitcoin-core-utils-31.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bitcoin-core-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bitcoin-core-utils}"
SRC_URI[x86_64_v2_bitcoin-core-utils.sha256sum] = "4133f795c401760202195ca891a475bbc8c8572acf7c709da880faaa864863f3"

URI_x86_64_v2_libbitcoinkernel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbitcoinkernel-31.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbitcoinkernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbitcoinkernel}"
SRC_URI[x86_64_v2_libbitcoinkernel.sha256sum] = "97dea679599b3adcb7caeb0e55898018a38a584b6ffba2ad4ab2901f4c5c921e"

URI_x86_64_v2_libbitcoinkernel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbitcoinkernel-devel-31.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbitcoinkernel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbitcoinkernel-devel}"
SRC_URI[x86_64_v2_libbitcoinkernel-devel.sha256sum] = "61695c135aaf4ecde6e2946e0fbf88b9c1cadb745f39debf63cddc7185af45e3"

URI_aarch64_bitcoin-core = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-31.1-1.el10_3.aarch64.rpm;name=aarch64_bitcoin-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core}"
SRC_URI[aarch64_bitcoin-core.sha256sum] = "e3fdcc6ba46f49a9781739d44cfbf9c7e997492e9ed317c79f65cc3df6bb854d"

URI_aarch64_bitcoin-core-desktop = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-desktop-31.1-1.el10_3.aarch64.rpm;name=aarch64_bitcoin-core-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-desktop}"
SRC_URI[aarch64_bitcoin-core-desktop.sha256sum] = "defe6039f19627e411bad85d205f4181455bafc51d0cb08e223cace8eb0df719"

URI_aarch64_bitcoin-core-server = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-server-31.1-1.el10_3.aarch64.rpm;name=aarch64_bitcoin-core-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-server}"
SRC_URI[aarch64_bitcoin-core-server.sha256sum] = "b2fab0d8d5cae39a4d3843cb98cdcb1fd7567765afd384e7e55bfe79780d3f6e"

URI_aarch64_bitcoin-core-utils = "${EPEL_MIRROR}/aarch64/Packages/b/bitcoin-core-utils-31.1-1.el10_3.aarch64.rpm;name=aarch64_bitcoin-core-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bitcoin-core-utils}"
SRC_URI[aarch64_bitcoin-core-utils.sha256sum] = "a50908fb1484bf8cfd34b08f3deb656e39dcd089efa361199c53c9a30e953229"

URI_aarch64_libbitcoinkernel = "${EPEL_MIRROR}/aarch64/Packages/l/libbitcoinkernel-31.1-1.el10_3.aarch64.rpm;name=aarch64_libbitcoinkernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbitcoinkernel}"
SRC_URI[aarch64_libbitcoinkernel.sha256sum] = "1e7f3b2f0bacbbe0fb365f2d5825ef2f6187d801d4d89c5d5b1c04676c2fb500"

URI_aarch64_libbitcoinkernel-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libbitcoinkernel-devel-31.1-1.el10_3.aarch64.rpm;name=aarch64_libbitcoinkernel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbitcoinkernel-devel}"
SRC_URI[aarch64_libbitcoinkernel-devel.sha256sum] = "8ad3b77499dbdee8fa3fa4d8e83893d38e0eed571d63c840259a84dda005ee1a"

RDEPENDS:bitcoin-core = " \
 bash \
 bitcoin-core-desktop \
 bitcoin-core-server \
 bitcoin-core-utils \
 capnproto-libs \
 glibc \
 libbitcoinkernel \
 libevent \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 sqlite-libs \
 zeromq \
 "
RDEPENDS:bitcoin-core-desktop = " \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 sqlite-libs \
 zeromq \
 "
RDEPENDS:bitcoin-core-server = " \
 bash \
 bitcoin-core-selinux \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 shadow-utils \
 sqlite-libs \
 zeromq \
 "
RDEPENDS:bitcoin-core-utils = " \
 glibc \
 libevent \
 libgcc \
 libstdc++ \
 sqlite-libs \
 "
RDEPENDS:libbitcoinkernel = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libbitcoinkernel-devel = " \
 glibc \
 libbitcoinkernel \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 "
