# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-object0.38"
PV = "0.38.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-object0.38+all-devel \
 rust-object0.38+archive-devel \
 rust-object0.38+build-devel \
 rust-object0.38+build_core-devel \
 rust-object0.38+cargo-all-devel \
 rust-object0.38+coff-devel \
 rust-object0.38+compression-devel \
 rust-object0.38+default-devel \
 rust-object0.38+doc-devel \
 rust-object0.38+elf-devel \
 rust-object0.38+macho-devel \
 rust-object0.38+pe-devel \
 rust-object0.38+read-devel \
 rust-object0.38+read_core-devel \
 rust-object0.38+std-devel \
 rust-object0.38+unaligned-devel \
 rust-object0.38+unstable-all-devel \
 rust-object0.38+unstable-devel \
 rust-object0.38+write-devel \
 rust-object0.38+write_core-devel \
 rust-object0.38+write_std-devel \
 rust-object0.38+xcoff-devel \
 rust-object0.38-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-object0.38-0.38.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abe5c5f76488f0c305b2159c35348dbfda08dcdcd956c44fbe2b1dcbe2634a03"

URI_x86_64_v2_rust-object0.38+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+all-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+all-devel}"
SRC_URI[x86_64_v2_rust-object0.38+all-devel.sha256sum] = "9562fcf011fe29b2d0ebc29d75bfe84ca0b52a8dbea8b94a237808769f79f334"

URI_x86_64_v2_rust-object0.38+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+archive-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+archive-devel}"
SRC_URI[x86_64_v2_rust-object0.38+archive-devel.sha256sum] = "49f945fbd2f5a772d7254a0919aa007635fbac6c905220a9ae678eed5ec42926"

URI_x86_64_v2_rust-object0.38+build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+build-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+build-devel}"
SRC_URI[x86_64_v2_rust-object0.38+build-devel.sha256sum] = "6e28302f9fca1000a220a92509f7b5c9a0c301a3ef283348359adef21cb74978"
RPROVIDES:rust-object0.38+build-devel:x86_64_v2 = "virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~"

URI_x86_64_v2_rust-object0.38+build_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+build_core-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+build_core-devel}"
SRC_URI[x86_64_v2_rust-object0.38+build_core-devel.sha256sum] = "3a28b97ac5ffe31ddb29d6458820b1adbaedaf9198c727082fd52198afe593ab"

URI_x86_64_v2_rust-object0.38+cargo-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+cargo-all-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+cargo-all-devel}"
SRC_URI[x86_64_v2_rust-object0.38+cargo-all-devel.sha256sum] = "0b62e2d693c79ffb8a9d72c88eb375ab4218aea1f461a90a02c8151d69a9bb78"

URI_x86_64_v2_rust-object0.38+coff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+coff-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+coff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+coff-devel}"
SRC_URI[x86_64_v2_rust-object0.38+coff-devel.sha256sum] = "0a53cf6dfbd07acc214463d1c16be5ec88260b8e0f76efe490df0d4796ee4167"

URI_x86_64_v2_rust-object0.38+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+compression-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+compression-devel}"
SRC_URI[x86_64_v2_rust-object0.38+compression-devel.sha256sum] = "17d5e89bb4c5b028dbefc12d4d485ddeae950769bce8ff6a79789664be725499"

URI_x86_64_v2_rust-object0.38+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+default-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+default-devel}"
SRC_URI[x86_64_v2_rust-object0.38+default-devel.sha256sum] = "61a1f20cba73abe05ee6d3d9be4aa05fa91bc676e3356675a1e8d567f3a3f3f5"

URI_x86_64_v2_rust-object0.38+doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+doc-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+doc-devel}"
SRC_URI[x86_64_v2_rust-object0.38+doc-devel.sha256sum] = "1276cd3b00495930173896552b6d37b4b0739c6c7780cc4d1d9c906de3721ac0"

URI_x86_64_v2_rust-object0.38+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+elf-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+elf-devel}"
SRC_URI[x86_64_v2_rust-object0.38+elf-devel.sha256sum] = "e220f97d6308c0ea9d0ad46a6ee832af811384e2dabcb680f2d56ffa27e34cb6"
RPROVIDES:rust-object0.38+elf-devel:x86_64_v2 = "virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~"

URI_x86_64_v2_rust-object0.38+macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+macho-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+macho-devel}"
SRC_URI[x86_64_v2_rust-object0.38+macho-devel.sha256sum] = "0033deda5630b4640a0371bf9305b50d479b5ef51a3e017539aaf406dda14c22"

URI_x86_64_v2_rust-object0.38+pe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+pe-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+pe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+pe-devel}"
SRC_URI[x86_64_v2_rust-object0.38+pe-devel.sha256sum] = "feb2d3a5725d58bb4d06256b77a21ac648e1a08095f8e650004eb44afdb17d02"

URI_x86_64_v2_rust-object0.38+read-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+read-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+read-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+read-devel}"
SRC_URI[x86_64_v2_rust-object0.38+read-devel.sha256sum] = "318c40e5d0dd7f74f107385088e5d032b11c7ed82138464643d0aa9e2f0c6b97"

URI_x86_64_v2_rust-object0.38+read_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+read_core-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+read_core-devel}"
SRC_URI[x86_64_v2_rust-object0.38+read_core-devel.sha256sum] = "cbd31eac7dad5c12c54bc53e1a14afc72fbc23f46ca06130e14111a439348fd1"

URI_x86_64_v2_rust-object0.38+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+std-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+std-devel}"
SRC_URI[x86_64_v2_rust-object0.38+std-devel.sha256sum] = "ee7d698ea4aa71b99100bec3f76e7d3c6f1d01d5340259eb86c94fe448f9a28d"

URI_x86_64_v2_rust-object0.38+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+unaligned-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+unaligned-devel}"
SRC_URI[x86_64_v2_rust-object0.38+unaligned-devel.sha256sum] = "eefcae50ac470ee8d1d6804c54ee59f25fde83f31ff5ce5671854f1cfd184a47"

URI_x86_64_v2_rust-object0.38+unstable-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+unstable-all-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+unstable-all-devel}"
SRC_URI[x86_64_v2_rust-object0.38+unstable-all-devel.sha256sum] = "30def4c9e234984c991b8926e92b5b9dd3130b5f17dc86e91dfd158ccd6f145a"

URI_x86_64_v2_rust-object0.38+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+unstable-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+unstable-devel}"
SRC_URI[x86_64_v2_rust-object0.38+unstable-devel.sha256sum] = "3afd078030bdb671eaf0bfa7266d24ae509135057ee3465d009a0165c7a5c8c5"

URI_x86_64_v2_rust-object0.38+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+write-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+write-devel}"
SRC_URI[x86_64_v2_rust-object0.38+write-devel.sha256sum] = "95e395f868ec026a57d9b0c9c6cb028769ef5cd94a31fffaf7dd4a11738c56a9"

URI_x86_64_v2_rust-object0.38+write_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+write_core-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+write_core-devel}"
SRC_URI[x86_64_v2_rust-object0.38+write_core-devel.sha256sum] = "2980948bab65119f2da21a42e46137488c5bb3f0d78fec06317f3f8376e59c88"

URI_x86_64_v2_rust-object0.38+write_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+write_std-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+write_std-devel}"
SRC_URI[x86_64_v2_rust-object0.38+write_std-devel.sha256sum] = "72c41688057a3fc845ce3f496f0f750359ead1ee79d2e10fce349032eaafb42c"

URI_x86_64_v2_rust-object0.38+xcoff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38+xcoff-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38+xcoff-devel}"
SRC_URI[x86_64_v2_rust-object0.38+xcoff-devel.sha256sum] = "2d007d0f2f6c33a2a3ed721168f0886007a36269694d4459a5ffb01199985575"

URI_x86_64_v2_rust-object0.38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.38-devel-0.38.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.38-devel}"
SRC_URI[x86_64_v2_rust-object0.38-devel.sha256sum] = "0d60dc11771d48accde030c0a76c3a7975542840dbd732d275365de3680e84e3"
RPROVIDES:rust-object0.38-devel:x86_64_v2 = "virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

URI_aarch64_rust-object0.38+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+all-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+all-devel}"
SRC_URI[aarch64_rust-object0.38+all-devel.sha256sum] = "47fa308c6d00174e0319e753edbbab26be844b5f7e98b23a25366e930289e460"

URI_aarch64_rust-object0.38+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+archive-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+archive-devel}"
SRC_URI[aarch64_rust-object0.38+archive-devel.sha256sum] = "2169f3d2c32389354c9be2d97caeac2ddd898b0a394c8d61ca8b14b644c4db49"

URI_aarch64_rust-object0.38+build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+build-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+build-devel}"
SRC_URI[aarch64_rust-object0.38+build-devel.sha256sum] = "cdab48f7ce162616cd63d47b9f194be18c8531ebd2ab5594ef8b313301bc75fe"
RPROVIDES:rust-object0.38+build-devel:aarch64 = "virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~"

URI_aarch64_rust-object0.38+build_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+build_core-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+build_core-devel}"
SRC_URI[aarch64_rust-object0.38+build_core-devel.sha256sum] = "3f98e6d595c8eda3c1db8fc35fb0ececa6f91a73310de15041415479afd61ea8"

URI_aarch64_rust-object0.38+cargo-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+cargo-all-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+cargo-all-devel}"
SRC_URI[aarch64_rust-object0.38+cargo-all-devel.sha256sum] = "1e52cb464c2ce00587c0608013cc0e3d73e5371cca251d2b4c5f99b81b22d511"

URI_aarch64_rust-object0.38+coff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+coff-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+coff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+coff-devel}"
SRC_URI[aarch64_rust-object0.38+coff-devel.sha256sum] = "8a81bf3c3e9eee964306bf38dd80d4472021a1bfdcac77de34c39a1d001d69d3"

URI_aarch64_rust-object0.38+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+compression-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+compression-devel}"
SRC_URI[aarch64_rust-object0.38+compression-devel.sha256sum] = "8ec303241ef120f56854eec4621eee92503fe7afd53ec19c82e4c8c05ba4928e"

URI_aarch64_rust-object0.38+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+default-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+default-devel}"
SRC_URI[aarch64_rust-object0.38+default-devel.sha256sum] = "6f5067a6da1d4a40226b7df17e0b279d47faa267ccf701f44acdbfcc3072d205"

URI_aarch64_rust-object0.38+doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+doc-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+doc-devel}"
SRC_URI[aarch64_rust-object0.38+doc-devel.sha256sum] = "bf30b13797edc3bf83b2ec5771193feec89ffa8cb514bd3bbe2169234228ffe0"

URI_aarch64_rust-object0.38+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+elf-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+elf-devel}"
SRC_URI[aarch64_rust-object0.38+elf-devel.sha256sum] = "c4fe9631f59ce7a7766462706c0b079832f159399ca0aedac98fcb7a71fb2b4f"
RPROVIDES:rust-object0.38+elf-devel:aarch64 = "virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~"

URI_aarch64_rust-object0.38+macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+macho-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+macho-devel}"
SRC_URI[aarch64_rust-object0.38+macho-devel.sha256sum] = "62564cc4ec8da51538ba549ba58682ddf25b1fe67495e64ae3da7383f7b23d55"

URI_aarch64_rust-object0.38+pe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+pe-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+pe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+pe-devel}"
SRC_URI[aarch64_rust-object0.38+pe-devel.sha256sum] = "b46c219385be23e561a5555d71ac47a8669e083f1da23adc6d4f4475ad4585fe"

URI_aarch64_rust-object0.38+read-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+read-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+read-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+read-devel}"
SRC_URI[aarch64_rust-object0.38+read-devel.sha256sum] = "9c61800b7687549925175788c4d57bb564038ea0a771e002ccc33326ca79d901"

URI_aarch64_rust-object0.38+read_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+read_core-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+read_core-devel}"
SRC_URI[aarch64_rust-object0.38+read_core-devel.sha256sum] = "451ab64fddb3222ef91c949fd9836d8a6e8029bdf68006f0828396450f40d6a6"

URI_aarch64_rust-object0.38+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+std-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+std-devel}"
SRC_URI[aarch64_rust-object0.38+std-devel.sha256sum] = "36997e4d39a4798dab3e977af4d3df34aa0c27542d0b12ec6df29a7f09d9f921"

URI_aarch64_rust-object0.38+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+unaligned-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+unaligned-devel}"
SRC_URI[aarch64_rust-object0.38+unaligned-devel.sha256sum] = "2047a33a003247fa84368867c679a8bfcdd238b283f11d12c5d3110c749dbf84"

URI_aarch64_rust-object0.38+unstable-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+unstable-all-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+unstable-all-devel}"
SRC_URI[aarch64_rust-object0.38+unstable-all-devel.sha256sum] = "dfe7f3a52eee57d4051cbf321cdf59cca4dae5932f05ba95ed32642909097491"

URI_aarch64_rust-object0.38+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+unstable-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+unstable-devel}"
SRC_URI[aarch64_rust-object0.38+unstable-devel.sha256sum] = "516797ef2d3636bcf50e549e98e7e388d08c9f5c85b5d23106bf62d427314d0a"

URI_aarch64_rust-object0.38+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+write-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+write-devel}"
SRC_URI[aarch64_rust-object0.38+write-devel.sha256sum] = "3a9b55308a25c2781441c0d16756bf5a6d89e1d0eab4ea3ddf22f8a228a50a6c"

URI_aarch64_rust-object0.38+write_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+write_core-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+write_core-devel}"
SRC_URI[aarch64_rust-object0.38+write_core-devel.sha256sum] = "07e393b8243e11e654a5fa8badf4c87f1c400cac2bbc014e14602530087ac5d3"

URI_aarch64_rust-object0.38+write_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+write_std-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+write_std-devel}"
SRC_URI[aarch64_rust-object0.38+write_std-devel.sha256sum] = "a4a17596bee466953b99e471fd6daa2b0a7e625e54747e0e86a26df0dc375767"

URI_aarch64_rust-object0.38+xcoff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38+xcoff-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38+xcoff-devel}"
SRC_URI[aarch64_rust-object0.38+xcoff-devel.sha256sum] = "b1f5e92effb9f760c3bfb9b1f891dcb2d38b092451357725b0013a118db59835"

URI_aarch64_rust-object0.38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.38-devel-0.38.1-1.el10_3.noarch.rpm;name=aarch64_rust-object0.38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.38-devel}"
SRC_URI[aarch64_rust-object0.38-devel.sha256sum] = "01313144226d574b36e74eaa292b8549cc9ca3c7b882f16fd7427601e2a7a087"
RPROVIDES:rust-object0.38-devel:aarch64 = "virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

RDEPENDS:rust-object0.38+all-devel = " \
 cargo \
 rust-object0.38+build-devel \
 rust-object0.38+compression-devel \
 rust-object0.38+read-devel \
 rust-object0.38+std-devel \
 rust-object0.38+write-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+archive-devel = " \
 cargo \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+build-devel = " \
 cargo \
 rust-object0.38+build_core-devel \
 rust-object0.38+elf-devel \
 rust-object0.38+write_std-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+build_core-devel = " \
 cargo \
 rust-object0.38+read_core-devel \
 rust-object0.38+write_core-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+cargo-all-devel = " \
 cargo \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+coff-devel = " \
 cargo \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+compression-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-object0.38+std-devel \
 rust-object0.38-devel \
 rust-ruzstd+default-devel \
 "
RDEPENDS:rust-object0.38+default-devel = " \
 cargo \
 rust-object0.38+compression-devel \
 rust-object0.38+read-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+doc-devel = " \
 cargo \
 rust-object0.38+archive-devel \
 rust-object0.38+build_core-devel \
 rust-object0.38+coff-devel \
 rust-object0.38+compression-devel \
 rust-object0.38+elf-devel \
 rust-object0.38+macho-devel \
 rust-object0.38+pe-devel \
 rust-object0.38+read_core-devel \
 rust-object0.38+std-devel \
 rust-object0.38+write_std-devel \
 rust-object0.38+xcoff-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+elf-devel = " \
 cargo \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+macho-devel = " \
 cargo \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+pe-devel = " \
 cargo \
 rust-object0.38+coff-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+read-devel = " \
 cargo \
 rust-object0.38+archive-devel \
 rust-object0.38+coff-devel \
 rust-object0.38+elf-devel \
 rust-object0.38+macho-devel \
 rust-object0.38+pe-devel \
 rust-object0.38+read_core-devel \
 rust-object0.38+unaligned-devel \
 rust-object0.38+xcoff-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+read_core-devel = " \
 cargo \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+unaligned-devel = " \
 cargo \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+unstable-all-devel = " \
 cargo \
 rust-object0.38+all-devel \
 rust-object0.38+unstable-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+unstable-devel = " \
 cargo \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+write-devel = " \
 cargo \
 rust-object0.38+coff-devel \
 rust-object0.38+elf-devel \
 rust-object0.38+macho-devel \
 rust-object0.38+pe-devel \
 rust-object0.38+write_std-devel \
 rust-object0.38+xcoff-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+write_core-devel = " \
 cargo \
 rust-crc32fast-devel \
 rust-hashbrown0.16+default-hasher-devel \
 rust-hashbrown0.16-devel \
 rust-indexmap-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+write_std-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-object0.38+std-devel \
 rust-object0.38+write_core-devel \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38+xcoff-devel = " \
 cargo \
 rust-object0.38-devel \
 "
RDEPENDS:rust-object0.38-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~ rpm/virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~ rpm/virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~ rpm/virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~ rpm/virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"
