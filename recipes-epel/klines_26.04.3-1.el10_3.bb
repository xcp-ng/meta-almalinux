# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klines"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 klines \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klines-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82f635d7d75fa20554fd9ffa1d480f4039dd85beb11f3e99fed335dab05f33a2"

URI_x86_64_v2_klines = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klines-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klines}"
SRC_URI[x86_64_v2_klines.sha256sum] = "689fbb40cfcacad72a6ed1102813966e277ea45ebb71bf605ddea0b007daf72c"

URI_aarch64_klines = "${EPEL_MIRROR}/aarch64/Packages/k/klines-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_klines;unpack=0"
SRC_URI:append = " ${URI_aarch64_klines}"
SRC_URI[aarch64_klines.sha256sum] = "4268007d2f2239bd8245b2e1bc90fc8107468c6c51415447fb8db17e5c3f2872"

RDEPENDS:klines = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
