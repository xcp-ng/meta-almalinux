# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg-expr"
PV = "0.20.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-cfg-expr+default-devel \
 rust-cfg-expr+target-lexicon-devel \
 rust-cfg-expr+targets-devel \
 rust-cfg-expr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cfg-expr-0.20.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "32295f3fce3d71cc02877d0579f31a803f09008779dd646b20e5b5db23cf18c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+default-devel-0.20.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cfg-expr+default-devel.sha256sum] = "53f23983aa8caac39b5f0e672d38d6d3359b8a068306a10ecd2f8aa9c01b1268"
RPROVIDES:rust-cfg-expr+default-devel:append:x86_64_v2 = " virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+target-lexicon-devel-0.20.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+target-lexicon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cfg-expr+target-lexicon-devel.sha256sum] = "bdf9075fbccbee4f4a7e2e208dc00879f1f24975f34e2313cdd8a945f9da8378"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+targets-devel-0.20.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+targets-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cfg-expr+targets-devel.sha256sum] = "22a942ea28e803b640399eb4132313c5084c76d966a75760dc2a0d1748a85027"
RPROVIDES:rust-cfg-expr+targets-devel:append:x86_64_v2 = " virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr-devel-0.20.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cfg-expr-devel.sha256sum] = "224cd59e4d944f4ccbb22be79f697aff1a396c0dcbf6c4f8fce8aec527224907"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+default-devel-0.20.9-1.el10_2.noarch.rpm;name=aarch64_rust-cfg-expr+default-devel;unpack=0"
SRC_URI[aarch64_rust-cfg-expr+default-devel.sha256sum] = "1a0e418c6ffc6dbb842d4332948692a87f46903a6907f4b28ab7d6fb9086ca30"
RPROVIDES:rust-cfg-expr+default-devel:append:aarch64 = " virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+target-lexicon-devel-0.20.9-1.el10_2.noarch.rpm;name=aarch64_rust-cfg-expr+target-lexicon-devel;unpack=0"
SRC_URI[aarch64_rust-cfg-expr+target-lexicon-devel.sha256sum] = "99e8b87c31d3a08c2dc3f0fd1f6348ad19b958c9d478d7c0982067874005ab2c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+targets-devel-0.20.9-1.el10_2.noarch.rpm;name=aarch64_rust-cfg-expr+targets-devel;unpack=0"
SRC_URI[aarch64_rust-cfg-expr+targets-devel.sha256sum] = "288f182af4672454e0d7f522f9a4d42ea5b4f8aefb416c3e757bee25308956af"
RPROVIDES:rust-cfg-expr+targets-devel:append:aarch64 = " virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr-devel-0.20.9-1.el10_2.noarch.rpm;name=aarch64_rust-cfg-expr-devel;unpack=0"
SRC_URI[aarch64_rust-cfg-expr-devel.sha256sum] = "8d50eb67aca4cbc8d588bc8b334bb3e9b01e9fd41b93fdd7d2c4b5a593032a57"

RDEPENDS:rust-cfg-expr+default-devel = " \
 cargo \
 rust-cfg-expr-devel \
 "
RDEPENDS:rust-cfg-expr+target-lexicon-devel = " \
 cargo \
 rust-cfg-expr-devel \
 rust-target-lexicon+default-devel \
 "
RDEPENDS:rust-cfg-expr+targets-devel = " \
 cargo \
 rust-cfg-expr+target-lexicon-devel \
 rust-cfg-expr-devel \
 "
RDEPENDS:rust-cfg-expr-devel = " \
 cargo \
 rust \
 rust-smallvec+default-devel \
 "
