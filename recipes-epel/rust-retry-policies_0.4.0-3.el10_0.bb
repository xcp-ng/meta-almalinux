# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-retry-policies"
PV = "0.4.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-retry-policies+default-devel \
 rust-retry-policies-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-retry-policies-0.4.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63c4df88b87d1db2678ccbbe256e082f678b625e95218e0a7127a3df576ec71d"

URI_x86_64_v2_rust-retry-policies+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-retry-policies+default-devel-0.4.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-retry-policies+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-retry-policies+default-devel}"
SRC_URI[x86_64_v2_rust-retry-policies+default-devel.sha256sum] = "bdc57b685275d638f3b5f35c5188e6cb02d426879a82e953067f89fb9fae107e"

URI_x86_64_v2_rust-retry-policies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-retry-policies-devel-0.4.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-retry-policies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-retry-policies-devel}"
SRC_URI[x86_64_v2_rust-retry-policies-devel.sha256sum] = "cd28439bffc99fd0d0afcabe8461f4f0e77bfa0d2f01c2e544ffec4bef22b054"

URI_aarch64_rust-retry-policies+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-retry-policies+default-devel-0.4.0-3.el10_0.noarch.rpm;name=aarch64_rust-retry-policies+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-retry-policies+default-devel}"
SRC_URI[aarch64_rust-retry-policies+default-devel.sha256sum] = "7da4d636bac51ec82bc59ff2e0a202ce7b251dfaf89ab124f37fc29c6d890d19"

URI_aarch64_rust-retry-policies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-retry-policies-devel-0.4.0-3.el10_0.noarch.rpm;name=aarch64_rust-retry-policies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-retry-policies-devel}"
SRC_URI[aarch64_rust-retry-policies-devel.sha256sum] = "e80916b314e397c8f1bd033edb12d049c904a346f9e78b537d656662b43061e7"

RDEPENDS:rust-retry-policies+default-devel = " \
 cargo \
 rust-retry-policies-devel \
 "
RDEPENDS:rust-retry-policies-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 "
