# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "copr-cli"
PV = "2.7"
PR = "1.el10_2"
PACKAGES = " \
 copr-cli \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/copr-cli-2.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "67a1709a1d6145eceb1e8e48408cc26c0b2d8389e8db5d4958d4d140f4a117c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/copr-cli-2.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_copr-cli;unpack=0"
SRC_URI[x86_64_v2_copr-cli.sha256sum] = "ee5e603089225b862314122e1a4e7bd16bfbe35bbbb86bedcdc420b467a614d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/copr-cli-2.7-1.el10_2.noarch.rpm;name=aarch64_copr-cli;unpack=0"
SRC_URI[aarch64_copr-cli.sha256sum] = "433b6bf8790dbfa81b863e981fb2c8db4f55dddb007bb527d0f5baaf10c5f109"

RDEPENDS:copr-cli = " \
 python3 \
 python3-copr \
 python3-humanize \
 python3-jinja2 \
 python3-koji \
 python3-rich \
 python3-setuptools \
 python3-typing-extensions \
 wget \
 "
