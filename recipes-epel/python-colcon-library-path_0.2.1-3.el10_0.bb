# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-library-path"
PV = "0.2.1"
PR = "3.el10_0"
PACKAGES = " \
 python3-colcon-library-path \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-library-path-0.2.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d2b33d82964eaa491f92695274baafdcdc8dc85bc7aa9ac1686871c3d068ec1"

URI_x86_64_v2_python3-colcon-library-path = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-library-path-0.2.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-library-path;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-library-path}"
SRC_URI[x86_64_v2_python3-colcon-library-path.sha256sum] = "4f0be7e6783efed6f4b5af04d38a2de8bfc88ab4eed15c8958469eed6a2f1217"

URI_aarch64_python3-colcon-library-path = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-library-path-0.2.1-3.el10_0.noarch.rpm;name=aarch64_python3-colcon-library-path;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-library-path}"
SRC_URI[aarch64_python3-colcon-library-path.sha256sum] = "b76101bef2a4023a485ba72a46b36123c454a2e437c17ee06c629a1cbc4d1103"

RDEPENDS:python3-colcon-library-path = " \
 python3 \
 python3-colcon-core \
 "
