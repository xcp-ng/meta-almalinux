# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "icewm"
PV = "3.9.0"
PR = "2.el10_2"
PACKAGES = " \
 icewm \
 icewm-data \
 icewm-minimal-session \
 icewm-themes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/icewm-3.9.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7821052d3c58aa8051cceb3f4d16336d10e745f434a0b29e509444aa15bd11c"

URI_x86_64_v2_icewm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icewm-3.9.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_icewm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icewm}"
SRC_URI[x86_64_v2_icewm.sha256sum] = "ffd1da9c6775acf129dc9e478dff391d7cf48e6014268eb3b7873270d88f0ab5"

URI_x86_64_v2_icewm-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icewm-data-3.9.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_icewm-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icewm-data}"
SRC_URI[x86_64_v2_icewm-data.sha256sum] = "050bcea73fa7ea6a1927b61cf3372c1ff8fae1eda2e2f3485f30595976642b5c"

URI_x86_64_v2_icewm-minimal-session = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icewm-minimal-session-3.9.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_icewm-minimal-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icewm-minimal-session}"
SRC_URI[x86_64_v2_icewm-minimal-session.sha256sum] = "58538e12bcc6553f8c67dc7debbe7d0ca7a59c871116ea6e51437ad59834dda7"

URI_x86_64_v2_icewm-themes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icewm-themes-3.9.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_icewm-themes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icewm-themes}"
SRC_URI[x86_64_v2_icewm-themes.sha256sum] = "61a09a5bf11be2d56cafa5897826680fcb39d792b8c6cd64738025e64b49dfd5"

URI_aarch64_icewm = "${EPEL_MIRROR}/aarch64/Packages/i/icewm-3.9.0-2.el10_2.aarch64.rpm;name=aarch64_icewm;unpack=0"
SRC_URI:append = " ${URI_aarch64_icewm}"
SRC_URI[aarch64_icewm.sha256sum] = "05e201faf416cbb68eded0cf5d1afa0fe1db77873b5c05d61d8db35265074c80"

URI_aarch64_icewm-data = "${EPEL_MIRROR}/aarch64/Packages/i/icewm-data-3.9.0-2.el10_2.noarch.rpm;name=aarch64_icewm-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_icewm-data}"
SRC_URI[aarch64_icewm-data.sha256sum] = "6f6f8d6bd203a16869eb2367a7e523c7269d6425095154dfaa43f9ad9606d3cb"

URI_aarch64_icewm-minimal-session = "${EPEL_MIRROR}/aarch64/Packages/i/icewm-minimal-session-3.9.0-2.el10_2.noarch.rpm;name=aarch64_icewm-minimal-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_icewm-minimal-session}"
SRC_URI[aarch64_icewm-minimal-session.sha256sum] = "3fd232f0f51aa936d14d498023e8ac9120658ab0f6384af7532cd4a17346aca5"

URI_aarch64_icewm-themes = "${EPEL_MIRROR}/aarch64/Packages/i/icewm-themes-3.9.0-2.el10_2.noarch.rpm;name=aarch64_icewm-themes;unpack=0"
SRC_URI:append = " ${URI_aarch64_icewm-themes}"
SRC_URI[aarch64_icewm-themes.sha256sum] = "ad1fdc0962e5d01fd1fefbc54cb2e3c638b67cfed63985bc7b609b28d4d331c2"

RDEPENDS:icewm = " \
 alsa-lib \
 bash \
 fribidi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 icewm-data \
 imlib2 \
 libICE \
 libSM \
 libX11 \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXft \
 libXinerama \
 libXrandr \
 libXrender \
 libao \
 libgcc \
 librsvg2 \
 libsndfile \
 libstdc++ \
 perl-interpreter \
 xdg-utils \
 "
RDEPENDS:icewm-data = " \
 icewm \
 "
RDEPENDS:icewm-minimal-session = " \
 icewm \
 "
RDEPENDS:icewm-themes = " \
 icewm \
 "
