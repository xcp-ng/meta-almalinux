# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tracer"
PV = "1.6"
PR = "1.el10_3"
PACKAGES = " \
 python3-tracer \
 tracer-common \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tracer-1.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d2ac21f6ebf27256bda629252cab005295a80ac8e8f42d982ef1427ebd37fff7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tracer-1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tracer;unpack=0"
SRC_URI[x86_64_v2_python3-tracer.sha256sum] = "7cea1adb1f0a74e6138696d143043d6d96e06f8b0e82939232aba23e8eb89997"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tracer-common-1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tracer-common;unpack=0"
SRC_URI[x86_64_v2_tracer-common.sha256sum] = "02d64a9ce6cb8484d973a9f021bbb0b68c1ef925054441eb9dc56ab0d3c54a4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-tracer-1.6-1.el10_3.noarch.rpm;name=aarch64_python3-tracer;unpack=0"
SRC_URI[aarch64_python3-tracer.sha256sum] = "0b2139aae8f61048c74daa6b2de574c6bc20d5bcf77be61ddae75122d7c46f28"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tracer-common-1.6-1.el10_3.noarch.rpm;name=aarch64_tracer-common;unpack=0"
SRC_URI[aarch64_tracer-common.sha256sum] = "6752f00158a13f1846f8f457df447307b65a200a830cbaac3a976d55c4593cdf"

RDEPENDS:python3-tracer = " \
 python3 \
 python3-dbus \
 python3-distro \
 python3-psutil \
 python3-rpm \
 python3-six \
 tracer-common \
 "
RDEPENDS:tracer-common = " \
 "
