# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-semver"
PV = "1.0.27"
PR = "1.el10_0"
PACKAGES = " \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-semver+std-devel \
 rust-semver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-semver-1.0.27-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92efd25b94c56b0862ca126cf7ef798ae9d58de73ad60bb3ca4915bdb569de7c"

URI_x86_64_v2_rust-semver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+default-devel-1.0.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+default-devel}"
SRC_URI[x86_64_v2_rust-semver+default-devel.sha256sum] = "ac15c32fd3d354a68c14d1b0db63c3cdba675fdb8d2685f47685bbda4c9e2c7d"

URI_x86_64_v2_rust-semver+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+serde-devel-1.0.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+serde-devel}"
SRC_URI[x86_64_v2_rust-semver+serde-devel.sha256sum] = "bd079b1ca0aca49d9819c64f64bc74c3680efc2da5d7daf4c53af929fc6e2045"

URI_x86_64_v2_rust-semver+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+std-devel-1.0.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+std-devel}"
SRC_URI[x86_64_v2_rust-semver+std-devel.sha256sum] = "cb18c85aa851d89c94b6182136e5a28c0f3e749eae0fe1b0f7560c0006b7c7cf"

URI_x86_64_v2_rust-semver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver-devel-1.0.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver-devel}"
SRC_URI[x86_64_v2_rust-semver-devel.sha256sum] = "bb0210ce38fda1faa7c50a72111e6d5daa733905e8f68e01f0afa68b59d57ddf"

URI_aarch64_rust-semver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+default-devel-1.0.27-1.el10_0.noarch.rpm;name=aarch64_rust-semver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+default-devel}"
SRC_URI[aarch64_rust-semver+default-devel.sha256sum] = "1b343cb4d4e7a0cc08e85f8e1dab7867e3046a1bad2eb2fe1c2aaa0c28cbee7e"

URI_aarch64_rust-semver+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+serde-devel-1.0.27-1.el10_0.noarch.rpm;name=aarch64_rust-semver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+serde-devel}"
SRC_URI[aarch64_rust-semver+serde-devel.sha256sum] = "81e97cc1006714ba6e13fc4f6b96857d274dd6aa94498704121352d35e2c0bc8"

URI_aarch64_rust-semver+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+std-devel-1.0.27-1.el10_0.noarch.rpm;name=aarch64_rust-semver+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+std-devel}"
SRC_URI[aarch64_rust-semver+std-devel.sha256sum] = "4969118bb3ddd1942ef09002957cba1d35cccd438989fc11b101e64d7b434b31"

URI_aarch64_rust-semver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver-devel-1.0.27-1.el10_0.noarch.rpm;name=aarch64_rust-semver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver-devel}"
SRC_URI[aarch64_rust-semver-devel.sha256sum] = "f916a5f25c9d334bb79d146905bc8ce3e2ebd8f0bfc7fcc82db97d8fac362530"

RDEPENDS:rust-semver+default-devel = " \
 cargo \
 rust-semver+std-devel \
 rust-semver-devel \
 "
RDEPENDS:rust-semver+serde-devel = " \
 cargo \
 rust-semver-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-semver+std-devel = " \
 cargo \
 rust-semver-devel \
 "
RDEPENDS:rust-semver-devel = " \
 cargo \
 rust \
 "
