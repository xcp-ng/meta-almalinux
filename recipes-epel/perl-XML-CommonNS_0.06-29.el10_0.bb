# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-CommonNS"
PV = "0.06"
PR = "29.el10_0"
PACKAGES = " \
 perl-XML-CommonNS \
 perl-XML-CommonNS-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-CommonNS-0.06-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f609e998fc917fdd18721908f32b92088611163d18a36772bb92ab9ca329ab6"

URI_x86_64_v2_perl-XML-CommonNS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-CommonNS-0.06-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-CommonNS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-CommonNS}"
SRC_URI[x86_64_v2_perl-XML-CommonNS.sha256sum] = "34ff5d7f53c78b286562cf0a20341decbf2d5ea0f06a815562477627196576d8"

URI_x86_64_v2_perl-XML-CommonNS-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-CommonNS-tests-0.06-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-CommonNS-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-CommonNS-tests}"
SRC_URI[x86_64_v2_perl-XML-CommonNS-tests.sha256sum] = "a2b19de05e206585de6f0002a7c1e127242f110c1f46a247715eeee97eb0990a"

URI_aarch64_perl-XML-CommonNS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-CommonNS-0.06-29.el10_0.noarch.rpm;name=aarch64_perl-XML-CommonNS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-CommonNS}"
SRC_URI[aarch64_perl-XML-CommonNS.sha256sum] = "8150d850295280ab8feb5f7cf3f73b07f18742ca2df6616352acec717fd7955e"

URI_aarch64_perl-XML-CommonNS-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-CommonNS-tests-0.06-29.el10_0.noarch.rpm;name=aarch64_perl-XML-CommonNS-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-CommonNS-tests}"
SRC_URI[aarch64_perl-XML-CommonNS-tests.sha256sum] = "9c528b9aa100ce14250ced2c07068a8e0f0f56f041d9f5bd2a84714f66e34842"

RDEPENDS:perl-XML-CommonNS = " \
 perl-Exporter \
 perl-XML-NamespaceFactory \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-XML-CommonNS-tests = " \
 bash \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-XML-CommonNS \
 perl-libs \
 "
