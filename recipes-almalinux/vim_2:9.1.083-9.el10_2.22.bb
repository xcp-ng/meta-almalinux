# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim"
PE = "2"
PV = "9.1.083"
PR = "9.el10_2.22"
PACKAGES = " \
 vim-X11 \
 vim-common \
 vim-data \
 vim-enhanced \
 vim-filesystem \
 vim-minimal \
 xxd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/vim-9.1.083-9.el10_2.22.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f0513648062a24e5f242b683675fd0b9ff0fa595ec11322458fad95ac17c1161"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-X11-9.1.083-9.el10_2.22.x86_64_v2.rpm;name=x86_64_v2_vim-X11;unpack=0"
SRC_URI[x86_64_v2_vim-X11.sha256sum] = "73bb4731191bbbfa442952e179ad43bf1a70eacd560f766b91bbd14173c2b0ac"
RPROVIDES:vim-X11:append:x86_64_v2 = " virtual/vim-enhanced_or_vim-X11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-common-9.1.083-9.el10_2.22.x86_64_v2.rpm;name=x86_64_v2_vim-common;unpack=0"
SRC_URI[x86_64_v2_vim-common.sha256sum] = "71c2b1e9ff6c1f260a707285a1267e66acad9ee9e5058af9ceb77ab1b19cb632"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-data-9.1.083-9.el10_2.22.noarch.rpm;name=x86_64_v2_vim-data;unpack=0"
SRC_URI[x86_64_v2_vim-data.sha256sum] = "20cc01ac4de62fb5162d82ed7f44e55460ce124b5fe9e70a8956f72cfc755924"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-enhanced-9.1.083-9.el10_2.22.x86_64_v2.rpm;name=x86_64_v2_vim-enhanced;unpack=0"
SRC_URI[x86_64_v2_vim-enhanced.sha256sum] = "e2b029358ac58f9c4b59cc0a7ee40167a2f02d8b16ad539e126ad0620897f0e3"
RPROVIDES:vim-enhanced:append:x86_64_v2 = " virtual/vim-enhanced_or_vim-X11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-filesystem-9.1.083-9.el10_2.22.noarch.rpm;name=x86_64_v2_vim-filesystem;unpack=0"
SRC_URI[x86_64_v2_vim-filesystem.sha256sum] = "598749c59ba34ca680a45e942d0fe9265c20679a9473cbaf9a40be99b03423b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-minimal-9.1.083-9.el10_2.22.x86_64_v2.rpm;name=x86_64_v2_vim-minimal;unpack=0"
SRC_URI[x86_64_v2_vim-minimal.sha256sum] = "44f3cb6002d7ea3e0f82a7e431ccaf92006fcf644082f038189de7e26829b087"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xxd-9.1.083-9.el10_2.22.x86_64_v2.rpm;name=x86_64_v2_xxd;unpack=0"
SRC_URI[x86_64_v2_xxd.sha256sum] = "636a314109864b7e8feb3fda967333d13b931383bf30549ccd6b769d8f6e3c94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-X11-9.1.083-9.el10_2.22.aarch64.rpm;name=aarch64_vim-X11;unpack=0"
SRC_URI[aarch64_vim-X11.sha256sum] = "f53ff8e16f5bd6c9cd5d549678da98bf2f96d93d986a4cb46ae7e6831f52a486"
RPROVIDES:vim-X11:append:aarch64 = " virtual/vim-enhanced_or_vim-X11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-common-9.1.083-9.el10_2.22.aarch64.rpm;name=aarch64_vim-common;unpack=0"
SRC_URI[aarch64_vim-common.sha256sum] = "0d4f3e2c7088124181c74cd774f5048b64f2664ebd75e32d77b5d51f72d45258"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-data-9.1.083-9.el10_2.22.noarch.rpm;name=aarch64_vim-data;unpack=0"
SRC_URI[aarch64_vim-data.sha256sum] = "20cc01ac4de62fb5162d82ed7f44e55460ce124b5fe9e70a8956f72cfc755924"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-enhanced-9.1.083-9.el10_2.22.aarch64.rpm;name=aarch64_vim-enhanced;unpack=0"
SRC_URI[aarch64_vim-enhanced.sha256sum] = "88dbb9e8b49eccdcecc8c2a616e104241647ebeb8862247a11967283050590be"
RPROVIDES:vim-enhanced:append:aarch64 = " virtual/vim-enhanced_or_vim-X11"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-filesystem-9.1.083-9.el10_2.22.noarch.rpm;name=aarch64_vim-filesystem;unpack=0"
SRC_URI[aarch64_vim-filesystem.sha256sum] = "598749c59ba34ca680a45e942d0fe9265c20679a9473cbaf9a40be99b03423b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-minimal-9.1.083-9.el10_2.22.aarch64.rpm;name=aarch64_vim-minimal;unpack=0"
SRC_URI[aarch64_vim-minimal.sha256sum] = "ed6859a20124376fc32fcf125da07b615f08e8e463e25b9ec5d9049d974fe6c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xxd-9.1.083-9.el10_2.22.aarch64.rpm;name=aarch64_xxd;unpack=0"
SRC_URI[aarch64_xxd.sha256sum] = "4c31a6463f6131673105af1983481a449e4ffe97612c797648cf2087a2270a91"

RDEPENDS:vim-X11 = " \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libICE \
 libSM \
 libX11 \
 libXt \
 libacl \
 libattr \
 libcanberra \
 libselinux \
 ncurses-libs \
 pango \
 vim-common \
 "
RDEPENDS:vim-common = " \
 bash \
 vim-data \
 vim-filesystem \
 xxd \
 "
RDEPENDS:vim-data = " \
 "
RDEPENDS:vim-enhanced = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-common \
 which \
 "
RDEPENDS:vim-filesystem = " \
 "
RDEPENDS:vim-minimal = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-data \
 "
RDEPENDS:xxd = " \
 glibc \
 "
