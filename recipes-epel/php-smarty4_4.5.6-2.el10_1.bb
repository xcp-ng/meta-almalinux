# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-smarty4"
PV = "4.5.6"
PR = "2.el10_1"
PACKAGES = " \
 php-smarty4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-smarty4-4.5.6-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80d9e43fc920d8e7d68fef9b7c276a8d4fc9175c9f99a5d40e13d5cc4e03bbca"

URI_x86_64_v2_php-smarty4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-smarty4-4.5.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_php-smarty4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-smarty4}"
SRC_URI[x86_64_v2_php-smarty4.sha256sum] = "eba66e651bbd4e3f2743ed08c29be96bdf497d5bb7077fd4c725ae9b0cfe8aba"

URI_aarch64_php-smarty4 = "${EPEL_MIRROR}/aarch64/Packages/p/php-smarty4-4.5.6-2.el10_1.noarch.rpm;name=aarch64_php-smarty4;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-smarty4}"
SRC_URI[aarch64_php-smarty4.sha256sum] = "857bdd30aef51cd28c3bb5104df0ba0ff435bcaa2320cc81991251a20710843b"

RDEPENDS:php-smarty4 = " \
 php-common \
 php-mbstring \
 php-opcache \
 php-pdo \
 "
