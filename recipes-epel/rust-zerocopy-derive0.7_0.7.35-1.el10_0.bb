# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy-derive0.7"
PV = "0.7.35"
PR = "1.el10_0"
PACKAGES = " \
 rust-zerocopy-derive0.7+default-devel \
 rust-zerocopy-derive0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-derive0.7-0.7.35-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d8996756aa5076b6ed55d81f129855d071a7c55e75ae5ae7428632d62b61fef"

URI_x86_64_v2_rust-zerocopy-derive0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive0.7+default-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-derive0.7+default-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-derive0.7+default-devel.sha256sum] = "e45c81a97b3902911826025657cf70674cf13f2194bc6f8db69c8b4d6e2d1559"

URI_x86_64_v2_rust-zerocopy-derive0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive0.7-devel-0.7.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-derive0.7-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-derive0.7-devel.sha256sum] = "2d00f92382d86daf6cfcd786b3609bf311521489a18fe5cbb5fd791ce2cbe3ab"

URI_aarch64_rust-zerocopy-derive0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive0.7+default-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy-derive0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-derive0.7+default-devel}"
SRC_URI[aarch64_rust-zerocopy-derive0.7+default-devel.sha256sum] = "cdce35cff002c0809764ec958f41203af66e1bc868d2a9c01e5cfeaabf48a8d8"

URI_aarch64_rust-zerocopy-derive0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive0.7-devel-0.7.35-1.el10_0.noarch.rpm;name=aarch64_rust-zerocopy-derive0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-derive0.7-devel}"
SRC_URI[aarch64_rust-zerocopy-derive0.7-devel.sha256sum] = "e9b35fd91067410048eed88257bc60e8aa5bdd588efbc1aa8029074a81aed6e5"

RDEPENDS:rust-zerocopy-derive0.7+default-devel = " \
 cargo \
 rust-zerocopy-derive0.7-devel \
 "
RDEPENDS:rust-zerocopy-derive0.7-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
