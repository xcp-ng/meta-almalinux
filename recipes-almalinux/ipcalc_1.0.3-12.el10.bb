# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipcalc"
PV = "1.0.3"
PR = "12.el10"
PACKAGES = " \
 ipcalc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ipcalc-1.0.3-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5e58fe31753bf0ebf65641067f276cd95d31e338dc9ba3b6cf4f58872b42a523"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipcalc-1.0.3-12.el10.x86_64_v2.rpm;name=x86_64_v2_ipcalc;unpack=0"
SRC_URI[x86_64_v2_ipcalc.sha256sum] = "0e44ee94cb902670970d287e23ebbe621a17987d58085f1a8f4ef405877397d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipcalc-1.0.3-12.el10.aarch64.rpm;name=aarch64_ipcalc;unpack=0"
SRC_URI[aarch64_ipcalc.sha256sum] = "759d0c0c6a95fa0b3f6bde44717c4ee00baca52c7aa0bdb5968573614c11a38d"

RDEPENDS:ipcalc = " \
 glibc \
 "
