# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-core2"
PV = "0.4.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-core2+alloc-devel \
 rust-core2+default-devel \
 rust-core2+std-devel \
 rust-core2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-core2-0.4.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47df8bc44aa85858539b4766aaa94b1fbcc38f3f1e61039f7c65f233c30ff321"

URI_x86_64_v2_rust-core2+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-core2+alloc-devel-0.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-core2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-core2+alloc-devel}"
SRC_URI[x86_64_v2_rust-core2+alloc-devel.sha256sum] = "7e82fabf11d442f96f3ff03389bf03477d2e51831be10d7bd69068048f5c5978"

URI_x86_64_v2_rust-core2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-core2+default-devel-0.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-core2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-core2+default-devel}"
SRC_URI[x86_64_v2_rust-core2+default-devel.sha256sum] = "aa2e8d622ed329402cddf7c592b530107b1e0e0ab7f325a38cdf2f211a3fb082"

URI_x86_64_v2_rust-core2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-core2+std-devel-0.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-core2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-core2+std-devel}"
SRC_URI[x86_64_v2_rust-core2+std-devel.sha256sum] = "cb9fce77162cdeabfe7854d7826d88dea37ab5c2c721a74daee3baa1ce1a2e4f"

URI_x86_64_v2_rust-core2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-core2-devel-0.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-core2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-core2-devel}"
SRC_URI[x86_64_v2_rust-core2-devel.sha256sum] = "97b792a56cd70bd137d9437bae3cc7f4fa7254fdfac70205c857a2c460c1f97a"

URI_aarch64_rust-core2+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-core2+alloc-devel-0.4.0-2.el10_0.noarch.rpm;name=aarch64_rust-core2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-core2+alloc-devel}"
SRC_URI[aarch64_rust-core2+alloc-devel.sha256sum] = "18b08337b52389c82909d852c3eeffc2eea678722748c23009359fdcd0fa52a5"

URI_aarch64_rust-core2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-core2+default-devel-0.4.0-2.el10_0.noarch.rpm;name=aarch64_rust-core2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-core2+default-devel}"
SRC_URI[aarch64_rust-core2+default-devel.sha256sum] = "a93ae7f78e33d8d1e2f4224353223c6329eb63ff6fae858e3319bc581e592e9a"

URI_aarch64_rust-core2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-core2+std-devel-0.4.0-2.el10_0.noarch.rpm;name=aarch64_rust-core2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-core2+std-devel}"
SRC_URI[aarch64_rust-core2+std-devel.sha256sum] = "05f1a548b55f89562cb34125afe58b16fa0710dcadfdf83fb6edb33fb3ae2a86"

URI_aarch64_rust-core2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-core2-devel-0.4.0-2.el10_0.noarch.rpm;name=aarch64_rust-core2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-core2-devel}"
SRC_URI[aarch64_rust-core2-devel.sha256sum] = "f72a0fdee212a595109ce1585b779f1b37d107f0eb8f25e7506b748eb48857cb"

RDEPENDS:rust-core2+alloc-devel = " \
 cargo \
 rust-core2-devel \
 "
RDEPENDS:rust-core2+default-devel = " \
 cargo \
 rust-core2+std-devel \
 rust-core2-devel \
 "
RDEPENDS:rust-core2+std-devel = " \
 cargo \
 rust-core2+alloc-devel \
 rust-core2-devel \
 "
RDEPENDS:rust-core2-devel = " \
 cargo \
 rust-memchr-devel \
 "
