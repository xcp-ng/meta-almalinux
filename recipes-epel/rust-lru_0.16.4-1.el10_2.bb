# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lru"
PV = "0.16.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-lru+default-devel \
 rust-lru+hashbrown-devel \
 rust-lru-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lru-0.16.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4ae7368110bb49aa7c5c56fdd825ca5b4f4d02bab03686252e19377dc927df4"

URI_x86_64_v2_rust-lru+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru+default-devel-0.16.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru+default-devel}"
SRC_URI[x86_64_v2_rust-lru+default-devel.sha256sum] = "851fa441e264f21d83a3694597653c17c70c6deecc61da37c4335d1ac46a5464"

URI_x86_64_v2_rust-lru+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru+hashbrown-devel-0.16.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-lru+hashbrown-devel.sha256sum] = "6801c928418aabc01191460a4e46f2d533747688bf2174f6a4a08d4851bc81ff"

URI_x86_64_v2_rust-lru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru-devel-0.16.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru-devel}"
SRC_URI[x86_64_v2_rust-lru-devel.sha256sum] = "170ad81f4f74878984f43028d7fa6dded27fc53f4215460195f945545b52f5d8"

URI_aarch64_rust-lru+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru+default-devel-0.16.4-1.el10_2.noarch.rpm;name=aarch64_rust-lru+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru+default-devel}"
SRC_URI[aarch64_rust-lru+default-devel.sha256sum] = "e622dfdb0796c23e9836aa2adfe0f6bc5bf1e59f1a9d9d38d3714f2b40760547"

URI_aarch64_rust-lru+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru+hashbrown-devel-0.16.4-1.el10_2.noarch.rpm;name=aarch64_rust-lru+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru+hashbrown-devel}"
SRC_URI[aarch64_rust-lru+hashbrown-devel.sha256sum] = "1a492f0d65e20601ae5519e908f2f5bcd8303b38eca09ee4050961e71d9ae8c4"

URI_aarch64_rust-lru-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru-devel-0.16.4-1.el10_2.noarch.rpm;name=aarch64_rust-lru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru-devel}"
SRC_URI[aarch64_rust-lru-devel.sha256sum] = "a29e738808776d4221beb36880baa98bf946963830c42346035719bb1ea43e9d"

RDEPENDS:rust-lru+default-devel = " \
 cargo \
 rust-lru+hashbrown-devel \
 rust-lru-devel \
 "
RDEPENDS:rust-lru+hashbrown-devel = " \
 cargo \
 rust-hashbrown+default-devel \
 rust-lru-devel \
 "
RDEPENDS:rust-lru-devel = " \
 cargo \
 rust \
 "
