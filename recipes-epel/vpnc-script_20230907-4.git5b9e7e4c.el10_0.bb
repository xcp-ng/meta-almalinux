# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vpnc-script"
PV = "20230907"
PR = "4.git5b9e7e4c.el10_0"
PACKAGES = " \
 vpnc-script \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vpnc-script-20230907-4.git5b9e7e4c.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4e53c9a36062bf5cb0300c900b6fda30fc12995b9ba5d63813838b487df7d8aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vpnc-script-20230907-4.git5b9e7e4c.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_vpnc-script;unpack=0"
SRC_URI[x86_64_v2_vpnc-script.sha256sum] = "123dafc3a5e3b88872e91835024df1f17da659b89c891071a24e0486058fd798"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vpnc-script-20230907-4.git5b9e7e4c.el10_0.noarch.rpm;name=aarch64_vpnc-script;unpack=0"
SRC_URI[aarch64_vpnc-script.sha256sum] = "ba3b4e4b145747dea1b7fe696e454ac77637d2be31a54300d3398215d1346fa5"

RDEPENDS:vpnc-script = " \
 bash \
 iproute \
 which \
 "
