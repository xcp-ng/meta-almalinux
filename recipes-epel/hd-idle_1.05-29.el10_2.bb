# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hd-idle"
PV = "1.05"
PR = "29.el10_2"
PACKAGES = " \
 hd-idle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hd-idle-1.05-29.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ad8ab970625e1998f49033cb8b02bf0e158d551eecdef987d69ed09f87b9d1f"

URI_x86_64_v2_hd-idle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hd-idle-1.05-29.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hd-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hd-idle}"
SRC_URI[x86_64_v2_hd-idle.sha256sum] = "e20a9e938c96964b26745479bffbb585ad91b3f941940ddc61331d8ad21d39ba"

URI_aarch64_hd-idle = "${EPEL_MIRROR}/aarch64/Packages/h/hd-idle-1.05-29.el10_2.aarch64.rpm;name=aarch64_hd-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_hd-idle}"
SRC_URI[aarch64_hd-idle.sha256sum] = "6044647274271c4299e1d8d9663df0d96319684343b32ed88bfbe86d2389f2ba"

RDEPENDS:hd-idle = " \
 bash \
 glibc \
 "
