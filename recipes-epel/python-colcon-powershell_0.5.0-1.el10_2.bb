# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-powershell"
PV = "0.5.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-powershell \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-powershell-0.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3996f5e0a341141b41195aa68a338f8d4c10633237291a1c604b094dfc236af2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-powershell-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-powershell;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-powershell.sha256sum] = "1590acbc7fc3652405c6655fc61184fbd7e98fc49b8c24f7ade287a8ec2c5b50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-powershell-0.5.0-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-powershell;unpack=0"
SRC_URI[aarch64_python3-colcon-powershell.sha256sum] = "8f331c8cd917ce2e047b08a229fc732884a9aca2d0bcf940485bae15c6f1dfbe"

RDEPENDS:python3-colcon-powershell = " \
 python3 \
 python3-colcon-core \
 "
