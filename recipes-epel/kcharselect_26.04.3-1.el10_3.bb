# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcharselect"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kcharselect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcharselect-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abc332f9e4ac5d5ed53544530f05c3908dfcedc54a0d2190a0edbbe797349fdb"

URI_x86_64_v2_kcharselect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcharselect-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcharselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcharselect}"
SRC_URI[x86_64_v2_kcharselect.sha256sum] = "13be73b6f9c25a65cebfe9cd42216c0030198895737d7c3f6d20d1beb55107c1"

URI_aarch64_kcharselect = "${EPEL_MIRROR}/aarch64/Packages/k/kcharselect-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kcharselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcharselect}"
SRC_URI[aarch64_kcharselect.sha256sum] = "e71fd7f777587914db9f613ef28c69755478ad4cad454df72e71628a91feb5f6"

RDEPENDS:kcharselect = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
