# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro2"
PV = "1.0.106"
PR = "1.el10_2"
PACKAGES = " \
 rust-proc-macro2+default-devel \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro2-1.0.106-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7389bd780d5f2e55a7198f719b3394a6c9d1e7e00746585d99f0e23c52bec031"

URI_x86_64_v2_rust-proc-macro2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+default-devel-1.0.106-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+default-devel.sha256sum] = "bab937c8dfc96c1d2d2f2a39b06d1541fd91f2b62836f3651797f7eab2727171"

URI_x86_64_v2_rust-proc-macro2+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+proc-macro-devel-1.0.106-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+proc-macro-devel.sha256sum] = "7d07686d9ea94b37de9bd23981aa5500719f9eaa0ab038fe81279bd0d95a7adb"

URI_x86_64_v2_rust-proc-macro2+span-locations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+span-locations-devel-1.0.106-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2+span-locations-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2+span-locations-devel.sha256sum] = "f01baae3ee8b3d11bc1896ba97a50b84d6c83b67abd9ff00a2ff676d51ebe5ad"

URI_x86_64_v2_rust-proc-macro2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2-devel-1.0.106-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro2-devel}"
SRC_URI[x86_64_v2_rust-proc-macro2-devel.sha256sum] = "b4c72de66fe99a683f6677da8ffa6c2dc4f11cc735ba603be9de6c9eec445a24"

URI_aarch64_rust-proc-macro2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+default-devel-1.0.106-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+default-devel}"
SRC_URI[aarch64_rust-proc-macro2+default-devel.sha256sum] = "ea48cf30cb5da7f063ee687d8a20ff200970e3af87a236b216b0a242cf760717"

URI_aarch64_rust-proc-macro2+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+proc-macro-devel-1.0.106-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+proc-macro-devel}"
SRC_URI[aarch64_rust-proc-macro2+proc-macro-devel.sha256sum] = "819aa122acf4f8ec2b41ea4095ec184401f279fee96b64860ebb39dd9e88a9eb"

URI_aarch64_rust-proc-macro2+span-locations-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+span-locations-devel-1.0.106-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2+span-locations-devel}"
SRC_URI[aarch64_rust-proc-macro2+span-locations-devel.sha256sum] = "11b4a80d5fdb2752417f96568657dd59463ce4fc416bb636abafb581b3547e6b"

URI_aarch64_rust-proc-macro2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2-devel-1.0.106-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro2-devel}"
SRC_URI[aarch64_rust-proc-macro2-devel.sha256sum] = "30cd8834cbc0423b3bdc8f860982fe29d8cec97020007cdf3628a08edc5a0191"

RDEPENDS:rust-proc-macro2+default-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+proc-macro-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+span-locations-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2-devel = " \
 cargo \
 rust \
 rust-unicode-ident+default-devel \
 "
