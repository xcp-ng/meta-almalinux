# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-modemmanager-qt"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-modemmanager-qt \
 kf6-modemmanager-qt-devel \
 kf6-modemmanager-qt-doc \
 kf6-modemmanager-qt-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-modemmanager-qt-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2140f9c168759f4afee557f8627a73ebced42d27a56375b02b56d574d65e704a"

URI_x86_64_v2_kf6-modemmanager-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-modemmanager-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt.sha256sum] = "e14c8a22a5cc7e2b3cf919bab9690928452dee8cad42925ef6ef1ab6e52879ed"

URI_x86_64_v2_kf6-modemmanager-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-modemmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-devel}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-devel.sha256sum] = "05b71d3e10b14307d08192827ec6e4daa9cb60a5279dae9719af73f2d88ff08f"

URI_x86_64_v2_kf6-modemmanager-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-modemmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-doc}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-doc.sha256sum] = "014fce6b002e19dbf0fecd9d5149787776abb5cb115403d61bcde3281dd490be"

URI_x86_64_v2_kf6-modemmanager-qt-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-modemmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-html}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-html.sha256sum] = "f4d38bafb5de22a8fd5929bf0b66ea1eae59e1a6940a5293a1d3d3398775d972"

URI_aarch64_kf6-modemmanager-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-modemmanager-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt}"
SRC_URI[aarch64_kf6-modemmanager-qt.sha256sum] = "2edabd63f62595571f9f9ea260ac49091570ed5b7f6463611e890e4f1cfe7174"

URI_aarch64_kf6-modemmanager-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-modemmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-devel}"
SRC_URI[aarch64_kf6-modemmanager-qt-devel.sha256sum] = "46afb8b31f24ef306e48b75ea68bed1017094fa9bdea24a29026bb030fde9802"

URI_aarch64_kf6-modemmanager-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-modemmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-doc}"
SRC_URI[aarch64_kf6-modemmanager-qt-doc.sha256sum] = "0c6dc990a130a1ae7c936ecd6d2ab27896f967ce1808de479aa97e55f5019450"

URI_aarch64_kf6-modemmanager-qt-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-modemmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-html}"
SRC_URI[aarch64_kf6-modemmanager-qt-html.sha256sum] = "758eb0d81539222ad25883433018909ae40d7e3e91edb44d0548e15f41889c38"

RDEPENDS:kf6-modemmanager-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-modemmanager-qt-devel = " \
 ModemManager-devel \
 cmake-filesystem \
 kf6-modemmanager-qt \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-modemmanager-qt-doc = " \
 "
RDEPENDS:kf6-modemmanager-qt-html = " \
 "
