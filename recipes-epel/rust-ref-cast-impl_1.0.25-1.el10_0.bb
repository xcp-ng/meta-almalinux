# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ref-cast-impl"
PV = "1.0.25"
PR = "1.el10_0"
PACKAGES = " \
 rust-ref-cast-impl+default-devel \
 rust-ref-cast-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ref-cast-impl-1.0.25-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a3cfcff30f7c6c513fa33fadc28ba5a6a3a76c3e8d1b36e4601af5930eb2f50"

URI_x86_64_v2_rust-ref-cast-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-impl+default-devel-1.0.25-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast-impl+default-devel}"
SRC_URI[x86_64_v2_rust-ref-cast-impl+default-devel.sha256sum] = "0e15381d4e145913647f8413a43d07458377a3e300f83f009f043772c98015fa"

URI_x86_64_v2_rust-ref-cast-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-impl-devel-1.0.25-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast-impl-devel}"
SRC_URI[x86_64_v2_rust-ref-cast-impl-devel.sha256sum] = "c37190e015630272bee71fff74a8eccd625e54519b58743e98459431d43a2c88"

URI_aarch64_rust-ref-cast-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-impl+default-devel-1.0.25-1.el10_0.noarch.rpm;name=aarch64_rust-ref-cast-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast-impl+default-devel}"
SRC_URI[aarch64_rust-ref-cast-impl+default-devel.sha256sum] = "08b33e3879bd9a7e6010f65773c9a7823b0c216cb72fada3690d6a2f12328f3e"

URI_aarch64_rust-ref-cast-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-impl-devel-1.0.25-1.el10_0.noarch.rpm;name=aarch64_rust-ref-cast-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast-impl-devel}"
SRC_URI[aarch64_rust-ref-cast-impl-devel.sha256sum] = "d9174c5119d600e97811a13081c297ba88ba029a9040ed39fe7c1545ef445c60"

RDEPENDS:rust-ref-cast-impl+default-devel = " \
 cargo \
 rust-ref-cast-impl-devel \
 "
RDEPENDS:rust-ref-cast-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
