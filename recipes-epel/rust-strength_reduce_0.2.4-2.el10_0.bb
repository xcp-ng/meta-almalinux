# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strength_reduce"
PV = "0.2.4"
PR = "2.el10_0"
PACKAGES = " \
 rust-strength_reduce+default-devel \
 rust-strength_reduce-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-strength_reduce-0.2.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "72610214cf43e60f1b583004fb9e55bc2f2d74b11c0484f21e7c7db36ce7bc70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strength_reduce+default-devel-0.2.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strength_reduce+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-strength_reduce+default-devel.sha256sum] = "b441885eae72e9e31f136f05e6789efe984f94e1bf67ba1f884ee20501358614"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strength_reduce-devel-0.2.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strength_reduce-devel;unpack=0"
SRC_URI[x86_64_v2_rust-strength_reduce-devel.sha256sum] = "bfc2c73320d9d750d68485e546c2226be2bdcfb2a8079b6434ed8568dba94e72"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-strength_reduce+default-devel-0.2.4-2.el10_0.noarch.rpm;name=aarch64_rust-strength_reduce+default-devel;unpack=0"
SRC_URI[aarch64_rust-strength_reduce+default-devel.sha256sum] = "43443837d63e2d44c538a1d9ef53671ab15d465f8dfa36991c60fc1ca20fe9a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-strength_reduce-devel-0.2.4-2.el10_0.noarch.rpm;name=aarch64_rust-strength_reduce-devel;unpack=0"
SRC_URI[aarch64_rust-strength_reduce-devel.sha256sum] = "4519cd5bd1e5b272fa776bdb85d8a6c9388d9f9da85e674fe84fece897ef8543"

RDEPENDS:rust-strength_reduce+default-devel = " \
 cargo \
 rust-strength_reduce-devel \
 "
RDEPENDS:rust-strength_reduce-devel = " \
 cargo \
 "
