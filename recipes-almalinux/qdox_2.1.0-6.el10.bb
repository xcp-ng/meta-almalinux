# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qdox"
PV = "2.1.0"
PR = "6.el10"
PACKAGES = " \
 qdox \
 qdox-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/qdox-2.1.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f30092bbe08f6d8c5209ed04313cad28ecc3315bb9cd18f34c1fad7572763a52"

URI_x86_64_v2_qdox = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qdox-2.1.0-6.el10.noarch.rpm;name=x86_64_v2_qdox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qdox}"
SRC_URI[x86_64_v2_qdox.sha256sum] = "559d192f763e2fd72209aac3bffcebc2f106d1a157043f2d1eb70258fc5d29f8"

URI_x86_64_v2_qdox-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qdox-javadoc-2.1.0-6.el10.noarch.rpm;name=x86_64_v2_qdox-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qdox-javadoc}"
SRC_URI[x86_64_v2_qdox-javadoc.sha256sum] = "cf4d5e01885c6fed8c04ecb4b6f59eb37de5644b38db2eaca610321f297051d1"

URI_aarch64_qdox = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qdox-2.1.0-6.el10.noarch.rpm;name=aarch64_qdox;unpack=0"
SRC_URI:append = " ${URI_aarch64_qdox}"
SRC_URI[aarch64_qdox.sha256sum] = "559d192f763e2fd72209aac3bffcebc2f106d1a157043f2d1eb70258fc5d29f8"

URI_aarch64_qdox-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qdox-javadoc-2.1.0-6.el10.noarch.rpm;name=aarch64_qdox-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qdox-javadoc}"
SRC_URI[aarch64_qdox-javadoc.sha256sum] = "cf4d5e01885c6fed8c04ecb4b6f59eb37de5644b38db2eaca610321f297051d1"

RDEPENDS:qdox = " \
 javapackages-filesystem \
 "
RDEPENDS:qdox-javadoc = " \
 javapackages-filesystem \
 "
