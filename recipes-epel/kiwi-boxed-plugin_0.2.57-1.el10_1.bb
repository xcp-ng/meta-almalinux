# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi-boxed-plugin"
PV = "0.2.57"
PR = "1.el10_1"
PACKAGES = " \
 kiwi-boxed-plugin \
 python3-kiwi-boxed-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiwi-boxed-plugin-0.2.57-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cf91a2f441c5b920090c3903c9d6560188ee6558fcac4f6f67209ad5916064c"

URI_x86_64_v2_kiwi-boxed-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-boxed-plugin-0.2.57-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-boxed-plugin}"
SRC_URI[x86_64_v2_kiwi-boxed-plugin.sha256sum] = "c67575f8963ee494e5e58dd284128c8426916cf7da75ac7bd38d0360660e3737"

URI_x86_64_v2_python3-kiwi-boxed-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-boxed-plugin-0.2.57-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kiwi-boxed-plugin}"
SRC_URI[x86_64_v2_python3-kiwi-boxed-plugin.sha256sum] = "be7be7c9a134ea6ea0ccf95eb92e2c50e30196b9faab52c198cc13093a5ac523"

URI_aarch64_kiwi-boxed-plugin = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-boxed-plugin-0.2.57-1.el10_1.noarch.rpm;name=aarch64_kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-boxed-plugin}"
SRC_URI[aarch64_kiwi-boxed-plugin.sha256sum] = "f1169017c01cb6621e719885f03bfd70314375135f22bba345348c674b6ca940"

URI_aarch64_python3-kiwi-boxed-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-boxed-plugin-0.2.57-1.el10_1.noarch.rpm;name=aarch64_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kiwi-boxed-plugin}"
SRC_URI[aarch64_python3-kiwi-boxed-plugin.sha256sum] = "dd026bec807f534dde0e083f7429be0df10f626c28e2f5af6d06e97ff5246ced"

RDEPENDS:kiwi-boxed-plugin = " \
 python3-kiwi-boxed-plugin \
 "
RDEPENDS:python3-kiwi-boxed-plugin = " \
 python3 \
 python3-cerberus \
 python3-docopt-ng \
 python3-kiwi \
 python3-progressbar2 \
 python3-pyyaml \
 python3-requests \
 qemu-kvm \
 "
