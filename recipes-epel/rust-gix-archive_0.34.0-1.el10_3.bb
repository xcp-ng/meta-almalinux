# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-archive"
PV = "0.34.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-archive+default-devel \
 rust-gix-archive+document-features-devel \
 rust-gix-archive+sha1-devel \
 rust-gix-archive+sha256-devel \
 rust-gix-archive+tar-devel \
 rust-gix-archive+tar_gz-devel \
 rust-gix-archive+zip-devel \
 rust-gix-archive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-archive-0.34.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89aea8b2a3e6cf477ab936552d3a49e446c7c50d528ad672b0d27505c6f95bf3"

URI_x86_64_v2_rust-gix-archive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+default-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+default-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+default-devel.sha256sum] = "21249574cdf3b49fcc3f273ed9fe5ca854301f8140d0fac92a4831683c6cea3a"

URI_x86_64_v2_rust-gix-archive+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+document-features-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+document-features-devel.sha256sum] = "51d8e3d892b11d77f50b2524cd333cc4366facdb0f01f5463d3134040353813e"

URI_x86_64_v2_rust-gix-archive+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+sha1-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+sha1-devel.sha256sum] = "85db261ed6db2e78f5a8aa1ffcc30ee136389ad0c7b838a54ff91164b8704ab9"

URI_x86_64_v2_rust-gix-archive+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+sha256-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+sha256-devel.sha256sum] = "1ea27eed3beb977b28e5088d44123cead3ff204186f096c99eff0106bd139458"

URI_x86_64_v2_rust-gix-archive+tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+tar-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+tar-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+tar-devel.sha256sum] = "260b162c1c15d2cb5e16fea874d7788bd860f145b6673484b0238c3732fd70f5"

URI_x86_64_v2_rust-gix-archive+tar_gz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+tar_gz-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+tar_gz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+tar_gz-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+tar_gz-devel.sha256sum] = "2a601e8d7c3304681e38cd6d73e6cc74b8c843d77db655b1f476ebe42cd872ea"

URI_x86_64_v2_rust-gix-archive+zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+zip-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+zip-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+zip-devel.sha256sum] = "5b1dffff3a6ddcc00017db48566d1ce5ed4b5142bc60de2e4e0b38a49000736f"

URI_x86_64_v2_rust-gix-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive-devel-0.34.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive-devel}"
SRC_URI[x86_64_v2_rust-gix-archive-devel.sha256sum] = "e83b72d8bbaa8bf10f63f08695f27ca01c7af24685b787cde8179657dab7e68e"

URI_aarch64_rust-gix-archive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+default-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-archive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+default-devel}"
SRC_URI[aarch64_rust-gix-archive+default-devel.sha256sum] = "db823b454e56461c8618ad6dc41282d5907905b8cd337f01d9ed50697a92e3b6"

URI_aarch64_rust-gix-archive+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+document-features-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-archive+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+document-features-devel}"
SRC_URI[aarch64_rust-gix-archive+document-features-devel.sha256sum] = "5861cf010a2831b437747c26802ea660b7d1862be0c40ea394df6f6a8a3f835e"

URI_aarch64_rust-gix-archive+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+sha1-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-archive+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+sha1-devel}"
SRC_URI[aarch64_rust-gix-archive+sha1-devel.sha256sum] = "8db8ade8ab79e09f4de5ae3262f15f715c9c0e33823212e7f01671b2ebb6923b"

URI_aarch64_rust-gix-archive+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+sha256-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-archive+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+sha256-devel}"
SRC_URI[aarch64_rust-gix-archive+sha256-devel.sha256sum] = "87e73fc00d0acf0b7ea62344234a2cf71a0bae01a6ba7867bf7fe49d23a44b46"

URI_aarch64_rust-gix-archive+tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+tar-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-archive+tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+tar-devel}"
SRC_URI[aarch64_rust-gix-archive+tar-devel.sha256sum] = "7046e93e07af79e0aeab801e7f303c4ba386e64de1348d77f618ee33506c4974"

URI_aarch64_rust-gix-archive+tar_gz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+tar_gz-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-archive+tar_gz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+tar_gz-devel}"
SRC_URI[aarch64_rust-gix-archive+tar_gz-devel.sha256sum] = "04c5ff6fa767ec549722721db6a05aaf6dc69747107ce6f366b84c8f1dd1c944"

URI_aarch64_rust-gix-archive+zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+zip-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-archive+zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+zip-devel}"
SRC_URI[aarch64_rust-gix-archive+zip-devel.sha256sum] = "c770165c079c8a2eaa0ed9be4f9d07c6305cb2352163a73088f3caa87e5c99ea"

URI_aarch64_rust-gix-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive-devel-0.34.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive-devel}"
SRC_URI[aarch64_rust-gix-archive-devel.sha256sum] = "1b897f5798f4ec4b8c1650a7fd98935ba77ed46a8feb146a5defa5285effd480"

RDEPENDS:rust-gix-archive+default-devel = " \
 cargo \
 rust-gix-archive+tar-devel \
 rust-gix-archive+tar_gz-devel \
 rust-gix-archive+zip-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+sha1-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-gix-worktree-stream+sha1-devel \
 "
RDEPENDS:rust-gix-archive+sha256-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-gix-worktree-stream+sha256-devel \
 "
RDEPENDS:rust-gix-archive+tar-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-gix-path+default-devel \
 rust-tar+default-devel \
 "
RDEPENDS:rust-gix-archive+tar_gz-devel = " \
 cargo \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-gix-archive+tar-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+zip-devel = " \
 cargo \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-gix-archive-devel \
 rust-rawzip+default-devel \
 "
RDEPENDS:rust-gix-archive-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-error+default-devel \
 rust-gix-object+default-devel \
 rust-gix-worktree-stream+default-devel \
 "
