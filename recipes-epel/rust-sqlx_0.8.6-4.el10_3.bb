# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx"
PV = "0.8.6"
PR = "4.el10_3"
PACKAGES = " \
 rust-sqlx+_rt-tokio-devel \
 rust-sqlx+_sqlite-devel \
 rust-sqlx+_unstable-all-types-devel \
 rust-sqlx+all-databases-devel \
 rust-sqlx+any-devel \
 rust-sqlx+bigdecimal-devel \
 rust-sqlx+bit-vec-devel \
 rust-sqlx+bstr-devel \
 rust-sqlx+chrono-devel \
 rust-sqlx+default-devel \
 rust-sqlx+derive-devel \
 rust-sqlx+ipnet-devel \
 rust-sqlx+ipnetwork-devel \
 rust-sqlx+json-devel \
 rust-sqlx+mac_address-devel \
 rust-sqlx+macros-devel \
 rust-sqlx+migrate-devel \
 rust-sqlx+mysql-devel \
 rust-sqlx+postgres-devel \
 rust-sqlx+regexp-devel \
 rust-sqlx+runtime-tokio-devel \
 rust-sqlx+runtime-tokio-native-tls-devel \
 rust-sqlx+runtime-tokio-rustls-devel \
 rust-sqlx+rust_decimal-devel \
 rust-sqlx+sqlite-devel \
 rust-sqlx+sqlite-preupdate-hook-devel \
 rust-sqlx+sqlite-unbundled-devel \
 rust-sqlx+sqlx-macros-devel \
 rust-sqlx+sqlx-mysql-devel \
 rust-sqlx+sqlx-postgres-devel \
 rust-sqlx+sqlx-sqlite-devel \
 rust-sqlx+time-devel \
 rust-sqlx+tls-native-tls-devel \
 rust-sqlx+tls-none-devel \
 rust-sqlx+tls-rustls-devel \
 rust-sqlx+tls-rustls-ring-devel \
 rust-sqlx+tls-rustls-ring-native-roots-devel \
 rust-sqlx+tls-rustls-ring-webpki-devel \
 rust-sqlx+uuid-devel \
 rust-sqlx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-0.8.6-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "483bdffc60c2e1896c929b94f057a76c1d415828ab8e7787e906400f24088ea3"

URI_x86_64_v2_rust-sqlx+_rt-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+_rt-tokio-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+_rt-tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx+_rt-tokio-devel.sha256sum] = "13eb0a7a0476765dea4c86c62e521f838de4adcd108a5e2d384559c23cea1253"

URI_x86_64_v2_rust-sqlx+_sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+_sqlite-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+_sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx+_sqlite-devel.sha256sum] = "41eef3d03623bea1b9ff40b33e5fe3b14b515355a24d12c5117d5e8908293a4e"

URI_x86_64_v2_rust-sqlx+_unstable-all-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+_unstable-all-types-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+_unstable-all-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+_unstable-all-types-devel}"
SRC_URI[x86_64_v2_rust-sqlx+_unstable-all-types-devel.sha256sum] = "bf90a8dc0f8cc88ed49a57d37394edd1a42a0d40bde5a3a171e3956aca242a7e"

URI_x86_64_v2_rust-sqlx+all-databases-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+all-databases-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+all-databases-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+all-databases-devel}"
SRC_URI[x86_64_v2_rust-sqlx+all-databases-devel.sha256sum] = "75de1ceb11f160b74ad846d4b013dc74274e68413b0a995422ff630ab9c75024"

URI_x86_64_v2_rust-sqlx+any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+any-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+any-devel}"
SRC_URI[x86_64_v2_rust-sqlx+any-devel.sha256sum] = "4471e9fef10e3fb2e2454386f4b05a02504d14763f5e886ad9e3cb39e2c87cea"

URI_x86_64_v2_rust-sqlx+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+bigdecimal-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx+bigdecimal-devel.sha256sum] = "f51aff946477116020857dd383bf87852177a97e945b6ca2160a2508d259911c"

URI_x86_64_v2_rust-sqlx+bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+bit-vec-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+bit-vec-devel}"
SRC_URI[x86_64_v2_rust-sqlx+bit-vec-devel.sha256sum] = "2055b4f5864ff75fcdb723e4d18ebfad87cc4a44d6f29e50925f898718dd15c7"

URI_x86_64_v2_rust-sqlx+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+bstr-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+bstr-devel}"
SRC_URI[x86_64_v2_rust-sqlx+bstr-devel.sha256sum] = "4ba9b9127050f7e8b3b8735120ccbd854753594d89f158ddecd68d68522f6c6f"

URI_x86_64_v2_rust-sqlx+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+chrono-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx+chrono-devel.sha256sum] = "40c214986a7e3fa16065480f346abe26c02ef745c5a745fa44c45cbc99278f21"

URI_x86_64_v2_rust-sqlx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+default-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx+default-devel.sha256sum] = "552e4b9aac7c49f70284b1e38b4e3336fd65ef1700649ed52a835e0a9045b383"

URI_x86_64_v2_rust-sqlx+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+derive-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+derive-devel}"
SRC_URI[x86_64_v2_rust-sqlx+derive-devel.sha256sum] = "0c3451e75d62730fef081a06104d43f027d2843ed4efc377440673b652eec274"

URI_x86_64_v2_rust-sqlx+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+ipnet-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+ipnet-devel}"
SRC_URI[x86_64_v2_rust-sqlx+ipnet-devel.sha256sum] = "c3b57643d9054e5398848784b6eb6b1c63f25560b5f2d272901e704dbbcc4fb4"

URI_x86_64_v2_rust-sqlx+ipnetwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+ipnetwork-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+ipnetwork-devel}"
SRC_URI[x86_64_v2_rust-sqlx+ipnetwork-devel.sha256sum] = "3e88da453dc1aa89a3010e7454f3c523e7fa2768dbeb7307e97661de9d2b2af8"

URI_x86_64_v2_rust-sqlx+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+json-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx+json-devel.sha256sum] = "9e639067ab24f9b805f319e9d22a850225075a34a26fd8e60cefa1c2b1462ba9"

URI_x86_64_v2_rust-sqlx+mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+mac_address-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+mac_address-devel}"
SRC_URI[x86_64_v2_rust-sqlx+mac_address-devel.sha256sum] = "d57564dd7c0bc7e4a791b114ed441ef1b1f3fbbb170c572c529405c7c0f38bb0"

URI_x86_64_v2_rust-sqlx+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+macros-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+macros-devel}"
SRC_URI[x86_64_v2_rust-sqlx+macros-devel.sha256sum] = "fc13c1d1fa169169361155921a3acdc27295524917a7558770143caad58c97c3"

URI_x86_64_v2_rust-sqlx+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+migrate-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx+migrate-devel.sha256sum] = "349fe4cc9cf389b7010a1ab9b65e7b38a25e2fca8e253e2fecc1863bde0e5ca4"

URI_x86_64_v2_rust-sqlx+mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+mysql-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+mysql-devel}"
SRC_URI[x86_64_v2_rust-sqlx+mysql-devel.sha256sum] = "4a9777be8ebe831b9d795926fdbd806638f49c04a7091c40b09d16c493d9dae6"

URI_x86_64_v2_rust-sqlx+postgres-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+postgres-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+postgres-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+postgres-devel}"
SRC_URI[x86_64_v2_rust-sqlx+postgres-devel.sha256sum] = "76b083d19c6c2af470c151bf03eb28c9d66fed9d7f9a8e293560daad60ed7859"

URI_x86_64_v2_rust-sqlx+regexp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+regexp-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+regexp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+regexp-devel}"
SRC_URI[x86_64_v2_rust-sqlx+regexp-devel.sha256sum] = "751eebe19dab17e9395146f133f3b8172af587ba87f9056984592493530301d9"

URI_x86_64_v2_rust-sqlx+runtime-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+runtime-tokio-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+runtime-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+runtime-tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx+runtime-tokio-devel.sha256sum] = "b2c611f2be5f72a2e2f99672d3351268bd58a51b8b208829437a97c7f68c8ea4"

URI_x86_64_v2_rust-sqlx+runtime-tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+runtime-tokio-native-tls-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+runtime-tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+runtime-tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx+runtime-tokio-native-tls-devel.sha256sum] = "0fd822d59e428e0e24603f96d98cc1d9ccf89c360ad4e975a242cf6bdbc4502f"

URI_x86_64_v2_rust-sqlx+runtime-tokio-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+runtime-tokio-rustls-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+runtime-tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+runtime-tokio-rustls-devel}"
SRC_URI[x86_64_v2_rust-sqlx+runtime-tokio-rustls-devel.sha256sum] = "4cdbd9baebc38b317794e19105529f9b3e52dd02675c5004187ac3849c511424"

URI_x86_64_v2_rust-sqlx+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+rust_decimal-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx+rust_decimal-devel.sha256sum] = "24ea0f207020d8b47306d5501a00b847d89577e7f6b5a2b211068243e2c8eb06"

URI_x86_64_v2_rust-sqlx+sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlite-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlite-devel.sha256sum] = "6871df8895212b1ebc91754c37881fd5a17621e44b7d17fc929400df5d896607"

URI_x86_64_v2_rust-sqlx+sqlite-preupdate-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlite-preupdate-hook-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlite-preupdate-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlite-preupdate-hook-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlite-preupdate-hook-devel.sha256sum] = "c8c5bfac10a1b2f8e53114b63257bb33e7f52d977a51b6c20846ed3df2cbbd00"

URI_x86_64_v2_rust-sqlx+sqlite-unbundled-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlite-unbundled-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlite-unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlite-unbundled-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlite-unbundled-devel.sha256sum] = "c7e28d143f9dd51636580ec13a0f6be499e32fa091fa1b20127071330c82b18b"

URI_x86_64_v2_rust-sqlx+sqlx-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlx-macros-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlx-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlx-macros-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlx-macros-devel.sha256sum] = "70fd27ae5887193db1a33da942718ea4a80a6a85f20602a4af339878d5e7b7d4"

URI_x86_64_v2_rust-sqlx+sqlx-mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlx-mysql-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlx-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlx-mysql-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlx-mysql-devel.sha256sum] = "a043870e462d930444e21a6bac6385e356a0a4132d1dde496ab1c668120bfe71"

URI_x86_64_v2_rust-sqlx+sqlx-postgres-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlx-postgres-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlx-postgres-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlx-postgres-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlx-postgres-devel.sha256sum] = "dab19d53e8a89c4f607fe5fe1d652b3b1ee31de2a63c1b22c66d4a89f11cfde5"

URI_x86_64_v2_rust-sqlx+sqlx-sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlx-sqlite-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlx-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlx-sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlx-sqlite-devel.sha256sum] = "cec0185cde7366721ef571444b3403fd85fc09052154035bc4ce4c454222c597"

URI_x86_64_v2_rust-sqlx+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+time-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx+time-devel.sha256sum] = "d5213f4f2c5e4f668cf2300998a0fdf57da12dd4352ed43659d65523015cc200"

URI_x86_64_v2_rust-sqlx+tls-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-native-tls-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-native-tls-devel.sha256sum] = "485a4edf093efc904b62ea24a0709af7ddc0935d166c53f9ebd7f3ac91158931"

URI_x86_64_v2_rust-sqlx+tls-none-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-none-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-none-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-none-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-none-devel.sha256sum] = "fd13da81e0c738b3a18d29ebc2975768ca63bb14507a287b8825c3c4abcddce6"

URI_x86_64_v2_rust-sqlx+tls-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-rustls-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-rustls-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-rustls-devel.sha256sum] = "1f719386df733dc68db84c6ea638676793ba42ec159a26a61b093951d0bcbc96"

URI_x86_64_v2_rust-sqlx+tls-rustls-ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-rustls-ring-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-rustls-ring-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-rustls-ring-devel.sha256sum] = "1adfa4aee369e6fb811d333d635e4ea08fb2812a26614e55a904115863480a68"

URI_x86_64_v2_rust-sqlx+tls-rustls-ring-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-rustls-ring-native-roots-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-rustls-ring-native-roots-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-rustls-ring-native-roots-devel.sha256sum] = "13beb9f9df39f72a44ed53f6eaa3f65d366734eee3664e6274d99b86ffefd732"

URI_x86_64_v2_rust-sqlx+tls-rustls-ring-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-rustls-ring-webpki-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-rustls-ring-webpki-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-rustls-ring-webpki-devel.sha256sum] = "b083e55ef9cea3450ca4a18f784a0704d4918982a7938277d1b9e0e47acac817"

URI_x86_64_v2_rust-sqlx+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+uuid-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx+uuid-devel.sha256sum] = "a9e37ccdc54df8ed32a4b4fcfc19a7dc32092175308dc02d443de8f4d9d57111"

URI_x86_64_v2_rust-sqlx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-devel}"
SRC_URI[x86_64_v2_rust-sqlx-devel.sha256sum] = "0a174890cbd92494d305ce3072932b9cb326cb9cee37ba58145714619f62e11e"

URI_aarch64_rust-sqlx+_rt-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+_rt-tokio-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+_rt-tokio-devel}"
SRC_URI[aarch64_rust-sqlx+_rt-tokio-devel.sha256sum] = "51264a25d69f8897715bf074bf2ab4d1760f7bb1b6d0c7e828e40a906e05d323"

URI_aarch64_rust-sqlx+_sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+_sqlite-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+_sqlite-devel}"
SRC_URI[aarch64_rust-sqlx+_sqlite-devel.sha256sum] = "3b79687e7b5fd3ead2c0ec91edfeba9fa12b14e150186ffda9fd96029a80ed06"

URI_aarch64_rust-sqlx+_unstable-all-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+_unstable-all-types-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+_unstable-all-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+_unstable-all-types-devel}"
SRC_URI[aarch64_rust-sqlx+_unstable-all-types-devel.sha256sum] = "ec8f7df3f527add77ce81cd899f94e2b9a24d22eefb06f1f4a7012de60c8a76e"

URI_aarch64_rust-sqlx+all-databases-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+all-databases-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+all-databases-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+all-databases-devel}"
SRC_URI[aarch64_rust-sqlx+all-databases-devel.sha256sum] = "cbadd1d9380f469c59c13e713087768922fd1cf47bbd6549efdb3f2c237d4a05"

URI_aarch64_rust-sqlx+any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+any-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+any-devel}"
SRC_URI[aarch64_rust-sqlx+any-devel.sha256sum] = "854a35fa0c3048fa3001bbbf61e8ecb1d6c6a0e7a0533e5764dc2ba58e1105a5"

URI_aarch64_rust-sqlx+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+bigdecimal-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx+bigdecimal-devel.sha256sum] = "af16c8c6b4e58eef94c4608c98fad54968a02d05af8e0677192cfcf1f4301ae0"

URI_aarch64_rust-sqlx+bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+bit-vec-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+bit-vec-devel}"
SRC_URI[aarch64_rust-sqlx+bit-vec-devel.sha256sum] = "086c62f7f54a4ea1833d4709555f63a852f5a8525b2edf6cccbed77932b94b2c"

URI_aarch64_rust-sqlx+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+bstr-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+bstr-devel}"
SRC_URI[aarch64_rust-sqlx+bstr-devel.sha256sum] = "4aee8c66a57bbf22c2ba9cbedbd9c2dace40686bc160c91445db679992f355b2"

URI_aarch64_rust-sqlx+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+chrono-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+chrono-devel}"
SRC_URI[aarch64_rust-sqlx+chrono-devel.sha256sum] = "79472b60bcfc7637a1bde17d93349c09492743de1069cba1140a730034e2a612"

URI_aarch64_rust-sqlx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+default-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+default-devel}"
SRC_URI[aarch64_rust-sqlx+default-devel.sha256sum] = "b7e408c7d22b79c1f6198f010f916987b0a14db5170756f3b35a85ac9c12f6ac"

URI_aarch64_rust-sqlx+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+derive-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+derive-devel}"
SRC_URI[aarch64_rust-sqlx+derive-devel.sha256sum] = "354f02e43e95f82fc144be04c205bdafb01794ee7ae58768105cea937169878e"

URI_aarch64_rust-sqlx+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+ipnet-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+ipnet-devel}"
SRC_URI[aarch64_rust-sqlx+ipnet-devel.sha256sum] = "c374e548fb62174d08a4999cc0f3666a172372bdad6a90835816267c70663754"

URI_aarch64_rust-sqlx+ipnetwork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+ipnetwork-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+ipnetwork-devel}"
SRC_URI[aarch64_rust-sqlx+ipnetwork-devel.sha256sum] = "922032a53cbf794a689b6c2b03b7979096e02bf6631d46a8530702a4843427b4"

URI_aarch64_rust-sqlx+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+json-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+json-devel}"
SRC_URI[aarch64_rust-sqlx+json-devel.sha256sum] = "ade91d607d4fff02470b6fe127d89cc331bf4d3e337e7c1d342542464dcd68be"

URI_aarch64_rust-sqlx+mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+mac_address-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+mac_address-devel}"
SRC_URI[aarch64_rust-sqlx+mac_address-devel.sha256sum] = "2873c1c09712d24332ac904e93d5e5e90f3b261df31bd6cd0f40d5229b942c1f"

URI_aarch64_rust-sqlx+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+macros-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+macros-devel}"
SRC_URI[aarch64_rust-sqlx+macros-devel.sha256sum] = "fff0f07edf58a22bf202d2e7bd1df807348592bdaef0f0abee9d4e5d39055ac6"

URI_aarch64_rust-sqlx+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+migrate-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+migrate-devel}"
SRC_URI[aarch64_rust-sqlx+migrate-devel.sha256sum] = "e03143273ec40c7aab57ddb0bafac9dbea7a0cc50eccba00b2a966d4a748eb7c"

URI_aarch64_rust-sqlx+mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+mysql-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+mysql-devel}"
SRC_URI[aarch64_rust-sqlx+mysql-devel.sha256sum] = "133b15bc86596c39144334eb23f750ce7415912185c01edf3974f8bd3f91de26"

URI_aarch64_rust-sqlx+postgres-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+postgres-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+postgres-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+postgres-devel}"
SRC_URI[aarch64_rust-sqlx+postgres-devel.sha256sum] = "40a3a875c9fdfdacdd029657a3d07481eea847228901c06b9d39ddedebfef3c4"

URI_aarch64_rust-sqlx+regexp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+regexp-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+regexp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+regexp-devel}"
SRC_URI[aarch64_rust-sqlx+regexp-devel.sha256sum] = "64ecb262d72943831f1e177ccf6978486c23569af3c1bba2421d717dc9a55a1d"

URI_aarch64_rust-sqlx+runtime-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+runtime-tokio-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+runtime-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+runtime-tokio-devel}"
SRC_URI[aarch64_rust-sqlx+runtime-tokio-devel.sha256sum] = "fd6aca33c00f441935d11e2d2b71d9d00475b855d65bf263b8028617603212af"

URI_aarch64_rust-sqlx+runtime-tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+runtime-tokio-native-tls-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+runtime-tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+runtime-tokio-native-tls-devel}"
SRC_URI[aarch64_rust-sqlx+runtime-tokio-native-tls-devel.sha256sum] = "53e1d64b33eb2c842e825c393f13b508ce05221c04e368702c4c4e1bf5405e67"

URI_aarch64_rust-sqlx+runtime-tokio-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+runtime-tokio-rustls-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+runtime-tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+runtime-tokio-rustls-devel}"
SRC_URI[aarch64_rust-sqlx+runtime-tokio-rustls-devel.sha256sum] = "cf5e2adaefe8dbfa981a40776f37b8b0d860e626684e602ac3eeb600dfd3e037"

URI_aarch64_rust-sqlx+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+rust_decimal-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx+rust_decimal-devel.sha256sum] = "ff4eca5d85bbf90ea85230a746d97336a5e901bc2d0979db5768c7f3e5ff3776"

URI_aarch64_rust-sqlx+sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlite-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlite-devel}"
SRC_URI[aarch64_rust-sqlx+sqlite-devel.sha256sum] = "52bdccb2260d17fc5c8716aff4fc255f53c45456df44ebdbfaafae8799583e10"

URI_aarch64_rust-sqlx+sqlite-preupdate-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlite-preupdate-hook-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+sqlite-preupdate-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlite-preupdate-hook-devel}"
SRC_URI[aarch64_rust-sqlx+sqlite-preupdate-hook-devel.sha256sum] = "b31390f9f4bc9788857388921f829aa0a2a2f20e3c636cb695337b6e3a97b814"

URI_aarch64_rust-sqlx+sqlite-unbundled-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlite-unbundled-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+sqlite-unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlite-unbundled-devel}"
SRC_URI[aarch64_rust-sqlx+sqlite-unbundled-devel.sha256sum] = "143912838a0e9a3202391769824b300225451f0e6bb3d7fb0a9433b52f5afea4"

URI_aarch64_rust-sqlx+sqlx-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlx-macros-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+sqlx-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlx-macros-devel}"
SRC_URI[aarch64_rust-sqlx+sqlx-macros-devel.sha256sum] = "4d3693bbf385e330664e94d52eb4333e036929ab338fc11710b811db2af2305c"

URI_aarch64_rust-sqlx+sqlx-mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlx-mysql-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+sqlx-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlx-mysql-devel}"
SRC_URI[aarch64_rust-sqlx+sqlx-mysql-devel.sha256sum] = "67ef3b7e22ec7bd6b71bb85508cb2992ab05e5dccea861e9267bd1c934b85743"

URI_aarch64_rust-sqlx+sqlx-postgres-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlx-postgres-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+sqlx-postgres-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlx-postgres-devel}"
SRC_URI[aarch64_rust-sqlx+sqlx-postgres-devel.sha256sum] = "6dcdc863859bbbe89d442b3973e4de35e30e84c55771066c8d5568aebf4c14df"

URI_aarch64_rust-sqlx+sqlx-sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlx-sqlite-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+sqlx-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlx-sqlite-devel}"
SRC_URI[aarch64_rust-sqlx+sqlx-sqlite-devel.sha256sum] = "d34d24224b1b60a455ff16f95072eb7ac3da96735aabe029628553853dd3e969"

URI_aarch64_rust-sqlx+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+time-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+time-devel}"
SRC_URI[aarch64_rust-sqlx+time-devel.sha256sum] = "6f05dcf133849a8a1ceb24b3cda386999c44d02ed150cabb91ee13f97eb320a3"

URI_aarch64_rust-sqlx+tls-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-native-tls-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-native-tls-devel}"
SRC_URI[aarch64_rust-sqlx+tls-native-tls-devel.sha256sum] = "26529f4ab0c77973fb79a2bba190a7bad48c4dcaaa00e21d4be0c99918b65064"

URI_aarch64_rust-sqlx+tls-none-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-none-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+tls-none-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-none-devel}"
SRC_URI[aarch64_rust-sqlx+tls-none-devel.sha256sum] = "54c9a1518f78446abfdd870722e22e6e867a3581f76b6fd02396d854ddaaac7d"

URI_aarch64_rust-sqlx+tls-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-rustls-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+tls-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-rustls-devel}"
SRC_URI[aarch64_rust-sqlx+tls-rustls-devel.sha256sum] = "f01f2f181dffd62c02a5052a50828340030f6d291b9ed7dc12aecd7ee99fe334"

URI_aarch64_rust-sqlx+tls-rustls-ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-rustls-ring-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+tls-rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-rustls-ring-devel}"
SRC_URI[aarch64_rust-sqlx+tls-rustls-ring-devel.sha256sum] = "15839e555a762bf066d7a057053bd57c38e7a1632793b05dd5391b5642da4d3b"

URI_aarch64_rust-sqlx+tls-rustls-ring-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-rustls-ring-native-roots-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-rustls-ring-native-roots-devel}"
SRC_URI[aarch64_rust-sqlx+tls-rustls-ring-native-roots-devel.sha256sum] = "cc12275f03e79402dfeab2d06fd6145388d4ffbe4b0115f9f19f8174add55acb"

URI_aarch64_rust-sqlx+tls-rustls-ring-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-rustls-ring-webpki-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-rustls-ring-webpki-devel}"
SRC_URI[aarch64_rust-sqlx+tls-rustls-ring-webpki-devel.sha256sum] = "8f7c71fe349ef019c63279ba79299cf4a0b01e27902937d04808facce34391f9"

URI_aarch64_rust-sqlx+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+uuid-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+uuid-devel}"
SRC_URI[aarch64_rust-sqlx+uuid-devel.sha256sum] = "d302c19036da09b32373a74ff9ab026987d0f44e5c08211f771350de3b2ee32f"

URI_aarch64_rust-sqlx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-devel}"
SRC_URI[aarch64_rust-sqlx-devel.sha256sum] = "296d1033dfc13d7a48195258796b7154ce7c93359f702ae440d7004ceb8436fc"

RDEPENDS:rust-sqlx+_rt-tokio-devel = " \
 cargo \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+_sqlite-devel = " \
 cargo \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+_unstable-all-types-devel = " \
 cargo \
 rust-sqlx+bigdecimal-devel \
 rust-sqlx+bit-vec-devel \
 rust-sqlx+bstr-devel \
 rust-sqlx+chrono-devel \
 rust-sqlx+ipnet-devel \
 rust-sqlx+ipnetwork-devel \
 rust-sqlx+json-devel \
 rust-sqlx+mac_address-devel \
 rust-sqlx+rust_decimal-devel \
 rust-sqlx+time-devel \
 rust-sqlx+uuid-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+all-databases-devel = " \
 cargo \
 rust-sqlx+any-devel \
 rust-sqlx+mysql-devel \
 rust-sqlx+postgres-devel \
 rust-sqlx+sqlite-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+any-devel = " \
 cargo \
 rust-sqlx-core+any-devel \
 rust-sqlx-devel \
 rust-sqlx-mysql+any-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-postgres+any-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-sqlite+any-devel \
 rust-sqlx-sqlite+default-devel \
 "
RDEPENDS:rust-sqlx+bigdecimal-devel = " \
 cargo \
 rust-sqlx-core+bigdecimal-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+bigdecimal-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-mysql+bigdecimal-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-postgres+bigdecimal-devel \
 rust-sqlx-postgres+default-devel \
 "
RDEPENDS:rust-sqlx+bit-vec-devel = " \
 cargo \
 rust-sqlx-core+bit-vec-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+bit-vec-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-postgres+bit-vec-devel \
 rust-sqlx-postgres+default-devel \
 "
RDEPENDS:rust-sqlx+bstr-devel = " \
 cargo \
 rust-sqlx-core+bstr-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+chrono-devel = " \
 cargo \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+chrono-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-mysql+chrono-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-postgres+chrono-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-sqlite+chrono-devel \
 rust-sqlx-sqlite+default-devel \
 "
RDEPENDS:rust-sqlx+default-devel = " \
 cargo \
 rust-sqlx+any-devel \
 rust-sqlx+json-devel \
 rust-sqlx+macros-devel \
 rust-sqlx+migrate-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+derive-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+derive-devel \
 "
RDEPENDS:rust-sqlx+ipnet-devel = " \
 cargo \
 rust-sqlx-core+ipnet-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+ipnet-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+ipnet-devel \
 "
RDEPENDS:rust-sqlx+ipnetwork-devel = " \
 cargo \
 rust-sqlx-core+ipnetwork-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+ipnetwork-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+ipnetwork-devel \
 "
RDEPENDS:rust-sqlx+json-devel = " \
 cargo \
 rust-sqlx-core+json-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+json-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+json-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+json-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+json-devel \
 "
RDEPENDS:rust-sqlx+mac_address-devel = " \
 cargo \
 rust-sqlx-core+mac_address-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+mac_address-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+mac_address-devel \
 "
RDEPENDS:rust-sqlx+macros-devel = " \
 cargo \
 rust-sqlx+derive-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+macros-devel \
 "
RDEPENDS:rust-sqlx+migrate-devel = " \
 cargo \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+migrate-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+migrate-devel \
 "
RDEPENDS:rust-sqlx+mysql-devel = " \
 cargo \
 rust-sqlx+sqlx-mysql-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+mysql-devel \
 "
RDEPENDS:rust-sqlx+postgres-devel = " \
 cargo \
 rust-sqlx+sqlx-postgres-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+postgres-devel \
 "
RDEPENDS:rust-sqlx+regexp-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+regexp-devel \
 "
RDEPENDS:rust-sqlx+runtime-tokio-devel = " \
 cargo \
 rust-sqlx+_rt-tokio-devel \
 rust-sqlx-core+_rt-tokio-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+_rt-tokio-devel \
 rust-sqlx-macros+default-devel \
 "
RDEPENDS:rust-sqlx+runtime-tokio-native-tls-devel = " \
 cargo \
 rust-sqlx+runtime-tokio-devel \
 rust-sqlx+tls-native-tls-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+runtime-tokio-rustls-devel = " \
 cargo \
 rust-sqlx+runtime-tokio-devel \
 rust-sqlx+tls-rustls-ring-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+rust_decimal-devel = " \
 cargo \
 rust-sqlx-core+rust_decimal-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+rust_decimal-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+rust_decimal-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+rust_decimal-devel \
 "
RDEPENDS:rust-sqlx+sqlite-devel = " \
 cargo \
 rust-sqlx+sqlite-unbundled-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+sqlite-preupdate-hook-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+preupdate-hook-devel \
 "
RDEPENDS:rust-sqlx+sqlite-unbundled-devel = " \
 cargo \
 rust-sqlx+_sqlite-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+sqlite-unbundled-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+unbundled-devel \
 "
RDEPENDS:rust-sqlx+sqlx-macros-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 "
RDEPENDS:rust-sqlx+sqlx-mysql-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-mysql+default-devel \
 "
RDEPENDS:rust-sqlx+sqlx-postgres-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-postgres+default-devel \
 "
RDEPENDS:rust-sqlx+sqlx-sqlite-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-sqlite+default-devel \
 "
RDEPENDS:rust-sqlx+time-devel = " \
 cargo \
 rust-sqlx-core+time-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+time-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+time-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+time-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+time-devel \
 "
RDEPENDS:rust-sqlx+tls-native-tls-devel = " \
 cargo \
 rust-sqlx-core+_tls-native-tls-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+_tls-native-tls-devel \
 rust-sqlx-macros+default-devel \
 "
RDEPENDS:rust-sqlx+tls-none-devel = " \
 cargo \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+tls-rustls-devel = " \
 cargo \
 rust-sqlx+tls-rustls-ring-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+tls-rustls-ring-devel = " \
 cargo \
 rust-sqlx+tls-rustls-ring-webpki-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+tls-rustls-ring-native-roots-devel = " \
 cargo \
 rust-sqlx-core+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-macros+default-devel \
 "
RDEPENDS:rust-sqlx+tls-rustls-ring-webpki-devel = " \
 cargo \
 rust-sqlx-core+_tls-rustls-ring-webpki-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+_tls-rustls-ring-webpki-devel \
 rust-sqlx-macros+default-devel \
 "
RDEPENDS:rust-sqlx+uuid-devel = " \
 cargo \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+uuid-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+uuid-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+uuid-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+uuid-devel \
 "
RDEPENDS:rust-sqlx-devel = " \
 cargo \
 rust-sqlx-core+default-devel \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-core+offline-devel \
 "
