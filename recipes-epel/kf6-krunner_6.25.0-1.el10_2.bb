# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-krunner"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-krunner \
 kf6-krunner-devel \
 kf6-krunner-doc \
 kf6-krunner-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-krunner-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f38175b8028a554dacc614bb256275bfcf8074c161e9e320bd4ad31757d9b30"

URI_x86_64_v2_kf6-krunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-krunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner}"
SRC_URI[x86_64_v2_kf6-krunner.sha256sum] = "45d3643fbd583b2d0de439d880b2fac329a4d65246ca7173698b5804e79a2454"

URI_x86_64_v2_kf6-krunner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-krunner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-devel}"
SRC_URI[x86_64_v2_kf6-krunner-devel.sha256sum] = "590628289b7d0416b76ca525a1a3e3d40ee202fc62535e24e3145dffaa4db534"

URI_x86_64_v2_kf6-krunner-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-krunner-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-doc}"
SRC_URI[x86_64_v2_kf6-krunner-doc.sha256sum] = "f285a501cebe9ba92209a24f02ae1455e4bde1fb6f56b6877b40f3fbb4e6de97"

URI_x86_64_v2_kf6-krunner-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-krunner-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-html}"
SRC_URI[x86_64_v2_kf6-krunner-html.sha256sum] = "e04d8b30fe5edbf47a2e5113efd06c9ed99a4969cf6cda98c03a66803baa920c"

URI_aarch64_kf6-krunner = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-krunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner}"
SRC_URI[aarch64_kf6-krunner.sha256sum] = "2db85ccc16b721a0648be9158594fae38900db8c107bc400da46a22662522ff7"

URI_aarch64_kf6-krunner-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-krunner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-devel}"
SRC_URI[aarch64_kf6-krunner-devel.sha256sum] = "0088c18f6120394c203c226726e0d517f30b047e0003a61a77a6271866b9e4ca"

URI_aarch64_kf6-krunner-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-krunner-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-doc}"
SRC_URI[aarch64_kf6-krunner-doc.sha256sum] = "cf7fa6b9072bdde8f672cb6ab9d6410714993f81b97613e9cddcde9156eabc77"

URI_aarch64_kf6-krunner-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-krunner-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-html}"
SRC_URI[aarch64_kf6-krunner-html.sha256sum] = "18c91272e5e5c13c468490de49024d024c25ddf4f3f48568faf16650be12a869"

RDEPENDS:kf6-krunner = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-krunner-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-krunner \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-krunner-doc = " \
 "
RDEPENDS:kf6-krunner-html = " \
 "
