# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Meta-YAML"
PV = "0.018"
PR = "512.el10"
PACKAGES = " \
 perl-CPAN-Meta-YAML \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-CPAN-Meta-YAML-0.018-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a08934228f9840f752a0198076a45aca78a30aacd7246d8c711412a8a593a52"

URI_x86_64_v2_perl-CPAN-Meta-YAML = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-CPAN-Meta-YAML-0.018-512.el10.noarch.rpm;name=x86_64_v2_perl-CPAN-Meta-YAML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-Meta-YAML}"
SRC_URI[x86_64_v2_perl-CPAN-Meta-YAML.sha256sum] = "8af7c7f0d072f10486e525ab5c90eb091e7b963a48767afe58f6e043ce9c44b4"

URI_aarch64_perl-CPAN-Meta-YAML = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-CPAN-Meta-YAML-0.018-512.el10.noarch.rpm;name=aarch64_perl-CPAN-Meta-YAML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-Meta-YAML}"
SRC_URI[aarch64_perl-CPAN-Meta-YAML.sha256sum] = "8af7c7f0d072f10486e525ab5c90eb091e7b963a48767afe58f6e043ce9c44b4"

RDEPENDS:perl-CPAN-Meta-YAML = " \
 perl-B \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-Scalar-List-Utils \
 perl-libs \
 "
