# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-machines"
PV = "348"
PR = "1.el10"
PACKAGES = " \
 cockpit-machines \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-machines-348-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e65832b5748fb02f34f490a94b8b3be4751c2495fef85141032222a6b8ae02a"

URI_x86_64_v2_cockpit-machines = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-machines-348-1.el10.noarch.rpm;name=x86_64_v2_cockpit-machines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-machines}"
SRC_URI[x86_64_v2_cockpit-machines.sha256sum] = "3755fa236a8888fdc5a0dbc0f86208c447b7137631cc79ab2a96cf7ff619ac77"

URI_aarch64_cockpit-machines = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-machines-348-1.el10.noarch.rpm;name=aarch64_cockpit-machines;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-machines}"
SRC_URI[aarch64_cockpit-machines.sha256sum] = "3755fa236a8888fdc5a0dbc0f86208c447b7137631cc79ab2a96cf7ff619ac77"

RDEPENDS:cockpit-machines = " \
 cockpit-bridge \
 libvirt-client \
 libvirt-daemon-config-network \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-storage-core \
 libvirt-dbus \
 qemu-kvm \
 virt-install \
 "
