# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_auth_gssapi"
PV = "1.6.5"
PR = "8.el10"
PACKAGES = " \
 mod_auth_gssapi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_auth_gssapi-1.6.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc2d0ff57bf9e01d8a97b95eb96c884606f282d8382925a8a405dd69e3e94768"

URI_x86_64_v2_mod_auth_gssapi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_auth_gssapi-1.6.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_mod_auth_gssapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_auth_gssapi}"
SRC_URI[x86_64_v2_mod_auth_gssapi.sha256sum] = "e4daf2a326d7e50f39dc1643c491f48afaf264f8bc3024bae0782f902047fbe8"

URI_aarch64_mod_auth_gssapi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_auth_gssapi-1.6.5-8.el10.aarch64.rpm;name=aarch64_mod_auth_gssapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_auth_gssapi}"
SRC_URI[aarch64_mod_auth_gssapi.sha256sum] = "34654b796676c22744339210a6dee688f131a815c35959cfca8d163e62f50f1f"

RDEPENDS:mod_auth_gssapi = " \
 glibc \
 httpd-core \
 krb5-libs \
 libcom_err \
 openssl-libs \
 "
