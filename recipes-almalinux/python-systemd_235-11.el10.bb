# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-systemd"
PV = "235"
PR = "11.el10"
PACKAGES = " \
 python3-systemd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-systemd-235-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4230f54b5efa3a1e57fcc7f51398336e394e9567c9710dde353d11656025e93c"

URI_x86_64_v2_python3-systemd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-systemd-235-11.el10.x86_64_v2.rpm;name=x86_64_v2_python3-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-systemd}"
SRC_URI[x86_64_v2_python3-systemd.sha256sum] = "5a15af009b2a4a8cf6c41893d670ae3ee55f654a09722841e31b76efeccbfbe1"

URI_aarch64_python3-systemd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-systemd-235-11.el10.aarch64.rpm;name=aarch64_python3-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-systemd}"
SRC_URI[aarch64_python3-systemd.sha256sum] = "1ad5e9be0049ed9c3598bcf76544bf56e37ca3e352c1565840bdc8bd21a4d6a5"

RDEPENDS:python3-systemd = " \
 glibc \
 libgcc \
 python3 \
 systemd-libs \
 "
