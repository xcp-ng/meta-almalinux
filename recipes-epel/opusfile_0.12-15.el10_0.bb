# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opusfile"
PV = "0.12"
PR = "15.el10_0"
PACKAGES = " \
 opusfile \
 opusfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opusfile-0.12-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1abdef087d1d9bb0b8dc78df6ec25915ffeced1c3545765c338882476da0795"

URI_x86_64_v2_opusfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opusfile-0.12-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opusfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opusfile}"
SRC_URI[x86_64_v2_opusfile.sha256sum] = "5086bc4a4faebdcb391af8981a8f896d60a9525207055cf9dd1cb2210143903f"

URI_x86_64_v2_opusfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opusfile-devel-0.12-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opusfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opusfile-devel}"
SRC_URI[x86_64_v2_opusfile-devel.sha256sum] = "9f94787efd5ec896fe066045c46db274abdc8db319b5420c92b1d5ccf8087605"

URI_aarch64_opusfile = "${EPEL_MIRROR}/aarch64/Packages/o/opusfile-0.12-15.el10_0.aarch64.rpm;name=aarch64_opusfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_opusfile}"
SRC_URI[aarch64_opusfile.sha256sum] = "7676fcc3aaf856900ef230c4234a45be9390d57633cefe37c475ba0966ba3a64"

URI_aarch64_opusfile-devel = "${EPEL_MIRROR}/aarch64/Packages/o/opusfile-devel-0.12-15.el10_0.aarch64.rpm;name=aarch64_opusfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opusfile-devel}"
SRC_URI[aarch64_opusfile-devel.sha256sum] = "6aa462c26e6d58a8846c78aa5c08301072832899ab5a52e70c11abf5e4f27dd0"

RDEPENDS:opusfile = " \
 glibc \
 libogg \
 openssl-libs \
 opus \
 "
RDEPENDS:opusfile-devel = " \
 libogg-devel \
 openssl-devel \
 opus-devel \
 opusfile \
 opusfile-devel \
 pkgconf-pkg-config \
 "
