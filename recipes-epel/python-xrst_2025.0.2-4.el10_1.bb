# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-xrst"
PV = "2025.0.2"
PR = "4.el10_1"
PACKAGES = " \
 python3-xrst \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-xrst-2025.0.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6759cead333759bd3a401f6caa388842dd3e5c5b9ca9bb7f5a0ac795dadf7275"

URI_x86_64_v2_python3-xrst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xrst-2025.0.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-xrst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xrst}"
SRC_URI[x86_64_v2_python3-xrst.sha256sum] = "0f0fcbb5023eb50cdce6503da10f18cd11737af54315faefd424b01d881546a5"

URI_aarch64_python3-xrst = "${EPEL_MIRROR}/aarch64/Packages/p/python3-xrst-2025.0.2-4.el10_1.noarch.rpm;name=aarch64_python3-xrst;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xrst}"
SRC_URI[aarch64_python3-xrst.sha256sum] = "21ce4dc9d1d529fa0dd44b1d6bf3d46e4be2bcd53df4a83ee654257554917b38"

RDEPENDS:python3-xrst = " \
 python3 \
 python3-furo \
 python3-pyspellchecker \
 python3-sphinx \
 python3-sphinx-copybutton \
 python3-tomli \
 "
