# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-deepmerge"
PV = "2.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-deepmerge \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-deepmerge-2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17d972d9702708dd811c42a270ca6c84880b67b61085f3d1fdae22fe82f9c835"

URI_x86_64_v2_python3-deepmerge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-deepmerge-2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-deepmerge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-deepmerge}"
SRC_URI[x86_64_v2_python3-deepmerge.sha256sum] = "7800988fbe81c47659255bdbd6a50a58bc1b46bcccef2cf282a75710cc0376ef"

URI_aarch64_python3-deepmerge = "${EPEL_MIRROR}/aarch64/Packages/p/python3-deepmerge-2.0-1.el10_0.noarch.rpm;name=aarch64_python3-deepmerge;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-deepmerge}"
SRC_URI[aarch64_python3-deepmerge.sha256sum] = "689237ac3215c14ebd0f37ed1be3eaa0a9270093a9de1789bfd652ca4f06c4ec"

RDEPENDS:python3-deepmerge = " \
 python3 \
 "
