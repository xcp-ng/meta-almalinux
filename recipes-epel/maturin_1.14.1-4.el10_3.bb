# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maturin"
PV = "1.14.1"
PR = "4.el10_3"
PACKAGES = " \
 maturin \
 maturin+patchelf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/maturin-1.14.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe04d9136e76dda11e9042b4c4dd3587d7ef3adf9a656c7c51d87b5c1df5778f"

URI_x86_64_v2_maturin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maturin-1.14.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maturin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maturin}"
SRC_URI[x86_64_v2_maturin.sha256sum] = "b780b8cb67a401df35df37f0cf46000899594db5a9e1d659e334883e2c1ea543"

URI_x86_64_v2_maturin+patchelf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/maturin+patchelf-1.14.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_maturin+patchelf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maturin+patchelf}"
SRC_URI[x86_64_v2_maturin+patchelf.sha256sum] = "c97f4da4f68b2b234b9e2eb710502a2b889b963cd8b5a9437dc8063586c79354"

URI_aarch64_maturin = "${EPEL_MIRROR}/aarch64/Packages/m/maturin-1.14.1-4.el10_3.aarch64.rpm;name=aarch64_maturin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maturin}"
SRC_URI[aarch64_maturin.sha256sum] = "7986d8018de215f6192a943af7c7c284bdd2649c2d356fda514585645b0a2794"

URI_aarch64_maturin+patchelf = "${EPEL_MIRROR}/aarch64/Packages/m/maturin+patchelf-1.14.1-4.el10_3.aarch64.rpm;name=aarch64_maturin+patchelf;unpack=0"
SRC_URI:append = " ${URI_aarch64_maturin+patchelf}"
SRC_URI[aarch64_maturin+patchelf.sha256sum] = "5b124d53302c479d62828ea74ec83dcfe1c1da2181e48eeb248b706335d90f92"

RDEPENDS:maturin = " \
 cargo \
 glibc \
 libgcc \
 libzstd \
 python3 \
 "
RDEPENDS:maturin+patchelf = " \
 maturin \
 patchelf \
 python3 \
 "
