# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pass"
PV = "1.7.4"
PR = "18.el10_1"
PACKAGES = " \
 pass \
 passmenu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pass-1.7.4-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef36c576f8fb2e8738fa590deda703f56b3e0048feb1803b56c4a2424655759a"

URI_x86_64_v2_pass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pass-1.7.4-18.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pass}"
SRC_URI[x86_64_v2_pass.sha256sum] = "37cdfffbe58b1b082ef7f1eaad46c4254fc2c0ebb5e134ecce375d233dd8f2e5"

URI_x86_64_v2_passmenu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/passmenu-1.7.4-18.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_passmenu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_passmenu}"
SRC_URI[x86_64_v2_passmenu.sha256sum] = "83f851bd197db1f7f7d1e8552f97bf308d39026809293cf303e349b32711d1b6"

URI_aarch64_pass = "${EPEL_MIRROR}/aarch64/Packages/p/pass-1.7.4-18.el10_1.noarch.rpm;name=aarch64_pass;unpack=0"
SRC_URI:append = " ${URI_aarch64_pass}"
SRC_URI[aarch64_pass.sha256sum] = "7b8c6443dd56eb71cb3e200b7d0d9df110138fd46aacd2711feeb1176c4fc418"

URI_aarch64_passmenu = "${EPEL_MIRROR}/aarch64/Packages/p/passmenu-1.7.4-18.el10_1.noarch.rpm;name=aarch64_passmenu;unpack=0"
SRC_URI:append = " ${URI_aarch64_passmenu}"
SRC_URI[aarch64_passmenu.sha256sum] = "75b42a124d1456ef4f05cbe49ece48d30ddbf67858e9b0ec4b356c088eab2966"

RDEPENDS:pass = " \
 bash \
 git-core \
 gnupg2 \
 qrencode \
 tree \
 "
RDEPENDS:passmenu = " \
 bash \
 pass \
 "
