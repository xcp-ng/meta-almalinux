# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sleuthkit"
PV = "4.14.0"
PR = "3.el10_1"
PACKAGES = " \
 sleuthkit \
 sleuthkit-devel \
 sleuthkit-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sleuthkit-4.14.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c12408588c8a557d1b529e1c37807c9523894d2777d0ed818b767a0c441e37e"

URI_x86_64_v2_sleuthkit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-4.14.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleuthkit}"
SRC_URI[x86_64_v2_sleuthkit.sha256sum] = "f0f1a0be325a26f783ceb81807bd44731910e1e446d386d05736435388dbbf08"

URI_x86_64_v2_sleuthkit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-devel-4.14.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleuthkit-devel}"
SRC_URI[x86_64_v2_sleuthkit-devel.sha256sum] = "3d97439b2a13afa802cec1d5d6ec96505da9188cf43054d0659020c2a1207de1"

URI_x86_64_v2_sleuthkit-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sleuthkit-libs-4.14.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sleuthkit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sleuthkit-libs}"
SRC_URI[x86_64_v2_sleuthkit-libs.sha256sum] = "78a0912e16be4b7e4dd1d99e80bb8a29d5443673474eb50d7384d4783b2cfa94"

URI_aarch64_sleuthkit = "${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-4.14.0-3.el10_1.aarch64.rpm;name=aarch64_sleuthkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleuthkit}"
SRC_URI[aarch64_sleuthkit.sha256sum] = "3280264bff93d9b8ab892d723610821671cd1c74fe4e8fe086957762db76e691"

URI_aarch64_sleuthkit-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-devel-4.14.0-3.el10_1.aarch64.rpm;name=aarch64_sleuthkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleuthkit-devel}"
SRC_URI[aarch64_sleuthkit-devel.sha256sum] = "778cf00bfdc36bace56eb0aa4ba388486428df71850f66331dafab96b145443f"

URI_aarch64_sleuthkit-libs = "${EPEL_MIRROR}/aarch64/Packages/s/sleuthkit-libs-4.14.0-3.el10_1.aarch64.rpm;name=aarch64_sleuthkit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_sleuthkit-libs}"
SRC_URI[aarch64_sleuthkit-libs.sha256sum] = "0d325b7e621843f04ce8346c47d93e43bd19f5ef30ed3828637373eee50e2944"

RDEPENDS:sleuthkit = " \
 afflib \
 file \
 glibc \
 libewf \
 libgcc \
 libstdc++ \
 mac-robber \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 sleuthkit-libs \
 "
RDEPENDS:sleuthkit-devel = " \
 libewf-devel \
 pkgconf-pkg-config \
 sleuthkit-libs \
 sqlite-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:sleuthkit-libs = " \
 afflib \
 glibc \
 libewf \
 libgcc \
 libstdc++ \
 sqlite-libs \
 zlib-ng-compat \
 "
