# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "roundcubemail"
PV = "1.6.19"
PR = "1.el10_3"
PACKAGES = " \
 roundcubemail \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/roundcubemail-1.6.19-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f41a09c2596748acfe2ec7f025cda8fbc9054754ef34979f343dfb9ed6489600"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roundcubemail-1.6.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_roundcubemail;unpack=0"
SRC_URI[x86_64_v2_roundcubemail.sha256sum] = "8a2d21449b059fa7f1bb1c75d725b8b653969bf1697f8940970a5ce95d57eca0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/roundcubemail-1.6.19-1.el10_3.noarch.rpm;name=aarch64_roundcubemail;unpack=0"
SRC_URI[aarch64_roundcubemail.sha256sum] = "1a258dea398c8b03c07a4f86a4d5117fa527460bf01eb4a6026a6e03c409772e"

RDEPENDS:roundcubemail = " \
 bash \
 httpd-filesystem \
 mailcap \
 nginx-filesystem \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-date \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-hash \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-posix \
 virtual/php-reflection \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-sockets \
 virtual/php-spl \
 virtual/php-tokenizer \
 virtual/php-zip \
 virtual/php_httpd_ \
 virtual/php_language__ge_7.3 \
 virtual/webserver \
 "
