# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-h2"
PV = "4.1.0"
PR = "22.el10_0"
PACKAGES = " \
 python-h2-doc \
 python3-h2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-h2-4.1.0-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63bac33a2ca20ec28d6d6d3b1a1cf972bbb15f6ea4d837ba0eab140bb983d593"

URI_x86_64_v2_python-h2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-h2-doc-4.1.0-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-h2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-h2-doc}"
SRC_URI[x86_64_v2_python-h2-doc.sha256sum] = "c38b55e723681223127bece28d2f5ae16fac1425812190f9aa23ac9a43b107ad"

URI_x86_64_v2_python3-h2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-h2-4.1.0-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-h2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-h2}"
SRC_URI[x86_64_v2_python3-h2.sha256sum] = "04c9ed365a512b1213fcc243cb2e3539fb205558bc11e8239df0782f6a517af4"

URI_aarch64_python-h2-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-h2-doc-4.1.0-22.el10_0.noarch.rpm;name=aarch64_python-h2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-h2-doc}"
SRC_URI[aarch64_python-h2-doc.sha256sum] = "2daf6fc686407eba761d209c5d749b1c70f8189f00b4a61f2bc05edae73576fb"

URI_aarch64_python3-h2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-h2-4.1.0-22.el10_0.noarch.rpm;name=aarch64_python3-h2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-h2}"
SRC_URI[aarch64_python3-h2.sha256sum] = "589a4cf4e532853fe70390efcee5459fc77db2b83d4dd3f6f80b9604d9d03cd0"

RDEPENDS:python-h2-doc = " \
 "
RDEPENDS:python3-h2 = " \
 python3 \
 python3-hpack \
 python3-hyperframe \
 "
