# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_properties_data"
PV = "2.1.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-icu_properties_data+default-devel \
 rust-icu_properties_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_properties_data-2.1.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abf838219a607655ae02315135a14f6dcbffd77e31a52ac5f726f99958bd1825"

URI_x86_64_v2_rust-icu_properties_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties_data+default-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_properties_data+default-devel.sha256sum] = "bb050539ce0f78c15af628317a3bfedc83d97ca7625248188918342766a7370b"

URI_x86_64_v2_rust-icu_properties_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties_data-devel-2.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties_data-devel}"
SRC_URI[x86_64_v2_rust-icu_properties_data-devel.sha256sum] = "0bc8e5fc9bc7a96db662c86c749fb03d8232431ec1c05e5ae7dfd90806b7f5c1"

URI_aarch64_rust-icu_properties_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties_data+default-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-icu_properties_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties_data+default-devel}"
SRC_URI[aarch64_rust-icu_properties_data+default-devel.sha256sum] = "35d9093a89987929e280247f697cef4997a35e93a63f511c78f525f7d0d4aa10"

URI_aarch64_rust-icu_properties_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties_data-devel-2.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-icu_properties_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties_data-devel}"
SRC_URI[aarch64_rust-icu_properties_data-devel.sha256sum] = "fa392a637ffcce2729ae53e17c804ca149c16a351e4de1e330b1b2d30f35216e"

RDEPENDS:rust-icu_properties_data+default-devel = " \
 cargo \
 rust-icu_properties_data-devel \
 "
RDEPENDS:rust-icu_properties_data-devel = " \
 cargo \
 rust \
 "
