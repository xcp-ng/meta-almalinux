# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "worker"
PV = "5.4.0"
PR = "1.el10_1"
PACKAGES = " \
 worker \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/worker-5.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c492d547fee5a6c08daaf31a8a1df70ff5993d2f4baf9528cb9af6032aef68c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/worker-5.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_worker;unpack=0"
SRC_URI[x86_64_v2_worker.sha256sum] = "3307f0510816633693ac3309a6d1578756b8e44c54e1f7c1c1ea94cc65aee1f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/worker-5.4.0-1.el10_1.aarch64.rpm;name=aarch64_worker;unpack=0"
SRC_URI[aarch64_worker.sha256sum] = "e91be40fc8a52090c85e61ce1c15ed5711cd3916137844f9b5a0c61ac48f9d4e"

RDEPENDS:worker = " \
 bash \
 dbus-libs \
 file-libs \
 glibc \
 imlib2 \
 libX11 \
 libXft \
 libXinerama \
 libgcc \
 libstdc++ \
 lua-libs \
 openssl-libs \
 python3 \
 "
