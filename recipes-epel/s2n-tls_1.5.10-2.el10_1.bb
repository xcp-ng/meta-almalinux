# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s2n-tls"
PV = "1.5.10"
PR = "2.el10_1"
PACKAGES = " \
 s2n-tls \
 s2n-tls-devel \
 s2n-tls-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/s2n-tls-1.5.10-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a14621b381b30f0f23dae2013b369893f5b0ea0f627fb553f79aabf1ed93337"

URI_x86_64_v2_s2n-tls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s2n-tls-1.5.10-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_s2n-tls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s2n-tls}"
SRC_URI[x86_64_v2_s2n-tls.sha256sum] = "d5e5433fcde7a4a727accd264f2ab829557fec249200e6a6a1113b589cb73e9e"

URI_x86_64_v2_s2n-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s2n-tls-devel-1.5.10-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_s2n-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s2n-tls-devel}"
SRC_URI[x86_64_v2_s2n-tls-devel.sha256sum] = "b3fd0d3c90ed09519c3fabc8d90bf61e307f0d972cb991e1a5191c93e214893a"

URI_x86_64_v2_s2n-tls-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s2n-tls-doc-1.5.10-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_s2n-tls-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s2n-tls-doc}"
SRC_URI[x86_64_v2_s2n-tls-doc.sha256sum] = "156673aebded980c115746a6e69c27bf97e6350176ef54327214f345354dc595"

URI_aarch64_s2n-tls = "${EPEL_MIRROR}/aarch64/Packages/s/s2n-tls-1.5.10-2.el10_1.aarch64.rpm;name=aarch64_s2n-tls;unpack=0"
SRC_URI:append = " ${URI_aarch64_s2n-tls}"
SRC_URI[aarch64_s2n-tls.sha256sum] = "ab730029dc7e9e7347f9b68308ae51111f1c7667975f89ea1a8ef02315ca08ef"

URI_aarch64_s2n-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/s/s2n-tls-devel-1.5.10-2.el10_1.aarch64.rpm;name=aarch64_s2n-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_s2n-tls-devel}"
SRC_URI[aarch64_s2n-tls-devel.sha256sum] = "0e8ac2db0ceea830942051fc08571c503ad367f9997a7501c8c21b26a020c24f"

URI_aarch64_s2n-tls-doc = "${EPEL_MIRROR}/aarch64/Packages/s/s2n-tls-doc-1.5.10-2.el10_1.noarch.rpm;name=aarch64_s2n-tls-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_s2n-tls-doc}"
SRC_URI[aarch64_s2n-tls-doc.sha256sum] = "a8a4e8751ff7aeb7ceaefd1da60a4bee5351b04465873418799ecb7c2843a7ba"

RDEPENDS:s2n-tls = " \
 glibc \
 libgcc \
 openssl-libs \
 "
RDEPENDS:s2n-tls-devel = " \
 cmake-filesystem \
 openssl-devel \
 s2n-tls \
 "
RDEPENDS:s2n-tls-doc = " \
 "
