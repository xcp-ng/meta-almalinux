# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crosstermion"
PV = "0.14.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-crosstermion+ansiterm-devel \
 rust-crosstermion+async-channel-devel \
 rust-crosstermion+color-devel \
 rust-crosstermion+crossterm-devel \
 rust-crosstermion+default-devel \
 rust-crosstermion+futures-channel-devel \
 rust-crosstermion+futures-core-devel \
 rust-crosstermion+futures-lite-devel \
 rust-crosstermion+input-async-crossterm-devel \
 rust-crosstermion+input-async-devel \
 rust-crosstermion+tui-crossterm-backend-devel \
 rust-crosstermion+tui-crossterm-devel \
 rust-crosstermion+tui-devel \
 rust-crosstermion+tui-react-crossterm-devel \
 rust-crosstermion+tui-react-devel \
 rust-crosstermion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crosstermion-0.14.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1619d53c16d43b9078367cc87f542baadbff9df074e17b3993f7d94c764307dd"

URI_x86_64_v2_rust-crosstermion+ansiterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+ansiterm-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+ansiterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+ansiterm-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+ansiterm-devel.sha256sum] = "f640d5154f53b48fb6a867868226da045f3294fdaea77186cc4e0d5cea9cf111"

URI_x86_64_v2_rust-crosstermion+async-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+async-channel-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+async-channel-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+async-channel-devel.sha256sum] = "8e23c8684f59a2a3c936cdea71702e44b800caf48c2e40f4e40c8f822f066247"

URI_x86_64_v2_rust-crosstermion+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+color-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+color-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+color-devel.sha256sum] = "b9e867f4ed9197e1940cd8913ea5a6ec95af53a8922857df8a9a652fb14208eb"

URI_x86_64_v2_rust-crosstermion+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+crossterm-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+crossterm-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+crossterm-devel.sha256sum] = "0835a5c3aaa888a4bf7b50c6dc7518659f2a06438aa0adaa9af7e581869d9d91"

URI_x86_64_v2_rust-crosstermion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+default-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+default-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+default-devel.sha256sum] = "dcb8a14a7496f955c798f59cb25598e5ab2e1f09dd752ab59d2daaa0b2a3810e"

URI_x86_64_v2_rust-crosstermion+futures-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+futures-channel-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+futures-channel-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+futures-channel-devel.sha256sum] = "3434e6b2aa58bd74eae0365add5f8ecf544796f5928ab701e6f58fe3fbf381c4"

URI_x86_64_v2_rust-crosstermion+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+futures-core-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+futures-core-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+futures-core-devel.sha256sum] = "71ce1bd0395fa052ee25cc438dfce89012b4bfb912de5855692b9ac02cd134c6"

URI_x86_64_v2_rust-crosstermion+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+futures-lite-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+futures-lite-devel.sha256sum] = "9ef6ff8bade1240c87322c0a4f26128053b06ca0e666601aff199794d4c60ea9"

URI_x86_64_v2_rust-crosstermion+input-async-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+input-async-crossterm-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+input-async-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+input-async-crossterm-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+input-async-crossterm-devel.sha256sum] = "6072f30c1af10ebba04bc9e31d0de34172b139884fd55dfed59bb9bddcaf5812"

URI_x86_64_v2_rust-crosstermion+input-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+input-async-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+input-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+input-async-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+input-async-devel.sha256sum] = "7be2d725201712808e86fb627d3dc315876303999c61391ccf71f9bd261c01ff"

URI_x86_64_v2_rust-crosstermion+tui-crossterm-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+tui-crossterm-backend-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+tui-crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+tui-crossterm-backend-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+tui-crossterm-backend-devel.sha256sum] = "fcc6fffe0e691d2490878935780f25a089ca974466d139ec57991b894f8ff7a4"

URI_x86_64_v2_rust-crosstermion+tui-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+tui-crossterm-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+tui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+tui-crossterm-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+tui-crossterm-devel.sha256sum] = "b36a08a60bd1d8a27ec6e46aef21201b03d8f1b94d3e9eb25eec56918cf0484e"

URI_x86_64_v2_rust-crosstermion+tui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+tui-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+tui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+tui-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+tui-devel.sha256sum] = "2ec1dd44ea667058acc799cd85eaf303647d457c1a3d07932186c44e180908e5"

URI_x86_64_v2_rust-crosstermion+tui-react-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+tui-react-crossterm-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+tui-react-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+tui-react-crossterm-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+tui-react-crossterm-devel.sha256sum] = "8098437aa1905c35eb28ee9cd79b87027a72a426631b8eb29b7cc80f0c2ea1d2"

URI_x86_64_v2_rust-crosstermion+tui-react-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion+tui-react-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion+tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion+tui-react-devel}"
SRC_URI[x86_64_v2_rust-crosstermion+tui-react-devel.sha256sum] = "75b1010a8f9ac0576592e70e64ae09f218e393173c7f468ff90ddb895317cc95"

URI_x86_64_v2_rust-crosstermion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crosstermion-devel-0.14.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crosstermion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crosstermion-devel}"
SRC_URI[x86_64_v2_rust-crosstermion-devel.sha256sum] = "f669b125f8d3a33a5747f95c4bea6c2d681613fa91c9a1d05aacc7a54256d4c5"

URI_aarch64_rust-crosstermion+ansiterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+ansiterm-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+ansiterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+ansiterm-devel}"
SRC_URI[aarch64_rust-crosstermion+ansiterm-devel.sha256sum] = "fabe261fe4577c545a819348de7117351e9fda5a6d8252678d42158314c232f1"

URI_aarch64_rust-crosstermion+async-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+async-channel-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+async-channel-devel}"
SRC_URI[aarch64_rust-crosstermion+async-channel-devel.sha256sum] = "7802a4a4a159aeea003356399dc68e76512f0e52e1e5140f57ecf11d859b5d38"

URI_aarch64_rust-crosstermion+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+color-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+color-devel}"
SRC_URI[aarch64_rust-crosstermion+color-devel.sha256sum] = "cc7f77fcb979469bfc82445c136157ff4cb44b89713548d649275d9c6dee2f2a"

URI_aarch64_rust-crosstermion+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+crossterm-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+crossterm-devel}"
SRC_URI[aarch64_rust-crosstermion+crossterm-devel.sha256sum] = "e4eabaf308f65cad282003f95ade6c81c83bda270f9b8095834e5516cffe5f10"

URI_aarch64_rust-crosstermion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+default-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+default-devel}"
SRC_URI[aarch64_rust-crosstermion+default-devel.sha256sum] = "c1d66cc95c00095b80855a5456506a64ef9e9e423712785c979be9eda435e413"

URI_aarch64_rust-crosstermion+futures-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+futures-channel-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+futures-channel-devel}"
SRC_URI[aarch64_rust-crosstermion+futures-channel-devel.sha256sum] = "6eec6972413a5f13558cd033fc7956e90e15ee16b0526d3eeaaf816128c9cdcf"

URI_aarch64_rust-crosstermion+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+futures-core-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+futures-core-devel}"
SRC_URI[aarch64_rust-crosstermion+futures-core-devel.sha256sum] = "2ee23544634601a9abf8666fed5d6d2aee05bb55fb11748d95b6fff27e2743c2"

URI_aarch64_rust-crosstermion+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+futures-lite-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+futures-lite-devel}"
SRC_URI[aarch64_rust-crosstermion+futures-lite-devel.sha256sum] = "25f1ba014b8a9c60b4c95a307f87b21a41dcb3b37b7390f5897988cfd661cdb3"

URI_aarch64_rust-crosstermion+input-async-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+input-async-crossterm-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+input-async-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+input-async-crossterm-devel}"
SRC_URI[aarch64_rust-crosstermion+input-async-crossterm-devel.sha256sum] = "6d7c02518a45f1a36e10a06f5c9d18b29ad4efa956cf11eb22b25674c79e98c9"

URI_aarch64_rust-crosstermion+input-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+input-async-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+input-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+input-async-devel}"
SRC_URI[aarch64_rust-crosstermion+input-async-devel.sha256sum] = "4680484a658c87670a0fa50a8c8841f842e9d587febe15a33766a245d1c03552"

URI_aarch64_rust-crosstermion+tui-crossterm-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+tui-crossterm-backend-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+tui-crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+tui-crossterm-backend-devel}"
SRC_URI[aarch64_rust-crosstermion+tui-crossterm-backend-devel.sha256sum] = "0e725c0ca506977342784f2bcfb62d27d8b027b546999aa43119cd220312e7bc"

URI_aarch64_rust-crosstermion+tui-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+tui-crossterm-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+tui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+tui-crossterm-devel}"
SRC_URI[aarch64_rust-crosstermion+tui-crossterm-devel.sha256sum] = "7a39432ae5b8b61de720f57c78a18b2cdc5fb3cbcc2357c6bb479e39b77ff979"

URI_aarch64_rust-crosstermion+tui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+tui-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+tui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+tui-devel}"
SRC_URI[aarch64_rust-crosstermion+tui-devel.sha256sum] = "5f4817889d917bdd5ec9cb86b7c03767573329ba336a63f3a45efae6d468e899"

URI_aarch64_rust-crosstermion+tui-react-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+tui-react-crossterm-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+tui-react-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+tui-react-crossterm-devel}"
SRC_URI[aarch64_rust-crosstermion+tui-react-crossterm-devel.sha256sum] = "0b0094d35ea52a09657445dc5bfc72c83487a67c7a5cd804290821da621d486c"

URI_aarch64_rust-crosstermion+tui-react-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion+tui-react-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion+tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion+tui-react-devel}"
SRC_URI[aarch64_rust-crosstermion+tui-react-devel.sha256sum] = "974b507cc731995d8301a4b069db87b1e626bffb573b72375692ea3f81dd31b0"

URI_aarch64_rust-crosstermion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crosstermion-devel-0.14.0-4.el10_1.noarch.rpm;name=aarch64_rust-crosstermion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crosstermion-devel}"
SRC_URI[aarch64_rust-crosstermion-devel.sha256sum] = "35a72a7045aea4a41e30516e672b975688b9e27a215f181a78166ef219c3a247"

RDEPENDS:rust-crosstermion+ansiterm-devel = " \
 cargo \
 rust-ansiterm-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+async-channel-devel = " \
 cargo \
 rust-async-channel+default-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+color-devel = " \
 cargo \
 rust-crosstermion+ansiterm-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+crossterm-devel = " \
 cargo \
 rust-crossterm0.27+events-devel \
 rust-crossterm0.27-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+default-devel = " \
 cargo \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+futures-channel-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-crosstermion+futures-core-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-crosstermion+futures-lite-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-futures-lite+default-devel \
 "
RDEPENDS:rust-crosstermion+input-async-crossterm-devel = " \
 cargo \
 rust-crossterm0.27+event-stream-devel \
 rust-crossterm0.27+events-devel \
 rust-crossterm0.27-devel \
 rust-crosstermion+input-async-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+input-async-devel = " \
 cargo \
 rust-crosstermion+async-channel-devel \
 rust-crosstermion+futures-channel-devel \
 rust-crosstermion+futures-core-devel \
 rust-crosstermion+futures-lite-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+tui-crossterm-backend-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-ratatui0.26+crossterm-devel \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-crosstermion+tui-crossterm-devel = " \
 cargo \
 rust-crosstermion+crossterm-devel \
 rust-crosstermion+tui-crossterm-backend-devel \
 rust-crosstermion+tui-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+tui-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-crosstermion+tui-react-crossterm-devel = " \
 cargo \
 rust-crosstermion+crossterm-devel \
 rust-crosstermion+tui-crossterm-backend-devel \
 rust-crosstermion+tui-devel \
 rust-crosstermion+tui-react-devel \
 rust-crosstermion-devel \
 "
RDEPENDS:rust-crosstermion+tui-react-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-tui-react-devel \
 "
RDEPENDS:rust-crosstermion-devel = " \
 cargo \
 "
