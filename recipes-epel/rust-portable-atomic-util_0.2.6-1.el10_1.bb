# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portable-atomic-util"
PV = "0.2.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 rust-portable-atomic-util+std-devel \
 rust-portable-atomic-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-portable-atomic-util-0.2.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ee9c0a5a4d62cb03ee9644e92933efc17df20b010b0f29cc300f21e2e164701"

URI_x86_64_v2_rust-portable-atomic-util+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+alloc-devel-0.2.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+alloc-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+alloc-devel.sha256sum] = "36d0160b93f57863ce2d875ff66888fcc4de7fc511963c9c9b1e9be11decd893"

URI_x86_64_v2_rust-portable-atomic-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+default-devel-0.2.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+default-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+default-devel.sha256sum] = "15ec4bb71f88dcb8bc260d5e753405a151102ae3d394f339e0334a7171d6e9e6"

URI_x86_64_v2_rust-portable-atomic-util+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+std-devel-0.2.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+std-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+std-devel.sha256sum] = "ab0dc31e52c19a45a6b67c1139d8c6327d48fc1c312cc65ab4ccf9d058e1c542"

URI_x86_64_v2_rust-portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util-devel-0.2.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util-devel.sha256sum] = "08be549a989ba43a043a57965659bf3b1a429243d2b3026c05fb681325ff815c"

URI_aarch64_rust-portable-atomic-util+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+alloc-devel-0.2.6-1.el10_1.noarch.rpm;name=aarch64_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+alloc-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+alloc-devel.sha256sum] = "767037c1eccf173d84f3e4c7e1c1ecb1b674a6347ff88d248ed05ac30c82cc5a"

URI_aarch64_rust-portable-atomic-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+default-devel-0.2.6-1.el10_1.noarch.rpm;name=aarch64_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+default-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+default-devel.sha256sum] = "4a5cb481b73703fa1e868dbd5cfe392dbf8bb2fa3950ebfdfd0298737af94da3"

URI_aarch64_rust-portable-atomic-util+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+std-devel-0.2.6-1.el10_1.noarch.rpm;name=aarch64_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+std-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+std-devel.sha256sum] = "68aebebbdba3a304a9c4584c2b0e8c74efa73c3d72a0d456e6071cdda6eaf0f7"

URI_aarch64_rust-portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util-devel-0.2.6-1.el10_1.noarch.rpm;name=aarch64_rust-portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util-devel}"
SRC_URI[aarch64_rust-portable-atomic-util-devel.sha256sum] = "1a5381319cbcbcfd3380a18fc88ae910fcaa74951f41d4d1a49c59ad07fdf200"

RDEPENDS:rust-portable-atomic-util+alloc-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+default-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+std-devel = " \
 cargo \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util-devel = " \
 cargo \
 rust \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
