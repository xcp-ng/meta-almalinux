# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-ansible-posix"
PV = "2.2.1"
PR = "1.el10_3"
PACKAGES = " \
 ansible-collection-ansible-posix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-ansible-posix-2.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9962379f5840690b9a0e83643c5072c0ce3e9968a03dc1c2462e5b13951ce822"

URI_x86_64_v2_ansible-collection-ansible-posix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-ansible-posix-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-ansible-posix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-ansible-posix}"
SRC_URI[x86_64_v2_ansible-collection-ansible-posix.sha256sum] = "49a030a1d0495e07ac87a04a0e984ae096dc66d910ba764f99df3917dae66636"

URI_aarch64_ansible-collection-ansible-posix = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-ansible-posix-2.2.1-1.el10_3.noarch.rpm;name=aarch64_ansible-collection-ansible-posix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-ansible-posix}"
SRC_URI[aarch64_ansible-collection-ansible-posix.sha256sum] = "47db63ea7e94351a9811b18bb4a3e392e79c75af359590a9394dc7ceff6999ab"

RDEPENDS:ansible-collection-ansible-posix = " \
 ansible-core \
 "
