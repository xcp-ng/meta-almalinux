# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-opensearch-py"
PV = "3.2.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-opensearch-py \
 python3-opensearch-py+async \
 python3-opensearch-py+kerberos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-opensearch-py-3.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcce61f0ea5c192d0b054f7a9fa80e8bda2ef438f7c8eb671b87b081ba58410e"

URI_x86_64_v2_python3-opensearch-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py-3.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py}"
SRC_URI[x86_64_v2_python3-opensearch-py.sha256sum] = "7f621f569deff7f7d8da67bc3334a2a80e423c12f4a5bbf81aeb9d002c836fd2"

URI_x86_64_v2_python3-opensearch-py+async = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py+async-3.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py+async;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py+async}"
SRC_URI[x86_64_v2_python3-opensearch-py+async.sha256sum] = "c8677e13b949a0dac359eeb2a4b8fb8bb062f8c7ba84336d36810ea4d07331b6"

URI_x86_64_v2_python3-opensearch-py+kerberos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py+kerberos-3.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py+kerberos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py+kerberos}"
SRC_URI[x86_64_v2_python3-opensearch-py+kerberos.sha256sum] = "576f30ad1b2b9645bcdae547542e7a90ea15127f0e1ab9f15f79e09da774abc0"

URI_aarch64_python3-opensearch-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py-3.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-opensearch-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py}"
SRC_URI[aarch64_python3-opensearch-py.sha256sum] = "914900fa37a43c40caa20fbbb558b296f829ab1e20018000a45cf2027a038abe"

URI_aarch64_python3-opensearch-py+async = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py+async-3.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-opensearch-py+async;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py+async}"
SRC_URI[aarch64_python3-opensearch-py+async.sha256sum] = "d7e5e914d77286edfba7d9e07cd5e3fa6811392374a31352f301a709596abb66"

URI_aarch64_python3-opensearch-py+kerberos = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py+kerberos-3.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-opensearch-py+kerberos;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py+kerberos}"
SRC_URI[aarch64_python3-opensearch-py+kerberos.sha256sum] = "ac77bbaf3b4c4b048b3652b1ca689aace7b7d2cf8cd33aba2f451859788b920c"

RDEPENDS:python3-opensearch-py = " \
 python3 \
 python3-certifi \
 python3-dateutil \
 python3-events \
 python3-requests \
 python3-urllib3 \
 "
RDEPENDS:python3-opensearch-py+async = " \
 python3 \
 python3-aiohttp \
 python3-opensearch-py \
 "
RDEPENDS:python3-opensearch-py+kerberos = " \
 python3 \
 python3-opensearch-py \
 python3-requests-kerberos \
 "
