# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pt-sans-fonts"
PV = "20141121"
PR = "30.el10"
PACKAGES = " \
 pt-sans-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pt-sans-fonts-20141121-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "264093baaeffa673d7d44aa78422955e5eaaf2570dc2f4df4f31d82ee08e5853"

URI_x86_64_v2_pt-sans-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pt-sans-fonts-20141121-30.el10.noarch.rpm;name=x86_64_v2_pt-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pt-sans-fonts}"
SRC_URI[x86_64_v2_pt-sans-fonts.sha256sum] = "3cd70f2a67fd40bd30f17018d923e323daa19c59106fd461feb59c7dcc79d774"

URI_aarch64_pt-sans-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pt-sans-fonts-20141121-30.el10.noarch.rpm;name=aarch64_pt-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_pt-sans-fonts}"
SRC_URI[aarch64_pt-sans-fonts.sha256sum] = "3cd70f2a67fd40bd30f17018d923e323daa19c59106fd461feb59c7dcc79d774"

RDEPENDS:pt-sans-fonts = " \
 fonts-filesystem \
 "
