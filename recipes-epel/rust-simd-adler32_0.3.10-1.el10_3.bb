# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simd-adler32"
PV = "0.3.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-simd-adler32+const-generics-devel \
 rust-simd-adler32+default-devel \
 rust-simd-adler32+nightly-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-simd-adler32-0.3.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79b4964ea18a149e3d71e508a191ea05fc9181b3f3114b4fea111ad1ae60c003"

URI_x86_64_v2_rust-simd-adler32+const-generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+const-generics-devel-0.3.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+const-generics-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+const-generics-devel.sha256sum] = "9e2ea13281f30f635dda22278278b1f0f84e2807735e25990b7ab0daf4b6cef9"

URI_x86_64_v2_rust-simd-adler32+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+default-devel-0.3.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+default-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+default-devel.sha256sum] = "bdf0b54223b40164a004ac3aa2df6122e6156a0d2939a16035bf3f1f748fb1b0"

URI_x86_64_v2_rust-simd-adler32+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+nightly-devel-0.3.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+nightly-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+nightly-devel.sha256sum] = "f0a908f573707d76f53c1f4709087a22194b8f13fe9039421d079909f0ee5210"

URI_x86_64_v2_rust-simd-adler32+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+std-devel-0.3.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+std-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+std-devel.sha256sum] = "e7b09bd48125f329ee411852e708388209c18a00d88cf52da8630903cf14fd66"

URI_x86_64_v2_rust-simd-adler32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32-devel-0.3.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32-devel.sha256sum] = "35aace93912b42fb26760ac7c81c08042b79920ae62a5013ff000aca955ea29e"

URI_aarch64_rust-simd-adler32+const-generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+const-generics-devel-0.3.10-1.el10_3.noarch.rpm;name=aarch64_rust-simd-adler32+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+const-generics-devel}"
SRC_URI[aarch64_rust-simd-adler32+const-generics-devel.sha256sum] = "a1c97044b63d5b6569a655ad1326e6d73e8d50f01eaa1f5cb977ff5dcaf7f7bc"

URI_aarch64_rust-simd-adler32+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+default-devel-0.3.10-1.el10_3.noarch.rpm;name=aarch64_rust-simd-adler32+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+default-devel}"
SRC_URI[aarch64_rust-simd-adler32+default-devel.sha256sum] = "803f8d92ce3dbfe90b2c5111785f29fda11b8bc0a65d20ce1e69d5e439129d73"

URI_aarch64_rust-simd-adler32+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+nightly-devel-0.3.10-1.el10_3.noarch.rpm;name=aarch64_rust-simd-adler32+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+nightly-devel}"
SRC_URI[aarch64_rust-simd-adler32+nightly-devel.sha256sum] = "83cbc115626861560859bcce4df66035de1a09264602f500b1292b4ff4cf93b4"

URI_aarch64_rust-simd-adler32+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+std-devel-0.3.10-1.el10_3.noarch.rpm;name=aarch64_rust-simd-adler32+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+std-devel}"
SRC_URI[aarch64_rust-simd-adler32+std-devel.sha256sum] = "ece22f4d8b972ae0f6e37145ca0895ba86e370e54c9d331e603de51103432765"

URI_aarch64_rust-simd-adler32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32-devel-0.3.10-1.el10_3.noarch.rpm;name=aarch64_rust-simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32-devel}"
SRC_URI[aarch64_rust-simd-adler32-devel.sha256sum] = "2d1272243039c11b5e01d011643f1daeaaeeb2ff76aa3fae5e292c985002705f"

RDEPENDS:rust-simd-adler32+const-generics-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+default-devel = " \
 cargo \
 rust-simd-adler32+const-generics-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+nightly-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+std-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32-devel = " \
 cargo \
 "
