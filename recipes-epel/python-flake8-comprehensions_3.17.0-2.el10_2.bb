# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8-comprehensions"
PV = "3.17.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-flake8-comprehensions \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flake8-comprehensions-3.17.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae864bd79bb0e88f70bf1adeaecac1af5082369ac02722be78a06b1590b85825"

URI_x86_64_v2_python3-flake8-comprehensions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-comprehensions-3.17.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8-comprehensions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flake8-comprehensions}"
SRC_URI[x86_64_v2_python3-flake8-comprehensions.sha256sum] = "b76bf6ce2566aba4f7dbeecb2587501f6c4ff9cc7f41549b0b3a648c6c432731"

URI_aarch64_python3-flake8-comprehensions = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-comprehensions-3.17.0-2.el10_2.noarch.rpm;name=aarch64_python3-flake8-comprehensions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flake8-comprehensions}"
SRC_URI[aarch64_python3-flake8-comprehensions.sha256sum] = "869a42346b6e974afc2bc044ddfb3fac8fd64f66d2fba7d5161b78205c960044"

RDEPENDS:python3-flake8-comprehensions = " \
 python3 \
 python3-flake8 \
 "
