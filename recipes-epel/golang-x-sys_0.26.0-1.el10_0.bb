# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-x-sys"
PV = "0.26.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-x-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-x-sys-0.26.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f06cfe412ab648a5a49feb2e5d20691ddd722b19c28980a935365b98cd8746d2"

URI_x86_64_v2_golang-x-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-x-sys-devel-0.26.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-x-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-x-sys-devel}"
SRC_URI[x86_64_v2_golang-x-sys-devel.sha256sum] = "27c29794956b83a83728291bbcc51e4a6579bad784f4861a83856d62b47d250f"

URI_aarch64_golang-x-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-x-sys-devel-0.26.0-1.el10_0.noarch.rpm;name=aarch64_golang-x-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-x-sys-devel}"
SRC_URI[aarch64_golang-x-sys-devel.sha256sum] = "8a083ae04cdcbe50a22761b016bf2dcb39cf8dab0f893f17dd71487953f14baa"

RDEPENDS:golang-x-sys-devel = " \
 go-filesystem \
 "
