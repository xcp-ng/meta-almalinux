# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iscsi-initiator-utils"
PV = "6.2.1.11"
PR = "2.git4b3e853.el10"
PACKAGES = " \
 iscsi-initiator-utils \
 iscsi-initiator-utils-iscsiuio \
 python3-iscsi-initiator-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iscsi-initiator-utils-6.2.1.11-2.git4b3e853.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "651c555370b0dc07cc4c33fde218fc56d0578beea1e1c96f00152199b29f49db"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - iscsi-initiator-utils: (fedora-release-common >= 38-0.23 if fedora-release-common)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - iscsi-initiator-utils: (fedora-release-common >= 38-0.23 if fedora-release-common)

URI_x86_64_v2_iscsi-initiator-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iscsi-initiator-utils-6.2.1.11-2.git4b3e853.el10.x86_64_v2.rpm;name=x86_64_v2_iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iscsi-initiator-utils}"
SRC_URI[x86_64_v2_iscsi-initiator-utils.sha256sum] = "da9e4dd5ac040bd96a5a6c4b7e4db73bc0952572838881db81d6324991ceada5"

URI_x86_64_v2_iscsi-initiator-utils-iscsiuio = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iscsi-initiator-utils-iscsiuio-6.2.1.11-2.git4b3e853.el10.x86_64_v2.rpm;name=x86_64_v2_iscsi-initiator-utils-iscsiuio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iscsi-initiator-utils-iscsiuio}"
SRC_URI[x86_64_v2_iscsi-initiator-utils-iscsiuio.sha256sum] = "881b13eb0f125d4700634c75c8f0a8b17f8b2d7728da4560310df7a9430f5550"

URI_x86_64_v2_python3-iscsi-initiator-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-iscsi-initiator-utils-6.2.1.11-2.git4b3e853.el10.x86_64_v2.rpm;name=x86_64_v2_python3-iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-iscsi-initiator-utils}"
SRC_URI[x86_64_v2_python3-iscsi-initiator-utils.sha256sum] = "db2c6161a3313f7080e093857f74bb3bed4ffac6002dc5c03f81fbaa4173187b"

URI_aarch64_iscsi-initiator-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iscsi-initiator-utils-6.2.1.11-2.git4b3e853.el10.aarch64.rpm;name=aarch64_iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_iscsi-initiator-utils}"
SRC_URI[aarch64_iscsi-initiator-utils.sha256sum] = "7a72bbed92afa418c63196b3d9e17b7f17d14d1614a7ab7aaf5003caeb85e121"

URI_aarch64_iscsi-initiator-utils-iscsiuio = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iscsi-initiator-utils-iscsiuio-6.2.1.11-2.git4b3e853.el10.aarch64.rpm;name=aarch64_iscsi-initiator-utils-iscsiuio;unpack=0"
SRC_URI:append = " ${URI_aarch64_iscsi-initiator-utils-iscsiuio}"
SRC_URI[aarch64_iscsi-initiator-utils-iscsiuio.sha256sum] = "d6d3a9b76811d7dc7bdb44f6011f6515c8e665c830057c023f3acd416e103760"

URI_aarch64_python3-iscsi-initiator-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-iscsi-initiator-utils-6.2.1.11-2.git4b3e853.el10.aarch64.rpm;name=aarch64_python3-iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-iscsi-initiator-utils}"
SRC_URI[aarch64_python3-iscsi-initiator-utils.sha256sum] = "d7566932818da8ebeaab3fd649d412f7517f88d247957b0f99144219d158cfab"

RDEPENDS:iscsi-initiator-utils = " \
 bash \
 glibc \
 iscsi-initiator-utils-iscsiuio \
 isns-utils-libs \
 kmod-libs \
 libmount \
 openssl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:iscsi-initiator-utils-iscsiuio = " \
 bash \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 systemd-libs \
 "
RDEPENDS:python3-iscsi-initiator-utils = " \
 glibc \
 iscsi-initiator-utils \
 python3 \
 "
