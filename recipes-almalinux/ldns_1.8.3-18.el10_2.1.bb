# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ldns"
PV = "1.8.3"
PR = "18.el10_2.1"
PACKAGES = " \
 ldns \
 ldns-devel \
 ldns-doc \
 ldns-utils \
 perl-ldns \
 python3-ldns \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ldns-1.8.3-18.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "594dd7c1ab1c0ee10b15a33d7d01bd3b587219b93bb228e077304df461b8ad55"

URI_x86_64_v2_ldns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ldns-1.8.3-18.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_ldns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldns}"
SRC_URI[x86_64_v2_ldns.sha256sum] = "54132f86ac2afad31d6c23a0256b23e3447dc295ba347fbaf724b7307212f63e"

URI_x86_64_v2_ldns-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ldns-devel-1.8.3-18.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_ldns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldns-devel}"
SRC_URI[x86_64_v2_ldns-devel.sha256sum] = "f07d37538f41dd8a7904803e591382a489267f3fc8c5c2a83c1e178d355d5f55"

URI_x86_64_v2_ldns-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ldns-doc-1.8.3-18.el10_2.1.noarch.rpm;name=x86_64_v2_ldns-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldns-doc}"
SRC_URI[x86_64_v2_ldns-doc.sha256sum] = "d3a9d21b00192966f42699a0a0e9a7496c7988733f2e1989217611c1e00a2679"

URI_x86_64_v2_ldns-utils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ldns-utils-1.8.3-18.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_ldns-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldns-utils}"
SRC_URI[x86_64_v2_ldns-utils.sha256sum] = "ef8e1e4a07f6946a2ea8cf45f565ea4ef6df28ea235e9df117de42e772a1d50d"

URI_x86_64_v2_perl-ldns = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-ldns-1.8.3-18.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_perl-ldns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ldns}"
SRC_URI[x86_64_v2_perl-ldns.sha256sum] = "e4abb16ab8f650c797bd1dac30162a90ff6e56d5101359cde6ee550de744261a"

URI_x86_64_v2_python3-ldns = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-ldns-1.8.3-18.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-ldns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ldns}"
SRC_URI[x86_64_v2_python3-ldns.sha256sum] = "a86c4ab50612e4f84c958a2d12528cfdd587989d90a32486ba9d20841b9d68ed"

URI_aarch64_ldns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ldns-1.8.3-18.el10_2.1.aarch64.rpm;name=aarch64_ldns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldns}"
SRC_URI[aarch64_ldns.sha256sum] = "82094e59548b876f97fc8f220aadda9ca8820f1a31886fc80efeaa29e3b57e12"

URI_aarch64_ldns-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ldns-devel-1.8.3-18.el10_2.1.aarch64.rpm;name=aarch64_ldns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldns-devel}"
SRC_URI[aarch64_ldns-devel.sha256sum] = "14bdc4a32974d36749c491ead4e4425e88ca268127bdfe1d0aec145343e3fed8"

URI_aarch64_ldns-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ldns-doc-1.8.3-18.el10_2.1.noarch.rpm;name=aarch64_ldns-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldns-doc}"
SRC_URI[aarch64_ldns-doc.sha256sum] = "d3a9d21b00192966f42699a0a0e9a7496c7988733f2e1989217611c1e00a2679"

URI_aarch64_ldns-utils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ldns-utils-1.8.3-18.el10_2.1.aarch64.rpm;name=aarch64_ldns-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldns-utils}"
SRC_URI[aarch64_ldns-utils.sha256sum] = "d0b59142ba53f23cc8f8d71a097272b24511101fa0df689a1673a4774c2fb116"

URI_aarch64_perl-ldns = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-ldns-1.8.3-18.el10_2.1.aarch64.rpm;name=aarch64_perl-ldns;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ldns}"
SRC_URI[aarch64_perl-ldns.sha256sum] = "e0c8d41c915766a5bcb24e5a57771ec51ca44f1cf2939a8345ad21f35ad6a875"

URI_aarch64_python3-ldns = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-ldns-1.8.3-18.el10_2.1.aarch64.rpm;name=aarch64_python3-ldns;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ldns}"
SRC_URI[aarch64_python3-ldns.sha256sum] = "77c80e08dbfbc0aa0c7a7d0bc8175e0ba4bc5312bbdd682b3793c42fc2341873"

RDEPENDS:ldns = " \
 ca-certificates \
 glibc \
 openssl-libs \
 "
RDEPENDS:ldns-devel = " \
 bash \
 ldns \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ldns-doc = " \
 "
RDEPENDS:ldns-utils = " \
 glibc \
 ldns \
 libpcap \
 openssl-libs \
 "
RDEPENDS:perl-ldns = " \
 glibc \
 ldns \
 perl-AutoLoader \
 perl-Carp \
 perl-Exporter \
 perl-ldns \
 perl-libs \
 "
RDEPENDS:python3-ldns = " \
 glibc \
 ldns \
 openssl-libs \
 python3 \
 python3-libs \
 "
