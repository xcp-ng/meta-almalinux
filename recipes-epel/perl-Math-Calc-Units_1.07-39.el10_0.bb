# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Math-Calc-Units"
PV = "1.07"
PR = "39.el10_0"
PACKAGES = " \
 perl-Math-Calc-Units \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Math-Calc-Units-1.07-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07b297ef3d43d9f5af267232cf20ba494d866eae683a5392c9e75a5a74f7ab14"

URI_x86_64_v2_perl-Math-Calc-Units = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Math-Calc-Units-1.07-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Math-Calc-Units;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-Calc-Units}"
SRC_URI[x86_64_v2_perl-Math-Calc-Units.sha256sum] = "2c34e4912f0af745b9a9abb7cf673bb0be2d6e758ccf21ecfc10e1798ba75304"

URI_aarch64_perl-Math-Calc-Units = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Math-Calc-Units-1.07-39.el10_0.noarch.rpm;name=aarch64_perl-Math-Calc-Units;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-Calc-Units}"
SRC_URI[aarch64_perl-Math-Calc-Units.sha256sum] = "025cbc792015a0313f486c1f2e7b247bd54caa094fdd3b886c44ad6e3d9ed98d"

RDEPENDS:perl-Math-Calc-Units = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Math-Calc-Units \
 perl-Time-Local \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
