# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-amqp"
PV = "2.2.0"
PR = "2.el10_2"
PACKAGES = " \
 php-pecl-amqp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-amqp-2.2.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92b78a42d3f759c11a44a314399dcd9cfd93e7fba683febe019179d900b0d659"

URI_x86_64_v2_php-pecl-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-amqp-2.2.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-amqp}"
SRC_URI[x86_64_v2_php-pecl-amqp.sha256sum] = "afc731aa0640ee0a156e712baef003fed9a3ee1a96cf687a1354741b43b5e135"

URI_aarch64_php-pecl-amqp = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-amqp-2.2.0-2.el10_2.aarch64.rpm;name=aarch64_php-pecl-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-amqp}"
SRC_URI[aarch64_php-pecl-amqp.sha256sum] = "2e0ec1edcf6f708c5c9408c282b6f8e800e7dc9d028cfa76b29b01e1280b272a"

RDEPENDS:php-pecl-amqp = " \
 glibc \
 librabbitmq \
 php-common \
 "
