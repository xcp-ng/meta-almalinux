# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit-pkla-compat"
PV = "0.1"
PR = "30.el10"
PACKAGES = " \
 polkit-pkla-compat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/polkit-pkla-compat-0.1-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1f31d63d5d6d67570a809a9d7537924ec7ce85862b29f7c474f3592b3ea96c1"

URI_x86_64_v2_polkit-pkla-compat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/polkit-pkla-compat-0.1-30.el10.x86_64_v2.rpm;name=x86_64_v2_polkit-pkla-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-pkla-compat}"
SRC_URI[x86_64_v2_polkit-pkla-compat.sha256sum] = "a428797addc9848813c96db43ad26bf69e58b98a19ddb34c6955cf5a37b52140"

URI_aarch64_polkit-pkla-compat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/polkit-pkla-compat-0.1-30.el10.aarch64.rpm;name=aarch64_polkit-pkla-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-pkla-compat}"
SRC_URI[aarch64_polkit-pkla-compat.sha256sum] = "78a9b85fd838d3ae4d9a50dc2affe5cb1cedd7f880b4f1cb6e808d6a1cfea015"

RDEPENDS:polkit-pkla-compat = " \
 glib2 \
 glibc \
 polkit \
 polkit-libs \
 "
