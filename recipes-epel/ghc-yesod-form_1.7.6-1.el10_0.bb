# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-yesod-form"
PV = "1.7.6"
PR = "1.el10_0"
PACKAGES = " \
 ghc-yesod-form \
 ghc-yesod-form-devel \
 ghc-yesod-form-doc \
 ghc-yesod-form-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-yesod-form-1.7.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd83710befa507526647bb9fee04fa4a294070a63b40234a6537eee93b37045a"

URI_x86_64_v2_ghc-yesod-form = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-form-1.7.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-form;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-form}"
SRC_URI[x86_64_v2_ghc-yesod-form.sha256sum] = "058d9aea49e6fb87e329c3968075976506db21efc1dc8e59f3dcc0396818f796"

URI_x86_64_v2_ghc-yesod-form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-form-devel-1.7.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-form-devel}"
SRC_URI[x86_64_v2_ghc-yesod-form-devel.sha256sum] = "d5ddf8c613b993c3fce4da2040c39142997afcae5b0e8cd4b6d52bd4a84cb1d5"

URI_x86_64_v2_ghc-yesod-form-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-form-doc-1.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-yesod-form-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-form-doc}"
SRC_URI[x86_64_v2_ghc-yesod-form-doc.sha256sum] = "c230f2616406930d71200f35e1457b87456d1dcf7a7e853fcfc9b6366536ed65"

URI_x86_64_v2_ghc-yesod-form-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-yesod-form-prof-1.7.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-yesod-form-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-yesod-form-prof}"
SRC_URI[x86_64_v2_ghc-yesod-form-prof.sha256sum] = "8e904ee513561a91b1b8c85dd118483138f8a3cb32a3d40211ad00702c235dae"

URI_aarch64_ghc-yesod-form = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-form-1.7.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-form;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-form}"
SRC_URI[aarch64_ghc-yesod-form.sha256sum] = "bd0140fc90e124e975f3fb571637ac47ee7ab5d3e1d5883e9edf32d0ad02f4b5"

URI_aarch64_ghc-yesod-form-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-form-devel-1.7.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-form-devel}"
SRC_URI[aarch64_ghc-yesod-form-devel.sha256sum] = "9c205af90b643a6b06fb39e65e3e0cf909c9c0be6aeca6964879d8250528b2b4"

URI_aarch64_ghc-yesod-form-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-form-doc-1.7.6-1.el10_0.noarch.rpm;name=aarch64_ghc-yesod-form-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-form-doc}"
SRC_URI[aarch64_ghc-yesod-form-doc.sha256sum] = "e2270a41a3db9178447d1f769185f449478e5e7961d034dc45be0719ba20e287"

URI_aarch64_ghc-yesod-form-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-yesod-form-prof-1.7.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-yesod-form-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-yesod-form-prof}"
SRC_URI[aarch64_ghc-yesod-form-prof.sha256sum] = "427a737da1bbd879e27be86332cc2f1b0201abead2c5ca4324fb323945c67c56"

RDEPENDS:ghc-yesod-form = " \
 ghc-HUnit \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-attoparsec-iso8601 \
 ghc-auto-update \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bsb-http-chunked \
 ghc-byteable \
 ghc-byteorder \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-clientsession \
 ghc-colour \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypto-api \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-cryptonite \
 ghc-css-text \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-easy-file \
 ghc-email-validate \
 ghc-entropy \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-file-embed \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-api-data \
 ghc-http-date \
 ghc-http-types \
 ghc-http2 \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-conversion \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-lift-type \
 ghc-lifted-base \
 ghc-memory \
 ghc-monad-control \
 ghc-monad-logger \
 ghc-monad-loops \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-byte-order \
 ghc-network-control \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-path-pieces \
 ghc-pem \
 ghc-persistent \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-psqueues \
 ghc-random \
 ghc-recv \
 ghc-resource-pool \
 ghc-resourcet \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-setenv \
 ghc-shakespeare \
 ghc-silently \
 ghc-simple-sendfile \
 ghc-skein \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-stm-chans \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-tagsoup \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-time-manager \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-wai \
 ghc-wai-extra \
 ghc-wai-logger \
 ghc-warp \
 ghc-witherable \
 ghc-word8 \
 ghc-xss-sanitize \
 ghc-yesod-core \
 ghc-yesod-persistent \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-yesod-form-devel = " \
 ghc-aeson-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-blaze-builder-devel \
 ghc-blaze-html-devel \
 ghc-blaze-markup-devel \
 ghc-byteable-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-data-default-devel \
 ghc-email-validate-devel \
 ghc-network-uri-devel \
 ghc-persistent-devel \
 ghc-resourcet-devel \
 ghc-shakespeare-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-wai-devel \
 ghc-xss-sanitize-devel \
 ghc-yesod-core-devel \
 ghc-yesod-form \
 ghc-yesod-persistent-devel \
 "
RDEPENDS:ghc-yesod-form-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-yesod-form-prof = " \
 ghc-aeson-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-blaze-builder-prof \
 ghc-blaze-html-prof \
 ghc-blaze-markup-prof \
 ghc-byteable-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-data-default-prof \
 ghc-email-validate-prof \
 ghc-network-uri-prof \
 ghc-persistent-prof \
 ghc-resourcet-prof \
 ghc-shakespeare-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-wai-prof \
 ghc-xss-sanitize-prof \
 ghc-yesod-core-prof \
 ghc-yesod-form-devel \
 ghc-yesod-persistent-prof \
 "
