# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-std"
PV = "1.13.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-std+alloc-devel \
 rust-async-std+async-attributes-devel \
 rust-async-std+async-channel-devel \
 rust-async-std+async-global-executor-devel \
 rust-async-std+async-io-devel \
 rust-async-std+async-lock-devel \
 rust-async-std+async-process-devel \
 rust-async-std+attributes-devel \
 rust-async-std+crossbeam-utils-devel \
 rust-async-std+default-devel \
 rust-async-std+docs-devel \
 rust-async-std+futures-core-devel \
 rust-async-std+futures-io-devel \
 rust-async-std+futures-lite-devel \
 rust-async-std+io_safety-devel \
 rust-async-std+log-devel \
 rust-async-std+memchr-devel \
 rust-async-std+once_cell-devel \
 rust-async-std+pin-project-lite-devel \
 rust-async-std+pin-utils-devel \
 rust-async-std+slab-devel \
 rust-async-std+std-devel \
 rust-async-std+tokio1-devel \
 rust-async-std+unstable-devel \
 rust-async-std-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-std-1.13.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b136404c3ccfccd87c304f239aa01511f733a8d8c23574671534955015687f7"

URI_x86_64_v2_rust-async-std+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+alloc-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+alloc-devel}"
SRC_URI[x86_64_v2_rust-async-std+alloc-devel.sha256sum] = "5b884a1073dc444dd99bbda57ede673509a9111c414e1f618be4df91fed8eefb"

URI_x86_64_v2_rust-async-std+async-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-attributes-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-attributes-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-attributes-devel.sha256sum] = "f5f0c73049431bc51a38cedd8aa9e81bb4412944f7a26a5e90956b5add7af7c4"

URI_x86_64_v2_rust-async-std+async-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-channel-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-channel-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-channel-devel.sha256sum] = "1131bd694564dd3d25b975ba5ce5d28288ce5cb778d401f02cbbbcda61733fe5"

URI_x86_64_v2_rust-async-std+async-global-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-global-executor-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-global-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-global-executor-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-global-executor-devel.sha256sum] = "81d25c118d7d47f555aeac96e66b45bac3974ce482532df8731b0800679e6a1e"

URI_x86_64_v2_rust-async-std+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-io-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-io-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-io-devel.sha256sum] = "967aa6f643a924604d3eace7468e1f2f8d32e76961f2e7de10927259e5235697"

URI_x86_64_v2_rust-async-std+async-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-lock-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-lock-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-lock-devel.sha256sum] = "3129840185bafba0f4c2b57a4de46fee73e6870f614ec84816c7520f08383dc0"

URI_x86_64_v2_rust-async-std+async-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+async-process-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+async-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+async-process-devel}"
SRC_URI[x86_64_v2_rust-async-std+async-process-devel.sha256sum] = "49232b03451ea6672b80f19fe323429e37c6338ff2edec880d6975c774f15e0c"

URI_x86_64_v2_rust-async-std+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+attributes-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+attributes-devel}"
SRC_URI[x86_64_v2_rust-async-std+attributes-devel.sha256sum] = "0eb21c5ebe41b5822bf30f82b1f1dd14f47f779fa71e0f5aff99bd3c31cf5845"

URI_x86_64_v2_rust-async-std+crossbeam-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+crossbeam-utils-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+crossbeam-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+crossbeam-utils-devel}"
SRC_URI[x86_64_v2_rust-async-std+crossbeam-utils-devel.sha256sum] = "4abdfb3dcff090782295af8e42b950b2d44473852d928d2a3be96901eb1cfe1d"

URI_x86_64_v2_rust-async-std+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+default-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+default-devel}"
SRC_URI[x86_64_v2_rust-async-std+default-devel.sha256sum] = "a43748e0c8444cbffde2d3f15bcdf7550ec481b3b087814dd47acc551775d9f5"

URI_x86_64_v2_rust-async-std+docs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+docs-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+docs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+docs-devel}"
SRC_URI[x86_64_v2_rust-async-std+docs-devel.sha256sum] = "5e1bc5444d27462e33666c85e323964689a62586c92759e97206f8327aa9e656"

URI_x86_64_v2_rust-async-std+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+futures-core-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+futures-core-devel}"
SRC_URI[x86_64_v2_rust-async-std+futures-core-devel.sha256sum] = "829815be1a5d8f388a0b7c40fc1d4753226f5a6b71d22ad7212a03c1ec20298a"

URI_x86_64_v2_rust-async-std+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+futures-io-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+futures-io-devel}"
SRC_URI[x86_64_v2_rust-async-std+futures-io-devel.sha256sum] = "38a5b0b0be9c8b251376ad9d712041cf168e29dbb2664920d681fb855d6f5218"

URI_x86_64_v2_rust-async-std+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+futures-lite-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-async-std+futures-lite-devel.sha256sum] = "1e91622df53eda47c9e7b6a499dc23e431d4f624d681d156fed1b8906ad81599"

URI_x86_64_v2_rust-async-std+io_safety-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+io_safety-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+io_safety-devel}"
SRC_URI[x86_64_v2_rust-async-std+io_safety-devel.sha256sum] = "1e9a711afe77b1a54602cce58fa26e832bfe273eab4dc43c517d4399e5a8265d"

URI_x86_64_v2_rust-async-std+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+log-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+log-devel}"
SRC_URI[x86_64_v2_rust-async-std+log-devel.sha256sum] = "263cac7a6ff8c8eee8e49a9fbbc295a86769b6907dd90b00576e6772e0d43772"

URI_x86_64_v2_rust-async-std+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+memchr-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+memchr-devel}"
SRC_URI[x86_64_v2_rust-async-std+memchr-devel.sha256sum] = "24eef43926dee9c2b328ff1b76f994c40cb37b6fccce427c126893d8ce5d108f"

URI_x86_64_v2_rust-async-std+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+once_cell-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+once_cell-devel}"
SRC_URI[x86_64_v2_rust-async-std+once_cell-devel.sha256sum] = "b9308ef62d8723f2b532283b1e64651956ad7f69716509c845a6252a40226afd"

URI_x86_64_v2_rust-async-std+pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+pin-project-lite-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-async-std+pin-project-lite-devel.sha256sum] = "bc919f6a98bc58f3d3d2865fddaa277c59216dae2593e73ba056959bba43c359"

URI_x86_64_v2_rust-async-std+pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+pin-utils-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+pin-utils-devel}"
SRC_URI[x86_64_v2_rust-async-std+pin-utils-devel.sha256sum] = "1823f1a8b1cba1cd8805b065df5555f9412d6117d40750b8b4aeaf79472a58e7"

URI_x86_64_v2_rust-async-std+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+slab-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+slab-devel}"
SRC_URI[x86_64_v2_rust-async-std+slab-devel.sha256sum] = "960c7ab321c87fff62cf7643cfddd0efb732099ed3c398af098017b5b1059cdb"

URI_x86_64_v2_rust-async-std+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+std-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+std-devel}"
SRC_URI[x86_64_v2_rust-async-std+std-devel.sha256sum] = "5c10d9363bcb4869c1dac53ca33c1bff810543cf54c4b43ae45710ec42c98cda"

URI_x86_64_v2_rust-async-std+tokio1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+tokio1-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+tokio1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+tokio1-devel}"
SRC_URI[x86_64_v2_rust-async-std+tokio1-devel.sha256sum] = "31f867b7e0b6cf0029437d4351135aaa8f0d7f2ab28c395cd01254cc3e49f6cf"

URI_x86_64_v2_rust-async-std+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std+unstable-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std+unstable-devel}"
SRC_URI[x86_64_v2_rust-async-std+unstable-devel.sha256sum] = "d8dc2f2ad4c9a0491b8e058f772df20071aabcd88e040c953df1d2e756b06fe8"

URI_x86_64_v2_rust-async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-std-devel-1.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-std-devel}"
SRC_URI[x86_64_v2_rust-async-std-devel.sha256sum] = "bbfba38930704c4690954a5154f59de9bb07a141c6dddaff22dd8b672d7fc5ca"

URI_aarch64_rust-async-std+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+alloc-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+alloc-devel}"
SRC_URI[aarch64_rust-async-std+alloc-devel.sha256sum] = "83878d9ada6bc36a62122fc901c39cb50e17afa2eb11a0b30407a5907b1d0400"

URI_aarch64_rust-async-std+async-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-attributes-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+async-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-attributes-devel}"
SRC_URI[aarch64_rust-async-std+async-attributes-devel.sha256sum] = "f81c10d3f25dc8da68b80aaa62de380935c78db6b3b27a10b6443d608bfa66f8"

URI_aarch64_rust-async-std+async-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-channel-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-channel-devel}"
SRC_URI[aarch64_rust-async-std+async-channel-devel.sha256sum] = "8d5a6d895774dc60b1863d59b65429ca718184c4fc1d3b68afdbf80315df1687"

URI_aarch64_rust-async-std+async-global-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-global-executor-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+async-global-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-global-executor-devel}"
SRC_URI[aarch64_rust-async-std+async-global-executor-devel.sha256sum] = "cfbb98df065bbb0b7a7dd227cf8809a7a56331843bdc7fe8f6bb08c3b48e0cda"

URI_aarch64_rust-async-std+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-io-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-io-devel}"
SRC_URI[aarch64_rust-async-std+async-io-devel.sha256sum] = "6d558ff7f87f9e0b5529021f0dae6fe274e5026a8aba48a0a02f974c3f138be9"

URI_aarch64_rust-async-std+async-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-lock-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-lock-devel}"
SRC_URI[aarch64_rust-async-std+async-lock-devel.sha256sum] = "b0ae3bdf1e518279ad121e92e9ed13e0a8dbf1a88a075014a63ce1095d9a1a6d"

URI_aarch64_rust-async-std+async-process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+async-process-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+async-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+async-process-devel}"
SRC_URI[aarch64_rust-async-std+async-process-devel.sha256sum] = "91cfbd89d0b8ad57e1b793dfa60349e897c7d462512967234d6deef6e7e9e660"

URI_aarch64_rust-async-std+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+attributes-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+attributes-devel}"
SRC_URI[aarch64_rust-async-std+attributes-devel.sha256sum] = "b171f05e7d39267150caf969fba3ebb2b7d2a730124ac396f5e795636336fafd"

URI_aarch64_rust-async-std+crossbeam-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+crossbeam-utils-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+crossbeam-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+crossbeam-utils-devel}"
SRC_URI[aarch64_rust-async-std+crossbeam-utils-devel.sha256sum] = "f11179e46d20479e63e5a74a155038942ae5c5b7e0867db573ba6c7f69a3d569"

URI_aarch64_rust-async-std+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+default-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+default-devel}"
SRC_URI[aarch64_rust-async-std+default-devel.sha256sum] = "73c85b2814d9e3ba2bf48c9c1bef5d86c0afaf0a6d6d219ddd0d331bff048f9d"

URI_aarch64_rust-async-std+docs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+docs-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+docs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+docs-devel}"
SRC_URI[aarch64_rust-async-std+docs-devel.sha256sum] = "1043263793cf6e9607962f96e0b072c75cfdc24c7044426922ae3822ab0e36b5"

URI_aarch64_rust-async-std+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+futures-core-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+futures-core-devel}"
SRC_URI[aarch64_rust-async-std+futures-core-devel.sha256sum] = "7679a704bb9fae6b1d6b358030343814081ad6723dec77bcf0b466fd32a0c442"

URI_aarch64_rust-async-std+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+futures-io-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+futures-io-devel}"
SRC_URI[aarch64_rust-async-std+futures-io-devel.sha256sum] = "437e35317672442a2c0502584284838fa71fa629716aae9926f5841d551b70bf"

URI_aarch64_rust-async-std+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+futures-lite-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+futures-lite-devel}"
SRC_URI[aarch64_rust-async-std+futures-lite-devel.sha256sum] = "e9a86e1ab0efb7631a7a7d1011d55ebe8fd1fd644434846ad253a1455e6fe2aa"

URI_aarch64_rust-async-std+io_safety-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+io_safety-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+io_safety-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+io_safety-devel}"
SRC_URI[aarch64_rust-async-std+io_safety-devel.sha256sum] = "777d165783adf802edbd5d295fad71b2c15f4db93e974d32ad5f26d21d9b2c12"

URI_aarch64_rust-async-std+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+log-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+log-devel}"
SRC_URI[aarch64_rust-async-std+log-devel.sha256sum] = "c582a695dc73e5c9143f4d8b6920049b5eda1939314218ce33c572129cc7f24e"

URI_aarch64_rust-async-std+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+memchr-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+memchr-devel}"
SRC_URI[aarch64_rust-async-std+memchr-devel.sha256sum] = "25f2cd73ed31857a6ab06861edf49a7e5ac98c1b18ef02e8dc62b30378693202"

URI_aarch64_rust-async-std+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+once_cell-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+once_cell-devel}"
SRC_URI[aarch64_rust-async-std+once_cell-devel.sha256sum] = "c74f502124192f1890430c72c1ffeab90dcb1478d5df8aec02bc4dbabc8b7d70"

URI_aarch64_rust-async-std+pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+pin-project-lite-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+pin-project-lite-devel}"
SRC_URI[aarch64_rust-async-std+pin-project-lite-devel.sha256sum] = "a15704bf7335a3f62a1d2532185a58e98dcc757aaf867e65de81194dbc98278e"

URI_aarch64_rust-async-std+pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+pin-utils-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+pin-utils-devel}"
SRC_URI[aarch64_rust-async-std+pin-utils-devel.sha256sum] = "e0a4af519af637937166f7b0ed9b3e3ade0673c0fd7ac4d574659e8e57b0109d"

URI_aarch64_rust-async-std+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+slab-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+slab-devel}"
SRC_URI[aarch64_rust-async-std+slab-devel.sha256sum] = "fcda361c62dc993e43078b8f70a96f2c8730a4c9d96dc4bff3349d7a6cd0c253"

URI_aarch64_rust-async-std+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+std-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+std-devel}"
SRC_URI[aarch64_rust-async-std+std-devel.sha256sum] = "c6dd8a1f99a36173c98da171479e97bea6c1d7115f8e1c9c7fd8400cceb532d2"

URI_aarch64_rust-async-std+tokio1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+tokio1-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+tokio1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+tokio1-devel}"
SRC_URI[aarch64_rust-async-std+tokio1-devel.sha256sum] = "1e4906b9b563592d6e76927a9cb7429e502707f832c9bfe4ea0b47f02925c648"

URI_aarch64_rust-async-std+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std+unstable-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std+unstable-devel}"
SRC_URI[aarch64_rust-async-std+unstable-devel.sha256sum] = "96d44ecfed35b318b0c3ce48f7461f725ae82b6ac6f11d8690449318a04ae501"

URI_aarch64_rust-async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-std-devel-1.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-std-devel}"
SRC_URI[aarch64_rust-async-std-devel.sha256sum] = "a6fdb8078f95309470b2b46f7a9001651d498b4166edfab346344750163a36a8"

RDEPENDS:rust-async-std+alloc-devel = " \
 cargo \
 rust-async-std+pin-project-lite-devel \
 rust-async-std-devel \
 rust-futures-core+alloc-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-async-std+async-attributes-devel = " \
 cargo \
 rust-async-attributes+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+async-channel-devel = " \
 cargo \
 rust-async-channel+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+async-global-executor-devel = " \
 cargo \
 rust-async-global-executor2+async-io-devel \
 rust-async-global-executor2+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+async-io-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+async-lock-devel = " \
 cargo \
 rust-async-lock+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+async-process-devel = " \
 cargo \
 rust-async-process+default-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+attributes-devel = " \
 cargo \
 rust-async-std+async-attributes-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+crossbeam-utils-devel = " \
 cargo \
 rust-async-std-devel \
 rust-crossbeam-utils+default-devel \
 "
RDEPENDS:rust-async-std+default-devel = " \
 cargo \
 rust-async-std+async-global-executor-devel \
 rust-async-std+async-io-devel \
 rust-async-std+futures-lite-devel \
 rust-async-std+log-devel \
 rust-async-std+pin-project-lite-devel \
 rust-async-std+std-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+docs-devel = " \
 cargo \
 rust-async-std+attributes-devel \
 rust-async-std+default-devel \
 rust-async-std+unstable-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+futures-core-devel = " \
 cargo \
 rust-async-std-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-async-std+futures-io-devel = " \
 cargo \
 rust-async-std-devel \
 rust-futures-io+default-devel \
 "
RDEPENDS:rust-async-std+futures-lite-devel = " \
 cargo \
 rust-async-std-devel \
 rust-futures-lite+default-devel \
 "
RDEPENDS:rust-async-std+io_safety-devel = " \
 cargo \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+log-devel = " \
 cargo \
 rust-async-std-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-async-std+memchr-devel = " \
 cargo \
 rust-async-std-devel \
 rust-memchr+default-devel \
 "
RDEPENDS:rust-async-std+once_cell-devel = " \
 cargo \
 rust-async-std-devel \
 rust-once_cell+default-devel \
 "
RDEPENDS:rust-async-std+pin-project-lite-devel = " \
 cargo \
 rust-async-std-devel \
 rust-pin-project-lite+default-devel \
 "
RDEPENDS:rust-async-std+pin-utils-devel = " \
 cargo \
 rust-async-std-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-async-std+slab-devel = " \
 cargo \
 rust-async-std-devel \
 rust-slab+default-devel \
 "
RDEPENDS:rust-async-std+std-devel = " \
 cargo \
 rust-async-std+alloc-devel \
 rust-async-std+async-channel-devel \
 rust-async-std+async-lock-devel \
 rust-async-std+crossbeam-utils-devel \
 rust-async-std+futures-io-devel \
 rust-async-std+memchr-devel \
 rust-async-std+once_cell-devel \
 rust-async-std+pin-utils-devel \
 rust-async-std+slab-devel \
 rust-async-std-devel \
 rust-futures-core+std-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-async-std+tokio1-devel = " \
 cargo \
 rust-async-global-executor2+async-io-devel \
 rust-async-global-executor2+default-devel \
 rust-async-global-executor2+tokio-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std+unstable-devel = " \
 cargo \
 rust-async-std+async-io-devel \
 rust-async-std+async-process-devel \
 rust-async-std+std-devel \
 rust-async-std-devel \
 "
RDEPENDS:rust-async-std-devel = " \
 cargo \
 rust \
 "
