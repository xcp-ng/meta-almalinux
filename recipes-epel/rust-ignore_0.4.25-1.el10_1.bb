# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ignore"
PV = "0.4.25"
PR = "1.el10_1"
PACKAGES = " \
 rust-ignore+default-devel \
 rust-ignore+simd-accel-devel \
 rust-ignore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ignore-0.4.25-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb9fb5aafe02d49486e5fc65fdd5fc6a1c00bc8c3f3520ef0263f6b72aba6c1d"

URI_x86_64_v2_rust-ignore+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore+default-devel-0.4.25-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore+default-devel}"
SRC_URI[x86_64_v2_rust-ignore+default-devel.sha256sum] = "f87bb2d469bdafb3c2d93f4940cc292c4f8237598890c5ad6f6dd0350a43ed2e"

URI_x86_64_v2_rust-ignore+simd-accel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore+simd-accel-devel-0.4.25-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore+simd-accel-devel}"
SRC_URI[x86_64_v2_rust-ignore+simd-accel-devel.sha256sum] = "e0acd8085d75a0d2420f950763665814f4a1ff6c45cb9475994547f6d145c347"

URI_x86_64_v2_rust-ignore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore-devel-0.4.25-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore-devel}"
SRC_URI[x86_64_v2_rust-ignore-devel.sha256sum] = "a10c707f31bb919f3c74b40f49cd649323c2ced67bce5acc508c2b9a82772bbb"

URI_aarch64_rust-ignore+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore+default-devel-0.4.25-1.el10_1.noarch.rpm;name=aarch64_rust-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore+default-devel}"
SRC_URI[aarch64_rust-ignore+default-devel.sha256sum] = "f40af815e7c6ccefc13314070e165839cd41762a60bc5444ed79d63b6a2f0631"

URI_aarch64_rust-ignore+simd-accel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore+simd-accel-devel-0.4.25-1.el10_1.noarch.rpm;name=aarch64_rust-ignore+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore+simd-accel-devel}"
SRC_URI[aarch64_rust-ignore+simd-accel-devel.sha256sum] = "b70c79dd68a13b2c42e8fdc24171ac02daccfeae498036bf76aa67405e6c37cc"

URI_aarch64_rust-ignore-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore-devel-0.4.25-1.el10_1.noarch.rpm;name=aarch64_rust-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore-devel}"
SRC_URI[aarch64_rust-ignore-devel.sha256sum] = "3b9448dcdf74721ef16c31af8962198ebea09c5efa0faaabdc79076a79b38d6f"

RDEPENDS:rust-ignore+default-devel = " \
 cargo \
 rust-ignore-devel \
 "
RDEPENDS:rust-ignore+simd-accel-devel = " \
 cargo \
 rust-ignore-devel \
 "
RDEPENDS:rust-ignore-devel = " \
 cargo \
 rust-crossbeam-deque+default-devel \
 rust-globset+default-devel \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-same-file+default-devel \
 rust-walkdir+default-devel \
 "
