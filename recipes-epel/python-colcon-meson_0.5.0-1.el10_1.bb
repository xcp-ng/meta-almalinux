# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-meson"
PV = "0.5.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-meson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-meson-0.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36a509292a9dfb5af098446f2f1413514a03b639f234a5dcf6435b7d5ed953f1"

URI_x86_64_v2_python3-colcon-meson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-meson-0.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-meson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-meson}"
SRC_URI[x86_64_v2_python3-colcon-meson.sha256sum] = "35a03dafe0d5231406fe7ad5d4149afcc9d0d051bdbee60468044d193f6c33e3"

URI_aarch64_python3-colcon-meson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-meson-0.5.0-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-meson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-meson}"
SRC_URI[aarch64_python3-colcon-meson.sha256sum] = "f3f9105187d0ead470f2167615e92a25ad39d45c3a05325f0b352653f1fb0d96"

RDEPENDS:python3-colcon-meson = " \
 meson \
 python3 \
 python3-colcon-core \
 python3-colcon-library-path \
 "
