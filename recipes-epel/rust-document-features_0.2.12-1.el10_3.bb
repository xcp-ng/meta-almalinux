# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-document-features"
PV = "0.2.12"
PR = "1.el10_3"
PACKAGES = " \
 rust-document-features+default-devel \
 rust-document-features+self-test-devel \
 rust-document-features-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-document-features-0.2.12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13b8244114612d566c1e4adeb79e2bd83cc1d92181dc3798be6324a0e6adb888"

URI_x86_64_v2_rust-document-features+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-document-features+default-devel-0.2.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-document-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-document-features+default-devel}"
SRC_URI[x86_64_v2_rust-document-features+default-devel.sha256sum] = "9afe979579c8f6d49f572a240eeebc1b8faf7f3df08fb3fcc97f74dc8e006917"

URI_x86_64_v2_rust-document-features+self-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-document-features+self-test-devel-0.2.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-document-features+self-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-document-features+self-test-devel}"
SRC_URI[x86_64_v2_rust-document-features+self-test-devel.sha256sum] = "f3a1cfa8e0cd039a05e7abfe4523a90698497c7405d9d5601f9b9c647963ad67"

URI_x86_64_v2_rust-document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-document-features-devel-0.2.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-document-features-devel}"
SRC_URI[x86_64_v2_rust-document-features-devel.sha256sum] = "2686d0043b7e874b7dadd3a1238976d5dce3270968d2a7eb373be68e9a1af967"

URI_aarch64_rust-document-features+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-document-features+default-devel-0.2.12-1.el10_3.noarch.rpm;name=aarch64_rust-document-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-document-features+default-devel}"
SRC_URI[aarch64_rust-document-features+default-devel.sha256sum] = "78803dd95e7e0a1a4db17cde55bbcd8968a1c58819c0dd00433282cac04651a7"

URI_aarch64_rust-document-features+self-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-document-features+self-test-devel-0.2.12-1.el10_3.noarch.rpm;name=aarch64_rust-document-features+self-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-document-features+self-test-devel}"
SRC_URI[aarch64_rust-document-features+self-test-devel.sha256sum] = "8cceb61b4afbd3081e43110e2318d5247e3ffad407070efc51889521f5a841e3"

URI_aarch64_rust-document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-document-features-devel-0.2.12-1.el10_3.noarch.rpm;name=aarch64_rust-document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-document-features-devel}"
SRC_URI[aarch64_rust-document-features-devel.sha256sum] = "a4c6198238e0da984273c66f4aa8110df0a05e2bcea4e3eca1b8617fadbfc9bf"

RDEPENDS:rust-document-features+default-devel = " \
 cargo \
 rust-document-features-devel \
 "
RDEPENDS:rust-document-features+self-test-devel = " \
 cargo \
 rust-document-features-devel \
 "
RDEPENDS:rust-document-features-devel = " \
 cargo \
 rust \
 rust-litrs+default-devel \
 "
