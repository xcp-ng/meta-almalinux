# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nkf"
PE = "1"
PV = "2.1.4"
PR = "35.el10_1"
PACKAGES = " \
 nkf \
 perl-NKF \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nkf-2.1.4-35.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88b417a16254555e46aa83ab8961c6aebac4b8b8bf18299c930e5f80d94b5f8b"

URI_x86_64_v2_nkf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nkf-2.1.4-35.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nkf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nkf}"
SRC_URI[x86_64_v2_nkf.sha256sum] = "6e73483914dfc762721232578d91a20a23554bf026d4822cbdf8ba8c651a10ef"

URI_x86_64_v2_perl-NKF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-NKF-2.1.4-35.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-NKF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-NKF}"
SRC_URI[x86_64_v2_perl-NKF.sha256sum] = "4ee2d9ceb1f586eeffc2d854dffe0db3c2f006bfd49b859e90433b79d41026b4"

URI_aarch64_nkf = "${EPEL_MIRROR}/aarch64/Packages/n/nkf-2.1.4-35.el10_1.aarch64.rpm;name=aarch64_nkf;unpack=0"
SRC_URI:append = " ${URI_aarch64_nkf}"
SRC_URI[aarch64_nkf.sha256sum] = "385fba5d70c2517d32359cbe88f4012a909c2a88f5b8e8a417f836b756cb1b46"

URI_aarch64_perl-NKF = "${EPEL_MIRROR}/aarch64/Packages/p/perl-NKF-2.1.4-35.el10_1.aarch64.rpm;name=aarch64_perl-NKF;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-NKF}"
SRC_URI[aarch64_perl-NKF.sha256sum] = "d5976a1ac3c52134f5c526cc4580fe647b24107429a5d36fa5cd57f845384bef"

RDEPENDS:nkf = " \
 glibc \
 "
RDEPENDS:perl-NKF = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
