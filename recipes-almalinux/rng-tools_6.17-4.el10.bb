# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rng-tools"
PV = "6.17"
PR = "4.el10"
PACKAGES = " \
 rng-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rng-tools-6.17-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a410a4771d933a29d79d2005f730c0215e29baf8edd54345c3b9b247f79d87f"

URI_x86_64_v2_rng-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rng-tools-6.17-4.el10.x86_64_v2.rpm;name=x86_64_v2_rng-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rng-tools}"
SRC_URI[x86_64_v2_rng-tools.sha256sum] = "178b9e41ad934abb59b484d7271adfe34340774e03227f25270fe5aff7d8e2d2"

URI_aarch64_rng-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rng-tools-6.17-4.el10.aarch64.rpm;name=aarch64_rng-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_rng-tools}"
SRC_URI[aarch64_rng-tools.sha256sum] = "1c43fc70c73f2e9dd7bd37dfc6419d83b9dec07e0287e08c5a46c8d2487daee3"

RDEPENDS:rng-tools = " \
 bash \
 glibc \
 jansson \
 jitterentropy \
 libcap \
 openssl-libs \
 selinux-policy \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
