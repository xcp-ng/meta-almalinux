# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxmlb"
PV = "0.3.15"
PR = "7.el10"
PACKAGES = " \
 libxmlb \
 libxmlb-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libxmlb-0.3.15-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07f30dd1fad717874080f7c6d7fc9eb05b27cec81f6019f5bb9d06e57859f7b7"

URI_x86_64_v2_libxmlb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libxmlb-0.3.15-7.el10.x86_64_v2.rpm;name=x86_64_v2_libxmlb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxmlb}"
SRC_URI[x86_64_v2_libxmlb.sha256sum] = "6a56e3472cbc7cd1faf16d60b3df1c2fd3dfe8f53e9dd3e6e696814d06742cb3"

URI_x86_64_v2_libxmlb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxmlb-devel-0.3.15-7.el10.x86_64_v2.rpm;name=x86_64_v2_libxmlb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxmlb-devel}"
SRC_URI[x86_64_v2_libxmlb-devel.sha256sum] = "509628fa9ad9fc8f0fc786856a40956885ee600cf325f8cd81a874df2d89469a"

URI_aarch64_libxmlb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libxmlb-0.3.15-7.el10.aarch64.rpm;name=aarch64_libxmlb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxmlb}"
SRC_URI[aarch64_libxmlb.sha256sum] = "dc58590878607420565d61912c02f1913e6a3c51f56caa704327a36896993220"

URI_aarch64_libxmlb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxmlb-devel-0.3.15-7.el10.aarch64.rpm;name=aarch64_libxmlb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxmlb-devel}"
SRC_URI[aarch64_libxmlb-devel.sha256sum] = "f98ee2c01a52de8380cb4629287ac696b7aa8e166855eaf43fa97ccaf54adf3e"

RDEPENDS:libxmlb = " \
 glib2 \
 glibc \
 libgcc \
 libzstd \
 shared-mime-info \
 xz-libs \
 "
RDEPENDS:libxmlb-devel = " \
 glib2-devel \
 libxmlb \
 libzstd-devel \
 pkgconf-pkg-config \
 xz-devel \
 "
