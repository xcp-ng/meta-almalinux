# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stress-ng"
PV = "0.18.06"
PR = "10.el10"
PACKAGES = " \
 stress-ng \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/stress-ng-0.18.06-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "275b39b7c96ddc6c0b6d5bad6b31a7e1eda0d4c3671583ae3fd3d70d867fa477"

URI_x86_64_v2_stress-ng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/stress-ng-0.18.06-10.el10.x86_64_v2.rpm;name=x86_64_v2_stress-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stress-ng}"
SRC_URI[x86_64_v2_stress-ng.sha256sum] = "1ddbc2fbd80c6cdc5389cbaa163036a4d52074d758fdff1ca9d7d38ff459b371"

URI_aarch64_stress-ng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/stress-ng-0.18.06-10.el10.aarch64.rpm;name=aarch64_stress-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_stress-ng}"
SRC_URI[aarch64_stress-ng.sha256sum] = "82e58799858dc3a82b78a78c3833d877b11132a5e0a9a4ca99c6bdb789ecb32f"

RDEPENDS:stress-ng = " \
 Judy \
 glibc \
 libxcrypt \
 lksctp-tools \
 zlib-ng-compat \
 "
