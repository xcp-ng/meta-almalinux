# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-string_cache_codegen"
PV = "0.6.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-string_cache_codegen+default-devel \
 rust-string_cache_codegen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-string_cache_codegen-0.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3553758a199cdf999ae188a654567ac713c10b3695fb90df8882c9baf3cf677f"

URI_x86_64_v2_rust-string_cache_codegen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache_codegen+default-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache_codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache_codegen+default-devel}"
SRC_URI[x86_64_v2_rust-string_cache_codegen+default-devel.sha256sum] = "9fa66cd289235a8c26b817c3b2de98ebc9e65f8b91f4b2384e3d05eb683384fa"

URI_x86_64_v2_rust-string_cache_codegen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache_codegen-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache_codegen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache_codegen-devel}"
SRC_URI[x86_64_v2_rust-string_cache_codegen-devel.sha256sum] = "7a9d3d0d0a03b82b81f319c558e20d531f0c454de15845da7c6e4a0ce8fa2d69"

URI_aarch64_rust-string_cache_codegen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache_codegen+default-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache_codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache_codegen+default-devel}"
SRC_URI[aarch64_rust-string_cache_codegen+default-devel.sha256sum] = "0844d7b81d9277d452fa80b69838204d4c9c56e75c1b728e6e119d3c2dfbfa8a"

URI_aarch64_rust-string_cache_codegen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache_codegen-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache_codegen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache_codegen-devel}"
SRC_URI[aarch64_rust-string_cache_codegen-devel.sha256sum] = "75879f96cb0b2bac743f6771b424fc1aae2e14290552a23b033e045c511ac6aa"

RDEPENDS:rust-string_cache_codegen+default-devel = " \
 cargo \
 rust-string_cache_codegen-devel \
 "
RDEPENDS:rust-string_cache_codegen-devel = " \
 cargo \
 rust-phf_generator+default-devel \
 rust-phf_shared+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
