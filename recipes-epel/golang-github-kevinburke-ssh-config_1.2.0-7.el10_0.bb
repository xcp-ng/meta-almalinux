# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-kevinburke-ssh-config"
PV = "1.2.0"
PR = "7.el10_0"
PACKAGES = " \
 golang-github-kevinburke-ssh-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-kevinburke-ssh-config-1.2.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa025dd0dee36c568b8cd36697ddc44a46e7b9c31704a0cd6bc8125263a599f3"

URI_x86_64_v2_golang-github-kevinburke-ssh-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-kevinburke-ssh-config-devel-1.2.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-kevinburke-ssh-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-kevinburke-ssh-config-devel}"
SRC_URI[x86_64_v2_golang-github-kevinburke-ssh-config-devel.sha256sum] = "d4c7e0ff157a1332c2dbbe153e28a0ff153c7396c4e0050d17086ac7aa259b89"

URI_aarch64_golang-github-kevinburke-ssh-config-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kevinburke-ssh-config-devel-1.2.0-7.el10_0.noarch.rpm;name=aarch64_golang-github-kevinburke-ssh-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kevinburke-ssh-config-devel}"
SRC_URI[aarch64_golang-github-kevinburke-ssh-config-devel.sha256sum] = "9d22b504a62c9d4d3c94b8818bddc1434eda9e12639bd80fa6adab4e9e04471a"

RDEPENDS:golang-github-kevinburke-ssh-config-devel = " \
 go-filesystem \
 "
