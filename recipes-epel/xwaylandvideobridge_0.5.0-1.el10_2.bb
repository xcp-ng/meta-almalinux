# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xwaylandvideobridge"
PV = "0.5.0"
PR = "1.el10_2"
PACKAGES = " \
 xwaylandvideobridge \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xwaylandvideobridge-0.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dad0b8c279bd9e2e9565239a6a96c151877c850c187c40fa88d7ad692985e5c7"

URI_x86_64_v2_xwaylandvideobridge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xwaylandvideobridge-0.5.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xwaylandvideobridge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xwaylandvideobridge}"
SRC_URI[x86_64_v2_xwaylandvideobridge.sha256sum] = "14b0dd4584d5b437f246729477805fdc71e489796979593a092506747cd7c50c"

URI_aarch64_xwaylandvideobridge = "${EPEL_MIRROR}/aarch64/Packages/x/xwaylandvideobridge-0.5.0-1.el10_2.aarch64.rpm;name=aarch64_xwaylandvideobridge;unpack=0"
SRC_URI:append = " ${URI_aarch64_xwaylandvideobridge}"
SRC_URI[aarch64_xwaylandvideobridge.sha256sum] = "9d2245d7987e992669ea94d63616ed7c5cf0ab1a4048adef46a885f469d0f358"

RDEPENDS:xwaylandvideobridge = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kpipewire \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
