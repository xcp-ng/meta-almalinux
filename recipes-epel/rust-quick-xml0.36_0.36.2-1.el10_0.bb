# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-xml0.36"
PV = "0.36.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-quick-xml0.36+arbitrary-devel \
 rust-quick-xml0.36+async-tokio-devel \
 rust-quick-xml0.36+default-devel \
 rust-quick-xml0.36+document-features-devel \
 rust-quick-xml0.36+encoding-devel \
 rust-quick-xml0.36+encoding_rs-devel \
 rust-quick-xml0.36+escape-html-devel \
 rust-quick-xml0.36+overlapped-lists-devel \
 rust-quick-xml0.36+serde-devel \
 rust-quick-xml0.36+serde-types-devel \
 rust-quick-xml0.36+serialize-devel \
 rust-quick-xml0.36+tokio-devel \
 rust-quick-xml0.36-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-xml0.36-0.36.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7c5e39f51c6f24d3e5b853c11e19c203c286849f0404e0fcbf956642705c630"

URI_x86_64_v2_rust-quick-xml0.36+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+arbitrary-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+arbitrary-devel.sha256sum] = "091ecda7141948fe96644b2d593437bb6b0f169e34fdc0d58db57b80ee94ffc4"

URI_x86_64_v2_rust-quick-xml0.36+async-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+async-tokio-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+async-tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+async-tokio-devel.sha256sum] = "86d4d7f6b28d59d310b77dec0acc756e92ad4f2255ceacb2406f4174621fa195"

URI_x86_64_v2_rust-quick-xml0.36+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+default-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+default-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+default-devel.sha256sum] = "584c2ff1341e34add46b2b8bc0ef2d2b9d98fef6d9d25e569597434cab8b96ae"

URI_x86_64_v2_rust-quick-xml0.36+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+document-features-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+document-features-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+document-features-devel.sha256sum] = "8cc34c36fc930b9f22f43a4d9c621e8d81c43d05b1614db32b8f50749283e351"

URI_x86_64_v2_rust-quick-xml0.36+encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+encoding-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+encoding-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+encoding-devel.sha256sum] = "af657b5c97698621e59fdc340941745a59c585cd9132acc60544f936b6dcc73e"

URI_x86_64_v2_rust-quick-xml0.36+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+encoding_rs-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+encoding_rs-devel.sha256sum] = "69427a6768fe6092bec1d3745d21e93c323ffc051d5aeeaaa038f08c7a3bfe75"

URI_x86_64_v2_rust-quick-xml0.36+escape-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+escape-html-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+escape-html-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+escape-html-devel.sha256sum] = "eec354338f483f3fdb826020b275811b6cf807d2e3c560a5ce62e032f88e21af"

URI_x86_64_v2_rust-quick-xml0.36+overlapped-lists-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+overlapped-lists-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+overlapped-lists-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+overlapped-lists-devel.sha256sum] = "6d5f9c6cea0f51b21fbd85e0729f8a5b03a7b7fea37b805129c2d1f5637e3fab"

URI_x86_64_v2_rust-quick-xml0.36+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+serde-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+serde-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+serde-devel.sha256sum] = "7cf24b0763f4effb800c0fe3499c7aaa782626159a7e61e365fd7d15b14e28d4"

URI_x86_64_v2_rust-quick-xml0.36+serde-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+serde-types-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+serde-types-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+serde-types-devel.sha256sum] = "17724085b9d09f55c13afa69344e2cf468b8d3369480f2bd30f606da57873252"

URI_x86_64_v2_rust-quick-xml0.36+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+serialize-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+serialize-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+serialize-devel.sha256sum] = "354fade216ac056aeac3218afca337e78d7dec7d1c23ddb3544055a0ac534c89"

URI_x86_64_v2_rust-quick-xml0.36+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36+tokio-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36+tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36+tokio-devel.sha256sum] = "b40b2fe920c32b219d918e943e581de932f4cca2b44789f81bb4a8a3a92a8c80"

URI_x86_64_v2_rust-quick-xml0.36-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.36-devel-0.36.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.36-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.36-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.36-devel.sha256sum] = "62998ba97ce113994a6c4544bb642985359c39db05fadaa2698ca248887bc8bf"

URI_aarch64_rust-quick-xml0.36+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+arbitrary-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+arbitrary-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+arbitrary-devel.sha256sum] = "ccb89aa812293ba4ed0136298f349dec6d47cad90d7821319fd5c377275973e4"

URI_aarch64_rust-quick-xml0.36+async-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+async-tokio-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+async-tokio-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+async-tokio-devel.sha256sum] = "073649c292aee9716979cef94cf9db7997c3aed89b86006a8b92ea57c44abbfe"

URI_aarch64_rust-quick-xml0.36+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+default-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+default-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+default-devel.sha256sum] = "d745ad3f6e9c9abdd34e3c604a3546e9b384a52abd0c78fcb4474c8704017655"

URI_aarch64_rust-quick-xml0.36+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+document-features-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+document-features-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+document-features-devel.sha256sum] = "34ffac94ee697ae21299afd6ec20bffc5be6570f13cfd83364e00d8f18f25bfd"

URI_aarch64_rust-quick-xml0.36+encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+encoding-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+encoding-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+encoding-devel.sha256sum] = "ad53642b0d6bdf6daf13e705904b84b7268007db5892b4b3bd333c836f3e9766"

URI_aarch64_rust-quick-xml0.36+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+encoding_rs-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+encoding_rs-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+encoding_rs-devel.sha256sum] = "7905eb8f03822a78dcc61fe9ab92ed54529fed0ad34a5996a55b7835a06bad57"

URI_aarch64_rust-quick-xml0.36+escape-html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+escape-html-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+escape-html-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+escape-html-devel.sha256sum] = "b7cc37434f69de56e233148e5be746091ebc07294ad5cd4ea633aefea420f609"

URI_aarch64_rust-quick-xml0.36+overlapped-lists-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+overlapped-lists-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+overlapped-lists-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+overlapped-lists-devel.sha256sum] = "d24946d453cfbd885e5574904e1b47f57cabc75d8a9d05b694e30bca8817fc70"

URI_aarch64_rust-quick-xml0.36+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+serde-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+serde-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+serde-devel.sha256sum] = "b85e3333d9073638f3f4b68095c6bb956eb5cca8218bbc757337ad6f1e2634b3"

URI_aarch64_rust-quick-xml0.36+serde-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+serde-types-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+serde-types-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+serde-types-devel.sha256sum] = "d7b6b96137717186a3b333893918a38dd6707ba41273b6c9d3d8f1d91878ddd7"

URI_aarch64_rust-quick-xml0.36+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+serialize-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+serialize-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+serialize-devel.sha256sum] = "10ea36b0c99a77c75b9bb762e04d568698110ed4f86aad44aeb27f3a20c4c6a0"

URI_aarch64_rust-quick-xml0.36+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36+tokio-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36+tokio-devel}"
SRC_URI[aarch64_rust-quick-xml0.36+tokio-devel.sha256sum] = "cede29c47a88aa17fead1c1dab51dd121d101b1fcc7daf1ed890e15e2b4adb57"

URI_aarch64_rust-quick-xml0.36-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.36-devel-0.36.2-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.36-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.36-devel}"
SRC_URI[aarch64_rust-quick-xml0.36-devel.sha256sum] = "9bf2ed11b87c6ed7de5b5884ffd1f35f58d111e85005d6c1e3e0e0d66ca0e8d5"

RDEPENDS:rust-quick-xml0.36+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-quick-xml0.36-devel \
 "
RDEPENDS:rust-quick-xml0.36+async-tokio-devel = " \
 cargo \
 rust-quick-xml0.36+tokio-devel \
 rust-quick-xml0.36-devel \
 "
RDEPENDS:rust-quick-xml0.36+default-devel = " \
 cargo \
 rust-quick-xml0.36-devel \
 "
RDEPENDS:rust-quick-xml0.36+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-quick-xml0.36-devel \
 "
RDEPENDS:rust-quick-xml0.36+encoding-devel = " \
 cargo \
 rust-quick-xml0.36+encoding_rs-devel \
 rust-quick-xml0.36-devel \
 "
RDEPENDS:rust-quick-xml0.36+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-quick-xml0.36-devel \
 "
RDEPENDS:rust-quick-xml0.36+escape-html-devel = " \
 cargo \
 rust-quick-xml0.36-devel \
 "
RDEPENDS:rust-quick-xml0.36+overlapped-lists-devel = " \
 cargo \
 rust-quick-xml0.36-devel \
 "
RDEPENDS:rust-quick-xml0.36+serde-devel = " \
 cargo \
 rust-quick-xml0.36-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-quick-xml0.36+serde-types-devel = " \
 cargo \
 rust-quick-xml0.36-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-quick-xml0.36+serialize-devel = " \
 cargo \
 rust-quick-xml0.36+serde-devel \
 rust-quick-xml0.36-devel \
 "
RDEPENDS:rust-quick-xml0.36+tokio-devel = " \
 cargo \
 rust-quick-xml0.36-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-quick-xml0.36-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 "
