# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-curl"
PV = "0.4.50"
PR = "1.el10_3"
PACKAGES = " \
 rust-curl+default-devel \
 rust-curl+http2-devel \
 rust-curl+ntlm-devel \
 rust-curl+openssl-probe-devel \
 rust-curl+openssl-sys-devel \
 rust-curl+poll_7_68_0-devel \
 rust-curl+protocol-ftp-devel \
 rust-curl+spnego-devel \
 rust-curl+ssl-devel \
 rust-curl+upkeep_7_62_0-devel \
 rust-curl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-curl-0.4.50-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26d07dc2ca28910d6c7d1f9578244a7445bc6b2d04008fbb3b9abd7df2c1ad1a"

URI_x86_64_v2_rust-curl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+default-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+default-devel}"
SRC_URI[x86_64_v2_rust-curl+default-devel.sha256sum] = "ff3045256a027d89dcd053c65ceebec4511568dc2052b036876e5646bb0881c2"

URI_x86_64_v2_rust-curl+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+http2-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+http2-devel}"
SRC_URI[x86_64_v2_rust-curl+http2-devel.sha256sum] = "af960d0c4770365a8714a3b9303bf9cf16220b9adf630faa4e5d4b8a8fd89204"

URI_x86_64_v2_rust-curl+ntlm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+ntlm-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+ntlm-devel}"
SRC_URI[x86_64_v2_rust-curl+ntlm-devel.sha256sum] = "8a2080defa754ef97f816e55a922499e4b0c5fa887b01865a08969da42f26139"

URI_x86_64_v2_rust-curl+openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+openssl-probe-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-curl+openssl-probe-devel.sha256sum] = "8a1a2b312928890f2ef5af186d7875f13a85988f8af2a28c06579b5958e76c49"

URI_x86_64_v2_rust-curl+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+openssl-sys-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-curl+openssl-sys-devel.sha256sum] = "83b0b61be08e01b8ae404d0199d4da162db785fb55cec708c648cd2f9cff69f7"

URI_x86_64_v2_rust-curl+poll_7_68_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+poll_7_68_0-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+poll_7_68_0-devel}"
SRC_URI[x86_64_v2_rust-curl+poll_7_68_0-devel.sha256sum] = "423d0142c903c6431e5ecd9ed5c50cc49c8b12c06cd855180331c6fc04b6fd69"

URI_x86_64_v2_rust-curl+protocol-ftp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+protocol-ftp-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+protocol-ftp-devel}"
SRC_URI[x86_64_v2_rust-curl+protocol-ftp-devel.sha256sum] = "5c6f1bf1bb2951209aa111e6c85f6da21d7051b2ba5506dd579f39d4dcf8f4a1"

URI_x86_64_v2_rust-curl+spnego-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+spnego-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+spnego-devel}"
SRC_URI[x86_64_v2_rust-curl+spnego-devel.sha256sum] = "fb2696e6fa4cebca31639efdedd52deed1857e54bbe70490a5a93a70a1afe0c6"

URI_x86_64_v2_rust-curl+ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+ssl-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+ssl-devel}"
SRC_URI[x86_64_v2_rust-curl+ssl-devel.sha256sum] = "a31495c1be56931c382b57dd6cae7c9a09b822fa72c67acaa7c7e84c160ebee8"

URI_x86_64_v2_rust-curl+upkeep_7_62_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+upkeep_7_62_0-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+upkeep_7_62_0-devel}"
SRC_URI[x86_64_v2_rust-curl+upkeep_7_62_0-devel.sha256sum] = "582cb2ca9e86e2d75a004cf330130357e21748b6792c613a88462d95ac906447"

URI_x86_64_v2_rust-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-devel-0.4.50-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-devel}"
SRC_URI[x86_64_v2_rust-curl-devel.sha256sum] = "a61eda7b644e11f1dd4c8b351d5768ec28804b8db2047ecdf481116294009c28"

URI_aarch64_rust-curl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+default-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+default-devel}"
SRC_URI[aarch64_rust-curl+default-devel.sha256sum] = "034680fc34d4c12d07ecf73d7c18b60f2ab578244a55c14f4714db85ccd63b10"

URI_aarch64_rust-curl+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+http2-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+http2-devel}"
SRC_URI[aarch64_rust-curl+http2-devel.sha256sum] = "24422df368960cd14f51fd67b351d9e0e9de4574a3b1214c00b7e8c89759b1f7"

URI_aarch64_rust-curl+ntlm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+ntlm-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+ntlm-devel}"
SRC_URI[aarch64_rust-curl+ntlm-devel.sha256sum] = "010ae65d87b997613ec8736787e96db48f6e2f694cc5dcc0067a98e827666115"

URI_aarch64_rust-curl+openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+openssl-probe-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+openssl-probe-devel}"
SRC_URI[aarch64_rust-curl+openssl-probe-devel.sha256sum] = "429deec2e072c8f1b56c87438d2dc156858663762c480bde0a540c70620bf37c"

URI_aarch64_rust-curl+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+openssl-sys-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+openssl-sys-devel}"
SRC_URI[aarch64_rust-curl+openssl-sys-devel.sha256sum] = "2550ff1240c26cc611aaad291e910928a6500818d657241e08c9eb97940be2cc"

URI_aarch64_rust-curl+poll_7_68_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+poll_7_68_0-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+poll_7_68_0-devel}"
SRC_URI[aarch64_rust-curl+poll_7_68_0-devel.sha256sum] = "73bc04857e0e081f385781cc289b6910bbbfaac6d1131f9c46ca2943f0936443"

URI_aarch64_rust-curl+protocol-ftp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+protocol-ftp-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+protocol-ftp-devel}"
SRC_URI[aarch64_rust-curl+protocol-ftp-devel.sha256sum] = "6dfe7d3a057fb84cd14505525d74b4184a5407c06554a0b47da008f6bb6cad6b"

URI_aarch64_rust-curl+spnego-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+spnego-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+spnego-devel}"
SRC_URI[aarch64_rust-curl+spnego-devel.sha256sum] = "7426c1756f851b3b442ff868b60bd9bd29712a63ade6f8d3f4de861373067d34"

URI_aarch64_rust-curl+ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+ssl-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+ssl-devel}"
SRC_URI[aarch64_rust-curl+ssl-devel.sha256sum] = "8306138a870524e59ef522e5efc6efd58669134a9c0ea4f62b3ade996fa37f21"

URI_aarch64_rust-curl+upkeep_7_62_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+upkeep_7_62_0-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+upkeep_7_62_0-devel}"
SRC_URI[aarch64_rust-curl+upkeep_7_62_0-devel.sha256sum] = "0669980d01650e3a0c07b528877ccf54d36c684a5e416af357bab97be44e7a74"

URI_aarch64_rust-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-devel-0.4.50-1.el10_3.noarch.rpm;name=aarch64_rust-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-devel}"
SRC_URI[aarch64_rust-curl-devel.sha256sum] = "9124aa8958cd90e1903ef263167b3fb23e606ccb1eae927420aee9d23b5ef809"

RDEPENDS:rust-curl+default-devel = " \
 cargo \
 rust-curl+ssl-devel \
 rust-curl-devel \
 "
RDEPENDS:rust-curl+http2-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+http2-devel \
 "
RDEPENDS:rust-curl+ntlm-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+ntlm-devel \
 "
RDEPENDS:rust-curl+openssl-probe-devel = " \
 cargo \
 rust-curl-devel \
 rust-openssl-probe0.1+default-devel \
 "
RDEPENDS:rust-curl+openssl-sys-devel = " \
 cargo \
 rust-curl-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-curl+poll_7_68_0-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+poll_7_68_0-devel \
 "
RDEPENDS:rust-curl+protocol-ftp-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+protocol-ftp-devel \
 "
RDEPENDS:rust-curl+spnego-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+spnego-devel \
 "
RDEPENDS:rust-curl+ssl-devel = " \
 cargo \
 rust-curl+openssl-probe-devel \
 rust-curl+openssl-sys-devel \
 rust-curl-devel \
 rust-curl-sys+ssl-devel \
 "
RDEPENDS:rust-curl+upkeep_7_62_0-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+upkeep_7_62_0-devel \
 "
RDEPENDS:rust-curl-devel = " \
 cargo \
 rust-curl-sys-devel \
 rust-libc+default-devel \
 rust-socket2+default-devel \
 "
