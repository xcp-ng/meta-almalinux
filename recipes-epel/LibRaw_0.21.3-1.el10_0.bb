# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "LibRaw"
PV = "0.21.3"
PR = "1.el10_0"
PACKAGES = " \
 LibRaw \
 LibRaw-devel \
 LibRaw-samples \
 LibRaw-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/LibRaw-0.21.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "963e0aa2f607a90209f2a1de93e4111fcc0830f4f55295cff0f24a1fa0066362"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/LibRaw-0.21.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_LibRaw;unpack=0"
SRC_URI[x86_64_v2_LibRaw.sha256sum] = "28e3c929f1bfc4d2ee7dece9890c8f79849f0ac38c83ce17804066bf6f9a467e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/LibRaw-devel-0.21.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_LibRaw-devel;unpack=0"
SRC_URI[x86_64_v2_LibRaw-devel.sha256sum] = "0c620eec3e723dce0823ca5145851534b3ec0389c6fc05c1aa36c27deeede454"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/LibRaw-samples-0.21.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_LibRaw-samples;unpack=0"
SRC_URI[x86_64_v2_LibRaw-samples.sha256sum] = "14fd695db88a45070088d84a92552ef263771c771da788171478330702185555"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/LibRaw-static-0.21.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_LibRaw-static;unpack=0"
SRC_URI[x86_64_v2_LibRaw-static.sha256sum] = "eace25393d06f367163493e83972d616a1e107b8c7a0329f14d5d03432e71cb1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/LibRaw-0.21.3-1.el10_0.aarch64.rpm;name=aarch64_LibRaw;unpack=0"
SRC_URI[aarch64_LibRaw.sha256sum] = "0e1d43f0cc21aaa811029c363fa3aac75dbe9d5eb76b7538c7589ccf87662ad6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/LibRaw-devel-0.21.3-1.el10_0.aarch64.rpm;name=aarch64_LibRaw-devel;unpack=0"
SRC_URI[aarch64_LibRaw-devel.sha256sum] = "6ee0f2f918f4513f0efbf5a99fbcb239797bb7af7010f9c8ec342297000485c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/LibRaw-samples-0.21.3-1.el10_0.aarch64.rpm;name=aarch64_LibRaw-samples;unpack=0"
SRC_URI[aarch64_LibRaw-samples.sha256sum] = "29a5fba03733faf90fe22d5378c4d611e367614b29c97e41528d6a13a5c90ead"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/LibRaw-static-0.21.3-1.el10_0.aarch64.rpm;name=aarch64_LibRaw-static;unpack=0"
SRC_URI[aarch64_LibRaw-static.sha256sum] = "5968740215e918bbd6113d7a3b6f55fb4c70898c889d2cc6096f6269da6a8790"

RDEPENDS:LibRaw = " \
 glibc \
 jasper-libs \
 lcms2 \
 libgcc \
 libgomp \
 libjpeg-turbo \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:LibRaw-devel = " \
 LibRaw \
 lcms2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:LibRaw-samples = " \
 LibRaw \
 glibc \
 libgcc \
 libgomp \
 libjpeg-turbo \
 libstdc++ \
 "
RDEPENDS:LibRaw-static = " \
 LibRaw-devel \
 "
