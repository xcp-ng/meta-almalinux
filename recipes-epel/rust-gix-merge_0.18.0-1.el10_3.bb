# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-merge"
PV = "0.18.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-merge+default-devel \
 rust-gix-merge+document-features-devel \
 rust-gix-merge+serde-devel \
 rust-gix-merge+sha1-devel \
 rust-gix-merge+sha256-devel \
 rust-gix-merge-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-merge-0.18.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48f74aa9088154d7c84de7d7e6cd35d39501734bd0a94eac4184e5d5584f7c20"

URI_x86_64_v2_rust-gix-merge+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+default-devel-0.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+default-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+default-devel.sha256sum] = "ef2d177517d0ccd0962d79c990af14a41b4c3eb27d7b2f8ff5c971043486e574"

URI_x86_64_v2_rust-gix-merge+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+document-features-devel-0.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+document-features-devel.sha256sum] = "14d5f453715cf058b31adcd501a5debe5d275e9cb8a9bec5d0614779080fe3ab"

URI_x86_64_v2_rust-gix-merge+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+serde-devel-0.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+serde-devel.sha256sum] = "a1fd4bf15d1a718f2697edb8d7744adcb79aa44e2789d4953007b94fa2a40367"

URI_x86_64_v2_rust-gix-merge+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+sha1-devel-0.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+sha1-devel.sha256sum] = "e99ae03e7302a629870552e8ce56bda901d499ff673105a2cd804a22bdc8ff9e"

URI_x86_64_v2_rust-gix-merge+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge+sha256-devel-0.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-merge+sha256-devel.sha256sum] = "a159697fb3d28d4ccd434847b86204f2b64c876ddb53093dd8be82c90154a109"

URI_x86_64_v2_rust-gix-merge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-merge-devel-0.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-merge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-merge-devel}"
SRC_URI[x86_64_v2_rust-gix-merge-devel.sha256sum] = "86bef3df76d878ae80f9570458c75446c375a1972cf746b432392dc5275fcd78"

URI_aarch64_rust-gix-merge+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+default-devel-0.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-merge+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+default-devel}"
SRC_URI[aarch64_rust-gix-merge+default-devel.sha256sum] = "be14f1d6014374cef4531350684e86f44ba8f09905b314609d4f35c7b0724b72"

URI_aarch64_rust-gix-merge+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+document-features-devel-0.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-merge+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+document-features-devel}"
SRC_URI[aarch64_rust-gix-merge+document-features-devel.sha256sum] = "2f10466de9d4b61fa696bf85f536a482fa76e57624a18b7a86554d48b57fb785"

URI_aarch64_rust-gix-merge+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+serde-devel-0.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-merge+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+serde-devel}"
SRC_URI[aarch64_rust-gix-merge+serde-devel.sha256sum] = "84d0833d9c7bccc8f51cd3cf2bc536f413a7ba8bca360c9ede15dc343970ecfa"

URI_aarch64_rust-gix-merge+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+sha1-devel-0.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-merge+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+sha1-devel}"
SRC_URI[aarch64_rust-gix-merge+sha1-devel.sha256sum] = "dbe743b44967916c8ed3a6f4a8da9ab543ef38ec597d92c61ee23ed6acf78244"

URI_aarch64_rust-gix-merge+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge+sha256-devel-0.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-merge+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge+sha256-devel}"
SRC_URI[aarch64_rust-gix-merge+sha256-devel.sha256sum] = "48547a43e5e6e9bb4fa34c35f441a60316dc7c1ac1d1feee66195009a4db3f0e"

URI_aarch64_rust-gix-merge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-merge-devel-0.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-merge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-merge-devel}"
SRC_URI[aarch64_rust-gix-merge-devel.sha256sum] = "c07b7400af2fdb9ffb20fb28d9674cc35e03580c5ab145f462e5f993fa9f08b4"

RDEPENDS:rust-gix-merge+default-devel = " \
 cargo \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix-merge+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix-merge+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-merge-devel \
 rust-gix-object+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-merge+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix-merge+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix-merge-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-command+default-devel \
 rust-gix-diff+blob-devel \
 rust-gix-diff-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-imara-diff+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-tempfile+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-nonempty+default-devel \
 rust-thiserror+default-devel \
 "
