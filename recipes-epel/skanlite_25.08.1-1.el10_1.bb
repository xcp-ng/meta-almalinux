# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skanlite"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 skanlite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/skanlite-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9db7f50bead3b0ced9fb3b215f02535d93b8d761cc1f184334f145033f6b7345"

URI_x86_64_v2_skanlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skanlite-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skanlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skanlite}"
SRC_URI[x86_64_v2_skanlite.sha256sum] = "2d58fb596521bb250bb66f71726d1ea75abb4006ccf57cd6da1155923aeef64a"

URI_aarch64_skanlite = "${EPEL_MIRROR}/aarch64/Packages/s/skanlite-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_skanlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_skanlite}"
SRC_URI[aarch64_skanlite.sha256sum] = "a1ee7d64d43689e11f8e477340bfc3bd019bb4bd5fcd7993ee9247bb17712147"

RDEPENDS:skanlite = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libksane \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
