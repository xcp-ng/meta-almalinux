# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmongocrypt"
PV = "1.15.2"
PR = "1.el10_1"
PACKAGES = " \
 libmongocrypt \
 libmongocrypt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmongocrypt-1.15.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78bf9374b4b41e514a5bc4e39446f597e9cc54afa2900b0cf3852f5107fb918a"

URI_x86_64_v2_libmongocrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmongocrypt-1.15.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmongocrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmongocrypt}"
SRC_URI[x86_64_v2_libmongocrypt.sha256sum] = "810cfe393fa94fea6d20a77e8690ac3088ba3fa0768ee617ea454958d3f5a472"

URI_x86_64_v2_libmongocrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmongocrypt-devel-1.15.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmongocrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmongocrypt-devel}"
SRC_URI[x86_64_v2_libmongocrypt-devel.sha256sum] = "265d52ebcaf583ac9dffa2847f51704cb535a02586d6459bc693ead97231fb29"

URI_aarch64_libmongocrypt = "${EPEL_MIRROR}/aarch64/Packages/l/libmongocrypt-1.15.2-1.el10_1.aarch64.rpm;name=aarch64_libmongocrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmongocrypt}"
SRC_URI[aarch64_libmongocrypt.sha256sum] = "936247b5281b3f56ca1cb9865c1abdbb549d6b1da7041af09208657baac10148"

URI_aarch64_libmongocrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmongocrypt-devel-1.15.2-1.el10_1.aarch64.rpm;name=aarch64_libmongocrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmongocrypt-devel}"
SRC_URI[aarch64_libmongocrypt-devel.sha256sum] = "80ea4bf14deb0a31e8aa58ece6d7650906dc5bdf958b841e1195dc55667cd43a"

RDEPENDS:libmongocrypt = " \
 glibc \
 libbson \
 openssl-libs \
 "
RDEPENDS:libmongocrypt-devel = " \
 cmake-filesystem \
 libbson-devel \
 libmongocrypt \
 pkgconf-pkg-config \
 "
