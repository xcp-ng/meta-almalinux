# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "botan3"
PV = "3.9.0"
PR = "4.el10_3"
PACKAGES = " \
 botan3 \
 botan3-devel \
 botan3-doc \
 python3-botan3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/botan3-3.9.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bc0441843110e8e75cf298c0b243ab18edec247d5f9604b82262bd55b3fec1a"

URI_x86_64_v2_botan3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan3-3.9.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_botan3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan3}"
SRC_URI[x86_64_v2_botan3.sha256sum] = "a0466e83397d9ad5c827fd943b1415262c2bab38d3c65a05555be261f9b85a87"

URI_x86_64_v2_botan3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan3-devel-3.9.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_botan3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan3-devel}"
SRC_URI[x86_64_v2_botan3-devel.sha256sum] = "10514626daf6123a7bf496002ac16fcafd4d8ebe364adb590a60a5d7e1ee7263"

URI_x86_64_v2_botan3-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/botan3-doc-3.9.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_botan3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_botan3-doc}"
SRC_URI[x86_64_v2_botan3-doc.sha256sum] = "d40e270d8958811adfd1899e10db5efa1cc1346dd113f84bf48849bbe5a326b3"

URI_x86_64_v2_python3-botan3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-botan3-3.9.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-botan3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-botan3}"
SRC_URI[x86_64_v2_python3-botan3.sha256sum] = "3cb1ebab2c1983956f7b0f2b835c7ad6afe9b32aacef056ec5b68cf8ba1bed77"

URI_aarch64_botan3 = "${EPEL_MIRROR}/aarch64/Packages/b/botan3-3.9.0-4.el10_3.aarch64.rpm;name=aarch64_botan3;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan3}"
SRC_URI[aarch64_botan3.sha256sum] = "199cca97e3f01584918272cafe24695e7a2864dc2d06d378ba4b9b85ad6064b7"

URI_aarch64_botan3-devel = "${EPEL_MIRROR}/aarch64/Packages/b/botan3-devel-3.9.0-4.el10_3.aarch64.rpm;name=aarch64_botan3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan3-devel}"
SRC_URI[aarch64_botan3-devel.sha256sum] = "523525e603729993ce8f2aff42878030247ab062f31c570258966564e2837c00"

URI_aarch64_botan3-doc = "${EPEL_MIRROR}/aarch64/Packages/b/botan3-doc-3.9.0-4.el10_3.noarch.rpm;name=aarch64_botan3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_botan3-doc}"
SRC_URI[aarch64_botan3-doc.sha256sum] = "77701dc141abc76ef6d1d9204a49fb948de6fbbd50eaa67ae9c2fc2f26f3acbf"

URI_aarch64_python3-botan3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-botan3-3.9.0-4.el10_3.noarch.rpm;name=aarch64_python3-botan3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-botan3}"
SRC_URI[aarch64_python3-botan3.sha256sum] = "6e5f1b405435cef06062ed7c75792881800e13cdecb87c5e1c40b1ae22cfb2df"

RDEPENDS:botan3 = " \
 bzip2-libs \
 glibc \
 jitterentropy \
 libgcc \
 libstdc++ \
 sqlite-libs \
 tpm2-tss \
 zlib-ng-compat \
 "
RDEPENDS:botan3-devel = " \
 botan3 \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:botan3-doc = " \
 "
RDEPENDS:python3-botan3 = " \
 botan3 \
 python3 \
 python3-libs \
 "
