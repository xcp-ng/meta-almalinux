# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syn"
PV = "2.0.117"
PR = "1.el10_1"
PACKAGES = " \
 rust-syn+clone-impls-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+test-devel \
 rust-syn+visit-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syn-2.0.117-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eae1d5feaf20aaa9e2d972dacac75e0964ad189b1a0b514d060fb268549d8b3a"

URI_x86_64_v2_rust-syn+clone-impls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+clone-impls-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+clone-impls-devel}"
SRC_URI[x86_64_v2_rust-syn+clone-impls-devel.sha256sum] = "8e883abde059ba294d071a1aebf886bcec90036c1b0771860e5f70657262c64c"

URI_x86_64_v2_rust-syn+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+default-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+default-devel}"
SRC_URI[x86_64_v2_rust-syn+default-devel.sha256sum] = "7fc8df28ac2b0e8867abd1cc892e445809675443370fb1311e0ec0194952e9a7"

URI_x86_64_v2_rust-syn+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+derive-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+derive-devel}"
SRC_URI[x86_64_v2_rust-syn+derive-devel.sha256sum] = "13d72518e6cd792977e294c987613cd77f06e7ab0ed6cd3e573611e2286e19af"

URI_x86_64_v2_rust-syn+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+extra-traits-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-syn+extra-traits-devel.sha256sum] = "12c001dab45abb29d9d9afc72e4a9a3df97bf4948bfb6477b4ab8a85e55ad3cb"

URI_x86_64_v2_rust-syn+fold-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+fold-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+fold-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+fold-devel}"
SRC_URI[x86_64_v2_rust-syn+fold-devel.sha256sum] = "8ce1a3d24a705b93c8fca827be3bead1f4b250dcfe7571e168662458b6f647cf"

URI_x86_64_v2_rust-syn+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+full-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+full-devel}"
SRC_URI[x86_64_v2_rust-syn+full-devel.sha256sum] = "e87fe0d1a6520c0ee8b1b5573451a7eb96c28cad50f21dbeaa9477bb19fa6a61"

URI_x86_64_v2_rust-syn+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+parsing-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+parsing-devel}"
SRC_URI[x86_64_v2_rust-syn+parsing-devel.sha256sum] = "0ed6f86ad96886a19522a808d161b87e39a20d67b3616795b2533ed834456a89"

URI_x86_64_v2_rust-syn+printing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+printing-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+printing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+printing-devel}"
SRC_URI[x86_64_v2_rust-syn+printing-devel.sha256sum] = "47dfba2118d112d4314bba89f3d5445134e94d467698c16d686529a94a852b5a"

URI_x86_64_v2_rust-syn+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+proc-macro-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-syn+proc-macro-devel.sha256sum] = "732f769954e8ac472e37a36eb1b8b94e8185fc17f3830f6072f827c8c207565c"

URI_x86_64_v2_rust-syn+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+test-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+test-devel}"
SRC_URI[x86_64_v2_rust-syn+test-devel.sha256sum] = "87e3eab000506dffd48dd58c457815f32ca6afa49a127daa172716997d8e6c72"

URI_x86_64_v2_rust-syn+visit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+visit-devel}"
SRC_URI[x86_64_v2_rust-syn+visit-devel.sha256sum] = "11738acba84e62313a5b415da7d69ede54a0ab481919b888ee4c50560dcac249"

URI_x86_64_v2_rust-syn+visit-mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-mut-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+visit-mut-devel}"
SRC_URI[x86_64_v2_rust-syn+visit-mut-devel.sha256sum] = "a9c82e6a4538add42a6f399dac4fb881825a76767829ff03a52fa986244f4531"

URI_x86_64_v2_rust-syn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn-devel-2.0.117-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn-devel}"
SRC_URI[x86_64_v2_rust-syn-devel.sha256sum] = "f171b68896e6ded5d3ef83f8852aab8440b49b48a0b3fedbc1820f45fee83883"

URI_aarch64_rust-syn+clone-impls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+clone-impls-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+clone-impls-devel}"
SRC_URI[aarch64_rust-syn+clone-impls-devel.sha256sum] = "e95ac7573cf9a75e8db9bf2cec49b8c5f603d834be6f88120a35d2aa96dd0307"

URI_aarch64_rust-syn+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+default-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+default-devel}"
SRC_URI[aarch64_rust-syn+default-devel.sha256sum] = "ac2103ac86705a7cb89ce5aa059bc224d3ecadbdc9ca04aed04145ca927f80f4"

URI_aarch64_rust-syn+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+derive-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+derive-devel}"
SRC_URI[aarch64_rust-syn+derive-devel.sha256sum] = "a2b116e14b43fbcbdb5b0e6446dab66ad4585177439f96639cf0408160b98f58"

URI_aarch64_rust-syn+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+extra-traits-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+extra-traits-devel}"
SRC_URI[aarch64_rust-syn+extra-traits-devel.sha256sum] = "18b2966820c00f9a677c5dbdeb11c1e445b774258870e27a6204d301c3d770fd"

URI_aarch64_rust-syn+fold-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+fold-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+fold-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+fold-devel}"
SRC_URI[aarch64_rust-syn+fold-devel.sha256sum] = "c1a105c17d7bb82934aa35ccda91c0c6ad2c79b15568b702465dc588d82176e6"

URI_aarch64_rust-syn+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+full-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+full-devel}"
SRC_URI[aarch64_rust-syn+full-devel.sha256sum] = "3486c97d9951a7ebdb436fe81a8d959a08ee14d545d0e1ca1e98f77526d62d4c"

URI_aarch64_rust-syn+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+parsing-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+parsing-devel}"
SRC_URI[aarch64_rust-syn+parsing-devel.sha256sum] = "30a82bb021489c76ac9435e4ff88b69d499a39720a49bd722754c8899364267e"

URI_aarch64_rust-syn+printing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+printing-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+printing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+printing-devel}"
SRC_URI[aarch64_rust-syn+printing-devel.sha256sum] = "6f1aa5f632d19bd677efb4e55d7bfacb443f8764063cd8f279c09ef2a71a11db"

URI_aarch64_rust-syn+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+proc-macro-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+proc-macro-devel}"
SRC_URI[aarch64_rust-syn+proc-macro-devel.sha256sum] = "c1e8c46ae920d05bfd7bde7dddc0cca5d1a6cac2bd77c63d8db373fea6b995e4"

URI_aarch64_rust-syn+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+test-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+test-devel}"
SRC_URI[aarch64_rust-syn+test-devel.sha256sum] = "4ec27a7385a946c703a6373daca41eec31b717b94f66a7c65869c68a96b65387"

URI_aarch64_rust-syn+visit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+visit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+visit-devel}"
SRC_URI[aarch64_rust-syn+visit-devel.sha256sum] = "21fc4b5f6da8019d222bec4bd369f0f8355d7f776447a9ee7ba9ff783b47a04c"

URI_aarch64_rust-syn+visit-mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-mut-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+visit-mut-devel}"
SRC_URI[aarch64_rust-syn+visit-mut-devel.sha256sum] = "cb48e7f1de30dd767b51b8d4cdc6399063e96dbb34968b517c538acd54e8bf50"

URI_aarch64_rust-syn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn-devel-2.0.117-1.el10_1.noarch.rpm;name=aarch64_rust-syn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn-devel}"
SRC_URI[aarch64_rust-syn-devel.sha256sum] = "7236ec9eb88834a69ae526e07948cb1a0918c9812b14fcd3824a4edb6510657f"

RDEPENDS:rust-syn+clone-impls-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+default-devel = " \
 cargo \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+derive-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+extra-traits-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+fold-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+full-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+parsing-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+printing-devel = " \
 cargo \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+test-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-mut-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-unicode-ident+default-devel \
 "
