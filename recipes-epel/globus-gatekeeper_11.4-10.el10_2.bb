# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gatekeeper"
PV = "11.4"
PR = "10.el10_2"
PACKAGES = " \
 globus-gatekeeper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gatekeeper-11.4-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "deafdd16955d22362b2d969b2ec66b7ba394a8955b69be9a577cdb2d8ba31677"

URI_x86_64_v2_globus-gatekeeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gatekeeper-11.4-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gatekeeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gatekeeper}"
SRC_URI[x86_64_v2_globus-gatekeeper.sha256sum] = "cec094f3cd03d428d3cc93f417a464fc85c8d49e125611ecca1cde63bdb24bab"

URI_aarch64_globus-gatekeeper = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gatekeeper-11.4-10.el10_2.aarch64.rpm;name=aarch64_globus-gatekeeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gatekeeper}"
SRC_URI[aarch64_globus-gatekeeper.sha256sum] = "0c16a5e351d2d2d2191c6483c51d51b5480a6ef3724afe8e57a1943c608641ed"

RDEPENDS:globus-gatekeeper = " \
 bash \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 logrotate \
 openssl-libs \
 systemd \
 "
