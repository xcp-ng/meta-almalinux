# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signify"
PV = "33"
PR = "1.el10_3"
PACKAGES = " \
 signify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/signify-33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f902b3ca7db80bfab5116af236daaf500812917eb746263e6d902fc55a2112dd"

URI_x86_64_v2_signify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signify-33-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signify}"
SRC_URI[x86_64_v2_signify.sha256sum] = "91d7a4a8e0e4d837608f75665e248299dc3f3901beeedc1f2e0f70677ef3a078"

URI_aarch64_signify = "${EPEL_MIRROR}/aarch64/Packages/s/signify-33-1.el10_3.aarch64.rpm;name=aarch64_signify;unpack=0"
SRC_URI:append = " ${URI_aarch64_signify}"
SRC_URI[aarch64_signify.sha256sum] = "619f60bdb5a83c99b26dcb18e34d5bc6e6da3daad98f830d28e53d0073488ca3"

RDEPENDS:signify = " \
 glibc \
 libbsd \
 "
