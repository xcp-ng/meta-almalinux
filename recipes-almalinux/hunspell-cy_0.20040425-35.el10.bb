# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-cy"
PV = "0.20040425"
PR = "35.el10"
PACKAGES = " \
 hunspell-cy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-cy-0.20040425-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d18cdeee2bcb2677f4222985e8c278ee710452c4af4009a2f776019447f36c6"

URI_x86_64_v2_hunspell-cy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-cy-0.20040425-35.el10.noarch.rpm;name=x86_64_v2_hunspell-cy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-cy}"
SRC_URI[x86_64_v2_hunspell-cy.sha256sum] = "1a143be340321a58976a17362968b0b3f4363cd03361eb2a1d4739dc093e6997"

URI_aarch64_hunspell-cy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-cy-0.20040425-35.el10.noarch.rpm;name=aarch64_hunspell-cy;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-cy}"
SRC_URI[aarch64_hunspell-cy.sha256sum] = "1a143be340321a58976a17362968b0b3f4363cd03361eb2a1d4739dc093e6997"

RDEPENDS:hunspell-cy = " \
 hunspell-filesystem \
 "
