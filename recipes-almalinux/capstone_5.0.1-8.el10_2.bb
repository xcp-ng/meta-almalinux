# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "capstone"
PV = "5.0.1"
PR = "8.el10_2"
PACKAGES = " \
 capstone \
 capstone-devel \
 capstone-java \
 python3-capstone \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/capstone-5.0.1-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4592f7bdfaeb2f08208389e8d48735edf0ba760be128dccd9f3896042e02e8ab"

URI_x86_64_v2_capstone = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/capstone-5.0.1-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_capstone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capstone}"
SRC_URI[x86_64_v2_capstone.sha256sum] = "55f3c91056e07760ac1e158a78b78166e913ab6fa8baa550af2cde7e0c87bc52"

URI_x86_64_v2_capstone-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/capstone-devel-5.0.1-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_capstone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capstone-devel}"
SRC_URI[x86_64_v2_capstone-devel.sha256sum] = "6305b033eee6caa9dfb12c7a247018fe5e88a3ce47edef89a9a8db11a48c4022"

URI_x86_64_v2_capstone-java = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/capstone-java-5.0.1-8.el10_2.noarch.rpm;name=x86_64_v2_capstone-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_capstone-java}"
SRC_URI[x86_64_v2_capstone-java.sha256sum] = "4d6c26536fb15a5a534978e8954db02c7a89a0099ac0cdfab3c627284a2de7a5"

URI_x86_64_v2_python3-capstone = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-capstone-5.0.1-8.el10_2.noarch.rpm;name=x86_64_v2_python3-capstone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-capstone}"
SRC_URI[x86_64_v2_python3-capstone.sha256sum] = "8b9d0a8dd2649692c800f72b41396bf2ddec6d471220a6f8f665e520cce48c26"

URI_aarch64_capstone = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/capstone-5.0.1-8.el10_2.aarch64.rpm;name=aarch64_capstone;unpack=0"
SRC_URI:append = " ${URI_aarch64_capstone}"
SRC_URI[aarch64_capstone.sha256sum] = "9f8a0a17c91319f4110b9277cb48feadae774891efa32ed61b2378fbe6286f4b"

URI_aarch64_capstone-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/capstone-devel-5.0.1-8.el10_2.aarch64.rpm;name=aarch64_capstone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_capstone-devel}"
SRC_URI[aarch64_capstone-devel.sha256sum] = "4bbebf5e9780b5e89985c49668af21e8597166868e22ca3524356688412d1362"

URI_aarch64_capstone-java = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/capstone-java-5.0.1-8.el10_2.noarch.rpm;name=aarch64_capstone-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_capstone-java}"
SRC_URI[aarch64_capstone-java.sha256sum] = "4d6c26536fb15a5a534978e8954db02c7a89a0099ac0cdfab3c627284a2de7a5"

URI_aarch64_python3-capstone = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-capstone-5.0.1-8.el10_2.noarch.rpm;name=aarch64_python3-capstone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-capstone}"
SRC_URI[aarch64_python3-capstone.sha256sum] = "8b9d0a8dd2649692c800f72b41396bf2ddec6d471220a6f8f665e520cce48c26"

RDEPENDS:capstone = " \
 glibc \
 "
RDEPENDS:capstone-devel = " \
 capstone \
 pkgconf-pkg-config \
 "
RDEPENDS:capstone-java = " \
 capstone \
 "
RDEPENDS:python3-capstone = " \
 capstone \
 python3 \
 "
