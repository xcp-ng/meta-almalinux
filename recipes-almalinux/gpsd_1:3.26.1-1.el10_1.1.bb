# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd"
PE = "1"
PV = "3.26.1"
PR = "1.el10_1.1"
PACKAGES = " \
 gpsd \
 gpsd-clients \
 python3-gpsd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gpsd-3.26.1-1.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad0a84977f64aa70cfd05b3e560957fb21f1b0993494fdff40831cc208fcd098"

URI_x86_64_v2_gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-3.26.1-1.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd}"
SRC_URI[x86_64_v2_gpsd.sha256sum] = "6f064b66cdf2592c4cb8676d3215d07d372c9faaf033c4e030a0a09c4cb70c1d"

URI_x86_64_v2_gpsd-clients = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpsd-clients-3.26.1-1.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_gpsd-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsd-clients}"
SRC_URI[x86_64_v2_gpsd-clients.sha256sum] = "3d6cfdea93a13a247b74e360bfebc6b217124bc550e7660e2ce88b87d252c792"

URI_x86_64_v2_python3-gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-gpsd-3.26.1-1.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_python3-gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gpsd}"
SRC_URI[x86_64_v2_python3-gpsd.sha256sum] = "a7c51840ba5269d9b9bca26f65ff7f0e772e2426e525e40b8ca3d63ed9dcbb83"

URI_aarch64_gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-3.26.1-1.el10_1.1.aarch64.rpm;name=aarch64_gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd}"
SRC_URI[aarch64_gpsd.sha256sum] = "190a883d2462b30c0432c207dcbc1101251a335b98910f366bf30c2f4f05ae21"

URI_aarch64_gpsd-clients = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpsd-clients-3.26.1-1.el10_1.1.aarch64.rpm;name=aarch64_gpsd-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsd-clients}"
SRC_URI[aarch64_gpsd-clients.sha256sum] = "68d793c7d64fc6d411cbc24035d04cec6d792043812c2bf647d2191a889f39af"

URI_aarch64_python3-gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-gpsd-3.26.1-1.el10_1.1.aarch64.rpm;name=aarch64_python3-gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gpsd}"
SRC_URI[aarch64_python3-gpsd.sha256sum] = "c08b551ba17532cb165fffc6a75127ffb175ce666a9f7c515f355251d39733e6"

RDEPENDS:gpsd = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 systemd \
 systemd-udev \
 "
RDEPENDS:gpsd-clients = " \
 bash \
 bluez-libs \
 dbus-libs \
 glibc \
 libusb1 \
 ncurses-libs \
 python3 \
 python3-gpsd \
 "
RDEPENDS:python3-gpsd = " \
 glibc \
 python3 \
 python3-pyserial \
 "
