# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pre-commit"
PV = "4.6.2"
PR = "1.el10_3"
PACKAGES = " \
 pre-commit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pre-commit-4.6.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "161d3208a12d3e393d2b602b0c44c7f557a95886f5b9ad2713d6eeed5e0fd5db"

URI_x86_64_v2_pre-commit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pre-commit-4.6.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pre-commit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pre-commit}"
SRC_URI[x86_64_v2_pre-commit.sha256sum] = "0339f5340300fa2d16705c0d4faa15b33e941775bd185bca1371a4b99dfe112e"

URI_aarch64_pre-commit = "${EPEL_MIRROR}/aarch64/Packages/p/pre-commit-4.6.2-1.el10_3.noarch.rpm;name=aarch64_pre-commit;unpack=0"
SRC_URI:append = " ${URI_aarch64_pre-commit}"
SRC_URI[aarch64_pre-commit.sha256sum] = "552574bc10f5b366712364aabea58dfeb5e95ef74384c2fbf437484c861aef41"

RDEPENDS:pre-commit = " \
 bash \
 git-core \
 python3 \
 python3-cfgv \
 python3-identify \
 python3-nodeenv \
 python3-pyyaml \
 python3-virtualenv \
 "
