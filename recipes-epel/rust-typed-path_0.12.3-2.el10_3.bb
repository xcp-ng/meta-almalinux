# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typed-path"
PV = "0.12.3"
PR = "2.el10_3"
PACKAGES = " \
 rust-typed-path+default-devel \
 rust-typed-path+std-devel \
 rust-typed-path-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typed-path-0.12.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08eea3af58a192d55a33502d9aba15b3215e06a6b5f0fcecd33970ffeda1f398"

URI_x86_64_v2_rust-typed-path+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-path+default-devel-0.12.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-path+default-devel}"
SRC_URI[x86_64_v2_rust-typed-path+default-devel.sha256sum] = "7cddaed4f20e18f9e3d8962834ae0325073df6455d495f5efadf8d2183c56d18"

URI_x86_64_v2_rust-typed-path+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-path+std-devel-0.12.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-path+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-path+std-devel}"
SRC_URI[x86_64_v2_rust-typed-path+std-devel.sha256sum] = "2969fb258844011dbc4dfcff1367cd9c181193a6ffaf6ee07528a2adb85a06c6"

URI_x86_64_v2_rust-typed-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-path-devel-0.12.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-path-devel}"
SRC_URI[x86_64_v2_rust-typed-path-devel.sha256sum] = "6f0cced3be315737ecb70731d198d3c615bbd1f1bcc15e3cee7488048a7660ae"

URI_aarch64_rust-typed-path+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-path+default-devel-0.12.3-2.el10_3.noarch.rpm;name=aarch64_rust-typed-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-path+default-devel}"
SRC_URI[aarch64_rust-typed-path+default-devel.sha256sum] = "04982991e2eb8a2ba2962139f67489b2dedcaddff60aab8b18f2aec52f265365"

URI_aarch64_rust-typed-path+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-path+std-devel-0.12.3-2.el10_3.noarch.rpm;name=aarch64_rust-typed-path+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-path+std-devel}"
SRC_URI[aarch64_rust-typed-path+std-devel.sha256sum] = "a19385a858920dc93aa984b0d5e3970f91bae45a60c22cf853dc566997c3ccb8"

URI_aarch64_rust-typed-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-path-devel-0.12.3-2.el10_3.noarch.rpm;name=aarch64_rust-typed-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-path-devel}"
SRC_URI[aarch64_rust-typed-path-devel.sha256sum] = "36927d7f312ad0647ee1462bc5a79b57d4db7b65719f8497b55a3fbd4083c2b9"

RDEPENDS:rust-typed-path+default-devel = " \
 cargo \
 rust-typed-path+std-devel \
 rust-typed-path-devel \
 "
RDEPENDS:rust-typed-path+std-devel = " \
 cargo \
 rust-typed-path-devel \
 "
RDEPENDS:rust-typed-path-devel = " \
 cargo \
 rust \
 "
