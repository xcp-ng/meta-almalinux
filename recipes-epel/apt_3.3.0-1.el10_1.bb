# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apt"
PV = "3.3.0"
PR = "1.el10_1"
PACKAGES = " \
 apt \
 apt-apidoc \
 apt-devel \
 apt-doc \
 apt-libs \
 apt-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apt-3.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9218b88157d9f36acfb084c8fbd76fb49575ecb3f7a4368eb1b0a9b1945c536"

URI_x86_64_v2_apt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-3.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt}"
SRC_URI[x86_64_v2_apt.sha256sum] = "f6cccbc79ad2fcfeab242298d8948252bf71b5b5baa0053d0e04fc0c858852ea"

URI_x86_64_v2_apt-apidoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-apidoc-3.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_apt-apidoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-apidoc}"
SRC_URI[x86_64_v2_apt-apidoc.sha256sum] = "f1217d95fd4602681c28b0522acc469653b6563d7503666f077094506fc70229"

URI_x86_64_v2_apt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-devel-3.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-devel}"
SRC_URI[x86_64_v2_apt-devel.sha256sum] = "c589e9b89b3ed4f9f0fe9a761318d56fed42c31e12c1ccf054a84322c057dbec"

URI_x86_64_v2_apt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-doc-3.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_apt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-doc}"
SRC_URI[x86_64_v2_apt-doc.sha256sum] = "714e24a1bf870bee3c1766a89d62413de01c8a86bd77e96c6e0626f68296962b"

URI_x86_64_v2_apt-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-libs-3.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-libs}"
SRC_URI[x86_64_v2_apt-libs.sha256sum] = "e8fdcff362562e1301b8275a7cbe63a7cbe878e5c856f678cd91f9630ef4a58d"

URI_x86_64_v2_apt-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-utils-3.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-utils}"
SRC_URI[x86_64_v2_apt-utils.sha256sum] = "f1991073be6e523ef8757d32d28b37597e4d974766be3531959c258b59ff131b"

URI_aarch64_apt = "${EPEL_MIRROR}/aarch64/Packages/a/apt-3.3.0-1.el10_1.aarch64.rpm;name=aarch64_apt;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt}"
SRC_URI[aarch64_apt.sha256sum] = "441096e37e4238d818c0f95ac95bd214ce1fae9cb67a03db656048c5e9958c53"

URI_aarch64_apt-apidoc = "${EPEL_MIRROR}/aarch64/Packages/a/apt-apidoc-3.3.0-1.el10_1.noarch.rpm;name=aarch64_apt-apidoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-apidoc}"
SRC_URI[aarch64_apt-apidoc.sha256sum] = "ba01309e893c4a05058d38c8e0ef821bf306cfc1aa96611ad9e1aba007192614"

URI_aarch64_apt-devel = "${EPEL_MIRROR}/aarch64/Packages/a/apt-devel-3.3.0-1.el10_1.aarch64.rpm;name=aarch64_apt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-devel}"
SRC_URI[aarch64_apt-devel.sha256sum] = "6a14d7e1c4ca29f0596ad52e87578bd36bbf060bab98e0809d4eda3a85ee3403"

URI_aarch64_apt-doc = "${EPEL_MIRROR}/aarch64/Packages/a/apt-doc-3.3.0-1.el10_1.noarch.rpm;name=aarch64_apt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-doc}"
SRC_URI[aarch64_apt-doc.sha256sum] = "0141dfc2a9ebdc92ee02e45f97bd0be7d10758d2aaea8782d72b012bec30e86d"

URI_aarch64_apt-libs = "${EPEL_MIRROR}/aarch64/Packages/a/apt-libs-3.3.0-1.el10_1.aarch64.rpm;name=aarch64_apt-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-libs}"
SRC_URI[aarch64_apt-libs.sha256sum] = "94323c8d80c6ec31f068937096a82f422fba66db900cbf93c0e85e7b842ac3f4"

URI_aarch64_apt-utils = "${EPEL_MIRROR}/aarch64/Packages/a/apt-utils-3.3.0-1.el10_1.aarch64.rpm;name=aarch64_apt-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-utils}"
SRC_URI[aarch64_apt-utils.sha256sum] = "68f81654f820bf1bc2d4f4bf3d091c431c0fd55b9fe187c25c1301aa72187238"

RDEPENDS:apt = " \
 apt-libs \
 bash \
 dpkg \
 glibc \
 libgcc \
 libseccomp \
 libstdc++ \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:apt-apidoc = " \
 "
RDEPENDS:apt-devel = " \
 apt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:apt-doc = " \
 "
RDEPENDS:apt-libs = " \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 openssl-libs \
 systemd-libs \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apt-utils = " \
 apt \
 apt-libs \
 glibc \
 libdb \
 libgcc \
 libstdc++ \
 "
