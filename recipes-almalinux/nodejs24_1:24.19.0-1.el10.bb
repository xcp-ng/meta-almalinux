# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs24"
PE = "1"
PV = "24.19.0"
PR = "1.el10"
PACKAGES = " \
 nodejs24 \
 nodejs24-devel \
 nodejs24-docs \
 nodejs24-full-i18n \
 nodejs24-libs \
 nodejs24-npm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs24-24.19.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d07fe43ce4bd57f5b98a190c59a553b04ac0a22fc5058087a218f95b2219ffdd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-24.19.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs24;unpack=0"
SRC_URI[x86_64_v2_nodejs24.sha256sum] = "71a7369675b4ecca1a4b073e93133a5d30b683fbefc6a2ea0f26f2a368894a5e"
RPROVIDES:nodejs24:append:x86_64_v2 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-devel-24.19.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs24-devel;unpack=0"
SRC_URI[x86_64_v2_nodejs24-devel.sha256sum] = "d59c8b18298da21607d72598e9d33a956bcb8355816da80ecde0ca729dba9335"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-docs-24.19.0-1.el10.noarch.rpm;name=x86_64_v2_nodejs24-docs;unpack=0"
SRC_URI[x86_64_v2_nodejs24-docs.sha256sum] = "e86407ecc458b04b5ed5b58fc617f380f9c16b06dfb1cd70bc6eef4201edd61b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-full-i18n-24.19.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs24-full-i18n;unpack=0"
SRC_URI[x86_64_v2_nodejs24-full-i18n.sha256sum] = "a353aa2da5d69c7e2f2e7968c079623e0adf9e517eca998e8006a2f40cb7c479"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-libs-24.19.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs24-libs;unpack=0"
SRC_URI[x86_64_v2_nodejs24-libs.sha256sum] = "b243abc4390328358c1dec2ddd161f448a264537f28764bd9fe5a3fd2153ec61"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs24-npm-11.17.0-1.24.19.0.1.el10.noarch.rpm;name=x86_64_v2_nodejs24-npm;unpack=0"
SRC_URI[x86_64_v2_nodejs24-npm.sha256sum] = "17ba70f660e4bdfebacf82c3ae58698873e68c238900f51bf8e2e3a6c3adbbe7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-24.19.0-1.el10.aarch64.rpm;name=aarch64_nodejs24;unpack=0"
SRC_URI[aarch64_nodejs24.sha256sum] = "cc2092741befb659d89f0c3da36e4820fbb2a5c1a24be4881a514aca078999fd"
RPROVIDES:nodejs24:append:aarch64 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-devel-24.19.0-1.el10.aarch64.rpm;name=aarch64_nodejs24-devel;unpack=0"
SRC_URI[aarch64_nodejs24-devel.sha256sum] = "5c372996ef51542aac3dbf5606dd9ec00d8e46ec232894498b96cfdfc0b62803"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-docs-24.19.0-1.el10.noarch.rpm;name=aarch64_nodejs24-docs;unpack=0"
SRC_URI[aarch64_nodejs24-docs.sha256sum] = "e86407ecc458b04b5ed5b58fc617f380f9c16b06dfb1cd70bc6eef4201edd61b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-full-i18n-24.19.0-1.el10.aarch64.rpm;name=aarch64_nodejs24-full-i18n;unpack=0"
SRC_URI[aarch64_nodejs24-full-i18n.sha256sum] = "53a8bae7abe1db4ceadd525e3daa1b4ed0982086ac5f2742b79c74ffbbf37d90"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-libs-24.19.0-1.el10.aarch64.rpm;name=aarch64_nodejs24-libs;unpack=0"
SRC_URI[aarch64_nodejs24-libs.sha256sum] = "28121e13e9a4a0a154d2c43d4c2120f974ddc6c83cf38524a6cc74901d58117e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs24-npm-11.17.0-1.24.19.0.1.el10.noarch.rpm;name=aarch64_nodejs24-npm;unpack=0"
SRC_URI[aarch64_nodejs24-npm.sha256sum] = "17ba70f660e4bdfebacf82c3ae58698873e68c238900f51bf8e2e3a6c3adbbe7"

RDEPENDS:nodejs24 = " \
 ca-certificates \
 glibc \
 nodejs24-libs \
 "
RDEPENDS:nodejs24-devel = " \
 brotli-devel \
 libuv-devel \
 nodejs-packaging \
 nodejs24 \
 nodejs24-libs \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs24-docs = " \
 nodejs24 \
 "
RDEPENDS:nodejs24-full-i18n = " \
 nodejs24 \
 "
RDEPENDS:nodejs24-libs = " \
 c-ares \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 libuv \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs24-npm = " \
 bash \
 nodejs24 \
 "
