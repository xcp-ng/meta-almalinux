# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cloc"
PV = "2.06"
PR = "1.el10_0"
PACKAGES = " \
 cloc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cloc-2.06-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e6b3b2ea1f462ca370615ea542ce1c97800efb24e5e90fbae5f67822f51c914"

URI_x86_64_v2_cloc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cloc-2.06-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cloc}"
SRC_URI[x86_64_v2_cloc.sha256sum] = "6dcc9a22eb9ef647794938ac652914e93562fc6a1a36065aff37125784d412d2"

URI_aarch64_cloc = "${EPEL_MIRROR}/aarch64/Packages/c/cloc-2.06-1.el10_0.noarch.rpm;name=aarch64_cloc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cloc}"
SRC_URI[aarch64_cloc.sha256sum] = "f51a3056f032584823ac4dc6d63986397ec8ed620256022c06301e44a617e2f3"

RDEPENDS:cloc = " \
 perl-Algorithm-Diff \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Encode \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-POSIX \
 perl-Parallel-ForkManager \
 perl-PathTools \
 perl-Regexp-Common \
 perl-Scalar-List-Utils \
 perl-Text-Tabs+Wrap \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 "
