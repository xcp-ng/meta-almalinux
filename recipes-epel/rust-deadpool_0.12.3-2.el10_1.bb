# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deadpool"
PV = "0.12.3"
PR = "2.el10_1"
PACKAGES = " \
 rust-deadpool+default-devel \
 rust-deadpool+managed-devel \
 rust-deadpool+rt_tokio_1-devel \
 rust-deadpool+serde-devel \
 rust-deadpool+unmanaged-devel \
 rust-deadpool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deadpool-0.12.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "688ee870d15614cd12677172bbbfaf01ece80cf348b0e58d7544513556f4cccc"

URI_x86_64_v2_rust-deadpool+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+default-devel-0.12.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+default-devel}"
SRC_URI[x86_64_v2_rust-deadpool+default-devel.sha256sum] = "a370f9c9bdda0fda4c622b5cfa14a4cf4ee9488004c77504d201c5cc182bf86b"

URI_x86_64_v2_rust-deadpool+managed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+managed-devel-0.12.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+managed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+managed-devel}"
SRC_URI[x86_64_v2_rust-deadpool+managed-devel.sha256sum] = "bddaed00fb2b98ee99a79d56b3b9d3129022455d20e08e906ea1c3da4494d17c"

URI_x86_64_v2_rust-deadpool+rt_tokio_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+rt_tokio_1-devel-0.12.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+rt_tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+rt_tokio_1-devel}"
SRC_URI[x86_64_v2_rust-deadpool+rt_tokio_1-devel.sha256sum] = "0aa1b698f1fc5ee28cb6d5e9fc9dfc94546044ac7dabcc9ea10c87c60069df3b"

URI_x86_64_v2_rust-deadpool+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+serde-devel-0.12.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+serde-devel}"
SRC_URI[x86_64_v2_rust-deadpool+serde-devel.sha256sum] = "5ccf9ce20e44b7225de874462bfc03e1caa1711b9a459b483c964f4bf2e645f2"

URI_x86_64_v2_rust-deadpool+unmanaged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+unmanaged-devel-0.12.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+unmanaged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+unmanaged-devel}"
SRC_URI[x86_64_v2_rust-deadpool+unmanaged-devel.sha256sum] = "3e410346befeb4c6ec7bcef752d4377cfcb3db8622213a700114c80004ef4aa8"

URI_x86_64_v2_rust-deadpool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-devel-0.12.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-devel}"
SRC_URI[x86_64_v2_rust-deadpool-devel.sha256sum] = "e226129937a40250df34e56638701ecd6f1dfe905ce5396182e3e3af77654410"

URI_aarch64_rust-deadpool+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+default-devel-0.12.3-2.el10_1.noarch.rpm;name=aarch64_rust-deadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+default-devel}"
SRC_URI[aarch64_rust-deadpool+default-devel.sha256sum] = "db53ae2e4a1e4c586006e5cd350ed15a6f70b9e3d2ffa4e45e1efe3d35e20d06"

URI_aarch64_rust-deadpool+managed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+managed-devel-0.12.3-2.el10_1.noarch.rpm;name=aarch64_rust-deadpool+managed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+managed-devel}"
SRC_URI[aarch64_rust-deadpool+managed-devel.sha256sum] = "f8f2cc5d298a9ece1adbb0b81299876ffd628ecde529f69d1351525a8704f2ed"

URI_aarch64_rust-deadpool+rt_tokio_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+rt_tokio_1-devel-0.12.3-2.el10_1.noarch.rpm;name=aarch64_rust-deadpool+rt_tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+rt_tokio_1-devel}"
SRC_URI[aarch64_rust-deadpool+rt_tokio_1-devel.sha256sum] = "a562061140348bdb79229410768f79575aa51d648ae2f9fdd9a23d6a98b4c537"

URI_aarch64_rust-deadpool+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+serde-devel-0.12.3-2.el10_1.noarch.rpm;name=aarch64_rust-deadpool+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+serde-devel}"
SRC_URI[aarch64_rust-deadpool+serde-devel.sha256sum] = "d7664f0a140027e6ed7f26224cc00b01b57e00d509fdb26f6cd87c472115af1e"

URI_aarch64_rust-deadpool+unmanaged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+unmanaged-devel-0.12.3-2.el10_1.noarch.rpm;name=aarch64_rust-deadpool+unmanaged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+unmanaged-devel}"
SRC_URI[aarch64_rust-deadpool+unmanaged-devel.sha256sum] = "a82a99f57e5b21d579cdd3336c1292b379d55c7917be883b6513a33111904c5d"

URI_aarch64_rust-deadpool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-devel-0.12.3-2.el10_1.noarch.rpm;name=aarch64_rust-deadpool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-devel}"
SRC_URI[aarch64_rust-deadpool-devel.sha256sum] = "a480abc92c8e67f84634d40731602ee5eda4dbba81a16752f1fac4da538a5fa7"

RDEPENDS:rust-deadpool+default-devel = " \
 cargo \
 rust-deadpool+managed-devel \
 rust-deadpool+unmanaged-devel \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool+managed-devel = " \
 cargo \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool+rt_tokio_1-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-deadpool-runtime+tokio_1-devel \
 "
RDEPENDS:rust-deadpool+serde-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-deadpool+unmanaged-devel = " \
 cargo \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool-devel = " \
 cargo \
 rust \
 rust-deadpool-runtime+default-devel \
 rust-lazy_static+default-devel \
 rust-num_cpus+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
