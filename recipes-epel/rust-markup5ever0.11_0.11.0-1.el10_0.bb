# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-markup5ever0.11"
PV = "0.11.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-markup5ever0.11+default-devel \
 rust-markup5ever0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-markup5ever0.11-0.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6bd02b0f425a87938fff6378c0cefdd8e41bed746d4c0db3f77d0e5401ef349"

URI_x86_64_v2_rust-markup5ever0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever0.11+default-devel-0.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever0.11+default-devel}"
SRC_URI[x86_64_v2_rust-markup5ever0.11+default-devel.sha256sum] = "d0f9cb2b9c7ed29433c1dabcb61c5cdd43261561c4c8ae2e87e66f74b2861e6a"

URI_x86_64_v2_rust-markup5ever0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever0.11-devel-0.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever0.11-devel}"
SRC_URI[x86_64_v2_rust-markup5ever0.11-devel.sha256sum] = "2d7bcdbb72827ec129aab8d7684f696bd97bc551b5932b6e0cffea34348b70d4"

URI_aarch64_rust-markup5ever0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever0.11+default-devel-0.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-markup5ever0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever0.11+default-devel}"
SRC_URI[aarch64_rust-markup5ever0.11+default-devel.sha256sum] = "2d01beba5d0584230f7822c12ab8fbee187c808545a940ef635761290daed0dc"

URI_aarch64_rust-markup5ever0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever0.11-devel-0.11.0-1.el10_0.noarch.rpm;name=aarch64_rust-markup5ever0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever0.11-devel}"
SRC_URI[aarch64_rust-markup5ever0.11-devel.sha256sum] = "06d44056b62744e139a47b98d07196ac4e7711cc0e1ee5dd4bb6b2c740dc4ac0"

RDEPENDS:rust-markup5ever0.11+default-devel = " \
 cargo \
 rust-markup5ever0.11-devel \
 "
RDEPENDS:rust-markup5ever0.11-devel = " \
 cargo \
 rust-log+default-devel \
 rust-phf0.11+default-devel \
 rust-phf_codegen0.11+default-devel \
 rust-string_cache0.8+default-devel \
 rust-string_cache_codegen0.5+default-devel \
 rust-tendril0.4+default-devel \
 "
