# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tie-Hash-Method"
PV = "0.02"
PR = "32.el10_2"
PACKAGES = " \
 perl-Tie-Hash-Method \
 perl-Tie-Hash-Method-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Tie-Hash-Method-0.02-32.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9119d187c39d626973e23842b0e14921141a1067dc40da2614de58acc45864ce"

URI_x86_64_v2_perl-Tie-Hash-Method = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Hash-Method-0.02-32.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Hash-Method;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Hash-Method}"
SRC_URI[x86_64_v2_perl-Tie-Hash-Method.sha256sum] = "a18a3952072c99576d34d6eaa15f149ac4ec8349c83ec1758cd3eb0a1e812494"

URI_x86_64_v2_perl-Tie-Hash-Method-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Hash-Method-tests-0.02-32.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Hash-Method-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Hash-Method-tests}"
SRC_URI[x86_64_v2_perl-Tie-Hash-Method-tests.sha256sum] = "15d14a27a039a4900d59c440c91c1af2cea9501b2c3a7829389b6ebdd8dd0273"

URI_aarch64_perl-Tie-Hash-Method = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Hash-Method-0.02-32.el10_2.noarch.rpm;name=aarch64_perl-Tie-Hash-Method;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Hash-Method}"
SRC_URI[aarch64_perl-Tie-Hash-Method.sha256sum] = "ff85d869500c92b7c275c2c4ffcdd34bc4a2863c1b58c687cc3a69c35bd67095"

URI_aarch64_perl-Tie-Hash-Method-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Hash-Method-tests-0.02-32.el10_2.noarch.rpm;name=aarch64_perl-Tie-Hash-Method-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Hash-Method-tests}"
SRC_URI[aarch64_perl-Tie-Hash-Method-tests.sha256sum] = "9d4e6ca645657e09da2afa858abaea9a7c7c1a314dd4b01248b110f934e75aa7"

RDEPENDS:perl-Tie-Hash-Method = " \
 perl-Data-Dumper \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Tie-Hash-Method-tests = " \
 bash \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tie-Hash-Method \
 "
