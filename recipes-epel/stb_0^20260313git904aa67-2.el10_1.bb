# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stb"
PV = "0^20260313git904aa67"
PR = "2.el10_1"
PACKAGES = " \
 stb-devel \
 stb-doc \
 stb_c_lexer-devel \
 stb_connected_components-devel \
 stb_divide-devel \
 stb_ds-devel \
 stb_dxt-devel \
 stb_easy_font-devel \
 stb_herringbone_wang_tile-devel \
 stb_hexwave-devel \
 stb_image-devel \
 stb_image_resize-devel \
 stb_image_resize2-devel \
 stb_image_write-devel \
 stb_leakcheck-devel \
 stb_perlin-devel \
 stb_rect_pack-devel \
 stb_sprintf-devel \
 stb_textedit-devel \
 stb_tilemap_editor-devel \
 stb_truetype-devel \
 stb_vorbis-devel \
 stb_voxel_render-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stb-0^20260313git904aa67-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b126d0c64e09ccb64d2f8268cecbeb26e77ad5e32801ef1b9ff3edf510a35b1d"

URI_x86_64_v2_stb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb-devel-0^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb-devel}"
SRC_URI[x86_64_v2_stb-devel.sha256sum] = "b6863b3da95b602d9e5529c3a1be8add051e7015f350e0dcf9ea961784d47502"

URI_x86_64_v2_stb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb-doc-0^20260313git904aa67-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_stb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb-doc}"
SRC_URI[x86_64_v2_stb-doc.sha256sum] = "6e001dc54717b6ba9d959eaac8523afc2197f7f33b10c735b8a0160b63c2f3b8"

URI_x86_64_v2_stb_c_lexer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_c_lexer-devel-0.12^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_c_lexer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_c_lexer-devel}"
SRC_URI[x86_64_v2_stb_c_lexer-devel.sha256sum] = "8968fd48a5f2ef5ef01599a31e0c0dee9e4eef38aef007dee1fbe7f3a1ed475c"

URI_x86_64_v2_stb_connected_components-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_connected_components-devel-0.96^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_connected_components-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_connected_components-devel}"
SRC_URI[x86_64_v2_stb_connected_components-devel.sha256sum] = "2dfbe40d76d25180de13b81f8acd693d0f887b426d64dfced2630ae05ca1e2b2"

URI_x86_64_v2_stb_divide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_divide-devel-0.94^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_divide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_divide-devel}"
SRC_URI[x86_64_v2_stb_divide-devel.sha256sum] = "98560eef4a2ebddeacfc5aecfbc19dd396af5c7f2d101adc1eac27104cd86554"

URI_x86_64_v2_stb_ds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_ds-devel-0.67^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_ds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_ds-devel}"
SRC_URI[x86_64_v2_stb_ds-devel.sha256sum] = "9fa34b0416f04d6ebc15a60e74d2e958fc0de5e0381f6f3e654ed68e1c410565"

URI_x86_64_v2_stb_dxt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_dxt-devel-1.12^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_dxt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_dxt-devel}"
SRC_URI[x86_64_v2_stb_dxt-devel.sha256sum] = "e16b0bfdb080f23bdbccb141f1a5a3b37402b401ab5c36323a2ed9159f883c7d"

URI_x86_64_v2_stb_easy_font-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_easy_font-devel-1.1^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_easy_font-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_easy_font-devel}"
SRC_URI[x86_64_v2_stb_easy_font-devel.sha256sum] = "9675379c83262ff6b1914004f53ec1fccd660b734ec2ae1c89a56247ec22ff67"

URI_x86_64_v2_stb_herringbone_wang_tile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_herringbone_wang_tile-devel-0.7^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_herringbone_wang_tile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_herringbone_wang_tile-devel}"
SRC_URI[x86_64_v2_stb_herringbone_wang_tile-devel.sha256sum] = "5afd9568e4b4e850c59d8e3c8237e454202784e6a3d110d10b6fb80b37a4e702"

URI_x86_64_v2_stb_hexwave-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_hexwave-devel-0.5^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_hexwave-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_hexwave-devel}"
SRC_URI[x86_64_v2_stb_hexwave-devel.sha256sum] = "a08a8b6d56fd5a4ce1e91667bc57d47c2ee04b5b81cdc00ee74e36c905ff4b24"

URI_x86_64_v2_stb_image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image-devel-2.30^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image-devel}"
SRC_URI[x86_64_v2_stb_image-devel.sha256sum] = "f00b69f372d3fb5c449d0e10838e07c67afaba38232123b55913f1dea9cfc853"

URI_x86_64_v2_stb_image_resize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_resize-devel-0.97^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_resize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_resize-devel}"
SRC_URI[x86_64_v2_stb_image_resize-devel.sha256sum] = "5ad82321d2a5d109fb28a54963032fe83c411d7fdea69b7ad9222c25074e0b68"

URI_x86_64_v2_stb_image_resize2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_resize2-devel-2.18^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_resize2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_resize2-devel}"
SRC_URI[x86_64_v2_stb_image_resize2-devel.sha256sum] = "6bdc0ca6a1e11ddae75ed779f90d9764beb972b085f63da5ce31ca8506e06822"

URI_x86_64_v2_stb_image_write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_write-devel-1.16^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_write-devel}"
SRC_URI[x86_64_v2_stb_image_write-devel.sha256sum] = "da9e61a389b25d858f995be0591c6669767e278382121dd5ac62ced068d9e263"

URI_x86_64_v2_stb_leakcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_leakcheck-devel-0.6^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_leakcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_leakcheck-devel}"
SRC_URI[x86_64_v2_stb_leakcheck-devel.sha256sum] = "2bc17bcec3c63b06b505ea4d82ec4eed600cb054645463423e5242afcc9a3e0b"

URI_x86_64_v2_stb_perlin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_perlin-devel-0.5^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_perlin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_perlin-devel}"
SRC_URI[x86_64_v2_stb_perlin-devel.sha256sum] = "f1420565d1552dc2ad4ed017e434ca45214fa3f45cafcb56445fe38dcce29b47"

URI_x86_64_v2_stb_rect_pack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_rect_pack-devel-1.1^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_rect_pack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_rect_pack-devel}"
SRC_URI[x86_64_v2_stb_rect_pack-devel.sha256sum] = "9d14576c829733ffb23de1005298a19fb7703db78ef30de2ea800f2610b9c6ce"

URI_x86_64_v2_stb_sprintf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_sprintf-devel-1.10^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_sprintf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_sprintf-devel}"
SRC_URI[x86_64_v2_stb_sprintf-devel.sha256sum] = "0a8cbd0d8b903503e42c5fa8ba001f1c73b58cab6bdc3d905bba5704371078ca"

URI_x86_64_v2_stb_textedit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_textedit-devel-1.14^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_textedit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_textedit-devel}"
SRC_URI[x86_64_v2_stb_textedit-devel.sha256sum] = "b06b443647444d58580a30c615c377a5e766c8f5727fc6ba6d21e9e986a867dd"

URI_x86_64_v2_stb_tilemap_editor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_tilemap_editor-devel-0.42^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_tilemap_editor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_tilemap_editor-devel}"
SRC_URI[x86_64_v2_stb_tilemap_editor-devel.sha256sum] = "17e9f05c008fe472ce1b0f62533cc824d148346c5824ac117dfbbe954421a56b"

URI_x86_64_v2_stb_truetype-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_truetype-devel-1.26^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_truetype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_truetype-devel}"
SRC_URI[x86_64_v2_stb_truetype-devel.sha256sum] = "f42dcec40344fa3d4ed404b0512353fa4fe96de2a70d1a61f9613778fdb0ec74"

URI_x86_64_v2_stb_vorbis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_vorbis-devel-1.22^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_vorbis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_vorbis-devel}"
SRC_URI[x86_64_v2_stb_vorbis-devel.sha256sum] = "73d6d5270d70946348bee2c80438078fa56ac90edbff98bde9d7b3b55237e76f"

URI_x86_64_v2_stb_voxel_render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_voxel_render-devel-0.89^20260313git904aa67-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_voxel_render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_voxel_render-devel}"
SRC_URI[x86_64_v2_stb_voxel_render-devel.sha256sum] = "460f069ec363d57e7ba04a966b3b55bd79c01bf262168e9c81e629e79744d32e"

URI_aarch64_stb-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb-devel-0^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb-devel}"
SRC_URI[aarch64_stb-devel.sha256sum] = "a3d7ef7c0013c19e43ff43550a22bc14115c15fa6e95fb1333b4f88e64944be7"

URI_aarch64_stb-doc = "${EPEL_MIRROR}/aarch64/Packages/s/stb-doc-0^20260313git904aa67-2.el10_1.noarch.rpm;name=aarch64_stb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb-doc}"
SRC_URI[aarch64_stb-doc.sha256sum] = "fa369fedd213593546d1b6c7e4eed11d85f9db90b74b6a459f7eaa52a418db46"

URI_aarch64_stb_c_lexer-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_c_lexer-devel-0.12^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_c_lexer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_c_lexer-devel}"
SRC_URI[aarch64_stb_c_lexer-devel.sha256sum] = "f4492bfeb1f276fc2f179d131c991731c6d3392dbd2af6c84d045276bb3ef9d0"

URI_aarch64_stb_connected_components-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_connected_components-devel-0.96^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_connected_components-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_connected_components-devel}"
SRC_URI[aarch64_stb_connected_components-devel.sha256sum] = "9e30f34e61a10344a3d93e073bd93b4457cfbc32516d26828631fbcc1d55c9a9"

URI_aarch64_stb_divide-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_divide-devel-0.94^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_divide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_divide-devel}"
SRC_URI[aarch64_stb_divide-devel.sha256sum] = "0f0a61748db62f976cdd995489796eac90138b5660988b3df5ce839870e782f8"

URI_aarch64_stb_ds-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_ds-devel-0.67^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_ds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_ds-devel}"
SRC_URI[aarch64_stb_ds-devel.sha256sum] = "31d30e8d90e42a056bf1be88b6d4baff2059fd12dae6e259f52ee06e0e595415"

URI_aarch64_stb_dxt-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_dxt-devel-1.12^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_dxt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_dxt-devel}"
SRC_URI[aarch64_stb_dxt-devel.sha256sum] = "8714546bfba24eecdfe505c4d9b0e73ae6c07fc24022317087b65c27b403e6cd"

URI_aarch64_stb_easy_font-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_easy_font-devel-1.1^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_easy_font-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_easy_font-devel}"
SRC_URI[aarch64_stb_easy_font-devel.sha256sum] = "4b6fa7a9da6ee6a00dee7a701e7d5ca586bf82a79112eb4e3284f8695ebac7aa"

URI_aarch64_stb_herringbone_wang_tile-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_herringbone_wang_tile-devel-0.7^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_herringbone_wang_tile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_herringbone_wang_tile-devel}"
SRC_URI[aarch64_stb_herringbone_wang_tile-devel.sha256sum] = "4abe232a1c3a15716bccf8e661d58e3cc03fbafe754cce490b7da5f942a4fb3c"

URI_aarch64_stb_hexwave-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_hexwave-devel-0.5^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_hexwave-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_hexwave-devel}"
SRC_URI[aarch64_stb_hexwave-devel.sha256sum] = "07e8360c4be12b8cf9ad3e1c22602e1ac0aff2d199832f61678b8456fba1633f"

URI_aarch64_stb_image-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image-devel-2.30^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image-devel}"
SRC_URI[aarch64_stb_image-devel.sha256sum] = "8758c749ab8d6d9602bcfeeb0168c5d4454c1d8e86b5aee0c3cf2205dd29e0f4"

URI_aarch64_stb_image_resize-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_resize-devel-0.97^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_image_resize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_resize-devel}"
SRC_URI[aarch64_stb_image_resize-devel.sha256sum] = "d3f15e859e0cb2c7661db5357ca7bdf0dad4d268ae4daff03f9f2d135b5ef9f1"

URI_aarch64_stb_image_resize2-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_resize2-devel-2.18^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_image_resize2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_resize2-devel}"
SRC_URI[aarch64_stb_image_resize2-devel.sha256sum] = "8f3efdd6de53f3180af4400a5745ca548e8340d3dfb1f2084dabb6fd83dc28f7"

URI_aarch64_stb_image_write-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_write-devel-1.16^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_image_write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_write-devel}"
SRC_URI[aarch64_stb_image_write-devel.sha256sum] = "4108df21faa9d42e9d39e8acd347dfaf086ea99beb48356d99e33ddc0f4e1ac0"

URI_aarch64_stb_leakcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_leakcheck-devel-0.6^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_leakcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_leakcheck-devel}"
SRC_URI[aarch64_stb_leakcheck-devel.sha256sum] = "f27bacd8b4f7ac02947c469e15f2ecf768bb8e5ad9386db2acb5ffa5f89e8e83"

URI_aarch64_stb_perlin-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_perlin-devel-0.5^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_perlin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_perlin-devel}"
SRC_URI[aarch64_stb_perlin-devel.sha256sum] = "4ac6e87443e6c7960cae0916680b24528005c139b73aaa55fcffaa8674aefc10"

URI_aarch64_stb_rect_pack-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_rect_pack-devel-1.1^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_rect_pack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_rect_pack-devel}"
SRC_URI[aarch64_stb_rect_pack-devel.sha256sum] = "5911b80900a917d9aa7e2d690c363f569d344aaf6afd0e5e769ca7011f349e5b"

URI_aarch64_stb_sprintf-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_sprintf-devel-1.10^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_sprintf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_sprintf-devel}"
SRC_URI[aarch64_stb_sprintf-devel.sha256sum] = "a28aa4bae418aaf1a14c834475bf75ca09bb841a614f39e879058748d62bd2cf"

URI_aarch64_stb_textedit-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_textedit-devel-1.14^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_textedit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_textedit-devel}"
SRC_URI[aarch64_stb_textedit-devel.sha256sum] = "65d6dddaa79a432ad23bc9227c0b0f8c80ee6e05ad623f9130d12d34082406e0"

URI_aarch64_stb_tilemap_editor-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_tilemap_editor-devel-0.42^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_tilemap_editor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_tilemap_editor-devel}"
SRC_URI[aarch64_stb_tilemap_editor-devel.sha256sum] = "0ca1c98dcdb00639bf5c3e501ef72f90272817460f4463940dfb2efec7436ae0"

URI_aarch64_stb_truetype-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_truetype-devel-1.26^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_truetype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_truetype-devel}"
SRC_URI[aarch64_stb_truetype-devel.sha256sum] = "232c2eadf7395c6c97d49c2f9dab268df97bca335412f403babf79f04de09c4b"

URI_aarch64_stb_vorbis-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_vorbis-devel-1.22^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_vorbis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_vorbis-devel}"
SRC_URI[aarch64_stb_vorbis-devel.sha256sum] = "fd957d62874d27dc4edb5615ac0dc076baaa5e8d61d182bb175bbe7d995326bd"

URI_aarch64_stb_voxel_render-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_voxel_render-devel-0.89^20260313git904aa67-2.el10_1.aarch64.rpm;name=aarch64_stb_voxel_render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_voxel_render-devel}"
SRC_URI[aarch64_stb_voxel_render-devel.sha256sum] = "89e15d56ed83c25bd0660ccdaf33a82b3fa07ebb4f026aeb55ee19544f5a0e95"

RDEPENDS:stb-devel = " \
 stb_c_lexer-devel \
 stb_connected_components-devel \
 stb_divide-devel \
 stb_ds-devel \
 stb_dxt-devel \
 stb_easy_font-devel \
 stb_herringbone_wang_tile-devel \
 stb_hexwave-devel \
 stb_image-devel \
 stb_image_resize2-devel \
 stb_image_write-devel \
 stb_leakcheck-devel \
 stb_perlin-devel \
 stb_rect_pack-devel \
 stb_sprintf-devel \
 stb_textedit-devel \
 stb_tilemap_editor-devel \
 stb_truetype-devel \
 stb_vorbis-devel \
 stb_voxel_render-devel \
 "
RDEPENDS:stb-doc = " \
 "
RDEPENDS:stb_c_lexer-devel = " \
 "
RDEPENDS:stb_connected_components-devel = " \
 "
RDEPENDS:stb_divide-devel = " \
 "
RDEPENDS:stb_ds-devel = " \
 "
RDEPENDS:stb_dxt-devel = " \
 "
RDEPENDS:stb_easy_font-devel = " \
 "
RDEPENDS:stb_herringbone_wang_tile-devel = " \
 "
RDEPENDS:stb_hexwave-devel = " \
 "
RDEPENDS:stb_image-devel = " \
 "
RDEPENDS:stb_image_resize-devel = " \
 "
RDEPENDS:stb_image_resize2-devel = " \
 "
RDEPENDS:stb_image_write-devel = " \
 "
RDEPENDS:stb_leakcheck-devel = " \
 "
RDEPENDS:stb_perlin-devel = " \
 "
RDEPENDS:stb_rect_pack-devel = " \
 "
RDEPENDS:stb_sprintf-devel = " \
 "
RDEPENDS:stb_textedit-devel = " \
 "
RDEPENDS:stb_tilemap_editor-devel = " \
 "
RDEPENDS:stb_truetype-devel = " \
 "
RDEPENDS:stb_vorbis-devel = " \
 "
RDEPENDS:stb_voxel_render-devel = " \
 "
