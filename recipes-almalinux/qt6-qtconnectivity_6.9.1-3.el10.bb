# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtconnectivity"
PV = "6.9.1"
PR = "3.el10"
PACKAGES = " \
 qt6-qtconnectivity \
 qt6-qtconnectivity-devel \
 qt6-qtconnectivity-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtconnectivity-6.9.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf39f9e0f274561e038d803221a95f539bf777c2cad28ebaab6c8bb06beb32ea"

URI_x86_64_v2_qt6-qtconnectivity = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtconnectivity-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtconnectivity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtconnectivity}"
SRC_URI[x86_64_v2_qt6-qtconnectivity.sha256sum] = "314739104754517f69fbedfd53defdbe1bb8c06b69e36a7a77eea886bd38727e"

URI_x86_64_v2_qt6-qtconnectivity-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtconnectivity-devel-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtconnectivity-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtconnectivity-devel}"
SRC_URI[x86_64_v2_qt6-qtconnectivity-devel.sha256sum] = "3a8a44d24a1fb4889884ab501330c2f5e680ef0b94d94d5252f690e664727984"

URI_x86_64_v2_qt6-qtconnectivity-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtconnectivity-examples-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtconnectivity-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtconnectivity-examples}"
SRC_URI[x86_64_v2_qt6-qtconnectivity-examples.sha256sum] = "1cb74f5e4fb0def4e283b5d796ec22affe727b3a6797ccf6263eaef67af8d613"

URI_aarch64_qt6-qtconnectivity = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtconnectivity-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtconnectivity;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtconnectivity}"
SRC_URI[aarch64_qt6-qtconnectivity.sha256sum] = "439ee66492c4f0c9d8c797a8612ebef643b10ad6c8edbaf288685a55d370eea1"

URI_aarch64_qt6-qtconnectivity-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtconnectivity-devel-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtconnectivity-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtconnectivity-devel}"
SRC_URI[aarch64_qt6-qtconnectivity-devel.sha256sum] = "c5071a2f869fbee82b6219199868d0e36244b753721a3a2d6482619cdffd6005"

URI_aarch64_qt6-qtconnectivity-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtconnectivity-examples-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtconnectivity-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtconnectivity-examples}"
SRC_URI[aarch64_qt6-qtconnectivity-examples.sha256sum] = "df91e917aa5a5baf76f4672c86d9b735304ab3597837b90e13e3f6242a718cdc"

RDEPENDS:qt6-qtconnectivity = " \
 bluez-libs \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtconnectivity-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtconnectivity \
 "
RDEPENDS:qt6-qtconnectivity-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtconnectivity \
 qt6-qtdeclarative \
 "
