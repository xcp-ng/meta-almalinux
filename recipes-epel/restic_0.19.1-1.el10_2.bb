# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "restic"
PV = "0.19.1"
PR = "1.el10_2"
PACKAGES = " \
 restic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/restic-0.19.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2523e73fa3e62cb19f336aa5a1717920d79ae9416622376a1218fda0ca529e58"

URI_x86_64_v2_restic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/restic-0.19.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_restic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_restic}"
SRC_URI[x86_64_v2_restic.sha256sum] = "bb8f401d2f8559cd186d160707bac5c04fbbf789ff945b046f8a6989fd88b744"

URI_aarch64_restic = "${EPEL_MIRROR}/aarch64/Packages/r/restic-0.19.1-1.el10_2.aarch64.rpm;name=aarch64_restic;unpack=0"
SRC_URI:append = " ${URI_aarch64_restic}"
SRC_URI[aarch64_restic.sha256sum] = "0fdae3b4da907fa623a40decc1041055e863fdc58ce7fe3be1ddfb5b53e2afc8"

RDEPENDS:restic = " \
 glibc \
 "
