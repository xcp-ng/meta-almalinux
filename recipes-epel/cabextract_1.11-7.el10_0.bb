# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cabextract"
PV = "1.11"
PR = "7.el10_0"
PACKAGES = " \
 cabextract \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cabextract-1.11-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e54bcd628ca44c0ede52b79a7ce81bdcfe6df24328d03a98c13dae3b83bdd79b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cabextract-1.11-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cabextract;unpack=0"
SRC_URI[x86_64_v2_cabextract.sha256sum] = "849f1073ac567fef1226a6e100b4e7bf5c7d94f7ef209db83752341fc2e4f447"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cabextract-1.11-7.el10_0.aarch64.rpm;name=aarch64_cabextract;unpack=0"
SRC_URI[aarch64_cabextract.sha256sum] = "946bc9780bca5d40ea73ee325e152b7a68b66ec47debabbf6b177b5613ecb469"

RDEPENDS:cabextract = " \
 glibc \
 "
