# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansifilter"
PV = "2.22"
PR = "1.el10_2"
PACKAGES = " \
 ansifilter \
 ansifilter-gui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansifilter-2.22-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bce524870d3015487acae2fb27315005b1506643f3945986e947c683bde098c7"

URI_x86_64_v2_ansifilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansifilter-2.22-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ansifilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansifilter}"
SRC_URI[x86_64_v2_ansifilter.sha256sum] = "a08d9d259fc6e3de76ec2674b78911bf9d92ae62dc4286e0b5cfcfdafe34eb1a"

URI_x86_64_v2_ansifilter-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansifilter-gui-2.22-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ansifilter-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansifilter-gui}"
SRC_URI[x86_64_v2_ansifilter-gui.sha256sum] = "a6c7da4291020ae73ac1df635f1a88f8539f2f2092c8f7202bdf81df6d21b118"

URI_aarch64_ansifilter = "${EPEL_MIRROR}/aarch64/Packages/a/ansifilter-2.22-1.el10_2.aarch64.rpm;name=aarch64_ansifilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansifilter}"
SRC_URI[aarch64_ansifilter.sha256sum] = "3000a473a76670fc40ab21cc3e65e343817a85f81dad2028b1ee41cfc323fbb0"

URI_aarch64_ansifilter-gui = "${EPEL_MIRROR}/aarch64/Packages/a/ansifilter-gui-2.22-1.el10_2.aarch64.rpm;name=aarch64_ansifilter-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansifilter-gui}"
SRC_URI[aarch64_ansifilter-gui.sha256sum] = "c583e539cffc1cba9a4c7b52ddba661a76a3e7edf400a94da8820a97942964a8"

RDEPENDS:ansifilter = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:ansifilter-gui = " \
 glibc \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
