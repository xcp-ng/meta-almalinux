# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkeepalive"
PV = "0.3"
PR = "24.el10"
PACKAGES = " \
 libkeepalive \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libkeepalive-0.3-24.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1dfd2c34fec8509e25da31f78c4054fef7a3366f05b43945d432c21d8e63045e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libkeepalive-0.3-24.el10.x86_64_v2.rpm;name=x86_64_v2_libkeepalive;unpack=0"
SRC_URI[x86_64_v2_libkeepalive.sha256sum] = "7b6a807c4c16c69acace6329595973cc9426c985570edd142e8a8d2bf4aa18d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libkeepalive-0.3-24.el10.aarch64.rpm;name=aarch64_libkeepalive;unpack=0"
SRC_URI[aarch64_libkeepalive.sha256sum] = "b9b87556c3ae92e21d4f8a8812f31974077f656a4ce7d2311b2b4d1464c05ad5"

RDEPENDS:libkeepalive = " \
 glibc \
 "
