# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-evanphx-json-patch"
PV = "5.9.0"
PR = "4.el10_0"
PACKAGES = " \
 compat-golang-gopkg-evanphx-json-patch-5-devel \
 golang-github-evanphx-json-patch \
 golang-github-evanphx-json-patch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-evanphx-json-patch-5.9.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06f2f57ad53dab24b4d0808890dce5b7ac5adc5667dbd1f4892e996986deed71"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-evanphx-json-patch-devel: golang(github.com/jessevdk/go-flags)

URI_x86_64_v2_compat-golang-gopkg-evanphx-json-patch-5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-gopkg-evanphx-json-patch-5-devel-5.9.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-gopkg-evanphx-json-patch-5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-gopkg-evanphx-json-patch-5-devel}"
SRC_URI[x86_64_v2_compat-golang-gopkg-evanphx-json-patch-5-devel.sha256sum] = "0476ada626c6017aed73024cfc2f139c69333f592068522840f671a27917ccba"

URI_x86_64_v2_golang-github-evanphx-json-patch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-evanphx-json-patch-5.9.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-evanphx-json-patch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-evanphx-json-patch}"
SRC_URI[x86_64_v2_golang-github-evanphx-json-patch.sha256sum] = "476129f72be526fa494f5174a33af9d0868b8bc6b4f8d5c307c9380c2cfd3b18"

URI_x86_64_v2_golang-github-evanphx-json-patch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-evanphx-json-patch-devel-5.9.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-evanphx-json-patch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-evanphx-json-patch-devel}"
SRC_URI[x86_64_v2_golang-github-evanphx-json-patch-devel.sha256sum] = "7f4642f37645d07a7a73736aaab231ecd2e1b21fbe8ee948c28146da92112109"

URI_aarch64_compat-golang-gopkg-evanphx-json-patch-5-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-gopkg-evanphx-json-patch-5-devel-5.9.0-4.el10_0.noarch.rpm;name=aarch64_compat-golang-gopkg-evanphx-json-patch-5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-gopkg-evanphx-json-patch-5-devel}"
SRC_URI[aarch64_compat-golang-gopkg-evanphx-json-patch-5-devel.sha256sum] = "490ea3e697743f6b100dfb9ec89d086f146dc29173268b396f5796d7c0312771"

URI_aarch64_golang-github-evanphx-json-patch = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-evanphx-json-patch-5.9.0-4.el10_0.aarch64.rpm;name=aarch64_golang-github-evanphx-json-patch;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-evanphx-json-patch}"
SRC_URI[aarch64_golang-github-evanphx-json-patch.sha256sum] = "99e3637a4b6246a7084e262e14e2148f7de08a082b87a54d4bdc0e576c6d39b9"

URI_aarch64_golang-github-evanphx-json-patch-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-evanphx-json-patch-devel-5.9.0-4.el10_0.noarch.rpm;name=aarch64_golang-github-evanphx-json-patch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-evanphx-json-patch-devel}"
SRC_URI[aarch64_golang-github-evanphx-json-patch-devel.sha256sum] = "4bbd6df8c07602e4a17d20541c25b4762f617dd7172a34f606d62527af3f6e2a"

RDEPENDS:compat-golang-gopkg-evanphx-json-patch-5-devel = " \
 go-filesystem \
 golang-github-evanphx-json-patch-devel \
 "
RDEPENDS:golang-github-evanphx-json-patch = " \
 glibc \
 "
RDEPENDS:golang-github-evanphx-json-patch-devel:x86_64_v2 = " \
 go-filesystem \
 golang-github-pkg-errors-devel \
"
RDEPENDS:golang-github-evanphx-json-patch-devel:aarch64 = " \
 go-filesystem \
 golang-github-jessevdk-flags-devel \
 golang-github-pkg-errors-devel \
"
