# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtgamepad"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtgamepad \
 qt5-qtgamepad-devel \
 qt5-qtgamepad-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtgamepad-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef7c2b9e44570380939eb8baef53a73e4f0a7e51d69c22d1b4ddd4f417d137aa"

URI_x86_64_v2_qt5-qtgamepad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgamepad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad}"
SRC_URI[x86_64_v2_qt5-qtgamepad.sha256sum] = "5ab454c5cc81aaacfd5e53c3092f5ff3bc3bf1a1d10ad00a00e2947c5eacc00f"

URI_x86_64_v2_qt5-qtgamepad-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgamepad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad-devel}"
SRC_URI[x86_64_v2_qt5-qtgamepad-devel.sha256sum] = "520b63b41518367cb639daa655174ddde8c6f9c4c83942aa5296a138ea10bd7d"

URI_x86_64_v2_qt5-qtgamepad-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgamepad-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad-examples}"
SRC_URI[x86_64_v2_qt5-qtgamepad-examples.sha256sum] = "748be4ac55a449862bc8686a9d8ae0a4a94d79da4f27746fd629076a8576e9a6"

URI_aarch64_qt5-qtgamepad = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtgamepad;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad}"
SRC_URI[aarch64_qt5-qtgamepad.sha256sum] = "9ba62808105f553b7c0d6316f07a92d66484398d2a474eb6defad2f516379bbe"

URI_aarch64_qt5-qtgamepad-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtgamepad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad-devel}"
SRC_URI[aarch64_qt5-qtgamepad-devel.sha256sum] = "3ff07bdb15e04b580a5cad4da6bda0a512616a279dda3a4ac1c94d3a1865aafc"

URI_aarch64_qt5-qtgamepad-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtgamepad-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad-examples}"
SRC_URI[aarch64_qt5-qtgamepad-examples.sha256sum] = "ea82a05c1c8a849af9b60273ef38377290e4abcc98503d983cc61fbcaf0e9228"

RDEPENDS:qt5-qtgamepad = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 systemd-libs \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:qt5-qtgamepad-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtgamepad \
 "
RDEPENDS:qt5-qtgamepad-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtgamepad \
 "
