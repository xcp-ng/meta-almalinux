# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-lpeg-patterns"
PV = "0.5"
PR = "15.el10_1"
PACKAGES = " \
 lua-lpeg-patterns \
 lua5.1-lpeg-patterns \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-lpeg-patterns-0.5-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e694025d94c3db92cb60a601ff807951645540ce5fafeab5c017755d67e6003"

URI_x86_64_v2_lua-lpeg-patterns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-lpeg-patterns-0.5-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua-lpeg-patterns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-lpeg-patterns}"
SRC_URI[x86_64_v2_lua-lpeg-patterns.sha256sum] = "8561b60a808a15983b46edaf4314dbc3d96d4fdec627fd72052c6417c4477e11"

URI_x86_64_v2_lua5.1-lpeg-patterns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-lpeg-patterns-0.5-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua5.1-lpeg-patterns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-lpeg-patterns}"
SRC_URI[x86_64_v2_lua5.1-lpeg-patterns.sha256sum] = "18153b310d96fa0cf6f922f0e6ea631196110ca5bd2aa9ba04da75f74d68a12b"

URI_aarch64_lua-lpeg-patterns = "${EPEL_MIRROR}/aarch64/Packages/l/lua-lpeg-patterns-0.5-15.el10_1.noarch.rpm;name=aarch64_lua-lpeg-patterns;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-lpeg-patterns}"
SRC_URI[aarch64_lua-lpeg-patterns.sha256sum] = "a8550dcfb06d434b3805e965d347de874811c72b29e87e0e119567354da6175d"

URI_aarch64_lua5.1-lpeg-patterns = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-lpeg-patterns-0.5-15.el10_1.noarch.rpm;name=aarch64_lua5.1-lpeg-patterns;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-lpeg-patterns}"
SRC_URI[aarch64_lua5.1-lpeg-patterns.sha256sum] = "5b475e456c04e06c5e8fc10abc5cdd4f926c50ca7b815f9ac44176bbd109fe0f"

RDEPENDS:lua-lpeg-patterns = " \
 lua-lpeg \
 "
RDEPENDS:lua5.1-lpeg-patterns = " \
 lua5.1-lpeg \
 "
