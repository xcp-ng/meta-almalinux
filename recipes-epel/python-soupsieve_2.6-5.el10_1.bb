# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-soupsieve"
PV = "2.6"
PR = "5.el10_1"
PACKAGES = " \
 python3-soupsieve \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-soupsieve-2.6-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "843c623b27c505c739fbf12125e64d8defe065decb2749cd6ed8df827473da28"

URI_x86_64_v2_python3-soupsieve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-soupsieve-2.6-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-soupsieve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-soupsieve}"
SRC_URI[x86_64_v2_python3-soupsieve.sha256sum] = "2656a6b5876b4abb60f698f7e6625512bf5d3b3bc4fe5866ad7e7c3817f21cd7"

URI_aarch64_python3-soupsieve = "${EPEL_MIRROR}/aarch64/Packages/p/python3-soupsieve-2.6-5.el10_1.noarch.rpm;name=aarch64_python3-soupsieve;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-soupsieve}"
SRC_URI[aarch64_python3-soupsieve.sha256sum] = "6af05c54cd1cda75cc38b9710ceaa455d59d7a5599243ef794626e3e322b28a8"

RDEPENDS:python3-soupsieve = " \
 python3 \
 "
