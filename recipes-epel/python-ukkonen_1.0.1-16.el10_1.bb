# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ukkonen"
PV = "1.0.1"
PR = "16.el10_1"
PACKAGES = " \
 python3-ukkonen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ukkonen-1.0.1-16.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7667575a63e3fd7c6949654334902599cf790a986f86e609fbb55f9efb74eaf0"

URI_x86_64_v2_python3-ukkonen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ukkonen-1.0.1-16.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-ukkonen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ukkonen}"
SRC_URI[x86_64_v2_python3-ukkonen.sha256sum] = "a54118afc996b5642385ae58cc8436a8eb1c3e8019d3f8119d9e87bb116c8392"

URI_aarch64_python3-ukkonen = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ukkonen-1.0.1-16.el10_1.aarch64.rpm;name=aarch64_python3-ukkonen;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ukkonen}"
SRC_URI[aarch64_python3-ukkonen.sha256sum] = "719efd24494a1030063bf304008a33df7d4664fdf34883f8db990875cc42f694"

RDEPENDS:python3-ukkonen = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-cffi \
 "
