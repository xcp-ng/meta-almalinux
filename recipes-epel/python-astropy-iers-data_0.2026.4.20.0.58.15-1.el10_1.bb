# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-astropy-iers-data"
PV = "0.2026.4.20.0.58.15"
PR = "1.el10_1"
PACKAGES = " \
 python3-astropy-iers-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-astropy-iers-data-0.2026.4.20.0.58.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0231275f879902623c137d00d9877b8b275b68c5ef887d7393ff2235df4c2ee2"

URI_x86_64_v2_python3-astropy-iers-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-astropy-iers-data-0.2026.4.20.0.58.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-astropy-iers-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-astropy-iers-data}"
SRC_URI[x86_64_v2_python3-astropy-iers-data.sha256sum] = "974a8ffea5f36a4a929e071748ad6536ceaa7ff1dbfb0044224b1cad4b0f995b"

URI_aarch64_python3-astropy-iers-data = "${EPEL_MIRROR}/aarch64/Packages/p/python3-astropy-iers-data-0.2026.4.20.0.58.15-1.el10_1.noarch.rpm;name=aarch64_python3-astropy-iers-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-astropy-iers-data}"
SRC_URI[aarch64_python3-astropy-iers-data.sha256sum] = "224770c38c28c6aa17167773ff430fed15c30ad3547b3b51ad155558bcec5430"

RDEPENDS:python3-astropy-iers-data = " \
 python3 \
 "
