# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cattrs"
PV = "24.1.3"
PR = "2.el10_0"
PACKAGES = " \
 python3-cattrs \
 python3-cattrs+bson \
 python3-cattrs+msgpack \
 python3-cattrs+pyyaml \
 python3-cattrs+tomlkit \
 python3-cattrs+ujson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cattrs-24.1.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "083415722a17c960d26e62abb8a83d504f8cf45cfeed7aaa829cf990f3da74ba"

URI_x86_64_v2_python3-cattrs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs-24.1.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs}"
SRC_URI[x86_64_v2_python3-cattrs.sha256sum] = "dcef10fb5c620260adcc5a357ccc56d871a0e70f738869a889b6f997307b45dc"

URI_x86_64_v2_python3-cattrs+bson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+bson-24.1.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+bson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+bson}"
SRC_URI[x86_64_v2_python3-cattrs+bson.sha256sum] = "644e8798af8ddf18b6d2730a1a024e5e3f239386f9434e86d6dfef8b4b496cd2"

URI_x86_64_v2_python3-cattrs+msgpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+msgpack-24.1.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+msgpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+msgpack}"
SRC_URI[x86_64_v2_python3-cattrs+msgpack.sha256sum] = "a7b90e01668ccca8c9a10436584eb07e8ced8fb4590d1d836659804aedd4074d"

URI_x86_64_v2_python3-cattrs+pyyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+pyyaml-24.1.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+pyyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+pyyaml}"
SRC_URI[x86_64_v2_python3-cattrs+pyyaml.sha256sum] = "7b8398b102f6e74fb20220eea84f07f2ef5133f5fb599208644b1c1d50ad080e"

URI_x86_64_v2_python3-cattrs+tomlkit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+tomlkit-24.1.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+tomlkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+tomlkit}"
SRC_URI[x86_64_v2_python3-cattrs+tomlkit.sha256sum] = "1cf306e0e31a8b0c9f599d93cce3551ac9ad56ea3b91ec59f658cedfaafa33c7"

URI_x86_64_v2_python3-cattrs+ujson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+ujson-24.1.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+ujson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+ujson}"
SRC_URI[x86_64_v2_python3-cattrs+ujson.sha256sum] = "59e28c1dd0e67f515a285d598697cc3af8ece7d405f5e819b68be00a5ebcffa5"

URI_aarch64_python3-cattrs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs-24.1.3-2.el10_0.noarch.rpm;name=aarch64_python3-cattrs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs}"
SRC_URI[aarch64_python3-cattrs.sha256sum] = "41b17b0e7546d984f6d302a82c612e33ec7891e0f89bba66e52ecf38d557ff5d"

URI_aarch64_python3-cattrs+bson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+bson-24.1.3-2.el10_0.noarch.rpm;name=aarch64_python3-cattrs+bson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+bson}"
SRC_URI[aarch64_python3-cattrs+bson.sha256sum] = "1ec4b640aacd72127450e62a1a89b4f7b8da793ccb7b7c97b2aa455ef6f910a7"

URI_aarch64_python3-cattrs+msgpack = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+msgpack-24.1.3-2.el10_0.noarch.rpm;name=aarch64_python3-cattrs+msgpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+msgpack}"
SRC_URI[aarch64_python3-cattrs+msgpack.sha256sum] = "a0c7b54b631c53dfb8543179b5b2c1489a6188e718556957339c17d2e00d0fb8"

URI_aarch64_python3-cattrs+pyyaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+pyyaml-24.1.3-2.el10_0.noarch.rpm;name=aarch64_python3-cattrs+pyyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+pyyaml}"
SRC_URI[aarch64_python3-cattrs+pyyaml.sha256sum] = "b6f0a4ed529ee7ff30378f88ac5c0630b05bb49f4dab64542c43ac2f20da4121"

URI_aarch64_python3-cattrs+tomlkit = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+tomlkit-24.1.3-2.el10_0.noarch.rpm;name=aarch64_python3-cattrs+tomlkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+tomlkit}"
SRC_URI[aarch64_python3-cattrs+tomlkit.sha256sum] = "f9bafdf3787c0a1a1f50a37d5937aad1ccbf2acfcb8a7592efe3821029094d8e"

URI_aarch64_python3-cattrs+ujson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+ujson-24.1.3-2.el10_0.noarch.rpm;name=aarch64_python3-cattrs+ujson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+ujson}"
SRC_URI[aarch64_python3-cattrs+ujson.sha256sum] = "ff04c55c75b363d85854893f804425772ebd28afe25c7c92bc8a3bfb253e75c4"

RDEPENDS:python3-cattrs = " \
 python3 \
 python3-attrs \
 "
RDEPENDS:python3-cattrs+bson = " \
 python3 \
 python3-cattrs \
 python3-pymongo \
 "
RDEPENDS:python3-cattrs+msgpack = " \
 python3 \
 python3-cattrs \
 python3-msgpack \
 "
RDEPENDS:python3-cattrs+pyyaml = " \
 python3 \
 python3-cattrs \
 python3-pyyaml \
 "
RDEPENDS:python3-cattrs+tomlkit = " \
 python3 \
 python3-cattrs \
 python3-tomlkit \
 "
RDEPENDS:python3-cattrs+ujson = " \
 python3 \
 python3-cattrs \
 python3-ujson \
 "
