# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proptest-macro"
PV = "0.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-proptest-macro+default-devel \
 rust-proptest-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proptest-macro-0.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3eea0d30b657cf3203e9c54ad6d02e327b2b40c3f65442decb5d8d393831984a"

URI_x86_64_v2_rust-proptest-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-macro+default-devel-0.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-macro+default-devel}"
SRC_URI[x86_64_v2_rust-proptest-macro+default-devel.sha256sum] = "d3d1a1bcb3266005be6165fcea996588df2a7a8ea3009bd6d0cb2b9cf743a1f4"

URI_x86_64_v2_rust-proptest-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proptest-macro-devel-0.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proptest-macro-devel}"
SRC_URI[x86_64_v2_rust-proptest-macro-devel.sha256sum] = "d02d5eae33964f2d162fc098ec4cee395e82f81f22bd4bf7032bd36812b563c1"

URI_aarch64_rust-proptest-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-macro+default-devel-0.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-macro+default-devel}"
SRC_URI[aarch64_rust-proptest-macro+default-devel.sha256sum] = "bfd8dcc8a39f34239ed497189a60b64fe449681fa5fa9058b0dc1da58ece5a48"

URI_aarch64_rust-proptest-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proptest-macro-devel-0.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-proptest-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proptest-macro-devel}"
SRC_URI[aarch64_rust-proptest-macro-devel.sha256sum] = "7fa310e7ed9dd35ddf9f6e43842da1f4659f59e5d1e29b1262d06e39a6dabd05"

RDEPENDS:rust-proptest-macro+default-devel = " \
 cargo \
 rust-proptest-macro-devel \
 "
RDEPENDS:rust-proptest-macro-devel = " \
 cargo \
 rust \
 rust-convert_case+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
