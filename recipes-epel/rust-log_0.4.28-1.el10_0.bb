# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-log"
PV = "0.4.28"
PR = "1.el10_0"
PACKAGES = " \
 rust-log+default-devel \
 rust-log+kv-devel \
 rust-log+max_level_debug-devel \
 rust-log+max_level_error-devel \
 rust-log+max_level_info-devel \
 rust-log+max_level_off-devel \
 rust-log+max_level_trace-devel \
 rust-log+max_level_warn-devel \
 rust-log+release_max_level_debug-devel \
 rust-log+release_max_level_error-devel \
 rust-log+release_max_level_info-devel \
 rust-log+release_max_level_off-devel \
 rust-log+release_max_level_trace-devel \
 rust-log+release_max_level_warn-devel \
 rust-log+serde-devel \
 rust-log+std-devel \
 rust-log-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-log-0.4.28-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d1b42c4b904f57b6b97961800bdb4fd8a79e937796e1752d4b10489e6aa364a"

URI_x86_64_v2_rust-log+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+default-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+default-devel}"
SRC_URI[x86_64_v2_rust-log+default-devel.sha256sum] = "0323c7ce1df0dd0cf09eae4532954304b29d921fedb10e83a88ec77f9d3fb526"

URI_x86_64_v2_rust-log+kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+kv-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+kv-devel}"
SRC_URI[x86_64_v2_rust-log+kv-devel.sha256sum] = "0ebe14a8d5d26910dbc60abc4a16a10f73f665799a5aeb95cbb0f7376c0a45ae"

URI_x86_64_v2_rust-log+max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_debug-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_debug-devel.sha256sum] = "fd6ef2912b81c8ee96c63731ca53f70c2dc89b14d858feb5551f2ccd1b176205"

URI_x86_64_v2_rust-log+max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_error-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_error-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_error-devel.sha256sum] = "987b111a288452a2d177b36e39c9fd1a22c45ca5360b139d9c54c513721ee6b7"

URI_x86_64_v2_rust-log+max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_info-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_info-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_info-devel.sha256sum] = "51feda97f5d5176afbaa5b004b2da7bb9c9504ff46716ae4bb80f4e642cb0179"

URI_x86_64_v2_rust-log+max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_off-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_off-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_off-devel.sha256sum] = "fea1a24a9eb51c8e3a9fceb4d257d193d6bd672a0bf343326372fa93f025351a"

URI_x86_64_v2_rust-log+max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_trace-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_trace-devel.sha256sum] = "7ff1aff8402b1eb4f9423ae1aac13e9a280cc9f8bfbb213919d69849a3d9b57e"

URI_x86_64_v2_rust-log+max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_warn-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_warn-devel.sha256sum] = "0baaf0cc3f5932b58b9ac157958a5d65c2a20d6045781171db55d9efa66719d1"

URI_x86_64_v2_rust-log+release_max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_debug-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_debug-devel.sha256sum] = "be1470f5c50f2d9488971fdc8044e946633bc51eeae6aab46b2cc84d7b09da12"

URI_x86_64_v2_rust-log+release_max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_error-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_error-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_error-devel.sha256sum] = "168f0dbae3401a5f57ee6cc1e6663a0e707aeb0b1920c06388f4a8e0707706c8"

URI_x86_64_v2_rust-log+release_max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_info-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_info-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_info-devel.sha256sum] = "ce2cbd5a0168ef83d7008360fc205af1ac8b2cbc42b37483ed7b572c7c13b45a"

URI_x86_64_v2_rust-log+release_max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_off-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_off-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_off-devel.sha256sum] = "8d9006c6919bfb111370e6afc781accafa35e4dcbdbd2ba4a08ee88c163a6880"

URI_x86_64_v2_rust-log+release_max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_trace-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_trace-devel.sha256sum] = "e351a02595d1684c0ee9a735b5033165328bf255cc610f94f102eb1052c2eb52"

URI_x86_64_v2_rust-log+release_max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_warn-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_warn-devel.sha256sum] = "e62532ed99f23331ef3d9165b180cb8eda3b71e1d19af2aaeb3611ceb350a6d2"

URI_x86_64_v2_rust-log+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+serde-devel}"
SRC_URI[x86_64_v2_rust-log+serde-devel.sha256sum] = "fbda28e23ff8d7a37e5ebb74c71192e8345b549c0367c0b2075bf1c6a3a5a0a4"

URI_x86_64_v2_rust-log+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+std-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+std-devel}"
SRC_URI[x86_64_v2_rust-log+std-devel.sha256sum] = "4e2b64947394e6eda72e37f93558d244ddf858c11140de05bede092095fbc162"

URI_x86_64_v2_rust-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log-devel-0.4.28-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log-devel}"
SRC_URI[x86_64_v2_rust-log-devel.sha256sum] = "4a56c815d0cc2d358a276163ab7bd758463a29c4078583ccaae3a3c50ef7a89f"

URI_aarch64_rust-log+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+default-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+default-devel}"
SRC_URI[aarch64_rust-log+default-devel.sha256sum] = "07f16ffc58c8651f6ca20ccf91ce732388d2e27363f98040c3df026d744fbba2"

URI_aarch64_rust-log+kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+kv-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+kv-devel}"
SRC_URI[aarch64_rust-log+kv-devel.sha256sum] = "6f7476ca1922a345dfa5670cf69d83a23c567b2431d6d0208d23cd3b07bbb25b"

URI_aarch64_rust-log+max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_debug-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_debug-devel}"
SRC_URI[aarch64_rust-log+max_level_debug-devel.sha256sum] = "26522a9d513a6460dde338c9f8e4c6eb08848e86f8926673c9d81a814254b742"

URI_aarch64_rust-log+max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_error-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_error-devel}"
SRC_URI[aarch64_rust-log+max_level_error-devel.sha256sum] = "18f8a87ec6765f2b11f940f7cd40fea0bf3105514b17be90f7f144002ec9b560"

URI_aarch64_rust-log+max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_info-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_info-devel}"
SRC_URI[aarch64_rust-log+max_level_info-devel.sha256sum] = "4ec36916882fa84d47ea4ac2c1536fc16a0f8deb436b466c1c4358d2e743bb38"

URI_aarch64_rust-log+max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_off-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_off-devel}"
SRC_URI[aarch64_rust-log+max_level_off-devel.sha256sum] = "1b528127c424e365f08f28ea1f86c8914d7a422e47a56a39a39256d3702bd293"

URI_aarch64_rust-log+max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_trace-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_trace-devel}"
SRC_URI[aarch64_rust-log+max_level_trace-devel.sha256sum] = "718a22942c97edcac65e2b167531a51a63c052b6087c334386bd054bbc22e2e1"

URI_aarch64_rust-log+max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_warn-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_warn-devel}"
SRC_URI[aarch64_rust-log+max_level_warn-devel.sha256sum] = "b4b5fa9b87a321792ae8b2f3c022403576466cad6e564eee56db1f996cef9090"

URI_aarch64_rust-log+release_max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_debug-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_debug-devel}"
SRC_URI[aarch64_rust-log+release_max_level_debug-devel.sha256sum] = "4fdfa99fa38983f07c99ed19c45be4d0141a61e87f31c27119414c8bc2b4cb1b"

URI_aarch64_rust-log+release_max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_error-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_error-devel}"
SRC_URI[aarch64_rust-log+release_max_level_error-devel.sha256sum] = "97bbe77cb6fb9a5ef64ec18fe3f0c8cacced3aa42940e769fbaf365fea3e0284"

URI_aarch64_rust-log+release_max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_info-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_info-devel}"
SRC_URI[aarch64_rust-log+release_max_level_info-devel.sha256sum] = "1f9e8361440498383981f460fd7a0b75e2178ba20c150449a72c37a8dd4eef93"

URI_aarch64_rust-log+release_max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_off-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_off-devel}"
SRC_URI[aarch64_rust-log+release_max_level_off-devel.sha256sum] = "57ed7a2e1680c926bacb8af4713d7a2d6f57a6365da5cb96fcef1e23ae7fdc72"

URI_aarch64_rust-log+release_max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_trace-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_trace-devel}"
SRC_URI[aarch64_rust-log+release_max_level_trace-devel.sha256sum] = "bdd0459f8e08e7fcdb4bad909fb38470e2422e2e21b9bf88ab98e552f241a7d8"

URI_aarch64_rust-log+release_max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_warn-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_warn-devel}"
SRC_URI[aarch64_rust-log+release_max_level_warn-devel.sha256sum] = "dc65be6eeb735d0f09e5ba1443f316e7a068382acdcf66212490cac42106ed68"

URI_aarch64_rust-log+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+serde-devel}"
SRC_URI[aarch64_rust-log+serde-devel.sha256sum] = "0b529007f541551a8e1d12a1a5933844090aa889e80c9ae8d9318422a98b7a51"

URI_aarch64_rust-log+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+std-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+std-devel}"
SRC_URI[aarch64_rust-log+std-devel.sha256sum] = "162aed3b08f5c3b2eb5c88283712f342e3fe32a13553179cf878252019afd4ab"

URI_aarch64_rust-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log-devel-0.4.28-1.el10_0.noarch.rpm;name=aarch64_rust-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log-devel}"
SRC_URI[aarch64_rust-log-devel.sha256sum] = "ee07d333e16f6f687fb4036a40767763ea8efc5389dfba207067bb08796aea54"

RDEPENDS:rust-log+default-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+kv-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde-devel = " \
 cargo \
 rust-log-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-log+std-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log-devel = " \
 cargo \
 rust \
 "
