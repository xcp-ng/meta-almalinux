# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-microlens-ghc"
PV = "0.4.14.3"
PR = "1.el10_0"
PACKAGES = " \
 ghc-microlens-ghc \
 ghc-microlens-ghc-devel \
 ghc-microlens-ghc-doc \
 ghc-microlens-ghc-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-microlens-ghc-0.4.14.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "170ba7d6e67f92e862ac77b871f37bc6e8c0150b19835ec25dbf72ebc8e16e84"

URI_x86_64_v2_ghc-microlens-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-ghc-0.4.14.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-ghc}"
SRC_URI[x86_64_v2_ghc-microlens-ghc.sha256sum] = "f791036f14eb76ce7a8066e3d6f58784c540fa001439a616997027a513afa57e"

URI_x86_64_v2_ghc-microlens-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-ghc-devel-0.4.14.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-ghc-devel}"
SRC_URI[x86_64_v2_ghc-microlens-ghc-devel.sha256sum] = "289a132d99774d524d7029ec0e6746d8d1b7e9ae56dbb3e2f9fbeca127635e39"

URI_x86_64_v2_ghc-microlens-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-ghc-doc-0.4.14.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-microlens-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-ghc-doc}"
SRC_URI[x86_64_v2_ghc-microlens-ghc-doc.sha256sum] = "b18e79a343d081b68f980ebde5447c912d416475e9e2517a504ba450bb5f6a26"

URI_x86_64_v2_ghc-microlens-ghc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-ghc-prof-0.4.14.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-ghc-prof}"
SRC_URI[x86_64_v2_ghc-microlens-ghc-prof.sha256sum] = "d0f64d67ae43ec05ca187b116db3582839ee23561a919920a6257feb21324357"

URI_aarch64_ghc-microlens-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-ghc-0.4.14.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-ghc}"
SRC_URI[aarch64_ghc-microlens-ghc.sha256sum] = "4af48bc5d02f4f83b9fef55260399dcab193ba5a48b63bb66ac819ac3a0612e1"

URI_aarch64_ghc-microlens-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-ghc-devel-0.4.14.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-ghc-devel}"
SRC_URI[aarch64_ghc-microlens-ghc-devel.sha256sum] = "cf11aea0ffc7029d3ef40771a929679e0f58c302e1d659d419aa494243c76551"

URI_aarch64_ghc-microlens-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-ghc-doc-0.4.14.3-1.el10_0.noarch.rpm;name=aarch64_ghc-microlens-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-ghc-doc}"
SRC_URI[aarch64_ghc-microlens-ghc-doc.sha256sum] = "9257f3783d74cd21d1c2f1f354890e6e3202f1c75af9c81c251c366b09938d69"

URI_aarch64_ghc-microlens-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-ghc-prof-0.4.14.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-ghc-prof}"
SRC_URI[aarch64_ghc-microlens-ghc-prof.sha256sum] = "d97a16a952614bb2fc235c5591c3f40c1727d04caa63109c1a3b9ead7817d89c"

RDEPENDS:ghc-microlens-ghc = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-microlens \
 ghc-pretty \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-microlens-ghc-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-microlens-devel \
 ghc-microlens-ghc \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-microlens-ghc-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-microlens-ghc-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-microlens-ghc-devel \
 ghc-microlens-prof \
 ghc-transformers-prof \
 "
