# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ct-codecs"
PV = "1.1.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-ct-codecs+default-devel \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ct-codecs-1.1.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edfef1ea0d0b053e413f212d838c64c90caebf1ad403ec745be955d089ac5963"

URI_x86_64_v2_rust-ct-codecs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+default-devel-1.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs+default-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs+default-devel.sha256sum] = "b8aac1e4f69dba117985e06f05e3a5d0bafb79182a36eb47188393c8be1a9140"

URI_x86_64_v2_rust-ct-codecs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+std-devel-1.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs+std-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs+std-devel.sha256sum] = "98f458ce17a0422165374065d5d28b5ecba2d675d0aaca72d6341a77a42c96f5"

URI_x86_64_v2_rust-ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs-devel-1.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs-devel.sha256sum] = "35be3e5b4fdd203ec78acef426b954f8efc33dd03de4f663d92c3a6e193dbbcd"

URI_aarch64_rust-ct-codecs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+default-devel-1.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-ct-codecs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs+default-devel}"
SRC_URI[aarch64_rust-ct-codecs+default-devel.sha256sum] = "6cb186e9f851e73e5c89a7729609ab8ff3f1186ea8af9a0d656c0ff1c1de8627"

URI_aarch64_rust-ct-codecs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+std-devel-1.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-ct-codecs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs+std-devel}"
SRC_URI[aarch64_rust-ct-codecs+std-devel.sha256sum] = "59d3eb237f742e8fa66ec4f5d04a7d68695a875ed9926c0c734b713ae254ac58"

URI_aarch64_rust-ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs-devel-1.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs-devel}"
SRC_URI[aarch64_rust-ct-codecs-devel.sha256sum] = "6a00081ce3b07e09a616684bf4292c643664956c649e5e9e5902c7f366f93ffc"

RDEPENDS:rust-ct-codecs+default-devel = " \
 cargo \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs+std-devel = " \
 cargo \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs-devel = " \
 cargo \
 "
