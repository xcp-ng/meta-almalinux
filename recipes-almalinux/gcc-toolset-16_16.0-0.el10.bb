# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-16"
PV = "16.0"
PR = "0.el10"
PACKAGES = " \
 gcc-toolset-16-runtime \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-16-16.0-0.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c17e9410940c18bdc5807ccd35539f83f8c366db909cd5a8ae2810863586e6cd"

URI_x86_64_v2_gcc-toolset-16-runtime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-runtime-16.0-0.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-16-runtime}"
SRC_URI[x86_64_v2_gcc-toolset-16-runtime.sha256sum] = "ab78f0efa806696ea4629999bf14e0df3d2494e0eacb38f668cf405d6d0980f1"

URI_aarch64_gcc-toolset-16-runtime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-runtime-16.0-0.el10.aarch64.rpm;name=aarch64_gcc-toolset-16-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-16-runtime}"
SRC_URI[aarch64_gcc-toolset-16-runtime.sha256sum] = "b9279b1aaac5b471ca2c6d4171a4758f144c0877ab7d3ad1c72a219ca8500a20"

RDEPENDS:gcc-toolset-16-runtime = " \
 "
