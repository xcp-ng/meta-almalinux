# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgpg-error"
PV = "1.50"
PR = "2.el10"
PACKAGES = " \
 libgpg-error \
 libgpg-error-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libgpg-error-1.50-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c7cc5f23c201b10cf285d2137ddc3f8fe3f29bae6767662c3d4452482a9f8d2c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgpg-error-1.50-2.el10.x86_64_v2.rpm;name=x86_64_v2_libgpg-error;unpack=0"
SRC_URI[x86_64_v2_libgpg-error.sha256sum] = "776c0fb2b4275a9aea6a8c561ff10ec325340e8282ccba9a7fffd7f2df3d8870"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgpg-error-devel-1.50-2.el10.x86_64_v2.rpm;name=x86_64_v2_libgpg-error-devel;unpack=0"
SRC_URI[x86_64_v2_libgpg-error-devel.sha256sum] = "9b5e86b58aac13798931fab088a5e774d9b9ada02b55a10161953e0fc09c9c0e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgpg-error-1.50-2.el10.aarch64.rpm;name=aarch64_libgpg-error;unpack=0"
SRC_URI[aarch64_libgpg-error.sha256sum] = "0adb03b48d55c5fb74f7ae8142356a4af282234908933b5397df003e1022662a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgpg-error-devel-1.50-2.el10.aarch64.rpm;name=aarch64_libgpg-error-devel;unpack=0"
SRC_URI[aarch64_libgpg-error-devel.sha256sum] = "b566a48ef1513ca5455dbeb9c353809b7514c40fffb17a4e32e03e16388ec478"

RDEPENDS:libgpg-error = " \
 glibc \
 "
RDEPENDS:libgpg-error-devel = " \
 bash \
 glibc \
 libgpg-error \
 pkgconf-pkg-config \
 "
