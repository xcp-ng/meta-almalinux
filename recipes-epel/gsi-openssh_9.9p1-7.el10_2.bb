# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsi-openssh"
PV = "9.9p1"
PR = "7.el10_2"
PACKAGES = " \
 gsi-openssh \
 gsi-openssh-clients \
 gsi-openssh-keysign \
 gsi-openssh-server \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gsi-openssh-9.9p1-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8e53d23e1839aad735cca0cb55dfd6d5f753f89c11521a4f020dc11144ffcad6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-9.9p1-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh;unpack=0"
SRC_URI[x86_64_v2_gsi-openssh.sha256sum] = "878e8e4192cef3744a084430cb1782d78a8f84c3698dc423ab558844a6613f1d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-clients-9.9p1-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-clients;unpack=0"
SRC_URI[x86_64_v2_gsi-openssh-clients.sha256sum] = "c78799513af858789e0c3990e151588eb768dc0623688f2d15294afe515e04dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-keysign-9.9p1-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-keysign;unpack=0"
SRC_URI[x86_64_v2_gsi-openssh-keysign.sha256sum] = "a3bf238b01c280c5f819373c7e98b7ba2a293df718cccc3b028f3cc197088eef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-server-9.9p1-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-server;unpack=0"
SRC_URI[x86_64_v2_gsi-openssh-server.sha256sum] = "edc971c13af39f220b78f3b763f337d01e64ce8cf0bde267816f9615d491b6f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-9.9p1-7.el10_2.aarch64.rpm;name=aarch64_gsi-openssh;unpack=0"
SRC_URI[aarch64_gsi-openssh.sha256sum] = "26a3cc7ce430e316041199335837a9c8482778bb3db24aebddb6903c61ac1368"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-clients-9.9p1-7.el10_2.aarch64.rpm;name=aarch64_gsi-openssh-clients;unpack=0"
SRC_URI[aarch64_gsi-openssh-clients.sha256sum] = "044ba3f88965fa98220df499f321ddb1385b5c58ab0cd2217695052e7399daa0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-keysign-9.9p1-7.el10_2.aarch64.rpm;name=aarch64_gsi-openssh-keysign;unpack=0"
SRC_URI[aarch64_gsi-openssh-keysign.sha256sum] = "a9a043acabbb07cd57a33f17b8997908487ca3f4f2ebf85e6798602b3481103f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-server-9.9p1-7.el10_2.aarch64.rpm;name=aarch64_gsi-openssh-server;unpack=0"
SRC_URI[aarch64_gsi-openssh-server.sha256sum] = "407b8d75db110325a39e47585b880bac1ae5433e6173e99612df6e40acb6a4ad"

RDEPENDS:gsi-openssh = " \
 audit-libs \
 glibc \
 libgcc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:gsi-openssh-clients = " \
 crypto-policies \
 glibc \
 globus-gssapi-gsi \
 gsi-openssh \
 libedit \
 libfido2 \
 libgcc \
 libselinux \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-keysign = " \
 glibc \
 gsi-openssh \
 libgcc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 gsi-openssh \
 libgcc \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam \
 pam-libs \
 policycoreutils-python-utils \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
