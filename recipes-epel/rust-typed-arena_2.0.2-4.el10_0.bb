# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typed-arena"
PV = "2.0.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-typed-arena+default-devel \
 rust-typed-arena+std-devel \
 rust-typed-arena-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typed-arena-2.0.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ad7f5224c45c3d110c50fb7b3b874f65b3d37ad6b1ab2cf1cd05fd6cd342d7b"

URI_x86_64_v2_rust-typed-arena+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-arena+default-devel-2.0.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-arena+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-arena+default-devel}"
SRC_URI[x86_64_v2_rust-typed-arena+default-devel.sha256sum] = "044462fa27a86cf361fc06ec7f2c0cdbfd5ae055081817a9cb5ece19bb6a2276"

URI_x86_64_v2_rust-typed-arena+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-arena+std-devel-2.0.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-arena+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-arena+std-devel}"
SRC_URI[x86_64_v2_rust-typed-arena+std-devel.sha256sum] = "2ec8091612dc58271dd1c2f85c00663de69f5324a13396226f72cb50b3365c7c"

URI_x86_64_v2_rust-typed-arena-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-arena-devel-2.0.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-arena-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-arena-devel}"
SRC_URI[x86_64_v2_rust-typed-arena-devel.sha256sum] = "30aa1773178907f93dc8b6ba3513dde8ed684d38b47de34ca07181567fd8c69e"

URI_aarch64_rust-typed-arena+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-arena+default-devel-2.0.2-4.el10_0.noarch.rpm;name=aarch64_rust-typed-arena+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-arena+default-devel}"
SRC_URI[aarch64_rust-typed-arena+default-devel.sha256sum] = "f9e0baad94cdba21b79d836c78fe9094f7f31220b1ae187a75fff11fceaaa8eb"

URI_aarch64_rust-typed-arena+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-arena+std-devel-2.0.2-4.el10_0.noarch.rpm;name=aarch64_rust-typed-arena+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-arena+std-devel}"
SRC_URI[aarch64_rust-typed-arena+std-devel.sha256sum] = "7470e9a29032c68f9acdcd065c686b0ebbe158c0f6346efdd37c942e65b6bb0a"

URI_aarch64_rust-typed-arena-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-arena-devel-2.0.2-4.el10_0.noarch.rpm;name=aarch64_rust-typed-arena-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-arena-devel}"
SRC_URI[aarch64_rust-typed-arena-devel.sha256sum] = "8b6a2a12b81807931847f28cf8629e3203830ca5b133dcee13a88905d3d09324"

RDEPENDS:rust-typed-arena+default-devel = " \
 cargo \
 rust-typed-arena+std-devel \
 rust-typed-arena-devel \
 "
RDEPENDS:rust-typed-arena+std-devel = " \
 cargo \
 rust-typed-arena-devel \
 "
RDEPENDS:rust-typed-arena-devel = " \
 cargo \
 "
