# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm18"
PV = "18.1.8"
PR = "4.el10_0"
PACKAGES = " \
 llvm18 \
 llvm18-cmake-utils \
 llvm18-devel \
 llvm18-doc \
 llvm18-googletest \
 llvm18-libs \
 llvm18-static \
 llvm18-test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/llvm18-18.1.8-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "239e8a11a8b171100b744e221e2a8f38fdfd0dd3eead1a7b1ff24e1489ed0e29"

URI_x86_64_v2_llvm18 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-18.1.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18}"
SRC_URI[x86_64_v2_llvm18.sha256sum] = "9d0fad7457954ba6ef00f579e59d14f54e953e45860c1f2a364a685f4c85b01a"

URI_x86_64_v2_llvm18-cmake-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-cmake-utils-18.1.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-cmake-utils}"
SRC_URI[x86_64_v2_llvm18-cmake-utils.sha256sum] = "92f79a3c12133769b0c3a3813902787c1c2f871490599ed410ac1b2915764337"

URI_x86_64_v2_llvm18-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-devel-18.1.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-devel}"
SRC_URI[x86_64_v2_llvm18-devel.sha256sum] = "296c7c4e30f3933c1d41859563bc690c468f2f8d1d3d197907256db1d72bf54a"

URI_x86_64_v2_llvm18-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-doc-18.1.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_llvm18-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-doc}"
SRC_URI[x86_64_v2_llvm18-doc.sha256sum] = "726f4178a2b41a9fd7531ebb947c2ad440becc4912c0faee2756c365a6a9a87d"

URI_x86_64_v2_llvm18-googletest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-googletest-18.1.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-googletest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-googletest}"
SRC_URI[x86_64_v2_llvm18-googletest.sha256sum] = "d79b362a4cdc145ae5f6082165fd69eab4bdae102d3fbeea5406d3992fdec3ee"

URI_x86_64_v2_llvm18-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-libs-18.1.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-libs}"
SRC_URI[x86_64_v2_llvm18-libs.sha256sum] = "95a9648421caa2e05d41506bc99181de81eae8cce54e14e57ddd05bcbe82769c"

URI_x86_64_v2_llvm18-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-static-18.1.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-static}"
SRC_URI[x86_64_v2_llvm18-static.sha256sum] = "a746f248a1c69b45cb0b88bf38c7cc55ce057809d5f1c35b3947dad8715d4eb9"

URI_x86_64_v2_llvm18-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm18-test-18.1.8-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm18-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm18-test}"
SRC_URI[x86_64_v2_llvm18-test.sha256sum] = "265ce0379a2d7c1d41411963fb5bf4c06e309c6144c03dc89378fd47d497f583"

URI_aarch64_llvm18 = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-18.1.8-4.el10_0.aarch64.rpm;name=aarch64_llvm18;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18}"
SRC_URI[aarch64_llvm18.sha256sum] = "8b294e5299ce94b71ff0268d598473feea9542a3b9e861b1afdd4c8bef450306"

URI_aarch64_llvm18-cmake-utils = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-cmake-utils-18.1.8-4.el10_0.aarch64.rpm;name=aarch64_llvm18-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-cmake-utils}"
SRC_URI[aarch64_llvm18-cmake-utils.sha256sum] = "6f0f893dc2a52dd8728d64edfc3617d098ceb7ecb68d5030fd3574e7c53e04f3"

URI_aarch64_llvm18-devel = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-devel-18.1.8-4.el10_0.aarch64.rpm;name=aarch64_llvm18-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-devel}"
SRC_URI[aarch64_llvm18-devel.sha256sum] = "479de868e4bc9e28232409056bdcfa51febf8c1368422eab865018c3c1c2fd86"

URI_aarch64_llvm18-doc = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-doc-18.1.8-4.el10_0.noarch.rpm;name=aarch64_llvm18-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-doc}"
SRC_URI[aarch64_llvm18-doc.sha256sum] = "506bc5dbd82751f21779a33b3b0b9e0545fc942bf54b4ad4cf8b2828f8f462e2"

URI_aarch64_llvm18-googletest = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-googletest-18.1.8-4.el10_0.aarch64.rpm;name=aarch64_llvm18-googletest;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-googletest}"
SRC_URI[aarch64_llvm18-googletest.sha256sum] = "337bae2e7ba11debf4c90de2a355650f75ad7f22bc533658315ff06c92261ed8"

URI_aarch64_llvm18-libs = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-libs-18.1.8-4.el10_0.aarch64.rpm;name=aarch64_llvm18-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-libs}"
SRC_URI[aarch64_llvm18-libs.sha256sum] = "14718557570ba9c1096ef56d4b89f13e2dd3a065e1139af8e9cb9652544fe3bc"

URI_aarch64_llvm18-static = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-static-18.1.8-4.el10_0.aarch64.rpm;name=aarch64_llvm18-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-static}"
SRC_URI[aarch64_llvm18-static.sha256sum] = "1dd9b1dff3fd7147add7f072422839e329ab0d4af8ce8ad9c1ebdb330ac66972"

URI_aarch64_llvm18-test = "${EPEL_MIRROR}/aarch64/Packages/l/llvm18-test-18.1.8-4.el10_0.aarch64.rpm;name=aarch64_llvm18-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm18-test}"
SRC_URI[aarch64_llvm18-test.sha256sum] = "ee105305e22d5528fa6332115f8e0eb74aba9d4cffbcbd59c8bcb006058fbaf4"

RDEPENDS:llvm18 = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm18-libs \
 ncurses-libs \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:llvm18-cmake-utils = " \
 "
RDEPENDS:llvm18-devel = " \
 alternatives \
 bash \
 libedit-devel \
 llvm18 \
 llvm18-googletest \
 llvm18-libs \
 llvm18-static \
 llvm18-test \
 "
RDEPENDS:llvm18-doc = " \
 llvm18 \
 "
RDEPENDS:llvm18-googletest = " \
 "
RDEPENDS:llvm18-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:llvm18-static = " \
 "
RDEPENDS:llvm18-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm18 \
 llvm18-libs \
 ncurses-libs \
 "
