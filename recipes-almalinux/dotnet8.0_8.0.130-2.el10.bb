# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet8.0"
PV = "8.0.130"
PR = "2.el10"
PACKAGES = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-runtime-dbg-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-hostfxr-8.0 \
 dotnet-runtime-8.0 \
 dotnet-runtime-dbg-8.0 \
 dotnet-sdk-8.0 \
 dotnet-sdk-8.0-source-built-artifacts \
 dotnet-sdk-dbg-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet8.0-8.0.130-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d8d7656626d8d82f525c68a6751da9b1332f39a8ceff16bbceb067da4fdd522"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-8.0-8.0.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-8.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-8.0.sha256sum] = "02032d187bbebc16a7f8f3889ef2e1d080bbe9d99b1fb301a5cd3127fcbbf104"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-8.0.sha256sum] = "02fd209559e917b63cbf868400a154404f88b7eb26ccf4e0e2e3143cb699fd14"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-8.0-8.0.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-8.0.sha256sum] = "0a6e389f584add8e8e1ee3849cb4e4a7df35084b41d8c9deaa350dd66dd3c2b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-8.0-8.0.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-apphost-pack-8.0.sha256sum] = "168d435ed6a605459dcdf0a86af84a208f563df04693480959e7e1d486608802"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-8.0-8.0.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-hostfxr-8.0.sha256sum] = "fc6e33ff48aee2a1e417a75f6766e1c75c4beb2a4a78d06f93d0e93f2380eb59"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-8.0-8.0.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-8.0.sha256sum] = "888a04e424eb53d6d35d40a493ea7d03e9ab2bf03181121b633f85dd3cdf25a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-8.0-8.0.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-8.0.sha256sum] = "89c35aa8d6e22a722a3622f071f6bf7ee3ec0988a34cffdd62fb62a351fd21b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-8.0-8.0.130-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-8.0.sha256sum] = "a92f88996985edeca36968401ed6e53c70717ef173aa8d172b3050775cd9f394"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.130-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "9d263f7ba1357cc37b66aabc6be7bc1346cc5995c0d4a0517f5244c3332de4c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-8.0-8.0.130-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-8.0.sha256sum] = "a17bb2c4d48f4dd8a8da9aa86e718d18d56ef81f1e8d7b49729218c2b0fec1ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-8.0-8.0.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-targeting-pack-8.0.sha256sum] = "c340977597c642e38a196111ebcb89aa2e2ecef6f721e2b5923e30285a0e6404"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-8.0-8.0.130-2.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-templates-8.0.sha256sum] = "c5d1db786dd40937e6714de5ca9049c7fe7f5d1074b20548cb10956d3614d415"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-8.0-8.0.30-2.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-8.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-8.0.sha256sum] = "a5a26466c6ad1b30fc41a97fc35524521bc7fc6c6ee75e405cae4cfc9e017800"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.30-2.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-dbg-8.0.sha256sum] = "1707a9c938098c0a13c163783eae8804e06306b62096f04f21859a0fcd3117be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-8.0-8.0.30-2.el10.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI[aarch64_aspnetcore-targeting-pack-8.0.sha256sum] = "fe2c40e9b09a4db7d33e2278c33cac04296601af3b89c11dfe1bc1f09f0fb6aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-8.0-8.0.30-2.el10.aarch64.rpm;name=aarch64_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI[aarch64_dotnet-apphost-pack-8.0.sha256sum] = "f3d22dc906e527ac9ca9bbe5bab2b8a66d633116213b2d24a536f113554796cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-8.0-8.0.30-2.el10.aarch64.rpm;name=aarch64_dotnet-hostfxr-8.0;unpack=0"
SRC_URI[aarch64_dotnet-hostfxr-8.0.sha256sum] = "50a60b423971c18bd7f3c275b0e5bbdf95a5c4d06f5c5b01b53e6d2ce2d83051"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-8.0-8.0.30-2.el10.aarch64.rpm;name=aarch64_dotnet-runtime-8.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-8.0.sha256sum] = "94595fdbd41db382551ba65a9634f884fad32b81187c55f74b97128b4ffa954f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-8.0-8.0.30-2.el10.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-dbg-8.0.sha256sum] = "0e685c649f43f6ced44bee49bf98a51f5d01c7c5ac3cdb6211c9135978fecce8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-8.0-8.0.130-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-8.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-8.0.sha256sum] = "8ae7a72c2585d9014b04db337907e0a0f38c84bfb88377984b28195d554053c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.130-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI[aarch64_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "e0f1f707d04ad7c1170b130cedfa84815aed4a9cbd3f4125d482b48751046a38"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-8.0-8.0.130-2.el10.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-dbg-8.0.sha256sum] = "9f0d4d8a0c73676e34f10d372c6825398fa82f76ce7b78045dde82baf4e94ff2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-8.0-8.0.30-2.el10.aarch64.rpm;name=aarch64_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI[aarch64_dotnet-targeting-pack-8.0.sha256sum] = "6e95a8457c17423838fd66faf0a8fcbacec430e6ed289bbab2b71fab5777d9e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-8.0-8.0.130-2.el10.aarch64.rpm;name=aarch64_dotnet-templates-8.0;unpack=0"
SRC_URI[aarch64_dotnet-templates-8.0.sha256sum] = "6878f5e4c47ce6a44d5a7a62a3f55d025cf8a0bba44531e2d4417fed1fa5f1d5"

RDEPENDS:aspnetcore-runtime-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-8.0 = " \
 aspnetcore-runtime-8.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-8.0 = " \
 dotnet-hostfxr-8.0 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:dotnet-sdk-8.0 = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-runtime-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-8.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-dbg-8.0 = " \
 dotnet-sdk-8.0 \
 "
RDEPENDS:dotnet-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-8.0 = " \
 dotnet-host \
 "
