# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnvme"
PV = "1.11.1"
PR = "1.el10"
PACKAGES = " \
 libnvme \
 libnvme-devel \
 python3-libnvme \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libnvme-1.11.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82236c2222c6b7b027279708f08399c67de071e2fb090854772b8cd40d3b90e6"

URI_x86_64_v2_libnvme = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnvme-1.11.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnvme}"
SRC_URI[x86_64_v2_libnvme.sha256sum] = "fa1fa9be60cf39703fc3ba8550ade09e52b8e4690843c504e85ffdf9706ab6b9"

URI_x86_64_v2_libnvme-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnvme-devel-1.11.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnvme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnvme-devel}"
SRC_URI[x86_64_v2_libnvme-devel.sha256sum] = "8fafd335305cce2d219706879b2f1c5d249cfeda8a41d27e1f8406583bfefcb3"

URI_x86_64_v2_python3-libnvme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnvme-1.11.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libnvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnvme}"
SRC_URI[x86_64_v2_python3-libnvme.sha256sum] = "1f527ee6d1e67b8e05480f94a7f9ea4de9e23bc4121c9f31b8604319be4f691a"

URI_aarch64_libnvme = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnvme-1.11.1-1.el10.aarch64.rpm;name=aarch64_libnvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnvme}"
SRC_URI[aarch64_libnvme.sha256sum] = "b22e63537bdecb8d0fdef1a3657250f9cbab31d0829004733c39aa6658a8c955"

URI_aarch64_libnvme-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnvme-devel-1.11.1-1.el10.aarch64.rpm;name=aarch64_libnvme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnvme-devel}"
SRC_URI[aarch64_libnvme-devel.sha256sum] = "6651ef7f2f193ecd2081366af70f4fd4a82567d00d76c978e719e3beb7b42f8b"

URI_aarch64_python3-libnvme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnvme-1.11.1-1.el10.aarch64.rpm;name=aarch64_python3-libnvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnvme}"
SRC_URI[aarch64_python3-libnvme.sha256sum] = "b397e53a1de7185603123942fe0f13afd8067bef5f73b28a668ef251a05ccbd7"

RDEPENDS:libnvme = " \
 dbus-libs \
 glibc \
 json-c \
 keyutils-libs \
 libgcc \
 openssl-libs \
 "
RDEPENDS:libnvme-devel = " \
 dbus-devel \
 json-c-devel \
 keyutils-libs-devel \
 libnvme \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libnvme = " \
 glibc \
 libnvme \
 python3 \
 "
