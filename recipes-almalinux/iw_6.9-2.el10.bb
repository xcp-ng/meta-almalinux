# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iw"
PV = "6.9"
PR = "2.el10"
PACKAGES = " \
 iw \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iw-6.9-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ef6ae62cd1c889a6b18fef37ceff163375870351ead3888994d00a271fe2856"

URI_x86_64_v2_iw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iw-6.9-2.el10.x86_64_v2.rpm;name=x86_64_v2_iw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iw}"
SRC_URI[x86_64_v2_iw.sha256sum] = "9fe2ed36366895459a96cffe288a12aa0171385a78b3354b80087cc3f0117cf4"

URI_aarch64_iw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iw-6.9-2.el10.aarch64.rpm;name=aarch64_iw;unpack=0"
SRC_URI:append = " ${URI_aarch64_iw}"
SRC_URI[aarch64_iw.sha256sum] = "5f4feeafe65f1f262f6b3c09a086fe9340bcbd725870e77a5fad8beef40c4b5f"

RDEPENDS:iw = " \
 glibc \
 libnl3 \
 "
