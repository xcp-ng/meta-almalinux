# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "curl"
PV = "8.12.1"
PR = "4.el10_2.4"
PACKAGES = " \
 curl \
 libcurl \
 libcurl-devel \
 libcurl-minimal \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/curl-8.12.1-4.el10_2.4.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a37b137b2823872f91e880b457f8d6a94ec272e4d10ddf40ddaac1ef6d2d15cb"

URI_x86_64_v2_curl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/curl-8.12.1-4.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_curl}"
SRC_URI[x86_64_v2_curl.sha256sum] = "37da4bf56a499803dbfa6b5055d96fb6774b7306c9286220dbff76bdcbe0138c"
RPROVIDES:curl:x86_64_v2 = "virtual/wget_or_curl"

URI_x86_64_v2_libcurl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcurl-8.12.1-4.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_libcurl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcurl}"
SRC_URI[x86_64_v2_libcurl.sha256sum] = "23098ced8cb514ed1b00e18230501e15d4de6859317cf7d44482a8912de88407"
RPROVIDES:libcurl:x86_64_v2 = "virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2 virtual/libcurl_x86-64_ virtual/libcurl_x86-64__eq_8.12.1-4.el10_2.4 virtual/libcurl_x86-64__ge_7.29.0 virtual/libcurl_x86-64__ge_7.52.0 virtual/libcurl_x86-64__ge_8.12.1-4.el10_2.4 virtual/libcurl_x86-64__ge_8.9.1"

URI_x86_64_v2_libcurl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcurl-devel-8.12.1-4.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_libcurl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcurl-devel}"
SRC_URI[x86_64_v2_libcurl-devel.sha256sum] = "6b00a1f78b84ad5c1f3edfe972e2cfa1f7ae4c18e6406a15f59d6e2b574b30ff"

URI_x86_64_v2_libcurl-minimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcurl-minimal-8.12.1-4.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_libcurl-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcurl-minimal}"
SRC_URI[x86_64_v2_libcurl-minimal.sha256sum] = "93e1f6b20de464392091e0ec12f33dd1cea062f64298fdb731041a2756a7d354"
RPROVIDES:libcurl-minimal:x86_64_v2 = "virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2 virtual/libcurl_x86-64_ virtual/libcurl_x86-64__eq_8.12.1-4.el10_2.4 virtual/libcurl_x86-64__ge_7.29.0 virtual/libcurl_x86-64__ge_7.52.0 virtual/libcurl_x86-64__ge_8.12.1-4.el10_2.4 virtual/libcurl_x86-64__ge_8.9.1"

URI_aarch64_curl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/curl-8.12.1-4.el10_2.4.aarch64.rpm;name=aarch64_curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_curl}"
SRC_URI[aarch64_curl.sha256sum] = "4eb8a3737ddfa0586c3e63b0b59f0214888ff9768444f4be33b1124b8bb82a29"
RPROVIDES:curl:aarch64 = "virtual/wget_or_curl"

URI_aarch64_libcurl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcurl-8.12.1-4.el10_2.4.aarch64.rpm;name=aarch64_libcurl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcurl}"
SRC_URI[aarch64_libcurl.sha256sum] = "6142ca21fdf24a40d30291b60e1d10da4c1e2d8fb405f83df089c447df756d67"
RPROVIDES:libcurl:aarch64 = "virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_aarch-64_ virtual/libcurl_aarch-64__eq_8.12.1-4.el10_2.4 virtual/libcurl_aarch-64__ge_7.29.0 virtual/libcurl_aarch-64__ge_7.52.0 virtual/libcurl_aarch-64__ge_8.12.1-4.el10_2.4 virtual/libcurl_aarch-64__ge_8.9.1 virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2"

URI_aarch64_libcurl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcurl-devel-8.12.1-4.el10_2.4.aarch64.rpm;name=aarch64_libcurl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcurl-devel}"
SRC_URI[aarch64_libcurl-devel.sha256sum] = "891a2cd2f15edbcbe731726dd5a647faa3b0d7727fa5954d905287ad48e4fe9f"

URI_aarch64_libcurl-minimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcurl-minimal-8.12.1-4.el10_2.4.aarch64.rpm;name=aarch64_libcurl-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcurl-minimal}"
SRC_URI[aarch64_libcurl-minimal.sha256sum] = "c96b8c324cc998d8dd0cf124ee792b1d869c1783f8ee7e91fda3261a8e596a66"
RPROVIDES:libcurl-minimal:aarch64 = "virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_aarch-64_ virtual/libcurl_aarch-64__eq_8.12.1-4.el10_2.4 virtual/libcurl_aarch-64__ge_7.29.0 virtual/libcurl_aarch-64__ge_7.52.0 virtual/libcurl_aarch-64__ge_8.12.1-4.el10_2.4 virtual/libcurl_aarch-64__ge_8.9.1 virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2"

RDEPENDS:curl:x86_64_v2 = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_8.12.1-4.el10_2.4 \
"
RDEPENDS:curl:aarch64 = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_8.12.1-4.el10_2.4 \
"
RDEPENDS:libcurl = " \
 glibc \
 krb5-libs \
 libbrotli \
 libidn2 \
 libnghttp2 \
 libpsl \
 libssh \
 openldap \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libcurl-devel:x86_64_v2 = " \
 bash \
 brotli-devel \
 krb5-devel \
 libidn2-devel \
 libnghttp2-devel \
 libpsl-devel \
 libssh-devel \
 openssl-devel \
 pkgconf-pkg-config \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__eq_8.12.1-4.el10_2.4 \
 zlib-ng-compat-devel \
"
RDEPENDS:libcurl-devel:aarch64 = " \
 bash \
 brotli-devel \
 krb5-devel \
 libidn2-devel \
 libnghttp2-devel \
 libpsl-devel \
 libssh-devel \
 openssl-devel \
 pkgconf-pkg-config \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__eq_8.12.1-4.el10_2.4 \
 zlib-ng-compat-devel \
"
RDEPENDS:libcurl-minimal = " \
 glibc \
 krb5-libs \
 libidn2 \
 libnghttp2 \
 openssl-libs \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libcurl rpm/virtual/libcurl.so.4___64bit_ rpm/virtual/libcurl_ge_7.12.0 rpm/virtual/libcurl_ge_7.21.7-2 rpm/virtual/libcurl_x86-64_ rpm/virtual/libcurl_x86-64__eq_8.12.1-4.el10_2.4 rpm/virtual/libcurl_x86-64__ge_7.29.0 rpm/virtual/libcurl_x86-64__ge_7.52.0 rpm/virtual/libcurl_x86-64__ge_8.12.1-4.el10_2.4 rpm/virtual/libcurl_x86-64__ge_8.9.1 rpm/virtual/wget_or_curl"

PROVIDES:append:aarch64 = " rpm/virtual/libcurl rpm/virtual/libcurl.so.4___64bit_ rpm/virtual/libcurl_aarch-64_ rpm/virtual/libcurl_aarch-64__eq_8.12.1-4.el10_2.4 rpm/virtual/libcurl_aarch-64__ge_7.29.0 rpm/virtual/libcurl_aarch-64__ge_7.52.0 rpm/virtual/libcurl_aarch-64__ge_8.12.1-4.el10_2.4 rpm/virtual/libcurl_aarch-64__ge_8.9.1 rpm/virtual/libcurl_ge_7.12.0 rpm/virtual/libcurl_ge_7.21.7-2 rpm/virtual/wget_or_curl"
