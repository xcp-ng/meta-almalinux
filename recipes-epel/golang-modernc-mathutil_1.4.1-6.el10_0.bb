# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-modernc-mathutil"
PV = "1.4.1"
PR = "6.el10_0"
PACKAGES = " \
 golang-modernc-mathutil-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-modernc-mathutil-1.4.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8dbe78d6de9fa166c619923fb6877423fa8d61043088c449ca84d0cd830b9fff"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-modernc-mathutil-devel: golang(github.com/remyoudompheng/bigfft)

URI_x86_64_v2_golang-modernc-mathutil-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-modernc-mathutil-devel-1.4.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-modernc-mathutil-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-modernc-mathutil-devel}"
SRC_URI[x86_64_v2_golang-modernc-mathutil-devel.sha256sum] = "3b970a07ff906b4be0739a6d71322a0cb0c7d37b93d666536a3311785c52d115"

URI_aarch64_golang-modernc-mathutil-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-modernc-mathutil-devel-1.4.1-6.el10_0.noarch.rpm;name=aarch64_golang-modernc-mathutil-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-modernc-mathutil-devel}"
SRC_URI[aarch64_golang-modernc-mathutil-devel.sha256sum] = "c19f513f57b412dbd00c8c5af99436215d0bddc2f801837d353715b9ac6c86fe"

RDEPENDS:golang-modernc-mathutil-devel:x86_64_v2 = " \
 go-filesystem \
"
RDEPENDS:golang-modernc-mathutil-devel:aarch64 = " \
 go-filesystem \
 golang-github-remyoudompheng-bigfft-devel \
"
