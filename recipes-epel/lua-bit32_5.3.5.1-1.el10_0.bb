# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-bit32"
PV = "5.3.5.1"
PR = "1.el10_0"
PACKAGES = " \
 lua-bit32 \
 lua5.1-bit32 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-bit32-5.3.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "193a7a04d07c71bb209313c7892e226dab8424772bedacc30f76ddf9b68ec74e"

URI_x86_64_v2_lua-bit32 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-bit32-5.3.5.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-bit32;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-bit32}"
SRC_URI[x86_64_v2_lua-bit32.sha256sum] = "7052f3e77433a4a2a6f4201d3c32fd54628a0b53b5e8b216036467b055c90832"

URI_x86_64_v2_lua5.1-bit32 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-bit32-5.3.5.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua5.1-bit32;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-bit32}"
SRC_URI[x86_64_v2_lua5.1-bit32.sha256sum] = "a2a9ba29a50b1914fc3bbc032b008e8f80e284e5315ad551479d7a1bfe351dbb"

URI_aarch64_lua-bit32 = "${EPEL_MIRROR}/aarch64/Packages/l/lua-bit32-5.3.5.1-1.el10_0.aarch64.rpm;name=aarch64_lua-bit32;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-bit32}"
SRC_URI[aarch64_lua-bit32.sha256sum] = "0a772eac47d903137e3ecb076d68276003635571e82179554212acc9c469c962"

URI_aarch64_lua5.1-bit32 = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-bit32-5.3.5.1-1.el10_0.aarch64.rpm;name=aarch64_lua5.1-bit32;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-bit32}"
SRC_URI[aarch64_lua5.1-bit32.sha256sum] = "02e6a6f986e3fdf27655e9797ec1b2a83e6292493fcbbd29a112bb3df564f274"

RDEPENDS:lua-bit32 = " \
 glibc \
 lua-libs \
 "
RDEPENDS:lua5.1-bit32 = " \
 compat-lua-libs \
 glibc \
 "
