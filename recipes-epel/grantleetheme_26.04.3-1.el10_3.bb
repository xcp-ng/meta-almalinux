# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grantleetheme"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 grantleetheme \
 grantleetheme-devel \
 grantleetheme-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grantleetheme-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0586f56252d5538f6fdd6363aaee21253b1cfbd95791a40bd3641f6393b08486"

URI_x86_64_v2_grantleetheme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantleetheme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme}"
SRC_URI[x86_64_v2_grantleetheme.sha256sum] = "34213a93043c064692f0d61a69a5cabfb8cecceb30fe810cf1588cf3a1341499"

URI_x86_64_v2_grantleetheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantleetheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme-devel}"
SRC_URI[x86_64_v2_grantleetheme-devel.sha256sum] = "b4abe5c38459e29c65cb40588f6a8f8eef389aeb03fd8896cf4af227ddfbc8c7"

URI_x86_64_v2_grantleetheme-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_grantleetheme-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme-doc}"
SRC_URI[x86_64_v2_grantleetheme-doc.sha256sum] = "b76ee58a946b9a8894f0ce6265bc3c078a72dca2a72669842cdae2fcec8734ba"

URI_aarch64_grantleetheme = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_grantleetheme;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme}"
SRC_URI[aarch64_grantleetheme.sha256sum] = "a4becf0fe4ba3e82bed3347b1b9954a223fef1e0cd283ec429437df64bbc2ad4"

URI_aarch64_grantleetheme-devel = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_grantleetheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme-devel}"
SRC_URI[aarch64_grantleetheme-devel.sha256sum] = "51760399c3134e9600624eec1fec9b4ed8c4d3ffa29795d69497e60418cfb1a1"

URI_aarch64_grantleetheme-doc = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_grantleetheme-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme-doc}"
SRC_URI[aarch64_grantleetheme-doc.sha256sum] = "2d5861850a0f702892367e5230693e68d83939f8981f2f5fd1f887bf767ea2e9"

RDEPENDS:grantleetheme = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knewstuff \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:grantleetheme-devel = " \
 cmake-filesystem \
 grantleetheme \
 kf6-ktexttemplate-devel \
 "
RDEPENDS:grantleetheme-doc = " \
 "
