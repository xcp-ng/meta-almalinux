# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "terminator"
PV = "2.1.5"
PR = "1.el10_2.1"
PACKAGES = " \
 terminator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/terminator-2.1.5-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "300731b659a3550112a8034fe2fff2a75bd0c0fea2c12b1f3cc9868dc2f073e8"

URI_x86_64_v2_terminator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/terminator-2.1.5-1.el10_2.1.alma_altarch.1.noarch.rpm;name=x86_64_v2_terminator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_terminator}"
SRC_URI[x86_64_v2_terminator.sha256sum] = "117c2c63576f7e366c4b40d8c02590ed45fc428f8b277b165ff6b0a70f626dd2"

URI_aarch64_terminator = "${EPEL_MIRROR}/aarch64/Packages/t/terminator-2.1.5-1.el10_2.1.noarch.rpm;name=aarch64_terminator;unpack=0"
SRC_URI:append = " ${URI_aarch64_terminator}"
SRC_URI[aarch64_terminator.sha256sum] = "00a815be962c51f2dc9f8dfadff177635d79c9c6426c8302a583e341c4a04533"

RDEPENDS:terminator = " \
 keybinder3 \
 python3 \
 python3-cairo \
 python3-configobj \
 python3-dbus \
 python3-gobject \
 python3-gobject-base \
 python3-psutil \
 vte291 \
 "
