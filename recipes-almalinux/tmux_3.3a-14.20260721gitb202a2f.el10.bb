# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tmux"
PV = "3.3a"
PR = "14.20260721gitb202a2f.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tmux-3.3a-14.20260721gitb202a2f.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff38020ea74a7ac38d5fd0fbd4c7c91ee5425e5bb9f6b7870558d2df7e2edd08"

