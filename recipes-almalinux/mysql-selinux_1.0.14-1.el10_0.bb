# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysql-selinux"
PV = "1.0.14"
PR = "1.el10_0"
PACKAGES = " \
 mysql-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mysql-selinux-1.0.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77b50027ed7933b14f9410d502a299f89de2b305d0ad6eaa8c2b20c3da4a7fe8"

URI_x86_64_v2_mysql-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql-selinux-1.0.14-1.el10_0.noarch.rpm;name=x86_64_v2_mysql-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysql-selinux}"
SRC_URI[x86_64_v2_mysql-selinux.sha256sum] = "393b6ef07b98aba06d8d9ec311bc54f97f64c3fd2729aaa30024c7861cd21427"

URI_aarch64_mysql-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql-selinux-1.0.14-1.el10_0.noarch.rpm;name=aarch64_mysql-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysql-selinux}"
SRC_URI[aarch64_mysql-selinux.sha256sum] = "393b6ef07b98aba06d8d9ec311bc54f97f64c3fd2729aaa30024c7861cd21427"

RDEPENDS:mysql-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
