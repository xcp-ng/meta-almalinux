# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-junegunn-shellwords"
PV = "0"
PR = "0.1.20241027gita62c48c.el10_0"
PACKAGES = " \
 golang-github-junegunn-shellwords-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-junegunn-shellwords-0-0.1.20241027gita62c48c.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b855256d1938b0a64ba6d6ced33a0102b03c6efea43cf4173bf3f41b1a622ff7"

URI_aarch64_golang-github-junegunn-shellwords-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-junegunn-shellwords-devel-0-0.1.20241027gita62c48c.el10_0.noarch.rpm;name=aarch64_golang-github-junegunn-shellwords-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-junegunn-shellwords-devel}"
SRC_URI[aarch64_golang-github-junegunn-shellwords-devel.sha256sum] = "88d5211d76ee8c95ca4ccf10e9410a3a2dbf4ef370913bfdc6132af10917f385"

RDEPENDS:golang-github-junegunn-shellwords-devel = " \
 go-filesystem \
 "
