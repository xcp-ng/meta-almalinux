# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rc"
PV = "1.7.4"
PR = "26.el10_1"
PACKAGES = " \
 rc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rc-1.7.4-26.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9677708d7c9f3b06750181b22f74fa1d11d80664ddc1e1e6afcef3a8a807d774"

URI_x86_64_v2_rc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rc-1.7.4-26.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rc}"
SRC_URI[x86_64_v2_rc.sha256sum] = "f6f5c4f5b1884e5b7f6f82fd9dca3b6d0cefa040e70a3f9052255dced314d7c6"

URI_aarch64_rc = "${EPEL_MIRROR}/aarch64/Packages/r/rc-1.7.4-26.el10_1.aarch64.rpm;name=aarch64_rc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rc}"
SRC_URI[aarch64_rc.sha256sum] = "f68982ef0f09d3e94b8671dcfed950441f858772c2511ceb856552e3968936b1"

RDEPENDS:rc = " \
 bash \
 glibc \
 grep \
 readline \
 sed \
 "
