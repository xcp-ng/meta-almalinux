# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-maxminddb"
PV = "1.12.1"
PR = "1.el10_0"
PACKAGES = " \
 php-maxmind-db-reader \
 php-maxminddb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-maxminddb-1.12.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ade8fd2be3ecb85fb3743c3b888a1573b2f9392f5ef066e9bb3623303b0a651d"

URI_x86_64_v2_php-maxmind-db-reader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-maxmind-db-reader-1.12.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_php-maxmind-db-reader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-maxmind-db-reader}"
SRC_URI[x86_64_v2_php-maxmind-db-reader.sha256sum] = "9e324f05450ae082f702baa89c57924e26f3cb6f849da48eeaf89e01697d0a46"

URI_x86_64_v2_php-maxminddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-maxminddb-1.12.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-maxminddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-maxminddb}"
SRC_URI[x86_64_v2_php-maxminddb.sha256sum] = "37cbc5fc0c3634c0411fa9c69e74d81af405ed207da584fec91c148a910b7e73"

URI_aarch64_php-maxmind-db-reader = "${EPEL_MIRROR}/aarch64/Packages/p/php-maxmind-db-reader-1.12.1-1.el10_0.noarch.rpm;name=aarch64_php-maxmind-db-reader;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-maxmind-db-reader}"
SRC_URI[aarch64_php-maxmind-db-reader.sha256sum] = "a405c7a8784c50950341dadfb6fda10169c8d1b721ad35b9be5cfbc604385001"

URI_aarch64_php-maxminddb = "${EPEL_MIRROR}/aarch64/Packages/p/php-maxminddb-1.12.1-1.el10_0.aarch64.rpm;name=aarch64_php-maxminddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-maxminddb}"
SRC_URI[aarch64_php-maxminddb.sha256sum] = "b9d3bb6dec2f38ee367a393ca91b611323e939d8faf17c5c23ea528c12a3f306"

RDEPENDS:php-maxmind-db-reader = " \
 php-common \
 php-fedora-autoloader \
 "
RDEPENDS:php-maxminddb = " \
 glibc \
 libmaxminddb \
 php-common \
 "
