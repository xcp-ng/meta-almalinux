# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf-plugin-perfmetrics"
PV = "1.0"
PR = "13.el10_0"
PACKAGES = " \
 python3-dnf-plugin-perfmetrics \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnf-plugin-perfmetrics-1.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2c0f8898d1005f1e9eed2390ebbda61db2413a84256735f00335d6ee62e0ad7"

URI_x86_64_v2_python3-dnf-plugin-perfmetrics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dnf-plugin-perfmetrics-1.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dnf-plugin-perfmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dnf-plugin-perfmetrics}"
SRC_URI[x86_64_v2_python3-dnf-plugin-perfmetrics.sha256sum] = "d707080816f6c0ab1b3dcf263709f0aeac2d7599161b5d5a97dbb68132f48189"

URI_aarch64_python3-dnf-plugin-perfmetrics = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dnf-plugin-perfmetrics-1.0-13.el10_0.noarch.rpm;name=aarch64_python3-dnf-plugin-perfmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dnf-plugin-perfmetrics}"
SRC_URI[aarch64_python3-dnf-plugin-perfmetrics.sha256sum] = "789703c74a4fbb0bb9b97e2c591e8e5d1ebddfbd6f7a5bcaa8f1faef8386748d"

RDEPENDS:python3-dnf-plugin-perfmetrics = " \
 python3 \
 python3-dnf \
 python3-psutil \
 "
