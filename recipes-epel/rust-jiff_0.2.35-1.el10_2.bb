# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiff"
PV = "0.2.35"
PR = "1.el10_2"
PACKAGES = " \
 rust-jiff+alloc-devel \
 rust-jiff+default-devel \
 rust-jiff+logging-devel \
 rust-jiff+perf-inline-devel \
 rust-jiff+serde-devel \
 rust-jiff+std-devel \
 rust-jiff+tz-fat-devel \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jiff-0.2.35-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61893e5f63d27e0764c4895316e8589bbf28ef6c8b4eb81353fde6767b0f4d3a"

URI_x86_64_v2_rust-jiff+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+alloc-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+alloc-devel}"
SRC_URI[x86_64_v2_rust-jiff+alloc-devel.sha256sum] = "26e3bd62340b183c1c3644175d39c44ae82f645c2a007d2f91215e211e48f7a4"

URI_x86_64_v2_rust-jiff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+default-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+default-devel}"
SRC_URI[x86_64_v2_rust-jiff+default-devel.sha256sum] = "b406af38e8929f18345821e2f8a9e35727e7e9d064d8838d10858f3d696ccf8f"

URI_x86_64_v2_rust-jiff+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+logging-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+logging-devel}"
SRC_URI[x86_64_v2_rust-jiff+logging-devel.sha256sum] = "b992c759686eabaeaa5d78782984425af0a7103470aea5dd94b12bcd8003f8d6"

URI_x86_64_v2_rust-jiff+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+perf-inline-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-jiff+perf-inline-devel.sha256sum] = "713cd926e7274030eca72c13105e8bf4e5fe28acbbae375062a827ef13da0e53"

URI_x86_64_v2_rust-jiff+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+serde-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+serde-devel}"
SRC_URI[x86_64_v2_rust-jiff+serde-devel.sha256sum] = "cf1a23d46fd17b011d821f48b4207d795ca92d1aaf3f72096f1a3febebc36993"

URI_x86_64_v2_rust-jiff+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+std-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+std-devel}"
SRC_URI[x86_64_v2_rust-jiff+std-devel.sha256sum] = "2972a8833fc0457e1b9ab325c1cd8865f1a12be01ccd26220ffebe26872b3742"

URI_x86_64_v2_rust-jiff+tz-fat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tz-fat-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tz-fat-devel}"
SRC_URI[x86_64_v2_rust-jiff+tz-fat-devel.sha256sum] = "c2bcb4007f2270829fab7d811483fc338d28556ab02a65927ad0dbbba648946f"

URI_x86_64_v2_rust-jiff+tz-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tz-system-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tz-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tz-system-devel}"
SRC_URI[x86_64_v2_rust-jiff+tz-system-devel.sha256sum] = "3f93e8be907f4ae4c43f388868f09e299096299e388a505174da4f6329eb1583"

URI_x86_64_v2_rust-jiff+tzdb-bundle-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-bundle-platform-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-bundle-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-bundle-platform-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-bundle-platform-devel.sha256sum] = "fea7c380430525959ab5cd97c74e85ad669c4bf9613564a23a84bf4835a14164"

URI_x86_64_v2_rust-jiff+tzdb-concatenated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-concatenated-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-concatenated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-concatenated-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-concatenated-devel.sha256sum] = "137f491013e49bb0c684576b9b4e5590e8b8a95cb719a57ce25ab8d17f07756a"

URI_x86_64_v2_rust-jiff+tzdb-zoneinfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff+tzdb-zoneinfo-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff+tzdb-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff+tzdb-zoneinfo-devel}"
SRC_URI[x86_64_v2_rust-jiff+tzdb-zoneinfo-devel.sha256sum] = "93a60a624b53b2cab452b99dc789f865e8bd73f9697ff7ad7ba4aaf6f0156864"

URI_x86_64_v2_rust-jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-devel-0.2.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-devel}"
SRC_URI[x86_64_v2_rust-jiff-devel.sha256sum] = "1919b07d85eb6e20c9561a2d0910102e568821f7d564eb608998171e1e361cc6"

URI_aarch64_rust-jiff+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+alloc-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+alloc-devel}"
SRC_URI[aarch64_rust-jiff+alloc-devel.sha256sum] = "92bb45bfbdbe97878707bd2e9d34c680f7de7560d399acff39a0d726f5034287"

URI_aarch64_rust-jiff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+default-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+default-devel}"
SRC_URI[aarch64_rust-jiff+default-devel.sha256sum] = "538647bd261c114d05646b3b0fbccfa530e5638aa02e5c32a7b214dbd2d9de0c"

URI_aarch64_rust-jiff+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+logging-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+logging-devel}"
SRC_URI[aarch64_rust-jiff+logging-devel.sha256sum] = "45c2e9ea183aafd2920e37063ea98319943430be3a07a5834634e5d53b60bda6"

URI_aarch64_rust-jiff+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+perf-inline-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+perf-inline-devel}"
SRC_URI[aarch64_rust-jiff+perf-inline-devel.sha256sum] = "056898854aa3d6719e6a8ccf748ccc4b2a647cdac93534a8ca5106cb1b2bde62"

URI_aarch64_rust-jiff+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+serde-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+serde-devel}"
SRC_URI[aarch64_rust-jiff+serde-devel.sha256sum] = "b8bfabbd6027b4b62fade5c05859504337c15ec50a05ce489849f937fa91d9c8"

URI_aarch64_rust-jiff+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+std-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+std-devel}"
SRC_URI[aarch64_rust-jiff+std-devel.sha256sum] = "8f9dbe43d52d4e54f3502f6756cf686bf8b5706ddf584d7020c77e36cbf531a4"

URI_aarch64_rust-jiff+tz-fat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tz-fat-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tz-fat-devel}"
SRC_URI[aarch64_rust-jiff+tz-fat-devel.sha256sum] = "a5ca3dbf55adbfdc4a43a6ac942f9bae26bd31a2a83dc363aeffe52080aeab92"

URI_aarch64_rust-jiff+tz-system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tz-system-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+tz-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tz-system-devel}"
SRC_URI[aarch64_rust-jiff+tz-system-devel.sha256sum] = "31b3ba3e6dc53576cf915c56701fa1b1e38eb36006df4d889f2e6be6d398ec6e"

URI_aarch64_rust-jiff+tzdb-bundle-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-bundle-platform-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+tzdb-bundle-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-bundle-platform-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-bundle-platform-devel.sha256sum] = "477d84b8dafa2dd78ed30cda1558b9d7e05e9f9ca6baf813b985e6f590547a14"

URI_aarch64_rust-jiff+tzdb-concatenated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-concatenated-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+tzdb-concatenated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-concatenated-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-concatenated-devel.sha256sum] = "365f377ad7cf8e43619b41ab1a7dd79eb8d2fd8344213e97e72e2c4b9fcc9f3c"

URI_aarch64_rust-jiff+tzdb-zoneinfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff+tzdb-zoneinfo-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff+tzdb-zoneinfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff+tzdb-zoneinfo-devel}"
SRC_URI[aarch64_rust-jiff+tzdb-zoneinfo-devel.sha256sum] = "173654e4718d25f073af37574d9e43c1b11ec928254989844aa67df5fedc5db8"

URI_aarch64_rust-jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-devel-0.2.35-1.el10_2.noarch.rpm;name=aarch64_rust-jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-devel}"
SRC_URI[aarch64_rust-jiff-devel.sha256sum] = "8572e18b27f44e48a9838e9e9d9c9291dcaf56fb0dad04899c1002a6d06839f5"

RDEPENDS:rust-jiff+alloc-devel = " \
 cargo \
 rust-jiff-core+alloc-devel \
 rust-jiff-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+default-devel = " \
 cargo \
 rust-jiff+perf-inline-devel \
 rust-jiff+std-devel \
 rust-jiff+tz-fat-devel \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-concatenated-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+logging-devel = " \
 cargo \
 rust-jiff-core+logging-devel \
 rust-jiff-devel \
 rust-log-devel \
 "
RDEPENDS:rust-jiff+perf-inline-devel = " \
 cargo \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+serde-devel = " \
 cargo \
 rust-jiff-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+std-devel = " \
 cargo \
 rust-jiff+alloc-devel \
 rust-jiff-core+std-devel \
 rust-jiff-devel \
 rust-log+std-devel \
 rust-log-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-jiff+tz-fat-devel = " \
 cargo \
 rust-jiff-core+tz-fat-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tz-system-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-bundle-platform-devel = " \
 cargo \
 rust-jiff+alloc-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-concatenated-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff+tzdb-zoneinfo-devel = " \
 cargo \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-jiff-devel = " \
 cargo \
 rust \
 rust-jiff-core-devel \
 "
