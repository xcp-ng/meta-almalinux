# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "masscan"
PV = "1.3.2"
PR = "12.el10_0"
PACKAGES = " \
 masscan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/masscan-1.3.2-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "352b0d40983654abc8380211c950e3635bee88482331e0aa8f5106771f95a7a8"

URI_x86_64_v2_masscan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/masscan-1.3.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_masscan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_masscan}"
SRC_URI[x86_64_v2_masscan.sha256sum] = "6b602c5e4aef1c7dba0751a07c5aa796551a318087d187b0cf0b079313a9e592"

URI_aarch64_masscan = "${EPEL_MIRROR}/aarch64/Packages/m/masscan-1.3.2-12.el10_0.aarch64.rpm;name=aarch64_masscan;unpack=0"
SRC_URI:append = " ${URI_aarch64_masscan}"
SRC_URI[aarch64_masscan.sha256sum] = "bcb2da1d2e8aadedb9bc4b50b62025a0620ab7bfbc65e58ce2c5d8d33e17da47"

RDEPENDS:masscan = " \
 glibc \
 libpcap-devel \
 "
