# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-setuptools"
PV = "78.1.1"
PR = "4.el10"
PACKAGES = " \
 python3.14-setuptools \
 python3.14-setuptools-wheel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-setuptools-78.1.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d266f61902fa498d5e59b80e0c0bbe597b23ad345c6f576050fc942116162f2"

URI_x86_64_v2_python3.14-setuptools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-setuptools-78.1.1-4.el10.noarch.rpm;name=x86_64_v2_python3.14-setuptools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-setuptools}"
SRC_URI[x86_64_v2_python3.14-setuptools.sha256sum] = "4a49fc41a811a4c8ecb0cd2a9c30ad9d79db9706e5866926a01104bbe41b3a08"

URI_x86_64_v2_python3.14-setuptools-wheel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-setuptools-wheel-78.1.1-4.el10.noarch.rpm;name=x86_64_v2_python3.14-setuptools-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-setuptools-wheel}"
SRC_URI[x86_64_v2_python3.14-setuptools-wheel.sha256sum] = "6ad88b81bb88cf32ec8dc6ab8ba58d4aafc495ad9789d4c98bab659d067e0fe1"

URI_aarch64_python3.14-setuptools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-setuptools-78.1.1-4.el10.noarch.rpm;name=aarch64_python3.14-setuptools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-setuptools}"
SRC_URI[aarch64_python3.14-setuptools.sha256sum] = "4a49fc41a811a4c8ecb0cd2a9c30ad9d79db9706e5866926a01104bbe41b3a08"

URI_aarch64_python3.14-setuptools-wheel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-setuptools-wheel-78.1.1-4.el10.noarch.rpm;name=aarch64_python3.14-setuptools-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-setuptools-wheel}"
SRC_URI[aarch64_python3.14-setuptools-wheel.sha256sum] = "6ad88b81bb88cf32ec8dc6ab8ba58d4aafc495ad9789d4c98bab659d067e0fe1"

RDEPENDS:python3.14-setuptools = " \
 python3.14 \
 "
RDEPENDS:python3.14-setuptools-wheel = " \
 "
