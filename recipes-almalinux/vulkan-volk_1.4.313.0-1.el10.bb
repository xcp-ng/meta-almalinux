# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-volk"
PV = "1.4.313.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-volk-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-volk-1.4.313.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d1b841e1d2148823b0f31afae3a5bc9bb1ba8179dbf5dc3c14acd4776edf298"

URI_x86_64_v2_vulkan-volk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-volk-devel-1.4.313.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-volk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-volk-devel}"
SRC_URI[x86_64_v2_vulkan-volk-devel.sha256sum] = "a8d5e7943e38e8fe58429e1a5805976abe057e78f7b041d5685d34d94015347d"

URI_aarch64_vulkan-volk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-volk-devel-1.4.313.0-1.el10.aarch64.rpm;name=aarch64_vulkan-volk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-volk-devel}"
SRC_URI[aarch64_vulkan-volk-devel.sha256sum] = "475da4d234cf0612a14835c38cf4b09fbdc55f366d51c70f4eb561e6a723db69"

RDEPENDS:vulkan-volk-devel = " \
 cmake-filesystem \
 vulkan-headers \
 "
