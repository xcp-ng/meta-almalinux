# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-glob"
PV = "0.3.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-glob+default-devel \
 rust-glob-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-glob-0.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12240dacfac98a1df4b4f2d9f9d81e22270130939c96de9a2e110350dd13b9a4"

URI_x86_64_v2_rust-glob+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-glob+default-devel-0.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-glob+default-devel}"
SRC_URI[x86_64_v2_rust-glob+default-devel.sha256sum] = "632ba9b4ff8f503b71b3e50e21b40e207cff2a3c900c315b076d965b9c8329e9"

URI_x86_64_v2_rust-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-glob-devel-0.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-glob-devel}"
SRC_URI[x86_64_v2_rust-glob-devel.sha256sum] = "cf75bc55851ae3cd63668340c8dc0a8c7e61852394e1af208a2d7fde96a8efd6"

URI_aarch64_rust-glob+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-glob+default-devel-0.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-glob+default-devel}"
SRC_URI[aarch64_rust-glob+default-devel.sha256sum] = "5429f2ac1a9a822e435d7f46d7f1109a19907d6d0c307cf34343ff9aee391693"

URI_aarch64_rust-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-glob-devel-0.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-glob-devel}"
SRC_URI[aarch64_rust-glob-devel.sha256sum] = "44e49cf4c1f8830150cc8808ea68c3c4de6fed564c2fe2655af9247afe134005"

RDEPENDS:rust-glob+default-devel = " \
 cargo \
 rust-glob-devel \
 "
RDEPENDS:rust-glob-devel = " \
 cargo \
 rust \
 "
