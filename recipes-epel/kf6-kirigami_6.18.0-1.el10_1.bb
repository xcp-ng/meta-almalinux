# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kirigami"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kirigami \
 kf6-kirigami-devel \
 kf6-kirigami-doc \
 kf6-kirigami-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kirigami-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ba22bb2656a2569775a4fc9af43216b509e7f38d0cae265a53e9875c2920fbf"

URI_x86_64_v2_kf6-kirigami = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami}"
SRC_URI[x86_64_v2_kf6-kirigami.sha256sum] = "887d3ca076fd2629cdecdfabcdc5596489bf7cdc0298067e1fd2bcfd4abca2b6"

URI_x86_64_v2_kf6-kirigami-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-devel}"
SRC_URI[x86_64_v2_kf6-kirigami-devel.sha256sum] = "34bd99046d156e72d681f61f449fa78d7b25e9a9b33c85f0298a4b46605f06cf"

URI_x86_64_v2_kf6-kirigami-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kirigami-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-doc}"
SRC_URI[x86_64_v2_kf6-kirigami-doc.sha256sum] = "ac08258715b1c80d5b9f6a5cb12de93934cf05e601ff77c46315e78c7a2bcdf9"

URI_x86_64_v2_kf6-kirigami-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kirigami-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-html}"
SRC_URI[x86_64_v2_kf6-kirigami-html.sha256sum] = "501ab3a1de3a7655765ec508b00ad55222133f1fdcf5a77bf369da29edb793e5"

URI_aarch64_kf6-kirigami = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kirigami;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami}"
SRC_URI[aarch64_kf6-kirigami.sha256sum] = "544da7b81426df78de77816b3fb16bb66674622098cc5a1ff045188f50ee1f82"

URI_aarch64_kf6-kirigami-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kirigami-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-devel}"
SRC_URI[aarch64_kf6-kirigami-devel.sha256sum] = "0079ef2136a23a0f2f629bdedf4322e9d7f593975ebcb460a9ca0a674170f370"

URI_aarch64_kf6-kirigami-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kirigami-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-doc}"
SRC_URI[aarch64_kf6-kirigami-doc.sha256sum] = "2e64f8ef3dd62da871a075a87cd5332c44e84d20bd745f9975d49df14a13fedb"

URI_aarch64_kf6-kirigami-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kirigami-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-html}"
SRC_URI[aarch64_kf6-kirigami-html.sha256sum] = "0734bbc41873c3904fd899dcb84bcf192cf7cf9104d519026366fc3f04785766"

RDEPENDS:kf6-kirigami = " \
 glibc \
 libgomp \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kirigami-devel = " \
 cmake-filesystem \
 kf6-kirigami \
 "
RDEPENDS:kf6-kirigami-doc = " \
 "
RDEPENDS:kf6-kirigami-html = " \
 "
