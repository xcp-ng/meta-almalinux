# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-progress"
PV = "0.1.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-anstyle-progress+default-devel \
 rust-anstyle-progress+std-devel \
 rust-anstyle-progress-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-progress-0.1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "552efc5dc8104d7f30fe665fe702778e793ef172aeb7c536f84b4a3a7605f3cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-progress+default-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-progress+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-anstyle-progress+default-devel.sha256sum] = "d8de26d8816ec0ca60bf3a10b9e6aa91ef6a72e542f44c6a30d2063cd2aa981f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-progress+std-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-progress+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-anstyle-progress+std-devel.sha256sum] = "59324edc3d2b698905e05396d614a7b8e53611f4ab565c32087d2c85ddf876cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-progress-devel-0.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-progress-devel;unpack=0"
SRC_URI[x86_64_v2_rust-anstyle-progress-devel.sha256sum] = "8be6cc44c3f70cec7c89972bea5be66fa8774d6266b059093e4e18d75934851f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-progress+default-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-progress+default-devel;unpack=0"
SRC_URI[aarch64_rust-anstyle-progress+default-devel.sha256sum] = "0d5f6fcc12e826024dd051999526709abe251184c4dcbee8c51195e75d99667c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-progress+std-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-progress+std-devel;unpack=0"
SRC_URI[aarch64_rust-anstyle-progress+std-devel.sha256sum] = "1bac22ffe9f90dc596f4d2563bbf2628c122dcc25e4948aff35e9f844d748c5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-progress-devel-0.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-anstyle-progress-devel;unpack=0"
SRC_URI[aarch64_rust-anstyle-progress-devel.sha256sum] = "a6890a0c8a3acabf52f6288ba5597aa1d80de9a943dae1b4f208163291213104"

RDEPENDS:rust-anstyle-progress+default-devel = " \
 cargo \
 rust-anstyle-progress+std-devel \
 rust-anstyle-progress-devel \
 "
RDEPENDS:rust-anstyle-progress+std-devel = " \
 cargo \
 rust-anstyle-progress-devel \
 "
RDEPENDS:rust-anstyle-progress-devel = " \
 cargo \
 rust \
 "
