# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-libcst"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-libcst \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-libcst-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47aab26796c1469ad8b5d7959bcc7bb5d0ac3cf05253de54f1a523e03f8d4887"

URI_x86_64_v2_python3-libcst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libcst-1.7.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libcst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libcst}"
SRC_URI[x86_64_v2_python3-libcst.sha256sum] = "13f8d3313f44a779921f1b8847a7f2fc48912deed6616c848b57eb787d53ac47"

URI_aarch64_python3-libcst = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libcst-1.7.0-1.el10_0.aarch64.rpm;name=aarch64_python3-libcst;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libcst}"
SRC_URI[aarch64_python3-libcst.sha256sum] = "f6d706216afe0564d41b6a0d7b09b328c0d4ddc5608e0c20b988143d053edde7"

RDEPENDS:python3-libcst = " \
 glibc \
 libgcc \
 python3 \
 python3-pyyaml \
 "
