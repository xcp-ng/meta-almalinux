# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Darwin-InitObjC"
PV = "0.001"
PR = "1.el10_0"
PACKAGES = " \
 perl-Darwin-InitObjC \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Darwin-InitObjC-0.001-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a50f75f068e1dbbd499666a9deede41c31ac873fda5024707d13cca97ca4d6fa"

URI_x86_64_v2_perl-Darwin-InitObjC = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Darwin-InitObjC-0.001-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Darwin-InitObjC;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Darwin-InitObjC}"
SRC_URI[x86_64_v2_perl-Darwin-InitObjC.sha256sum] = "9499e028b8a7e4da11d622db0f69437c039c45bec7e09871b8727c689ad82d91"

URI_aarch64_perl-Darwin-InitObjC = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Darwin-InitObjC-0.001-1.el10_0.noarch.rpm;name=aarch64_perl-Darwin-InitObjC;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Darwin-InitObjC}"
SRC_URI[aarch64_perl-Darwin-InitObjC.sha256sum] = "e8c23bf41c25b2dbc86950c01c24ee2c56e8b6865b6b258f39aab776ca86a7fb"

RDEPENDS:perl-Darwin-InitObjC = " \
 perl-DynaLoader \
 perl-libs \
 "
