# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-recommonmark"
PV = "0.7.1"
PR = "10.git.el10_0"
PACKAGES = " \
 python3-recommonmark \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-recommonmark-0.7.1-10.git.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dda7067cc35028ad9207666b10f3eb2a68185d5a49c99e855f48e5be6df718b"

URI_x86_64_v2_python3-recommonmark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-recommonmark-0.7.1-10.git.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-recommonmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-recommonmark}"
SRC_URI[x86_64_v2_python3-recommonmark.sha256sum] = "87edd54bf3e98b2fa8fd916d5990839e78567ee4b1fad08af38192217306bf91"

URI_aarch64_python3-recommonmark = "${EPEL_MIRROR}/aarch64/Packages/p/python3-recommonmark-0.7.1-10.git.el10_0.noarch.rpm;name=aarch64_python3-recommonmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-recommonmark}"
SRC_URI[aarch64_python3-recommonmark.sha256sum] = "462fde0d10281ca3a92d0f7814740d920bc6bfc559ff749bbe4d92c8950202c0"

RDEPENDS:python3-recommonmark = " \
 python3 \
 python3-CommonMark \
 python3-docutils \
 python3-sphinx \
 "
