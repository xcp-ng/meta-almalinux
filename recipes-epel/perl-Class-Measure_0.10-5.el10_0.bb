# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Measure"
PV = "0.10"
PR = "5.el10_0"
PACKAGES = " \
 perl-Class-Measure \
 perl-Class-Measure-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Measure-0.10-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cdde853ca47b7616f517acd45aa0cfacfc2f19bc0882129fe65e9253a4d27b6"

URI_x86_64_v2_perl-Class-Measure = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Measure-0.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Measure;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Measure}"
SRC_URI[x86_64_v2_perl-Class-Measure.sha256sum] = "8db68d1f70f8531e3d414c1cdafe8d8a50502dc2dc1ff1f0a4cd69c621ebf7e0"

URI_x86_64_v2_perl-Class-Measure-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Measure-tests-0.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Measure-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Measure-tests}"
SRC_URI[x86_64_v2_perl-Class-Measure-tests.sha256sum] = "155578a0b852662afad2bf0f03056ad40537189f0661dc07e245b8f88ccf641a"

URI_aarch64_perl-Class-Measure = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Measure-0.10-5.el10_0.noarch.rpm;name=aarch64_perl-Class-Measure;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Measure}"
SRC_URI[aarch64_perl-Class-Measure.sha256sum] = "a9f4e2338b9297f5584a590f2fdf02bb5706afd72f68e35e863eb0284eba27d7"

URI_aarch64_perl-Class-Measure-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Measure-tests-0.10-5.el10_0.noarch.rpm;name=aarch64_perl-Class-Measure-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Measure-tests}"
SRC_URI[aarch64_perl-Class-Measure-tests.sha256sum] = "a3fa3de54ca0c06003fe535e0a5fc0a46e3669ba232829ad3b759e20c68ccd69"

RDEPENDS:perl-Class-Measure = " \
 perl-Carp \
 perl-Class-Measure \
 perl-Scalar-List-Utils \
 perl-Sub-Exporter \
 perl-base \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Class-Measure-tests = " \
 bash \
 perl-Class-Measure \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-base \
 perl-interpreter \
 perl-libs \
 "
