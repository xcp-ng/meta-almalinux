# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-crypt"
PV = "0.8.0"
PR = "1.el10_2"
PACKAGES = " \
 git-crypt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-crypt-0.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60dc249e27fbfa50b9b4e90fc062daa4026c6968410d583c77ba9a4a0ee70f86"

URI_x86_64_v2_git-crypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-crypt-0.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-crypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-crypt}"
SRC_URI[x86_64_v2_git-crypt.sha256sum] = "fde6bc7c26044f5a9589d9e9dfee87b60140c0371dd254ecbd38aa96aa604ab0"

URI_aarch64_git-crypt = "${EPEL_MIRROR}/aarch64/Packages/g/git-crypt-0.8.0-1.el10_2.aarch64.rpm;name=aarch64_git-crypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-crypt}"
SRC_URI[aarch64_git-crypt.sha256sum] = "929ab969695d70f676d272a55f1a7ab8a2ce09c54465d26a8275e3f85f45ffe6"

RDEPENDS:git-crypt = " \
 git \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
