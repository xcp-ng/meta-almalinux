# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dracut"
PV = "107"
PR = "9.el10_2"
PACKAGES = " \
 dracut \
 dracut-caps \
 dracut-config-generic \
 dracut-config-rescue \
 dracut-live \
 dracut-network \
 dracut-squash \
 dracut-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dracut-107-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3b09f72025c64ce9209cffcd202c5547b06f290daabecd1be5397d5b9ed4e7db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-107-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_dracut;unpack=0"
SRC_URI[x86_64_v2_dracut.sha256sum] = "e4182abd37570451e3123a5c45f9f3b94949ea13f04719800f92bf532ef59e4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dracut-caps-107-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_dracut-caps;unpack=0"
SRC_URI[x86_64_v2_dracut-caps.sha256sum] = "5c1a700dc44a04055dec3c8ecabf28513f28aee13c48ec9c22b9e79ad5e13b8e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-config-generic-107-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_dracut-config-generic;unpack=0"
SRC_URI[x86_64_v2_dracut-config-generic.sha256sum] = "f82e098c56081612dd846bbe020e72b7a9291612a19e1cf2d2405301f3d9b362"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-config-rescue-107-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_dracut-config-rescue;unpack=0"
SRC_URI[x86_64_v2_dracut-config-rescue.sha256sum] = "49d6075d80efdf1d49074e31784751341b194ff09fa882e029b3a3269331e500"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dracut-live-107-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_dracut-live;unpack=0"
SRC_URI[x86_64_v2_dracut-live.sha256sum] = "6ff7e323b6eefd6888207df2915d1341ba7144a9d2d26da06c77cf254629d3ae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-network-107-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_dracut-network;unpack=0"
SRC_URI[x86_64_v2_dracut-network.sha256sum] = "a2ff377953761b4bfb32829732f1ac0258a054e3637300e5a289213d39524e30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-squash-107-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_dracut-squash;unpack=0"
SRC_URI[x86_64_v2_dracut-squash.sha256sum] = "f1ae83de2d0d1189150effe79ba647e1c5c606ade97433de5e16999aba4d1a65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-tools-107-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_dracut-tools;unpack=0"
SRC_URI[x86_64_v2_dracut-tools.sha256sum] = "d498b3a84629a599258fd78b897f9d266988284613ee743b05e8ce99eb36f0e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-107-9.el10_2.aarch64.rpm;name=aarch64_dracut;unpack=0"
SRC_URI[aarch64_dracut.sha256sum] = "a3060bbe930aed2bcb37d66698531bf15709a94d533d8fb02142f94c943a67a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dracut-caps-107-9.el10_2.aarch64.rpm;name=aarch64_dracut-caps;unpack=0"
SRC_URI[aarch64_dracut-caps.sha256sum] = "b645bb057383c784fb1c1d1b096844b943f247546a112730d2768e2e60cdf9f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-config-generic-107-9.el10_2.aarch64.rpm;name=aarch64_dracut-config-generic;unpack=0"
SRC_URI[aarch64_dracut-config-generic.sha256sum] = "ff19699ec31aae8f02f1646803d2a268a9e3b090304c7dc45b208a249f97379d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-config-rescue-107-9.el10_2.aarch64.rpm;name=aarch64_dracut-config-rescue;unpack=0"
SRC_URI[aarch64_dracut-config-rescue.sha256sum] = "4d17edce9bfc727270d29fd0197a8cd0c74df565c320f01e5b04d60bd6eec981"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dracut-live-107-9.el10_2.aarch64.rpm;name=aarch64_dracut-live;unpack=0"
SRC_URI[aarch64_dracut-live.sha256sum] = "18ef1b4d1a52d0ed9ffa28bc5822fb18f3bdafef33d94c51e6a3cfe0a3a5a4b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-network-107-9.el10_2.aarch64.rpm;name=aarch64_dracut-network;unpack=0"
SRC_URI[aarch64_dracut-network.sha256sum] = "2eb4b7db209ccff96114635e0558ed91e2e65e3fe277010ebd8a2ab5d85ab2a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-squash-107-9.el10_2.aarch64.rpm;name=aarch64_dracut-squash;unpack=0"
SRC_URI[aarch64_dracut-squash.sha256sum] = "c4653df1002d7747f6339acf401702a04d003232d88bfc0ecfcb01cfd08df020"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-tools-107-9.el10_2.aarch64.rpm;name=aarch64_dracut-tools;unpack=0"
SRC_URI[aarch64_dracut-tools.sha256sum] = "2325f3882c3d842d856fe10f84a6ddefb9eac756c4439856761bae9317c21550"

RDEPENDS:dracut = " \
 bash \
 cpio \
 filesystem \
 findutils \
 glibc \
 grep \
 gzip \
 kmod \
 kmod-libs \
 libgcc \
 libkcapi-hmaccalc \
 openssl-libs \
 procps-ng \
 sed \
 systemd \
 systemd-udev \
 util-linux \
 virtual/coreutils \
 xz \
 "
RDEPENDS:dracut-caps = " \
 bash \
 dracut \
 libcap \
 "
RDEPENDS:dracut-config-generic = " \
 dracut \
 "
RDEPENDS:dracut-config-rescue = " \
 bash \
 dracut \
 "
RDEPENDS:dracut-live = " \
 bash \
 curl \
 device-mapper \
 dracut \
 dracut-network \
 gzip \
 parted \
 tar \
 virtual/coreutils \
 "
RDEPENDS:dracut-network = " \
 NetworkManager \
 bash \
 dracut \
 iproute \
 iputils \
 jq \
 "
RDEPENDS:dracut-squash = " \
 bash \
 dracut \
 erofs-utils \
 "
RDEPENDS:dracut-tools = " \
 bash \
 dracut \
 "
