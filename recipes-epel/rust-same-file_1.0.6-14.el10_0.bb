# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-same-file"
PV = "1.0.6"
PR = "14.el10_0"
PACKAGES = " \
 rust-same-file+default-devel \
 rust-same-file-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-same-file-1.0.6-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f79e59d4865a1da9d8e73cd822001ff8bfe05164effd18c7ef995aec3370cb3"

URI_x86_64_v2_rust-same-file+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-same-file+default-devel-1.0.6-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-same-file+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-same-file+default-devel}"
SRC_URI[x86_64_v2_rust-same-file+default-devel.sha256sum] = "84c40fe74fd9bbf08b3bd513ef3ef6159b51937a5f09caafbc9a0007552e5b26"

URI_x86_64_v2_rust-same-file-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-same-file-devel-1.0.6-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-same-file-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-same-file-devel}"
SRC_URI[x86_64_v2_rust-same-file-devel.sha256sum] = "9956e08da5a1001f0115f8c2d25ec7b5dcaf1e8b5db2fa50b5a91456142a44a8"

URI_aarch64_rust-same-file+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-same-file+default-devel-1.0.6-14.el10_0.noarch.rpm;name=aarch64_rust-same-file+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-same-file+default-devel}"
SRC_URI[aarch64_rust-same-file+default-devel.sha256sum] = "01c3680984b6f35a03cd216c23700a2a9642d6d28cc42df49f55b7dc86a01ff0"

URI_aarch64_rust-same-file-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-same-file-devel-1.0.6-14.el10_0.noarch.rpm;name=aarch64_rust-same-file-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-same-file-devel}"
SRC_URI[aarch64_rust-same-file-devel.sha256sum] = "aef246df5d1962a6292c7836cfa69f76a0b713177488ebe569e8f915f18169d5"

RDEPENDS:rust-same-file+default-devel = " \
 cargo \
 rust-same-file-devel \
 "
RDEPENDS:rust-same-file-devel = " \
 cargo \
 "
