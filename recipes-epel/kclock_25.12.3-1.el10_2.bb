# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kclock"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kclock \
 kclock-plasma-applet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kclock-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2e78c9004c3e18353c2b9b77d656d875f6481b70329250164030e4607801b09"

URI_x86_64_v2_kclock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kclock-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kclock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kclock}"
SRC_URI[x86_64_v2_kclock.sha256sum] = "474a885044aadd86c988cc121bc3b85fc398b490c43c1cf9a289ee6229c2886b"

URI_x86_64_v2_kclock-plasma-applet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kclock-plasma-applet-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kclock-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kclock-plasma-applet}"
SRC_URI[x86_64_v2_kclock-plasma-applet.sha256sum] = "35edb5567eff7b1c609b2597e6703c052d2cb1eaa33c9efc62b24ce0499f5f3b"

URI_aarch64_kclock = "${EPEL_MIRROR}/aarch64/Packages/k/kclock-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kclock;unpack=0"
SRC_URI:append = " ${URI_aarch64_kclock}"
SRC_URI[aarch64_kclock.sha256sum] = "6d7a61da8b3d7ffab6ca9cb37bf9e2af9d3951c647e67d93a724968932fbdcc8"

URI_aarch64_kclock-plasma-applet = "${EPEL_MIRROR}/aarch64/Packages/k/kclock-plasma-applet-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kclock-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kclock-plasma-applet}"
SRC_URI[aarch64_kclock-plasma-applet.sha256sum] = "98f14216b95527d91b84d4552cd0cf677a07d07db40889c132d5443ae027e0cd"

RDEPENDS:kclock = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:kclock-plasma-applet = " \
 glibc \
 kclock \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-kservice \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 "
