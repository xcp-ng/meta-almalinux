# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter0.23"
PV = "0.23.2"
PR = "4.el10_2"
PACKAGES = " \
 rust-tree-sitter0.23+default-devel \
 rust-tree-sitter0.23+std-devel \
 rust-tree-sitter0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter0.23-0.23.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c245d3e1cb4080316057bd9881237b50878a2a3950dc4c89c860e67cbae90a2f"

URI_x86_64_v2_rust-tree-sitter0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter0.23+default-devel-0.23.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter0.23+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter0.23+default-devel.sha256sum] = "b0e6386636a1fb53492d8d5d6c3d29596ddaa70c433f111a2365652fb81356ea"

URI_x86_64_v2_rust-tree-sitter0.23+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter0.23+std-devel-0.23.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter0.23+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter0.23+std-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter0.23+std-devel.sha256sum] = "58c7a51e960d361ff6ea609bc161a43ba7813b8b25bb1b1530915e703ca55ecb"

URI_x86_64_v2_rust-tree-sitter0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter0.23-devel-0.23.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter0.23-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter0.23-devel.sha256sum] = "3e5c10e1325ea5fc71fb1e4b4b6209ca45308822291d64fb731720b2dad28b2a"

URI_aarch64_rust-tree-sitter0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter0.23+default-devel-0.23.2-4.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter0.23+default-devel}"
SRC_URI[aarch64_rust-tree-sitter0.23+default-devel.sha256sum] = "62171d7f99dfb9ec21ec2f3ef35c2e66c25a5158bb30f4394c82d3610708806c"

URI_aarch64_rust-tree-sitter0.23+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter0.23+std-devel-0.23.2-4.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter0.23+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter0.23+std-devel}"
SRC_URI[aarch64_rust-tree-sitter0.23+std-devel.sha256sum] = "a51bb698e38713ccc68203450ba60c8526241f3b312ac73e7e2ba7dccd4f9374"

URI_aarch64_rust-tree-sitter0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter0.23-devel-0.23.2-4.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter0.23-devel}"
SRC_URI[aarch64_rust-tree-sitter0.23-devel.sha256sum] = "ab53f2afdb65347a0e952d729895ea294104bb01180d3110ea48738ba94b2fde"

RDEPENDS:rust-tree-sitter0.23+default-devel = " \
 cargo \
 rust-tree-sitter0.23+std-devel \
 rust-tree-sitter0.23-devel \
 "
RDEPENDS:rust-tree-sitter0.23+std-devel = " \
 cargo \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-syntax+unicode-devel \
 rust-tree-sitter0.23-devel \
 "
RDEPENDS:rust-tree-sitter0.23-devel = " \
 cargo \
 rust \
 rust-bindgen+default-devel \
 rust-cc+default-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax-devel \
 rust-tree-sitter-language+default-devel \
 "
