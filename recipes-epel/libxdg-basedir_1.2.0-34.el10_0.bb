# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxdg-basedir"
PV = "1.2.0"
PR = "34.el10_0"
PACKAGES = " \
 libxdg-basedir \
 libxdg-basedir-devel \
 libxdg-basedir-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libxdg-basedir-1.2.0-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4153b4b52eba99e26f41d8d209c7f2d9fb5c51bdb98f8f540086c6085d855bf"

URI_x86_64_v2_libxdg-basedir = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxdg-basedir-1.2.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxdg-basedir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdg-basedir}"
SRC_URI[x86_64_v2_libxdg-basedir.sha256sum] = "94bc5faa9c368e351423d810923147b2bd129919c1dc12e136c173d07b8cb154"

URI_x86_64_v2_libxdg-basedir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxdg-basedir-devel-1.2.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxdg-basedir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdg-basedir-devel}"
SRC_URI[x86_64_v2_libxdg-basedir-devel.sha256sum] = "d690ce611c047e0c08a8d0a83cfb92bb92819dcae4a30fa9064a386d47546bc7"

URI_x86_64_v2_libxdg-basedir-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxdg-basedir-doc-1.2.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxdg-basedir-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdg-basedir-doc}"
SRC_URI[x86_64_v2_libxdg-basedir-doc.sha256sum] = "fbfa29c03b8a129f334da4c71e59f5e20c8b5f0ebab6cabee33705105a54da63"

URI_aarch64_libxdg-basedir = "${EPEL_MIRROR}/aarch64/Packages/l/libxdg-basedir-1.2.0-34.el10_0.aarch64.rpm;name=aarch64_libxdg-basedir;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdg-basedir}"
SRC_URI[aarch64_libxdg-basedir.sha256sum] = "45cce2803ae93e2a52be3f1e057a8cd953e8a8a080b6f42e4dde766e7b153a81"

URI_aarch64_libxdg-basedir-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libxdg-basedir-devel-1.2.0-34.el10_0.aarch64.rpm;name=aarch64_libxdg-basedir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdg-basedir-devel}"
SRC_URI[aarch64_libxdg-basedir-devel.sha256sum] = "2d86dcb26b769bc4e83ad58557f9d5a2b64742bb470704d841cd68cf98a0a02c"

URI_aarch64_libxdg-basedir-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libxdg-basedir-doc-1.2.0-34.el10_0.aarch64.rpm;name=aarch64_libxdg-basedir-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdg-basedir-doc}"
SRC_URI[aarch64_libxdg-basedir-doc.sha256sum] = "2f25cb20f231972dd321098487ba34180f4a2efc026a7c8df1bd57af53332dce"

RDEPENDS:libxdg-basedir = " \
 glibc \
 "
RDEPENDS:libxdg-basedir-devel = " \
 libxdg-basedir \
 pkgconf-pkg-config \
 "
RDEPENDS:libxdg-basedir-doc = " \
 libxdg-basedir \
 "
