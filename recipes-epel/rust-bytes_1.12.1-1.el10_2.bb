# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytes"
PV = "1.12.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-bytes+default-devel \
 rust-bytes+extra-platforms-devel \
 rust-bytes+serde-devel \
 rust-bytes+std-devel \
 rust-bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytes-1.12.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9aedd6b0379469e4433f38a9ff71a80e6cc44658d366f3c643c89ca83fa489c9"

URI_x86_64_v2_rust-bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+default-devel-1.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+default-devel}"
SRC_URI[x86_64_v2_rust-bytes+default-devel.sha256sum] = "fcac014de3b8ee7222ed8548c6f365d70d45569c7015a0f181ff0fbfb1e16cd2"

URI_x86_64_v2_rust-bytes+extra-platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+extra-platforms-devel-1.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+extra-platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+extra-platforms-devel}"
SRC_URI[x86_64_v2_rust-bytes+extra-platforms-devel.sha256sum] = "b69215ee8c34904c16b67354a7aa5ac03e215e89acd8bd31adb9c7f8e1842ff0"

URI_x86_64_v2_rust-bytes+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+serde-devel-1.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+serde-devel}"
SRC_URI[x86_64_v2_rust-bytes+serde-devel.sha256sum] = "aa724f30d3de82ed486958d62874a59da5559e9793e763a955f77d7379412355"

URI_x86_64_v2_rust-bytes+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes+std-devel-1.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes+std-devel}"
SRC_URI[x86_64_v2_rust-bytes+std-devel.sha256sum] = "d5a0caf25b91cee590ca9c47dd5e077a7000ae69abf93e21ae2edd09981061e4"

URI_x86_64_v2_rust-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytes-devel-1.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytes-devel}"
SRC_URI[x86_64_v2_rust-bytes-devel.sha256sum] = "461146544188b42056f372a631ae07c67a5b00fa34f88f91426e29b660169fb5"

URI_aarch64_rust-bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+default-devel-1.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+default-devel}"
SRC_URI[aarch64_rust-bytes+default-devel.sha256sum] = "fccf04c2ece2d6245bd59b7e971a379edd4f9277bca1fd680e87e4dde3010732"

URI_aarch64_rust-bytes+extra-platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+extra-platforms-devel-1.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-bytes+extra-platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+extra-platforms-devel}"
SRC_URI[aarch64_rust-bytes+extra-platforms-devel.sha256sum] = "2f2e3e7e2c7f8a34ca469b5f6775c3a74597625ef118aaa5ce7e7a95c37b2b34"

URI_aarch64_rust-bytes+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+serde-devel-1.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-bytes+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+serde-devel}"
SRC_URI[aarch64_rust-bytes+serde-devel.sha256sum] = "543ff9884bed7053034411954a7d0fbf9f26be5e13fa36904eb5bab2d06a2fd9"

URI_aarch64_rust-bytes+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes+std-devel-1.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-bytes+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes+std-devel}"
SRC_URI[aarch64_rust-bytes+std-devel.sha256sum] = "84a77f736faf9bf1a059cc00b04abf018643228431ec90911fe4a153563fe30d"

URI_aarch64_rust-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytes-devel-1.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytes-devel}"
SRC_URI[aarch64_rust-bytes-devel.sha256sum] = "b9bd179f4242823e001d36f4718560b07ac8412394ff5f01842de60918833d73"

RDEPENDS:rust-bytes+default-devel = " \
 cargo \
 rust-bytes+std-devel \
 rust-bytes-devel \
 "
RDEPENDS:rust-bytes+extra-platforms-devel = " \
 cargo \
 rust-bytes-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-bytes+serde-devel = " \
 cargo \
 rust-bytes-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bytes+std-devel = " \
 cargo \
 rust-bytes-devel \
 "
RDEPENDS:rust-bytes-devel = " \
 cargo \
 rust \
 "
