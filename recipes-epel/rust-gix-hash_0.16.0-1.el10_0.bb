# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-hash"
PV = "0.16.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-hash+default-devel \
 rust-gix-hash+document-features-devel \
 rust-gix-hash+serde-devel \
 rust-gix-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-hash-0.16.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e698bdca17a1116f475b95816d5ea837ec8d46e28fcecac7150496df1789b3a"

URI_x86_64_v2_rust-gix-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+default-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+default-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+default-devel.sha256sum] = "2310afb64ef01021013f174ec6d104a9aef18a034dae03f733762e77e61d981e"

URI_x86_64_v2_rust-gix-hash+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+document-features-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+document-features-devel.sha256sum] = "3ad8a040b164fa32846b8c9f36f8a88004cd20f9ad91bf0100cedd0f947b810f"

URI_x86_64_v2_rust-gix-hash+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+serde-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+serde-devel.sha256sum] = "2c13e11aefc2e6ae463cb9cda18a2dbe759403a19c0af5bda23250f193f1dc24"

URI_x86_64_v2_rust-gix-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash-devel}"
SRC_URI[x86_64_v2_rust-gix-hash-devel.sha256sum] = "5f68ed39e655b098ccc0d2fc3034c7cc582474fb8a0d06ff550c7519c4b8805f"

URI_aarch64_rust-gix-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+default-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+default-devel}"
SRC_URI[aarch64_rust-gix-hash+default-devel.sha256sum] = "fda580a4fc2802a9cc826b723ec97cc73522362edf7badc7895e5e106b1d6296"

URI_aarch64_rust-gix-hash+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+document-features-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-hash+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+document-features-devel}"
SRC_URI[aarch64_rust-gix-hash+document-features-devel.sha256sum] = "28853cd7b9511439b9fde516fa4487c5cc9352ff4dd74e09e4520d634af56390"

URI_aarch64_rust-gix-hash+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+serde-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-hash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+serde-devel}"
SRC_URI[aarch64_rust-gix-hash+serde-devel.sha256sum] = "8208ccccdf4ac2c56e89d2d96131d4112ef7889292b99ebb61d67e7500d5a4dd"

URI_aarch64_rust-gix-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash-devel}"
SRC_URI[aarch64_rust-gix-hash-devel.sha256sum] = "c914f2bf5a99780d87be1e3edfde04b52af3bd8689ed985130bc6a3ce25e64f1"

RDEPENDS:rust-gix-hash+default-devel = " \
 cargo \
 rust-gix-hash-devel \
 "
RDEPENDS:rust-gix-hash+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-hash-devel \
 "
RDEPENDS:rust-gix-hash+serde-devel = " \
 cargo \
 rust-gix-hash-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-hash-devel = " \
 cargo \
 rust \
 rust-faster-hex+default-devel \
 rust-thiserror+default-devel \
 "
