# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-purl"
PV = "0.1.6"
PR = "2.el10_2"
PACKAGES = " \
 rust-purl+default-devel \
 rust-purl+package-type-devel \
 rust-purl+phf-devel \
 rust-purl+serde-devel \
 rust-purl+smartstring-devel \
 rust-purl+unicase-devel \
 rust-purl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-purl-0.1.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9944a719ace5281fe2430ae13142edc44434c92e816ef0b7759fd2074d3936f"

URI_x86_64_v2_rust-purl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-purl+default-devel-0.1.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-purl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-purl+default-devel}"
SRC_URI[x86_64_v2_rust-purl+default-devel.sha256sum] = "371914a22ab4111fd2c7843747ffb157be1ac0af2ef370b96e68bdc00065b4a8"

URI_x86_64_v2_rust-purl+package-type-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-purl+package-type-devel-0.1.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-purl+package-type-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-purl+package-type-devel}"
SRC_URI[x86_64_v2_rust-purl+package-type-devel.sha256sum] = "d74bab3de6cd70835ea5efb789572b591b27e359e2e6d85b49ee85813574adc6"

URI_x86_64_v2_rust-purl+phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-purl+phf-devel-0.1.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-purl+phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-purl+phf-devel}"
SRC_URI[x86_64_v2_rust-purl+phf-devel.sha256sum] = "1bb7129af15d3b0ee763052d11c7107f8d5d56454d6297c46fdc727d64d7588b"

URI_x86_64_v2_rust-purl+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-purl+serde-devel-0.1.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-purl+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-purl+serde-devel}"
SRC_URI[x86_64_v2_rust-purl+serde-devel.sha256sum] = "ba1b2a371c6694d489476d48728b0b4a142e81ea81429bdd1ec33faf3dcc3c3e"

URI_x86_64_v2_rust-purl+smartstring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-purl+smartstring-devel-0.1.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-purl+smartstring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-purl+smartstring-devel}"
SRC_URI[x86_64_v2_rust-purl+smartstring-devel.sha256sum] = "bd2a16f9bf70878866727733ad3aec7cf1a1cb9d5cd0b5af8fbd0e8d0515f94a"

URI_x86_64_v2_rust-purl+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-purl+unicase-devel-0.1.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-purl+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-purl+unicase-devel}"
SRC_URI[x86_64_v2_rust-purl+unicase-devel.sha256sum] = "f866267c7d652be1140d511ef422a08982e9f3ea397da5ce7f122397381a2a4f"

URI_x86_64_v2_rust-purl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-purl-devel-0.1.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-purl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-purl-devel}"
SRC_URI[x86_64_v2_rust-purl-devel.sha256sum] = "823e0817e5ca41c4c8cf7e72b4f5ad959090531ee83f6e0c18f00c00e187ff28"

URI_aarch64_rust-purl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-purl+default-devel-0.1.6-2.el10_2.noarch.rpm;name=aarch64_rust-purl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-purl+default-devel}"
SRC_URI[aarch64_rust-purl+default-devel.sha256sum] = "4e3342593243b0a727d21d368b25bb5662b770034bab7c50f7996268fb8fe437"

URI_aarch64_rust-purl+package-type-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-purl+package-type-devel-0.1.6-2.el10_2.noarch.rpm;name=aarch64_rust-purl+package-type-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-purl+package-type-devel}"
SRC_URI[aarch64_rust-purl+package-type-devel.sha256sum] = "a9732fbc321fb608876b5407bc4a27618e37a51f9427a216d252d1f873397764"

URI_aarch64_rust-purl+phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-purl+phf-devel-0.1.6-2.el10_2.noarch.rpm;name=aarch64_rust-purl+phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-purl+phf-devel}"
SRC_URI[aarch64_rust-purl+phf-devel.sha256sum] = "59e5fec63ed49da20d2dfdfa4604b35607a64fc77ab93a55792f4685bb0b8930"

URI_aarch64_rust-purl+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-purl+serde-devel-0.1.6-2.el10_2.noarch.rpm;name=aarch64_rust-purl+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-purl+serde-devel}"
SRC_URI[aarch64_rust-purl+serde-devel.sha256sum] = "61c56932df3f5d6d8098ee660367b12fc4969a209bdda17392be937d63d4ff55"

URI_aarch64_rust-purl+smartstring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-purl+smartstring-devel-0.1.6-2.el10_2.noarch.rpm;name=aarch64_rust-purl+smartstring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-purl+smartstring-devel}"
SRC_URI[aarch64_rust-purl+smartstring-devel.sha256sum] = "dcfffd581364ac45db53ae7dd9586bd56c130487f4ab3576c2e342456287bfe8"

URI_aarch64_rust-purl+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-purl+unicase-devel-0.1.6-2.el10_2.noarch.rpm;name=aarch64_rust-purl+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-purl+unicase-devel}"
SRC_URI[aarch64_rust-purl+unicase-devel.sha256sum] = "0ec3f92a6716ffa3b7a2ed09000ce88732183715e2cb971d56ded1407405f662"

URI_aarch64_rust-purl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-purl-devel-0.1.6-2.el10_2.noarch.rpm;name=aarch64_rust-purl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-purl-devel}"
SRC_URI[aarch64_rust-purl-devel.sha256sum] = "77430ef8ab6c4a851f38c3572d0e70dc92934cf1257f6952871a26ae261cce72"

RDEPENDS:rust-purl+default-devel = " \
 cargo \
 rust-purl+package-type-devel \
 rust-purl+smartstring-devel \
 rust-purl-devel \
 "
RDEPENDS:rust-purl+package-type-devel = " \
 cargo \
 rust-purl+phf-devel \
 rust-purl+unicase-devel \
 rust-purl-devel \
 "
RDEPENDS:rust-purl+phf-devel = " \
 cargo \
 rust-phf0.11+default-devel \
 rust-phf0.11+macros-devel \
 rust-phf0.11+unicase-devel \
 rust-purl-devel \
 "
RDEPENDS:rust-purl+serde-devel = " \
 cargo \
 rust-purl-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-purl+smartstring-devel = " \
 cargo \
 rust-purl-devel \
 rust-smartstring+default-devel \
 "
RDEPENDS:rust-purl+unicase-devel = " \
 cargo \
 rust-purl-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-purl-devel = " \
 cargo \
 rust-hex+default-devel \
 rust-percent-encoding+default-devel \
 rust-thiserror+default-devel \
 "
