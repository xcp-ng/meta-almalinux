# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nest-asyncio"
PV = "1.6.0"
PR = "5.el10_1"
PACKAGES = " \
 python3-nest-asyncio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nest-asyncio-1.6.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38c43739db161714ce667b82e30a4937b647f15993c77bfffe8ec2b357d8b192"

URI_x86_64_v2_python3-nest-asyncio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nest-asyncio-1.6.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nest-asyncio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nest-asyncio}"
SRC_URI[x86_64_v2_python3-nest-asyncio.sha256sum] = "c01568b755c1f42d51d57ae51090723da08fe2450ed77175a4029b10bc6cef61"

URI_aarch64_python3-nest-asyncio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nest-asyncio-1.6.0-5.el10_1.noarch.rpm;name=aarch64_python3-nest-asyncio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nest-asyncio}"
SRC_URI[aarch64_python3-nest-asyncio.sha256sum] = "042f12cf95d64324628594942749c010e35986fb7a8d21b74715e45eabaf2ba1"

RDEPENDS:python3-nest-asyncio = " \
 python3 \
 "
