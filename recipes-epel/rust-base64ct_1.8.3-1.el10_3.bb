# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base64ct"
PV = "1.8.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-base64ct+alloc-devel \
 rust-base64ct+default-devel \
 rust-base64ct+std-devel \
 rust-base64ct-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-base64ct-1.8.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e25b40f1e1376966e445b1b55501f02bfddb63f4b8def575fc4ced687e8db084"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+alloc-devel-1.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-base64ct+alloc-devel.sha256sum] = "3e70c84ef36e25ada1e6466a957f27f87f85ee66430ab3fd2998914de26cbce0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+default-devel-1.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-base64ct+default-devel.sha256sum] = "1978e6e2f581fdfb896270a0b6cd7ec9d29ebf181245dbe14500acb338935040"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+std-devel-1.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-base64ct+std-devel.sha256sum] = "fb0bd43f7914df515aeba788e1642b4936692c455313667f882ad93b85129fa5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct-devel-1.8.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct-devel;unpack=0"
SRC_URI[x86_64_v2_rust-base64ct-devel.sha256sum] = "1bfe6a17e5b3fe19a6569332e6bbfaf65b9c915cd47838291c06b89a4e8ae13b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+alloc-devel-1.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-base64ct+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-base64ct+alloc-devel.sha256sum] = "eb85ae374ecb602d530568c0e9020a39bff19fb8a7b2ba70357e28bba5fb475e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+default-devel-1.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-base64ct+default-devel;unpack=0"
SRC_URI[aarch64_rust-base64ct+default-devel.sha256sum] = "3daa898cbcf99d380d47cee97db1b5cd689aff51db6b940950247ed62c76c4a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+std-devel-1.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-base64ct+std-devel;unpack=0"
SRC_URI[aarch64_rust-base64ct+std-devel.sha256sum] = "61507d5baff90f0505367bba31f6180b068c6d52c3443a8639db9f1e133dbc46"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct-devel-1.8.3-1.el10_3.noarch.rpm;name=aarch64_rust-base64ct-devel;unpack=0"
SRC_URI[aarch64_rust-base64ct-devel.sha256sum] = "487932b23e151586670c61a6760173ecf784f1555d224828d5deae91e410fa0c"

RDEPENDS:rust-base64ct+alloc-devel = " \
 cargo \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct+default-devel = " \
 cargo \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct+std-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct-devel = " \
 cargo \
 rust \
 "
