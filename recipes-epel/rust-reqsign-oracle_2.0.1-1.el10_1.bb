# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-oracle"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-reqsign-oracle+default-devel \
 rust-reqsign-oracle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-oracle-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bdeecc4339374e16dea75c4759cb4b47f243572e9bfe8aec5264941dcda5a1e"

URI_x86_64_v2_rust-reqsign-oracle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-oracle+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-oracle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-oracle+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-oracle+default-devel.sha256sum] = "e81a9c228b0223bb43876f0d7aa730a9f48638fe50273d76231b91b5472d991f"

URI_x86_64_v2_rust-reqsign-oracle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-oracle-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-oracle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-oracle-devel}"
SRC_URI[x86_64_v2_rust-reqsign-oracle-devel.sha256sum] = "c7ce581a8d9788296cce3bd55a36e9d5d7371f0098c861340ad973638d807c51"

URI_aarch64_rust-reqsign-oracle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-oracle+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-oracle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-oracle+default-devel}"
SRC_URI[aarch64_rust-reqsign-oracle+default-devel.sha256sum] = "a33a7b16d4ee1e8b694f6fc8d7b094a494713fcdfe991857130a24fee93c0057"

URI_aarch64_rust-reqsign-oracle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-oracle-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-oracle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-oracle-devel}"
SRC_URI[aarch64_rust-reqsign-oracle-devel.sha256sum] = "9ff4ca6473ddb01c1df8c49c6080906a066943d2c6958c869283c68ae33d7af6"

RDEPENDS:rust-reqsign-oracle+default-devel = " \
 cargo \
 rust-reqsign-oracle-devel \
 "
RDEPENDS:rust-reqsign-oracle-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-base64+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-reqsign-core+default-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-rust-ini+default-devel \
 "
