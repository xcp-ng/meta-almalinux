# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-questionary"
PV = "2.1.1"
PR = "2.el10_3"
PACKAGES = " \
 python3-questionary \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-questionary-2.1.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2609389a286b6c1d367dab03787aa12a7f97676672ea2647e47a34c95f799ff8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-questionary-2.1.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-questionary;unpack=0"
SRC_URI[x86_64_v2_python3-questionary.sha256sum] = "11616584e543bfd98d6a5ddda7725a7b31b395504caa88258afcc6ef8e8f5c20"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-questionary-2.1.1-2.el10_3.noarch.rpm;name=aarch64_python3-questionary;unpack=0"
SRC_URI[aarch64_python3-questionary.sha256sum] = "ff21030d6168d30db2cc8c28521d7e22972ad10cae6739ddf381a1aa50c963bf"

RDEPENDS:python3-questionary = " \
 python3 \
 python3-prompt-toolkit \
 "
